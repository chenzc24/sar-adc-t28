VEXT (SAMPLE 0) vsource type=pwl wave=[ \
0 0 5.999999999999614e-08 0 6.000021116344028e-08 0.001900470962571042 6.000044244454719e-08 0.003982000924727166 \
6.0000905006761e-08 0.008145060849039413 6.000136232062722e-08 0.01226088564504064 6.000183680352553e-08 0.01653123172985639 6.000236929936775e-08 0.02132369430982749 \
6.000303918194168e-08 0.02735263747515369 6.000389628605121e-08 0.03506657446094884 6.000501103204629e-08 0.04509928841663746 6.000663202963762e-08 0.05968826673863754 \
6.00089746991287e-08 0.08077229215837188 6.001366003811087e-08 0.1229403429978405 6.001796446524037e-08 0.1616801871633537 6.002181440695147e-08 0.1963296625632528 \
6.002607848391735e-08 0.2347063552562001 6.002914848129145e-08 0.2623363316230807 6.003161142144612e-08 0.2845027930151538 6.00335732345164e-08 0.3021591106476817 \
6.003528302999053e-08 0.3175472699147922 6.003678662173108e-08 0.3310795955797556 6.003812571946623e-08 0.3431314751960884 6.003937239923287e-08 0.3543515930958913 \
6.004051433890699e-08 0.3646290501629268 6.004157231144696e-08 0.3741508030226791 6.004258135718935e-08 0.3832322147042228 6.004360026022795e-08 0.3924023420515681 \
6.004455673847403e-08 0.4010106462662745 6.004550457186604e-08 0.4095411467944404 6.004636814717431e-08 0.4173133245688312 6.004711084845196e-08 0.423997636067712 \
6.004777056290232e-08 0.4299350661209142 6.004846509286008e-08 0.4361858357407548 6.004913443997256e-08 0.4422099597530631 6.004974500555238e-08 0.4477050499714701 \
6.005052115903607e-08 0.454690431324675 6.005157758303665e-08 0.4641982473299416 6.00525733032824e-08 0.4731597295416305 6.005343914699659e-08 0.4809523229693754 \
6.005437529799977e-08 0.4893776819979773 6.005510176673559e-08 0.4959159006203305 6.005576798472682e-08 0.5019118625413875 6.005638295891082e-08 0.5074466301974319 \
6.005716765846853e-08 0.5145089262167936 6.005787693185715e-08 0.5208923867144013 6.005857672855696e-08 0.5271905570126808 6.005924114313236e-08 0.5331702881913303 \
6.005989647373366e-08 0.539068263602977 6.006053579805412e-08 0.5448221824871196 6.006112594576222e-08 0.5501335118600457 6.006165324981427e-08 0.5548792483285057 \
6.006203010496504e-08 0.5582709446854013 6.006242563516139e-08 0.5618307164525158 6.00627887403595e-08 0.5650986632355098 6.006316517501063e-08 0.5684865750957045 \
6.006351315482221e-08 0.5716183933999566 6.00637778468606e-08 0.5740006217454657 6.006404298552272e-08 0.5763868697045537 6.006457326284696e-08 0.5811593656227293 \
6.006495931382602e-08 0.5846338244342608 6.006536821020663e-08 0.5883138918597329 6.006587063576047e-08 0.5928357218442383 6.006645565011999e-08 0.5981008510799999 \
6.006699678518503e-08 0.6029710666652875 6.006741714435488e-08 0.6067542991940013 6.006782498280831e-08 0.6104248452748176 6.00682323094902e-08 0.6140907854118068 \
6.006864215761304e-08 0.6177794185173828 6.006906579944176e-08 0.62159219497586 6.006951003721081e-08 0.6255903348973357 6.006996676859544e-08 0.6297009173589793 \
6.007044454604313e-08 0.6340009143882042 6.007097508932965e-08 0.6387758039669345 6.007154147141563e-08 0.6438732427407217 6.007214542213926e-08 0.6493087992533674 \
6.007279338162497e-08 0.6551404346247349 6.007350576260285e-08 0.6615518634257037 6.007416845905097e-08 0.6675161314588195 6.007478116681779e-08 0.6730305013601764 \
6.007535905794417e-08 0.6782315214975446 6.007592173687325e-08 0.6832956318592801 6.007648334276126e-08 0.6883500848513783 6.007707488323627e-08 0.6936739491264482 \
6.007765599364083e-08 0.6989039427675531 6.007823074791064e-08 0.7040767311958204 6.00788319459405e-08 0.7094875134645067 6.007932481118163e-08 0.7139233006347314 \
6.007975183504059e-08 0.7177665153653698 6.008015387325312e-08 0.7213848592781456 6.008053797786439e-08 0.7248418007795954 6.008089808188881e-08 0.728082736999342 \
6.008129097838802e-08 0.731618805492268 6.008135080376212e-08 0.7321572338590965 6.00814704545103e-08 0.7332340905927537 6.008170975600667e-08 0.735387804060068 \
6.008197632210015e-08 0.7377868989013747 6.008227304926134e-08 0.7404574433520882 6.008272938994466e-08 0.7445645095019819 6.008312964185751e-08 0.7481667767176134 \
6.008354241140011e-08 0.7518817026010159 6.008391132891742e-08 0.7552019602568045 6.008433491975726e-08 0.7590142778153435 6.008470452944265e-08 0.762340764983916 \
6.008510473479002e-08 0.7659426131102501 6.008543493825515e-08 0.7689144442964062 6.008570049500366e-08 0.7713044550329466 6.008597025622573e-08 0.7737323060316124 \
6.00863809870304e-08 0.7774288832736076 6.008667585935043e-08 0.7800827341539526 6.008707839699264e-08 0.7837055729337647 6.008742159413382e-08 0.786794347204456 \
6.008777441965341e-08 0.7899697768807414 6.008810170868909e-08 0.7929153782018739 6.00884210221114e-08 0.7957891990026931 6.008872760096025e-08 0.798548408642265 \
6.008902587566532e-08 0.8012328809879466 6.008932084870663e-08 0.8038876383597224 6.008959145927683e-08 0.8063231334915267 6.008986804860275e-08 0.808812437424818 \
6.009015247317017e-08 0.8113722585315476 6.00903934753628e-08 0.813541278265291 6.009066577804522e-08 0.8159920024070124 6.00909709274073e-08 0.8187383466657218 \
6.009127121855881e-08 0.8214409670293247 6.009157648705737e-08 0.8241883835163635 6.009187106798696e-08 0.8268396118826479 6.009219310452811e-08 0.8297379407530008 \
6.009243265402767e-08 0.8318938862491163 6.009268812858413e-08 0.8341931572572034 6.009295074826409e-08 0.8365567343768243 6.00931961574212e-08 0.8387654167908133 \
6.009343071822838e-08 0.8408764640555111 6.009363477444329e-08 0.8427129699896301 6.009384536631582e-08 0.8446082968424707 6.009405600496048e-08 0.8465040446443356 \
6.009424465536319e-08 0.8482018982687493 6.009441931283294e-08 0.8497738154964893 6.009459927891827e-08 0.8513935102645009 6.009476268807612e-08 0.8528641926851036 \
6.009493663077795e-08 0.854429677001575 6.009509164946979e-08 0.8558248452281332 6.009525869490326e-08 0.8573282541293438 6.009541703953808e-08 0.8587533558427882 \
6.009558556135024e-08 0.8602700521522246 6.009574277580943e-08 0.8616849822849083 6.009586144915362e-08 0.8627530423825936 6.009601186791429e-08 0.8641068112286804 \
6.009613649493326e-08 0.865228454399422 6.009629768913074e-08 0.8666792021766703 6.009645446677061e-08 0.8680902009355517 6.009658011685325e-08 0.8692210516792804 \
6.009672405222259e-08 0.8705164700033486 6.009688958843485e-08 0.8720062959137309 6.009705905395212e-08 0.8735314855691456 6.009722443841126e-08 0.8750199457013955 \
6.009739735364894e-08 0.8765761828405442 6.009754860878184e-08 0.8779374790365844 6.009770545583516e-08 0.8793491025165162 6.009783756042612e-08 0.8805380438351178 \
6.009795116890232e-08 0.8815605201209382 6.009806673281797e-08 0.8826005953617506 6.009817394451516e-08 0.8835655006364479 6.009825194963934e-08 0.8842675467541018 \
6.009836920387935e-08 0.8853228349141965 6.009846961351914e-08 0.886226521672304 6.009857728767347e-08 0.8871955890613133 6.009865345234814e-08 0.8878810711332904 \
6.009876090738315e-08 0.8888481664483866 6.009885423081482e-08 0.8896880773334693 6.009895491012407e-08 0.8905941911166799 6.009904970736928e-08 0.8914473663235497 \
6.009913587369029e-08 0.8922228632126831 6.009922632816014e-08 0.8930369534412941 6.009936601707639e-08 0.8942941536875396 6.009948682985209e-08 0.8953814686688766 \
6.009961245929363e-08 0.8965121336427553 6.009975660694623e-08 0.8978094625160885 6.009989290737896e-08 0.8990361664106589 1.000001758102986e-07 0.8984177073129849 \
1.000003877361149e-07 0.8965103749658082 1.000008115877476e-07 0.892695710271455 1.000012928172893e-07 0.8883646443965901 1.000018222188688e-07 0.8836000301806309 \
1.000024138577026e-07 0.8782752806762187 1.000031297402391e-07 0.8718323378482702 1.000040214704179e-07 0.8638067662390768 1.000051855656758e-07 0.8533299089180234 \
1.000067300393038e-07 0.8394296462657486 1.000090477353378e-07 0.8185703819595179 1.000131021755398e-07 0.7820804201414684 1.000204056090592e-07 0.7163495184672377 \
1.000247095522191e-07 0.6776140300278762 1.000277199251216e-07 0.6505206739058862 1.000310010700412e-07 0.6209903696287848 1.000334899484913e-07 0.5985904635786021 \
1.000356256577758e-07 0.5793690800177949 1.000374059763451e-07 0.5633462128944384 1.000390140106705e-07 0.5488739039651435 1.000404831996955e-07 0.5356512027400909 \
1.000418285509597e-07 0.5235430413622801 1.000430428116061e-07 0.512614695545089 1.000441792238918e-07 0.5023869849741911 1.000452298258402e-07 0.4929315674378034 \
1.000462112660969e-07 0.484098605128202 1.000471240497254e-07 0.4758835524716363 1.000480188040211e-07 0.4678307638102979 1.000488469775522e-07 0.4603772020305483 \
1.00049661640793e-07 0.4530452328630955 1.000505037998778e-07 0.4454658010995214 1.000513926171525e-07 0.4374664456271048 1.000521321735227e-07 0.430810438295329 \
1.000530270092319e-07 0.4227569169129836 1.000541079024271e-07 0.4130288781558488 1.000561152622711e-07 0.3949626395600662 1.00056875998171e-07 0.3881160164607345 \
1.000578118664211e-07 0.3796932022097708 1.000584871463134e-07 0.373615683179101 1.000591594028932e-07 0.3675653739608269 1.000599621211418e-07 0.3603409097239061 \
1.000607194141275e-07 0.3535252728520237 1.000614695536323e-07 0.3467740173091934 1.00062198861823e-07 0.3402102435925485 1.000629171974964e-07 0.3337452225319747 \
1.000635435959067e-07 0.3281076368399389 1.000639489157798e-07 0.3244597579820502 1.000644317377765e-07 0.3201143600118136 1.000648010781158e-07 0.3167902969580316 \
1.00065253165156e-07 0.3127215135955985 1.000656846607823e-07 0.3088380529590536 1.00066036022831e-07 0.3056757945211269 1.000662437559126e-07 0.3038061967869528 \
1.000665313819854e-07 0.3012175621312337 1.000667767138012e-07 0.2990095757891347 1.00067080098449e-07 0.2962791139586973 1.00067337968212e-07 0.2939582860917911 \
1.000675842641366e-07 0.2917416227702929 1.000680121406541e-07 0.2878907341130054 1.000684326169099e-07 0.2841064478110101 1.000689744294793e-07 0.2792301346858994 \
1.000694310496987e-07 0.2751205527117666 1.000698649698748e-07 0.2712152711268295 1.00070276250537e-07 0.2675137451671025 1.000707093494526e-07 0.2636158549267912 \
1.000711257521107e-07 0.2598682310032753 1.000715772789096e-07 0.2558044898132805 1.000720198267563e-07 0.2518215591932373 1.000724867531407e-07 0.2476192217332239 \
1.000729779079945e-07 0.2431988280497077 1.000734969797613e-07 0.2385271821480127 1.000740655752672e-07 0.2334098225947888 1.000746646288799e-07 0.2280183400805964 \
1.000752953396527e-07 0.2223419431252401 1.00076027928546e-07 0.2157486430863834 1.000767372312741e-07 0.2093649185333881 1.000774052783738e-07 0.2033524946355669 \
1.000780314861686e-07 0.1977166244827963 1.000786423893507e-07 0.1922184958436388 1.000792377776886e-07 0.1868600008026635 1.00079853866796e-07 0.1813151988360575 \
1.000804543976034e-07 0.1759104215697842 1.000810467364748e-07 0.1705793717271608 1.000816706037987e-07 0.164964565812095 1.000822539901237e-07 0.1597140888870844 \
1.000827867469318e-07 0.1549192776137643 1.000833311463823e-07 0.1500196825588286 1.000838590783176e-07 0.1452682951413614 1.00084435818527e-07 0.1400776332571309 \
1.000850022377844e-07 0.1349798599404549 1.000855520823249e-07 0.1300312590758997 1.000861686813856e-07 0.1244818675298257 1.000866369972226e-07 0.1202670249965557 \
1.000872299951725e-07 0.114930043447014 1.000876909574825e-07 0.1107813826574622 1.000881066844685e-07 0.1070398397831492 1.00088462796911e-07 0.1038348278011874 \
1.000888104250938e-07 0.1007061741557836 1.000891128590561e-07 0.09798426849538755 1.000894173801862e-07 0.09524357832398211 1.000896897024939e-07 0.09279267755476828 \
1.000899532804389e-07 0.09042047604958559 1.000901972751047e-07 0.08822452405742931 1.000904672234071e-07 0.08579498933604146 1.000907063969493e-07 0.08364242745616901 \
1.000909698641177e-07 0.08127122294071432 1.000912247411014e-07 0.07897733008697083 1.000914549713496e-07 0.07690525785341851 1.000917197517262e-07 0.07452223446371342 \
1.00092001524411e-07 0.07198628030108556 1.000922771037338e-07 0.06950606639574286 1.000926178497145e-07 0.06643935256942901 1.000929047711241e-07 0.06385705988345824 \
1.000932105231113e-07 0.06110529199863279 1.000935025276799e-07 0.0584772508810687 1.000937743584833e-07 0.05603077365032616 1.000940213615499e-07 0.05380774605057426 \
1.000942171920341e-07 0.05204527169284134 1.000943943123614e-07 0.05045118874764443 1.000945695254918e-07 0.04887427057365767 1.000947271734062e-07 0.04745543934452334 \
1.000948749691591e-07 0.04612527756805263 1.000950200501117e-07 0.04481954899450691 1.000951580483332e-07 0.0435775650013065 1.000953003028957e-07 0.04229727393901672 \
1.000954263034713e-07 0.04116326875785103 1.000955598319525e-07 0.03996151242777013 1.000956821020666e-07 0.03886108140050326 1.000958151620155e-07 0.0376635418603275 \
1.000959296039086e-07 0.03663356482247337 1.000960217395757e-07 0.03580434381845876 1.000961185938143e-07 0.03493265567158488 1.000962580032994e-07 0.03367797030500419 \
1.000963723296091e-07 0.03264903351765647 1.000964819349537e-07 0.03166258541696143 1.000966151874731e-07 0.03046331274235659 1.000967280577828e-07 0.02944747995458197 \
1.000968505551189e-07 0.02834500393025741 1.000969864971123e-07 0.02712152598905548 1.000971045042059e-07 0.02605946214676502 1.000972335603972e-07 0.02489795642556891 \
1.000973440508587e-07 0.02390354227171532 1.000974794893149e-07 0.02268459616553509 1.000975991229856e-07 0.02160789312944722 1.000977000043597e-07 0.02069996076227698 \
1.000978203514515e-07 0.01961683693679572 1.000979616112103e-07 0.01834549910740102 1.000981236968955e-07 0.01688672794015589 1.000982728348491e-07 0.01554448635840755 \
1.000984257131347e-07 0.014168581787533 1.000985760067313e-07 0.01281593941858328 1.000987228351463e-07 0.01149448368366224 1.000988791913148e-07 0.01008727816647481 \
1.000989984546065e-07 0.009013908541385951 1.000990930871204e-07 0.008162215916559523 1.000991965644665e-07 0.007230919801462066 1.000992690484371e-07 0.006578564066408443 \
1.00099347396487e-07 0.005873431617253289 1.000994370778813e-07 0.005066299068704372 1.000995698899392e-07 0.003870990547362063 1.000996714898243e-07 0.002956591581575796 \
1.000997774547152e-07 0.002002907563398826 1.000998932860907e-07 0.000960425183447966 1.589900000000113e-07 0 1.599999999999961e-07 0 \
1.600002111634403e-07 0.001900470962571042 1.600004424445472e-07 0.003982000924727166 1.60000905006761e-07 0.008145060849039413 1.600013623206272e-07 0.01226088564504064 \
1.600018368035255e-07 0.01653123172985639 1.600023692993677e-07 0.02132369430982749 1.600030391819417e-07 0.02735263747515369 1.600038962860512e-07 0.03506657446094884 \
1.600050110320463e-07 0.04509928841663746 1.600066320296376e-07 0.05968826673863754 1.600089746991287e-07 0.08077229215837188 1.600136600381109e-07 0.1229403429978405 \
1.600179644652404e-07 0.1616801871633537 1.600218144069515e-07 0.1963296625632528 1.600260784839173e-07 0.2347063552562001 1.600291484812914e-07 0.2623363316230807 \
1.600316114214461e-07 0.2845027930151538 1.600335732345164e-07 0.3021591106476817 1.600352830299905e-07 0.3175472699147922 1.600367866217311e-07 0.3310795955797556 \
1.600381257194662e-07 0.3431314751960884 1.600393723992329e-07 0.3543515930958913 1.60040514338907e-07 0.3646290501629268 1.60041572311447e-07 0.3741508030226791 \
1.600425813571893e-07 0.3832322147042228 1.600436002602279e-07 0.3924023420515681 1.60044556738474e-07 0.4010106462662745 1.60045504571866e-07 0.4095411467944404 \
1.600463681471743e-07 0.4173133245688312 1.600471108484519e-07 0.423997636067712 1.600477705629023e-07 0.4299350661209142 1.600484650928601e-07 0.4361858357407548 \
1.600491344399726e-07 0.4422099597530631 1.600497450055524e-07 0.4477050499714701 1.600505211590361e-07 0.454690431324675 1.600515775830367e-07 0.4641982473299416 \
1.600525733032824e-07 0.4731597295416305 1.600534391469966e-07 0.4809523229693754 1.600543752979998e-07 0.4893776819979773 1.600551017667356e-07 0.4959159006203305 \
1.600557679847268e-07 0.5019118625413875 1.600563829589108e-07 0.5074466301974319 1.600571676584685e-07 0.5145089262167936 1.600578769318571e-07 0.5208923867144013 \
1.60058576728557e-07 0.5271905570126808 1.600592411431324e-07 0.5331702881913303 1.600598964737337e-07 0.539068263602977 1.600605357980541e-07 0.5448221824871196 \
1.600611259457622e-07 0.5501335118600457 1.600616532498143e-07 0.5548792483285057 1.60062030104965e-07 0.5582709446854013 1.600624256351614e-07 0.5618307164525158 \
1.600627887403595e-07 0.5650986632355098 1.600631651750106e-07 0.5684865750957045 1.600635131548222e-07 0.5716183933999566 1.600637778468606e-07 0.5740006217454657 \
1.600640429855227e-07 0.5763868697045537 1.60064573262847e-07 0.5811593656227293 1.60064959313826e-07 0.5846338244342608 1.600653682102066e-07 0.5883138918597329 \
1.600658706357605e-07 0.5928357218442383 1.6006645565012e-07 0.5981008510799999 1.60066996785185e-07 0.6029710666652875 1.600674171443549e-07 0.6067542991940013 \
1.600678249828083e-07 0.6104248452748176 1.600682323094902e-07 0.6140907854118068 1.60068642157613e-07 0.6177794185173828 1.600690657994417e-07 0.62159219497586 \
1.600695100372108e-07 0.6255903348973357 1.600699667685954e-07 0.6297009173589793 1.600704445460431e-07 0.6340009143882042 1.600709750893296e-07 0.6387758039669345 \
1.600715414714156e-07 0.6438732427407217 1.600721454221393e-07 0.6493087992533674 1.60072793381625e-07 0.6551404346247349 1.600735057626029e-07 0.6615518634257037 \
1.60074168459051e-07 0.6675161314588195 1.600747811668178e-07 0.6730305013601764 1.600753590579442e-07 0.6782315214975446 1.600759217368733e-07 0.6832956318592801 \
1.600764833427612e-07 0.6883500848513783 1.600770748832363e-07 0.6936739491264482 1.600776559936408e-07 0.6989039427675531 1.600782307479106e-07 0.7040767311958204 \
1.600788319459405e-07 0.7094875134645067 1.600793248111816e-07 0.7139233006347314 1.600797518350406e-07 0.7177665153653698 1.600801538732531e-07 0.7213848592781456 \
1.600805379778644e-07 0.7248418007795954 1.600808980818888e-07 0.728082736999342 1.60081290978388e-07 0.731618805492268 1.600813508037621e-07 0.7321572338590965 \
1.600814704545103e-07 0.7332340905927537 1.600817097560067e-07 0.735387804060068 1.600819763221001e-07 0.7377868989013747 1.600822730492613e-07 0.7404574433520882 \
1.600827293899447e-07 0.7445645095019819 1.600831296418575e-07 0.7481667767176134 1.600835424114001e-07 0.7518817026010159 1.600839113289174e-07 0.7552019602568045 \
1.600843349197573e-07 0.7590142778153435 1.600847045294427e-07 0.762340764983916 1.6008510473479e-07 0.7659426131102501 1.600854349382551e-07 0.7689144442964062 \
1.600857004950036e-07 0.7713044550329466 1.600859702562257e-07 0.7737323060316124 1.600863809870304e-07 0.7774288832736076 1.600866758593504e-07 0.7800827341539526 \
1.600870783969926e-07 0.7837055729337647 1.600874215941338e-07 0.786794347204456 1.600877744196534e-07 0.7899697768807414 1.600881017086891e-07 0.7929153782018739 \
1.600884210221114e-07 0.7957891990026931 1.600887276009602e-07 0.798548408642265 1.600890258756653e-07 0.8012328809879466 1.600893208487066e-07 0.8038876383597224 \
1.600895914592768e-07 0.8063231334915267 1.600898680486027e-07 0.808812437424818 1.600901524731701e-07 0.8113722585315476 1.600903934753628e-07 0.813541278265291 \
1.600906657780452e-07 0.8159920024070124 1.600909709274073e-07 0.8187383466657218 1.600912712185588e-07 0.8214409670293247 1.600915764870574e-07 0.8241883835163635 \
1.60091871067987e-07 0.8268396118826479 1.600921931045281e-07 0.8297379407530008 1.600924326540277e-07 0.8318938862491163 1.600926881285841e-07 0.8341931572572034 \
1.600929507482641e-07 0.8365567343768243 1.600931961574212e-07 0.8387654167908133 1.600934307182284e-07 0.8408764640555111 1.600936347744433e-07 0.8427129699896301 \
1.600938453663158e-07 0.8446082968424707 1.600940560049605e-07 0.8465040446443356 1.600942446553632e-07 0.8482018982687493 1.600944193128329e-07 0.8497738154964893 \
1.600945992789183e-07 0.8513935102645009 1.600947626880761e-07 0.8528641926851036 1.600949366307779e-07 0.854429677001575 1.600950916494698e-07 0.8558248452281332 \
1.600952586949033e-07 0.8573282541293438 1.600954170395381e-07 0.8587533558427882 1.600955855613502e-07 0.8602700521522246 1.600957427758094e-07 0.8616849822849083 \
1.600958614491536e-07 0.8627530423825936 1.600960118679143e-07 0.8641068112286804 1.600961364949333e-07 0.865228454399422 1.600962976891307e-07 0.8666792021766703 \
1.600964544667706e-07 0.8680902009355517 1.600965801168532e-07 0.8692210516792804 1.600967240522226e-07 0.8705164700033486 1.600968895884348e-07 0.8720062959137309 \
1.600970590539521e-07 0.8735314855691456 1.600972244384113e-07 0.8750199457013955 1.60097397353649e-07 0.8765761828405442 1.600975486087818e-07 0.8779374790365844 \
1.600977054558352e-07 0.8793491025165162 1.600978375604261e-07 0.8805380438351178 1.600979511689023e-07 0.8815605201209382 1.600980667328179e-07 0.8826005953617506 \
1.600981739445152e-07 0.8835655006364479 1.600982519496393e-07 0.8842675467541018 1.600983692038793e-07 0.8853228349141965 1.600984696135191e-07 0.886226521672304 \
1.600985772876735e-07 0.8871955890613133 1.600986534523481e-07 0.8878810711332904 1.600987609073832e-07 0.8888481664483866 1.600988542308148e-07 0.8896880773334693 \
1.600989549101241e-07 0.8905941911166799 1.600990497073693e-07 0.8914473663235497 1.600991358736903e-07 0.8922228632126831 1.600992263281601e-07 0.8930369534412941 \
1.600993660170764e-07 0.8942941536875396 1.600994868298521e-07 0.8953814686688766 1.600996124592936e-07 0.8965121336427553 1.600997566069462e-07 0.8978094625160885 \
1.60099892907379e-07 0.8990361664106589 2.000001758102986e-07 0.8984177073129849 2.000003877361149e-07 0.8965103749658082 2.000008115877476e-07 0.892695710271455 \
2.000012928172893e-07 0.8883646443965901 2.000018222188688e-07 0.8836000301806309 2.000024138577026e-07 0.8782752806762187 2.000031297402391e-07 0.8718323378482702 \
2.000040214704179e-07 0.8638067662390768 2.000051855656758e-07 0.8533299089180234 2.000067300393038e-07 0.8394296462657486 2.000090477353378e-07 0.8185703819595179 \
2.000131021755398e-07 0.7820804201414684 2.000204056090592e-07 0.7163495184672377 2.000247095522191e-07 0.6776140300278762 2.000277199251216e-07 0.6505206739058862 \
2.000310010700412e-07 0.6209903696287848 2.000334899484913e-07 0.5985904635786021 2.000356256577758e-07 0.5793690800177949 2.000374059763451e-07 0.5633462128944384 \
2.000390140106705e-07 0.5488739039651435 2.000404831996955e-07 0.5356512027400909 2.000418285509597e-07 0.5235430413622801 2.000430428116061e-07 0.512614695545089 \
2.000441792238918e-07 0.5023869849741911 2.000452298258402e-07 0.4929315674378034 2.000462112660969e-07 0.484098605128202 2.000471240497254e-07 0.4758835524716363 \
2.000480188040211e-07 0.4678307638102979 2.000488469775522e-07 0.4603772020305483 2.00049661640793e-07 0.4530452328630955 2.000505037998778e-07 0.4454658010995214 \
2.000513926171525e-07 0.4374664456271048 2.000521321735227e-07 0.430810438295329 2.000530270092319e-07 0.4227569169129836 2.000541079024271e-07 0.4130288781558488 \
2.000561152622711e-07 0.3949626395600662 2.00056875998171e-07 0.3881160164607345 2.000578118664211e-07 0.3796932022097708 2.000584871463134e-07 0.373615683179101 \
2.000591594028932e-07 0.3675653739608269 2.000599621211418e-07 0.3603409097239061 2.000607194141275e-07 0.3535252728520237 2.000614695536323e-07 0.3467740173091934 \
2.00062198861823e-07 0.3402102435925485 2.000629171974964e-07 0.3337452225319747 2.000635435959067e-07 0.3281076368399389 2.000639489157798e-07 0.3244597579820502 \
2.000644317377765e-07 0.3201143600118136 2.000648010781158e-07 0.3167902969580316 2.00065253165156e-07 0.3127215135955985 2.000656846607823e-07 0.3088380529590536 \
2.00066036022831e-07 0.3056757945211269 2.000662437559126e-07 0.3038061967869528 2.000665313819854e-07 0.3012175621312337 2.000667767138012e-07 0.2990095757891347 \
2.00067080098449e-07 0.2962791139586973 2.00067337968212e-07 0.2939582860917911 2.000675842641366e-07 0.2917416227702929 2.000680121406541e-07 0.2878907341130054 \
2.000684326169099e-07 0.2841064478110101 2.000689744294793e-07 0.2792301346858994 2.000694310496987e-07 0.2751205527117666 2.000698649698748e-07 0.2712152711268295 \
2.00070276250537e-07 0.2675137451671025 2.000707093494526e-07 0.2636158549267912 2.000711257521107e-07 0.2598682310032753 2.000715772789096e-07 0.2558044898132805 \
2.000720198267563e-07 0.2518215591932373 2.000724867531407e-07 0.2476192217332239 2.000729779079945e-07 0.2431988280497077 2.000734969797613e-07 0.2385271821480127 \
2.000740655752672e-07 0.2334098225947888 2.000746646288799e-07 0.2280183400805964 2.000752953396527e-07 0.2223419431252401 2.00076027928546e-07 0.2157486430863834 \
2.000767372312741e-07 0.2093649185333881 2.000774052783738e-07 0.2033524946355669 2.000780314861686e-07 0.1977166244827963 2.000786423893507e-07 0.1922184958436388 \
2.000792377776886e-07 0.1868600008026635 2.00079853866796e-07 0.1813151988360575 2.000804543976034e-07 0.1759104215697842 2.000810467364748e-07 0.1705793717271608 \
2.000816706037987e-07 0.164964565812095 2.000822539901237e-07 0.1597140888870844 2.000827867469318e-07 0.1549192776137643 2.000833311463823e-07 0.1500196825588286 \
2.000838590783176e-07 0.1452682951413614 2.00084435818527e-07 0.1400776332571309 2.000850022377844e-07 0.1349798599404549 2.000855520823249e-07 0.1300312590758997 \
2.000861686813856e-07 0.1244818675298257 2.000866369972226e-07 0.1202670249965557 2.000872299951725e-07 0.114930043447014 2.000876909574825e-07 0.1107813826574622 \
2.000881066844685e-07 0.1070398397831492 2.00088462796911e-07 0.1038348278011874 2.000888104250938e-07 0.1007061741557836 2.000891128590561e-07 0.09798426849538755 \
2.000894173801862e-07 0.09524357832398211 2.000896897024939e-07 0.09279267755476828 2.000899532804389e-07 0.09042047604958559 2.000901972751047e-07 0.08822452405742931 \
2.000904672234071e-07 0.08579498933604146 2.000907063969493e-07 0.08364242745616901 2.000909698641177e-07 0.08127122294071432 2.000912247411014e-07 0.07897733008697083 \
2.000914549713496e-07 0.07690525785341851 2.000917197517262e-07 0.07452223446371342 2.00092001524411e-07 0.07198628030108556 2.000922771037338e-07 0.06950606639574286 \
2.000926178497145e-07 0.06643935256942901 2.000929047711241e-07 0.06385705988345824 2.000932105231113e-07 0.06110529199863279 2.000935025276799e-07 0.0584772508810687 \
2.000937743584833e-07 0.05603077365032616 2.000940213615499e-07 0.05380774605057426 2.000942171920341e-07 0.05204527169284134 2.000943943123614e-07 0.05045118874764443 \
2.000945695254918e-07 0.04887427057365767 2.000947271734062e-07 0.04745543934452334 2.000948749691591e-07 0.04612527756805263 2.000950200501117e-07 0.04481954899450691 \
2.000951580483332e-07 0.0435775650013065 2.000953003028957e-07 0.04229727393901672 2.000954263034713e-07 0.04116326875785103 2.000955598319525e-07 0.03996151242777013 \
2.000956821020666e-07 0.03886108140050326 2.000958151620155e-07 0.0376635418603275 2.000959296039086e-07 0.03663356482247337 2.000960217395757e-07 0.03580434381845876 \
2.000961185938143e-07 0.03493265567158488 2.000962580032994e-07 0.03367797030500419 2.000963723296091e-07 0.03264903351765647 2.000964819349537e-07 0.03166258541696143 \
2.000966151874731e-07 0.03046331274235659 2.000967280577828e-07 0.02944747995458197 2.000968505551189e-07 0.02834500393025741 2.000969864971123e-07 0.02712152598905548 \
2.000971045042059e-07 0.02605946214676502 2.000972335603972e-07 0.02489795642556891 2.000973440508587e-07 0.02390354227171532 2.000974794893149e-07 0.02268459616553509 \
2.000975991229856e-07 0.02160789312944722 2.000977000043597e-07 0.02069996076227698 2.000978203514515e-07 0.01961683693679572 2.000979616112103e-07 0.01834549910740102 \
2.000981236968955e-07 0.01688672794015589 2.000982728348491e-07 0.01554448635840755 2.000984257131347e-07 0.014168581787533 2.000985760067313e-07 0.01281593941858328 \
2.000987228351463e-07 0.01149448368366224 2.000988791913148e-07 0.01008727816647481 2.000989984546065e-07 0.009013908541385951 2.000990930871204e-07 0.008162215916559523 \
2.000991965644665e-07 0.007230919801462066 2.000992690484371e-07 0.006578564066408443 2.00099347396487e-07 0.005873431617253289 2.000994370778813e-07 0.005066299068704372 \
2.000995698899392e-07 0.003870990547362063 2.000996714898243e-07 0.002956591581575796 2.000997774547152e-07 0.002002907563398826 2.000998932860907e-07 0.000960425183447966 \
2.589900000000113e-07 0 2.599999999999961e-07 0 2.600002111634403e-07 0.001900470962571042 2.600004424445472e-07 0.003982000924727166 \
2.60000905006761e-07 0.008145060849039413 2.600013623206272e-07 0.01226088564504064 2.600018368035255e-07 0.01653123172985639 2.600023692993678e-07 0.02132369430982749 \
2.600030391819417e-07 0.02735263747515369 2.600038962860512e-07 0.03506657446094884 2.600050110320463e-07 0.04509928841663746 2.600066320296376e-07 0.05968826673863754 \
2.600089746991287e-07 0.08077229215837188 2.600136600381109e-07 0.1229403429978405 2.600179644652404e-07 0.1616801871633537 2.600218144069515e-07 0.1963296625632528 \
2.600260784839173e-07 0.2347063552562001 2.600291484812914e-07 0.2623363316230807 2.600316114214461e-07 0.2845027930151538 2.600335732345164e-07 0.3021591106476817 \
2.600352830299905e-07 0.3175472699147922 2.600367866217311e-07 0.3310795955797556 2.600381257194662e-07 0.3431314751960884 2.600393723992329e-07 0.3543515930958913 \
2.60040514338907e-07 0.3646290501629268 2.600415723114469e-07 0.3741508030226791 2.600425813571893e-07 0.3832322147042228 2.600436002602279e-07 0.3924023420515681 \
2.60044556738474e-07 0.4010106462662745 2.60045504571866e-07 0.4095411467944404 2.600463681471743e-07 0.4173133245688312 2.600471108484519e-07 0.423997636067712 \
2.600477705629023e-07 0.4299350661209142 2.600484650928601e-07 0.4361858357407548 2.600491344399726e-07 0.4422099597530631 2.600497450055524e-07 0.4477050499714701 \
2.600505211590361e-07 0.454690431324675 2.600515775830367e-07 0.4641982473299416 2.600525733032824e-07 0.4731597295416305 2.600534391469966e-07 0.4809523229693754 \
2.600543752979998e-07 0.4893776819979773 2.600551017667356e-07 0.4959159006203305 2.600557679847268e-07 0.5019118625413875 2.600563829589108e-07 0.5074466301974319 \
2.600571676584685e-07 0.5145089262167936 2.600578769318571e-07 0.5208923867144013 2.60058576728557e-07 0.5271905570126808 2.600592411431324e-07 0.5331702881913303 \
2.600598964737336e-07 0.539068263602977 2.600605357980541e-07 0.5448221824871196 2.600611259457622e-07 0.5501335118600457 2.600616532498142e-07 0.5548792483285057 \
2.60062030104965e-07 0.5582709446854013 2.600624256351614e-07 0.5618307164525158 2.600627887403595e-07 0.5650986632355098 2.600631651750106e-07 0.5684865750957045 \
2.600635131548222e-07 0.5716183933999566 2.600637778468606e-07 0.5740006217454657 2.600640429855227e-07 0.5763868697045537 2.60064573262847e-07 0.5811593656227293 \
2.60064959313826e-07 0.5846338244342608 2.600653682102066e-07 0.5883138918597329 2.600658706357605e-07 0.5928357218442383 2.6006645565012e-07 0.5981008510799999 \
2.60066996785185e-07 0.6029710666652875 2.600674171443549e-07 0.6067542991940013 2.600678249828083e-07 0.6104248452748176 2.600682323094902e-07 0.6140907854118068 \
2.600686421576131e-07 0.6177794185173828 2.600690657994417e-07 0.62159219497586 2.600695100372108e-07 0.6255903348973357 2.600699667685954e-07 0.6297009173589793 \
2.600704445460431e-07 0.6340009143882042 2.600709750893296e-07 0.6387758039669345 2.600715414714156e-07 0.6438732427407217 2.600721454221392e-07 0.6493087992533674 \
2.60072793381625e-07 0.6551404346247349 2.600735057626029e-07 0.6615518634257037 2.600741684590509e-07 0.6675161314588195 2.600747811668178e-07 0.6730305013601764 \
2.600753590579442e-07 0.6782315214975446 2.600759217368733e-07 0.6832956318592801 2.600764833427612e-07 0.6883500848513783 2.600770748832363e-07 0.6936739491264482 \
2.600776559936408e-07 0.6989039427675531 2.600782307479106e-07 0.7040767311958204 2.600788319459405e-07 0.7094875134645067 2.600793248111816e-07 0.7139233006347314 \
2.600797518350406e-07 0.7177665153653698 2.600801538732531e-07 0.7213848592781456 2.600805379778644e-07 0.7248418007795954 2.600808980818888e-07 0.728082736999342 \
2.60081290978388e-07 0.731618805492268 2.600813508037621e-07 0.7321572338590965 2.600814704545103e-07 0.7332340905927537 2.600817097560066e-07 0.735387804060068 \
2.600819763221002e-07 0.7377868989013747 2.600822730492613e-07 0.7404574433520882 2.600827293899446e-07 0.7445645095019819 2.600831296418575e-07 0.7481667767176134 \
2.600835424114001e-07 0.7518817026010159 2.600839113289174e-07 0.7552019602568045 2.600843349197573e-07 0.7590142778153435 2.600847045294427e-07 0.762340764983916 \
2.6008510473479e-07 0.7659426131102501 2.600854349382552e-07 0.7689144442964062 2.600857004950036e-07 0.7713044550329466 2.600859702562257e-07 0.7737323060316124 \
2.600863809870304e-07 0.7774288832736076 2.600866758593504e-07 0.7800827341539526 2.600870783969926e-07 0.7837055729337647 2.600874215941338e-07 0.786794347204456 \
2.600877744196534e-07 0.7899697768807414 2.600881017086891e-07 0.7929153782018739 2.600884210221114e-07 0.7957891990026931 2.600887276009602e-07 0.798548408642265 \
2.600890258756653e-07 0.8012328809879466 2.600893208487066e-07 0.8038876383597224 2.600895914592768e-07 0.8063231334915267 2.600898680486027e-07 0.808812437424818 \
2.600901524731701e-07 0.8113722585315476 2.600903934753628e-07 0.813541278265291 2.600906657780452e-07 0.8159920024070124 2.600909709274073e-07 0.8187383466657218 \
2.600912712185588e-07 0.8214409670293247 2.600915764870574e-07 0.8241883835163635 2.600918710679869e-07 0.8268396118826479 2.600921931045281e-07 0.8297379407530008 \
2.600924326540277e-07 0.8318938862491163 2.600926881285841e-07 0.8341931572572034 2.600929507482641e-07 0.8365567343768243 2.600931961574212e-07 0.8387654167908133 \
2.600934307182284e-07 0.8408764640555111 2.600936347744433e-07 0.8427129699896301 2.600938453663158e-07 0.8446082968424707 2.600940560049605e-07 0.8465040446443356 \
2.600942446553632e-07 0.8482018982687493 2.600944193128329e-07 0.8497738154964893 2.600945992789183e-07 0.8513935102645009 2.600947626880761e-07 0.8528641926851036 \
2.600949366307779e-07 0.854429677001575 2.600950916494698e-07 0.8558248452281332 2.600952586949032e-07 0.8573282541293438 2.600954170395381e-07 0.8587533558427882 \
2.600955855613503e-07 0.8602700521522246 2.600957427758094e-07 0.8616849822849083 2.600958614491536e-07 0.8627530423825936 2.600960118679143e-07 0.8641068112286804 \
2.600961364949332e-07 0.865228454399422 2.600962976891307e-07 0.8666792021766703 2.600964544667706e-07 0.8680902009355517 2.600965801168532e-07 0.8692210516792804 \
2.600967240522226e-07 0.8705164700033486 2.600968895884348e-07 0.8720062959137309 2.600970590539521e-07 0.8735314855691456 2.600972244384113e-07 0.8750199457013955 \
2.600973973536489e-07 0.8765761828405442 2.600975486087818e-07 0.8779374790365844 2.600977054558352e-07 0.8793491025165162 2.600978375604261e-07 0.8805380438351178 \
2.600979511689023e-07 0.8815605201209382 2.600980667328179e-07 0.8826005953617506 2.600981739445152e-07 0.8835655006364479 2.600982519496393e-07 0.8842675467541018 \
2.600983692038793e-07 0.8853228349141965 2.600984696135191e-07 0.886226521672304 2.600985772876734e-07 0.8871955890613133 2.600986534523481e-07 0.8878810711332904 \
2.600987609073832e-07 0.8888481664483866 2.600988542308148e-07 0.8896880773334693 2.600989549101241e-07 0.8905941911166799 2.600990497073693e-07 0.8914473663235497 \
2.600991358736903e-07 0.8922228632126831 2.600992263281602e-07 0.8930369534412941 2.600993660170764e-07 0.8942941536875396 2.600994868298521e-07 0.8953814686688766 \
2.600996124592936e-07 0.8965121336427553 2.600997566069462e-07 0.8978094625160885 2.600998929073789e-07 0.8990361664106589 3.000001758102986e-07 0.8984177073129849 \
3.000003877361149e-07 0.8965103749658082 3.000008115877476e-07 0.892695710271455 3.000012928172893e-07 0.8883646443965901 3.000018222188688e-07 0.8836000301806309 \
3.000024138577026e-07 0.8782752806762187 3.000031297402391e-07 0.8718323378482702 3.000040214704179e-07 0.8638067662390768 3.000051855656758e-07 0.8533299089180234 \
3.000067300393038e-07 0.8394296462657486 3.000090477353378e-07 0.8185703819595179 3.000131021755398e-07 0.7820804201414684 3.000204056090592e-07 0.7163495184672377 \
3.000247095522191e-07 0.6776140300278762 3.000277199251216e-07 0.6505206739058862 3.000310010700412e-07 0.6209903696287848 3.000334899484913e-07 0.5985904635786021 \
3.000356256577758e-07 0.5793690800177949 3.000374059763451e-07 0.5633462128944384 3.000390140106705e-07 0.5488739039651435 3.000404831996955e-07 0.5356512027400909 \
3.000418285509597e-07 0.5235430413622801 3.000430428116061e-07 0.512614695545089 3.000441792238918e-07 0.5023869849741911 3.000452298258402e-07 0.4929315674378034 \
3.000462112660969e-07 0.484098605128202 3.000471240497254e-07 0.4758835524716363 3.000480188040211e-07 0.4678307638102979 3.000488469775522e-07 0.4603772020305483 \
3.00049661640793e-07 0.4530452328630955 3.000505037998778e-07 0.4454658010995214 3.000513926171525e-07 0.4374664456271048 3.000521321735227e-07 0.430810438295329 \
3.000530270092319e-07 0.4227569169129836 3.000541079024271e-07 0.4130288781558488 3.000561152622711e-07 0.3949626395600662 3.00056875998171e-07 0.3881160164607345 \
3.000578118664211e-07 0.3796932022097708 3.000584871463134e-07 0.373615683179101 3.000591594028932e-07 0.3675653739608269 3.000599621211418e-07 0.3603409097239061 \
3.000607194141275e-07 0.3535252728520237 3.000614695536323e-07 0.3467740173091934 3.00062198861823e-07 0.3402102435925485 3.000629171974964e-07 0.3337452225319747 \
3.000635435959067e-07 0.3281076368399389 3.000639489157798e-07 0.3244597579820502 3.000644317377765e-07 0.3201143600118136 3.000648010781158e-07 0.3167902969580316 \
3.00065253165156e-07 0.3127215135955985 3.000656846607823e-07 0.3088380529590536 3.00066036022831e-07 0.3056757945211269 3.000662437559126e-07 0.3038061967869528 \
3.000665313819854e-07 0.3012175621312337 3.000667767138012e-07 0.2990095757891347 3.00067080098449e-07 0.2962791139586973 3.00067337968212e-07 0.2939582860917911 \
3.000675842641366e-07 0.2917416227702929 3.000680121406541e-07 0.2878907341130054 3.000684326169099e-07 0.2841064478110101 3.000689744294793e-07 0.2792301346858994 \
3.000694310496987e-07 0.2751205527117666 3.000698649698748e-07 0.2712152711268295 3.00070276250537e-07 0.2675137451671025 3.000707093494526e-07 0.2636158549267912 \
3.000711257521107e-07 0.2598682310032753 3.000715772789096e-07 0.2558044898132805 3.000720198267563e-07 0.2518215591932373 3.000724867531407e-07 0.2476192217332239 \
3.000729779079945e-07 0.2431988280497077 3.000734969797613e-07 0.2385271821480127 3.000740655752672e-07 0.2334098225947888 3.000746646288799e-07 0.2280183400805964 \
3.000752953396527e-07 0.2223419431252401 3.00076027928546e-07 0.2157486430863834 3.000767372312741e-07 0.2093649185333881 3.000774052783738e-07 0.2033524946355669 \
3.000780314861686e-07 0.1977166244827963 3.000786423893507e-07 0.1922184958436388 3.000792377776886e-07 0.1868600008026635 3.00079853866796e-07 0.1813151988360575 \
3.000804543976034e-07 0.1759104215697842 3.000810467364748e-07 0.1705793717271608 3.000816706037987e-07 0.164964565812095 3.000822539901237e-07 0.1597140888870844 \
3.000827867469318e-07 0.1549192776137643 3.000833311463823e-07 0.1500196825588286 3.000838590783176e-07 0.1452682951413614 3.00084435818527e-07 0.1400776332571309 \
3.000850022377844e-07 0.1349798599404549 3.000855520823249e-07 0.1300312590758997 3.000861686813856e-07 0.1244818675298257 3.000866369972226e-07 0.1202670249965557 \
3.000872299951725e-07 0.114930043447014 3.000876909574825e-07 0.1107813826574622 3.000881066844685e-07 0.1070398397831492 3.00088462796911e-07 0.1038348278011874 \
3.000888104250938e-07 0.1007061741557836 3.000891128590561e-07 0.09798426849538755 3.000894173801862e-07 0.09524357832398211 3.000896897024939e-07 0.09279267755476828 \
3.000899532804389e-07 0.09042047604958559 3.000901972751047e-07 0.08822452405742931 3.000904672234071e-07 0.08579498933604146 3.000907063969493e-07 0.08364242745616901 \
3.000909698641177e-07 0.08127122294071432 3.000912247411014e-07 0.07897733008697083 3.000914549713496e-07 0.07690525785341851 3.000917197517262e-07 0.07452223446371342 \
3.00092001524411e-07 0.07198628030108556 3.000922771037338e-07 0.06950606639574286 3.000926178497145e-07 0.06643935256942901 3.000929047711241e-07 0.06385705988345824 \
3.000932105231113e-07 0.06110529199863279 3.000935025276799e-07 0.0584772508810687 3.000937743584833e-07 0.05603077365032616 3.000940213615499e-07 0.05380774605057426 \
3.000942171920341e-07 0.05204527169284134 3.000943943123614e-07 0.05045118874764443 3.000945695254918e-07 0.04887427057365767 3.000947271734062e-07 0.04745543934452334 \
3.000948749691591e-07 0.04612527756805263 3.000950200501117e-07 0.04481954899450691 3.000951580483332e-07 0.0435775650013065 3.000953003028957e-07 0.04229727393901672 \
3.000954263034713e-07 0.04116326875785103 3.000955598319525e-07 0.03996151242777013 3.000956821020666e-07 0.03886108140050326 3.000958151620155e-07 0.0376635418603275 \
3.000959296039086e-07 0.03663356482247337 3.000960217395757e-07 0.03580434381845876 3.000961185938143e-07 0.03493265567158488 3.000962580032994e-07 0.03367797030500419 \
3.000963723296091e-07 0.03264903351765647 3.000964819349537e-07 0.03166258541696143 3.000966151874731e-07 0.03046331274235659 3.000967280577828e-07 0.02944747995458197 \
3.000968505551189e-07 0.02834500393025741 3.000969864971123e-07 0.02712152598905548 3.000971045042059e-07 0.02605946214676502 3.000972335603972e-07 0.02489795642556891 \
3.000973440508587e-07 0.02390354227171532 3.000974794893149e-07 0.02268459616553509 3.000975991229856e-07 0.02160789312944722 3.000977000043597e-07 0.02069996076227698 \
3.000978203514515e-07 0.01961683693679572 3.000979616112103e-07 0.01834549910740102 3.000981236968955e-07 0.01688672794015589 3.000982728348491e-07 0.01554448635840755 \
3.000984257131347e-07 0.014168581787533 3.000985760067313e-07 0.01281593941858328 3.000987228351463e-07 0.01149448368366224 3.000988791913148e-07 0.01008727816647481 \
3.000989984546065e-07 0.009013908541385951 3.000990930871204e-07 0.008162215916559523 3.000991965644665e-07 0.007230919801462066 3.000992690484371e-07 0.006578564066408443 \
3.00099347396487e-07 0.005873431617253289 3.000994370778813e-07 0.005066299068704372 3.000995698899392e-07 0.003870990547362063 3.000996714898243e-07 0.002956591581575796 \
3.000997774547152e-07 0.002002907563398826 3.000998932860907e-07 0.000960425183447966 3.589900000000113e-07 0 3.599999999999961e-07 0 \
3.600002111634403e-07 0.001900470962571042 3.600004424445472e-07 0.003982000924727166 3.60000905006761e-07 0.008145060849039413 3.600013623206272e-07 0.01226088564504064 \
3.600018368035255e-07 0.01653123172985639 3.600023692993678e-07 0.02132369430982749 3.600030391819417e-07 0.02735263747515369 3.600038962860512e-07 0.03506657446094884 \
3.600050110320463e-07 0.04509928841663746 3.600066320296376e-07 0.05968826673863754 3.600089746991287e-07 0.08077229215837188 3.600136600381109e-07 0.1229403429978405 \
3.600179644652404e-07 0.1616801871633537 3.600218144069515e-07 0.1963296625632528 3.600260784839173e-07 0.2347063552562001 3.600291484812914e-07 0.2623363316230807 \
3.600316114214461e-07 0.2845027930151538 3.600335732345164e-07 0.3021591106476817 3.600352830299905e-07 0.3175472699147922 3.600367866217311e-07 0.3310795955797556 \
3.600381257194662e-07 0.3431314751960884 3.600393723992329e-07 0.3543515930958913 3.60040514338907e-07 0.3646290501629268 3.600415723114469e-07 0.3741508030226791 \
3.600425813571893e-07 0.3832322147042228 3.600436002602279e-07 0.3924023420515681 3.60044556738474e-07 0.4010106462662745 3.60045504571866e-07 0.4095411467944404 \
3.600463681471743e-07 0.4173133245688312 3.600471108484519e-07 0.423997636067712 3.600477705629023e-07 0.4299350661209142 3.600484650928601e-07 0.4361858357407548 \
3.600491344399726e-07 0.4422099597530631 3.600497450055524e-07 0.4477050499714701 3.600505211590361e-07 0.454690431324675 3.600515775830367e-07 0.4641982473299416 \
3.600525733032824e-07 0.4731597295416305 3.600534391469966e-07 0.4809523229693754 3.600543752979998e-07 0.4893776819979773 3.600551017667356e-07 0.4959159006203305 \
3.600557679847268e-07 0.5019118625413875 3.600563829589108e-07 0.5074466301974319 3.600571676584685e-07 0.5145089262167936 3.600578769318571e-07 0.5208923867144013 \
3.600585767285569e-07 0.5271905570126808 3.600592411431324e-07 0.5331702881913303 3.600598964737336e-07 0.539068263602977 3.600605357980541e-07 0.5448221824871196 \
3.600611259457622e-07 0.5501335118600457 3.600616532498142e-07 0.5548792483285057 3.60062030104965e-07 0.5582709446854013 3.600624256351614e-07 0.5618307164525158 \
3.600627887403595e-07 0.5650986632355098 3.600631651750106e-07 0.5684865750957045 3.600635131548222e-07 0.5716183933999566 3.600637778468606e-07 0.5740006217454657 \
3.600640429855227e-07 0.5763868697045537 3.60064573262847e-07 0.5811593656227293 3.60064959313826e-07 0.5846338244342608 3.600653682102066e-07 0.5883138918597329 \
3.600658706357605e-07 0.5928357218442383 3.6006645565012e-07 0.5981008510799999 3.60066996785185e-07 0.6029710666652875 3.600674171443549e-07 0.6067542991940013 \
3.600678249828083e-07 0.6104248452748176 3.600682323094902e-07 0.6140907854118068 3.600686421576131e-07 0.6177794185173828 3.600690657994417e-07 0.62159219497586 \
3.600695100372108e-07 0.6255903348973357 3.600699667685954e-07 0.6297009173589793 3.600704445460431e-07 0.6340009143882042 3.600709750893296e-07 0.6387758039669345 \
3.600715414714156e-07 0.6438732427407217 3.600721454221392e-07 0.6493087992533674 3.60072793381625e-07 0.6551404346247349 3.600735057626029e-07 0.6615518634257037 \
3.600741684590509e-07 0.6675161314588195 3.600747811668178e-07 0.6730305013601764 3.600753590579442e-07 0.6782315214975446 3.600759217368732e-07 0.6832956318592801 \
3.600764833427612e-07 0.6883500848513783 3.600770748832363e-07 0.6936739491264482 3.600776559936408e-07 0.6989039427675531 3.600782307479106e-07 0.7040767311958204 \
3.600788319459405e-07 0.7094875134645067 3.600793248111816e-07 0.7139233006347314 3.600797518350406e-07 0.7177665153653698 3.600801538732531e-07 0.7213848592781456 \
3.600805379778644e-07 0.7248418007795954 3.600808980818888e-07 0.728082736999342 3.60081290978388e-07 0.731618805492268 3.600813508037621e-07 0.7321572338590965 \
3.600814704545103e-07 0.7332340905927537 3.600817097560066e-07 0.735387804060068 3.600819763221002e-07 0.7377868989013747 3.600822730492613e-07 0.7404574433520882 \
3.600827293899446e-07 0.7445645095019819 3.600831296418575e-07 0.7481667767176134 3.600835424114001e-07 0.7518817026010159 3.600839113289174e-07 0.7552019602568045 \
3.600843349197573e-07 0.7590142778153435 3.600847045294427e-07 0.762340764983916 3.6008510473479e-07 0.7659426131102501 3.600854349382552e-07 0.7689144442964062 \
3.600857004950036e-07 0.7713044550329466 3.600859702562257e-07 0.7737323060316124 3.600863809870304e-07 0.7774288832736076 3.600866758593504e-07 0.7800827341539526 \
3.600870783969926e-07 0.7837055729337647 3.600874215941338e-07 0.786794347204456 3.600877744196534e-07 0.7899697768807414 3.600881017086891e-07 0.7929153782018739 \
3.600884210221114e-07 0.7957891990026931 3.600887276009602e-07 0.798548408642265 3.600890258756653e-07 0.8012328809879466 3.600893208487066e-07 0.8038876383597224 \
3.600895914592768e-07 0.8063231334915267 3.600898680486027e-07 0.808812437424818 3.600901524731701e-07 0.8113722585315476 3.600903934753628e-07 0.813541278265291 \
3.600906657780452e-07 0.8159920024070124 3.600909709274073e-07 0.8187383466657218 3.600912712185588e-07 0.8214409670293247 3.600915764870574e-07 0.8241883835163635 \
3.600918710679869e-07 0.8268396118826479 3.600921931045281e-07 0.8297379407530008 3.600924326540277e-07 0.8318938862491163 3.600926881285841e-07 0.8341931572572034 \
3.600929507482641e-07 0.8365567343768243 3.600931961574212e-07 0.8387654167908133 3.600934307182284e-07 0.8408764640555111 3.600936347744433e-07 0.8427129699896301 \
3.600938453663158e-07 0.8446082968424707 3.600940560049605e-07 0.8465040446443356 3.600942446553632e-07 0.8482018982687493 3.600944193128329e-07 0.8497738154964893 \
3.600945992789183e-07 0.8513935102645009 3.600947626880761e-07 0.8528641926851036 3.600949366307779e-07 0.854429677001575 3.600950916494697e-07 0.8558248452281332 \
3.600952586949032e-07 0.8573282541293438 3.600954170395381e-07 0.8587533558427882 3.600955855613503e-07 0.8602700521522246 3.600957427758094e-07 0.8616849822849083 \
3.600958614491536e-07 0.8627530423825936 3.600960118679143e-07 0.8641068112286804 3.600961364949332e-07 0.865228454399422 3.600962976891307e-07 0.8666792021766703 \
3.600964544667706e-07 0.8680902009355517 3.600965801168532e-07 0.8692210516792804 3.600967240522226e-07 0.8705164700033486 3.600968895884348e-07 0.8720062959137309 \
3.600970590539521e-07 0.8735314855691456 3.600972244384113e-07 0.8750199457013955 3.600973973536489e-07 0.8765761828405442 3.600975486087818e-07 0.8779374790365844 \
3.600977054558352e-07 0.8793491025165162 3.600978375604261e-07 0.8805380438351178 3.600979511689023e-07 0.8815605201209382 3.600980667328179e-07 0.8826005953617506 \
3.600981739445152e-07 0.8835655006364479 3.600982519496393e-07 0.8842675467541018 3.600983692038793e-07 0.8853228349141965 3.600984696135191e-07 0.886226521672304 \
3.600985772876734e-07 0.8871955890613133 3.600986534523481e-07 0.8878810711332904 3.600987609073831e-07 0.8888481664483866 3.600988542308148e-07 0.8896880773334693 \
3.600989549101241e-07 0.8905941911166799 3.600990497073693e-07 0.8914473663235497 3.600991358736903e-07 0.8922228632126831 3.600992263281602e-07 0.8930369534412941 \
3.600993660170764e-07 0.8942941536875396 3.600994868298521e-07 0.8953814686688766 3.600996124592936e-07 0.8965121336427553 3.600997566069462e-07 0.8978094625160885 \
3.600998929073789e-07 0.8990361664106589 4.000001758102986e-07 0.8984177073129849 4.000003877361149e-07 0.8965103749658082 4.000008115877476e-07 0.892695710271455 \
4.000012928172893e-07 0.8883646443965901 4.000018222188688e-07 0.8836000301806309 4.000024138577026e-07 0.8782752806762187 4.000031297402391e-07 0.8718323378482702 \
4.000040214704179e-07 0.8638067662390768 4.000051855656758e-07 0.8533299089180234 4.000067300393038e-07 0.8394296462657486 4.000090477353378e-07 0.8185703819595179 \
4.000131021755398e-07 0.7820804201414684 4.000204056090592e-07 0.7163495184672377 4.000247095522191e-07 0.6776140300278762 4.000277199251216e-07 0.6505206739058862 \
4.000310010700412e-07 0.6209903696287848 4.000334899484913e-07 0.5985904635786021 4.000356256577758e-07 0.5793690800177949 4.000374059763451e-07 0.5633462128944384 \
4.000390140106705e-07 0.5488739039651435 4.000404831996955e-07 0.5356512027400909 4.000418285509597e-07 0.5235430413622801 4.000430428116061e-07 0.512614695545089 \
4.000441792238918e-07 0.5023869849741911 4.000452298258402e-07 0.4929315674378034 4.000462112660969e-07 0.484098605128202 4.000471240497254e-07 0.4758835524716363 \
4.000480188040211e-07 0.4678307638102979 4.000488469775522e-07 0.4603772020305483 4.00049661640793e-07 0.4530452328630955 4.000505037998778e-07 0.4454658010995214 \
4.000513926171525e-07 0.4374664456271048 4.000521321735227e-07 0.430810438295329 4.000530270092319e-07 0.4227569169129836 4.000541079024271e-07 0.4130288781558488 \
4.000561152622711e-07 0.3949626395600662 4.00056875998171e-07 0.3881160164607345 4.000578118664211e-07 0.3796932022097708 4.000584871463134e-07 0.373615683179101 \
4.000591594028932e-07 0.3675653739608269 4.000599621211418e-07 0.3603409097239061 4.000607194141275e-07 0.3535252728520237 4.000614695536323e-07 0.3467740173091934 \
4.00062198861823e-07 0.3402102435925485 4.000629171974964e-07 0.3337452225319747 4.000635435959067e-07 0.3281076368399389 4.000639489157798e-07 0.3244597579820502 \
4.000644317377765e-07 0.3201143600118136 4.000648010781158e-07 0.3167902969580316 4.00065253165156e-07 0.3127215135955985 4.000656846607823e-07 0.3088380529590536 \
4.00066036022831e-07 0.3056757945211269 4.000662437559126e-07 0.3038061967869528 4.000665313819854e-07 0.3012175621312337 4.000667767138012e-07 0.2990095757891347 \
4.00067080098449e-07 0.2962791139586973 4.00067337968212e-07 0.2939582860917911 4.000675842641366e-07 0.2917416227702929 4.000680121406541e-07 0.2878907341130054 \
4.000684326169099e-07 0.2841064478110101 4.000689744294793e-07 0.2792301346858994 4.000694310496987e-07 0.2751205527117666 4.000698649698748e-07 0.2712152711268295 \
4.00070276250537e-07 0.2675137451671025 4.000707093494526e-07 0.2636158549267912 4.000711257521107e-07 0.2598682310032753 4.000715772789096e-07 0.2558044898132805 \
4.000720198267563e-07 0.2518215591932373 4.000724867531407e-07 0.2476192217332239 4.000729779079945e-07 0.2431988280497077 4.000734969797613e-07 0.2385271821480127 \
4.000740655752672e-07 0.2334098225947888 4.000746646288799e-07 0.2280183400805964 4.000752953396527e-07 0.2223419431252401 4.00076027928546e-07 0.2157486430863834 \
4.000767372312741e-07 0.2093649185333881 4.000774052783738e-07 0.2033524946355669 4.000780314861686e-07 0.1977166244827963 4.000786423893507e-07 0.1922184958436388 \
4.000792377776886e-07 0.1868600008026635 4.00079853866796e-07 0.1813151988360575 4.000804543976034e-07 0.1759104215697842 4.000810467364748e-07 0.1705793717271608 \
4.000816706037987e-07 0.164964565812095 4.000822539901237e-07 0.1597140888870844 4.000827867469318e-07 0.1549192776137643 4.000833311463823e-07 0.1500196825588286 \
4.000838590783176e-07 0.1452682951413614 4.00084435818527e-07 0.1400776332571309 4.000850022377844e-07 0.1349798599404549 4.000855520823249e-07 0.1300312590758997 \
4.000861686813856e-07 0.1244818675298257 4.000866369972226e-07 0.1202670249965557 4.000872299951725e-07 0.114930043447014 4.000876909574825e-07 0.1107813826574622 \
4.000881066844685e-07 0.1070398397831492 4.00088462796911e-07 0.1038348278011874 4.000888104250938e-07 0.1007061741557836 4.000891128590561e-07 0.09798426849538755 \
4.000894173801862e-07 0.09524357832398211 4.000896897024939e-07 0.09279267755476828 4.000899532804389e-07 0.09042047604958559 4.000901972751047e-07 0.08822452405742931 \
4.000904672234071e-07 0.08579498933604146 4.000907063969493e-07 0.08364242745616901 4.000909698641177e-07 0.08127122294071432 4.000912247411014e-07 0.07897733008697083 \
4.000914549713496e-07 0.07690525785341851 4.000917197517262e-07 0.07452223446371342 4.00092001524411e-07 0.07198628030108556 4.000922771037338e-07 0.06950606639574286 \
4.000926178497145e-07 0.06643935256942901 4.000929047711241e-07 0.06385705988345824 4.000932105231113e-07 0.06110529199863279 4.000935025276799e-07 0.0584772508810687 \
4.000937743584833e-07 0.05603077365032616 4.000940213615499e-07 0.05380774605057426 4.000942171920341e-07 0.05204527169284134 4.000943943123614e-07 0.05045118874764443 \
4.000945695254918e-07 0.04887427057365767 4.000947271734062e-07 0.04745543934452334 4.000948749691591e-07 0.04612527756805263 4.000950200501117e-07 0.04481954899450691 \
4.000951580483332e-07 0.0435775650013065 4.000953003028957e-07 0.04229727393901672 4.000954263034713e-07 0.04116326875785103 4.000955598319525e-07 0.03996151242777013 \
4.000956821020666e-07 0.03886108140050326 4.000958151620155e-07 0.0376635418603275 4.000959296039086e-07 0.03663356482247337 4.000960217395757e-07 0.03580434381845876 \
4.000961185938143e-07 0.03493265567158488 4.000962580032994e-07 0.03367797030500419 4.000963723296091e-07 0.03264903351765647 4.000964819349537e-07 0.03166258541696143 \
4.000966151874731e-07 0.03046331274235659 4.000967280577828e-07 0.02944747995458197 4.000968505551189e-07 0.02834500393025741 4.000969864971123e-07 0.02712152598905548 \
4.000971045042059e-07 0.02605946214676502 4.000972335603972e-07 0.02489795642556891 4.000973440508587e-07 0.02390354227171532 4.000974794893149e-07 0.02268459616553509 \
4.000975991229856e-07 0.02160789312944722 4.000977000043597e-07 0.02069996076227698 4.000978203514515e-07 0.01961683693679572 4.000979616112103e-07 0.01834549910740102 \
4.000981236968955e-07 0.01688672794015589 4.000982728348491e-07 0.01554448635840755 4.000984257131347e-07 0.014168581787533 4.000985760067313e-07 0.01281593941858328 \
4.000987228351463e-07 0.01149448368366224 4.000988791913148e-07 0.01008727816647481 4.000989984546065e-07 0.009013908541385951 4.000990930871204e-07 0.008162215916559523 \
4.000991965644665e-07 0.007230919801462066 4.000992690484371e-07 0.006578564066408443 4.00099347396487e-07 0.005873431617253289 4.000994370778813e-07 0.005066299068704372 \
4.000995698899392e-07 0.003870990547362063 4.000996714898243e-07 0.002956591581575796 4.000997774547152e-07 0.002002907563398826 4.000998932860907e-07 0.000960425183447966 \
4.589900000000113e-07 0 4.599999999999961e-07 0 4.600002111634403e-07 0.001900470962571042 4.600004424445472e-07 0.003982000924727166 \
4.60000905006761e-07 0.008145060849039413 4.600013623206272e-07 0.01226088564504064 4.600018368035255e-07 0.01653123172985639 4.600023692993678e-07 0.02132369430982749 \
4.600030391819417e-07 0.02735263747515369 4.600038962860512e-07 0.03506657446094884 4.600050110320463e-07 0.04509928841663746 4.600066320296376e-07 0.05968826673863754 \
4.600089746991287e-07 0.08077229215837188 4.600136600381109e-07 0.1229403429978405 4.600179644652403e-07 0.1616801871633537 4.600218144069514e-07 0.1963296625632528 \
4.600260784839173e-07 0.2347063552562001 4.600291484812914e-07 0.2623363316230807 4.600316114214461e-07 0.2845027930151538 4.600335732345164e-07 0.3021591106476817 \
4.600352830299905e-07 0.3175472699147922 4.60036786621731e-07 0.3310795955797556 4.600381257194662e-07 0.3431314751960884 4.600393723992329e-07 0.3543515930958913 \
4.60040514338907e-07 0.3646290501629268 4.600415723114469e-07 0.3741508030226791 4.600425813571893e-07 0.3832322147042228 4.600436002602279e-07 0.3924023420515681 \
4.60044556738474e-07 0.4010106462662745 4.60045504571866e-07 0.4095411467944404 4.600463681471743e-07 0.4173133245688312 4.600471108484519e-07 0.423997636067712 \
4.600477705629023e-07 0.4299350661209142 4.6004846509286e-07 0.4361858357407548 4.600491344399726e-07 0.4422099597530631 4.600497450055524e-07 0.4477050499714701 \
4.600505211590361e-07 0.454690431324675 4.600515775830366e-07 0.4641982473299416 4.600525733032824e-07 0.4731597295416305 4.600534391469966e-07 0.4809523229693754 \
4.600543752979998e-07 0.4893776819979773 4.600551017667356e-07 0.4959159006203305 4.600557679847268e-07 0.5019118625413875 4.600563829589108e-07 0.5074466301974319 \
4.600571676584685e-07 0.5145089262167936 4.600578769318571e-07 0.5208923867144013 4.600585767285569e-07 0.5271905570126808 4.600592411431324e-07 0.5331702881913303 \
4.600598964737336e-07 0.539068263602977 4.600605357980541e-07 0.5448221824871196 4.600611259457622e-07 0.5501335118600457 4.600616532498142e-07 0.5548792483285057 \
4.60062030104965e-07 0.5582709446854013 4.600624256351614e-07 0.5618307164525158 4.600627887403595e-07 0.5650986632355098 4.600631651750106e-07 0.5684865750957045 \
4.600635131548222e-07 0.5716183933999566 4.600637778468606e-07 0.5740006217454657 4.600640429855227e-07 0.5763868697045537 4.600645732628469e-07 0.5811593656227293 \
4.60064959313826e-07 0.5846338244342608 4.600653682102066e-07 0.5883138918597329 4.600658706357604e-07 0.5928357218442383 4.6006645565012e-07 0.5981008510799999 \
4.60066996785185e-07 0.6029710666652875 4.600674171443549e-07 0.6067542991940013 4.600678249828083e-07 0.6104248452748176 4.600682323094902e-07 0.6140907854118068 \
4.60068642157613e-07 0.6177794185173828 4.600690657994417e-07 0.62159219497586 4.600695100372108e-07 0.6255903348973357 4.600699667685954e-07 0.6297009173589793 \
4.600704445460431e-07 0.6340009143882042 4.600709750893296e-07 0.6387758039669345 4.600715414714156e-07 0.6438732427407217 4.600721454221392e-07 0.6493087992533674 \
4.60072793381625e-07 0.6551404346247349 4.600735057626028e-07 0.6615518634257037 4.600741684590509e-07 0.6675161314588195 4.600747811668178e-07 0.6730305013601764 \
4.600753590579442e-07 0.6782315214975446 4.600759217368732e-07 0.6832956318592801 4.600764833427612e-07 0.6883500848513783 4.600770748832362e-07 0.6936739491264482 \
4.600776559936408e-07 0.6989039427675531 4.600782307479106e-07 0.7040767311958204 4.600788319459405e-07 0.7094875134645067 4.600793248111816e-07 0.7139233006347314 \
4.600797518350406e-07 0.7177665153653698 4.600801538732531e-07 0.7213848592781456 4.600805379778643e-07 0.7248418007795954 4.600808980818888e-07 0.728082736999342 \
4.60081290978388e-07 0.731618805492268 4.600813508037621e-07 0.7321572338590965 4.600814704545103e-07 0.7332340905927537 4.600817097560066e-07 0.735387804060068 \
4.600819763221002e-07 0.7377868989013747 4.600822730492613e-07 0.7404574433520882 4.600827293899446e-07 0.7445645095019819 4.600831296418575e-07 0.7481667767176134 \
4.600835424114001e-07 0.7518817026010159 4.600839113289174e-07 0.7552019602568045 4.600843349197573e-07 0.7590142778153435 4.600847045294426e-07 0.762340764983916 \
4.6008510473479e-07 0.7659426131102501 4.600854349382552e-07 0.7689144442964062 4.600857004950036e-07 0.7713044550329466 4.600859702562257e-07 0.7737323060316124 \
4.600863809870304e-07 0.7774288832736076 4.600866758593504e-07 0.7800827341539526 4.600870783969926e-07 0.7837055729337647 4.600874215941338e-07 0.786794347204456 \
4.600877744196534e-07 0.7899697768807414 4.60088101708689e-07 0.7929153782018739 4.600884210221114e-07 0.7957891990026931 4.600887276009602e-07 0.798548408642265 \
4.600890258756653e-07 0.8012328809879466 4.600893208487066e-07 0.8038876383597224 4.600895914592768e-07 0.8063231334915267 4.600898680486027e-07 0.808812437424818 \
4.600901524731701e-07 0.8113722585315476 4.600903934753628e-07 0.813541278265291 4.600906657780452e-07 0.8159920024070124 4.600909709274073e-07 0.8187383466657218 \
4.600912712185588e-07 0.8214409670293247 4.600915764870574e-07 0.8241883835163635 4.600918710679869e-07 0.8268396118826479 4.600921931045281e-07 0.8297379407530008 \
4.600924326540277e-07 0.8318938862491163 4.600926881285841e-07 0.8341931572572034 4.600929507482641e-07 0.8365567343768243 4.600931961574212e-07 0.8387654167908133 \
4.600934307182284e-07 0.8408764640555111 4.600936347744433e-07 0.8427129699896301 4.600938453663158e-07 0.8446082968424707 4.600940560049605e-07 0.8465040446443356 \
4.600942446553632e-07 0.8482018982687493 4.600944193128329e-07 0.8497738154964893 4.600945992789183e-07 0.8513935102645009 4.600947626880761e-07 0.8528641926851036 \
4.600949366307779e-07 0.854429677001575 4.600950916494697e-07 0.8558248452281332 4.600952586949032e-07 0.8573282541293438 4.600954170395381e-07 0.8587533558427882 \
4.600955855613503e-07 0.8602700521522246 4.600957427758094e-07 0.8616849822849083 4.600958614491536e-07 0.8627530423825936 4.600960118679143e-07 0.8641068112286804 \
4.600961364949332e-07 0.865228454399422 4.600962976891307e-07 0.8666792021766703 4.600964544667706e-07 0.8680902009355517 4.600965801168532e-07 0.8692210516792804 \
4.600967240522226e-07 0.8705164700033486 4.600968895884348e-07 0.8720062959137309 4.600970590539521e-07 0.8735314855691456 4.600972244384113e-07 0.8750199457013955 \
4.600973973536489e-07 0.8765761828405442 4.600975486087818e-07 0.8779374790365844 4.600977054558352e-07 0.8793491025165162 4.600978375604261e-07 0.8805380438351178 \
4.600979511689023e-07 0.8815605201209382 4.600980667328179e-07 0.8826005953617506 4.600981739445152e-07 0.8835655006364479 4.600982519496393e-07 0.8842675467541018 \
4.600983692038793e-07 0.8853228349141965 4.600984696135191e-07 0.886226521672304 4.600985772876734e-07 0.8871955890613133 4.600986534523481e-07 0.8878810711332904 \
4.600987609073831e-07 0.8888481664483866 4.600988542308148e-07 0.8896880773334693 4.600989549101241e-07 0.8905941911166799 4.600990497073693e-07 0.8914473663235497 \
4.600991358736903e-07 0.8922228632126831 4.600992263281601e-07 0.8930369534412941 4.600993660170764e-07 0.8942941536875396 4.600994868298521e-07 0.8953814686688766 \
4.600996124592936e-07 0.8965121336427553 4.600997566069462e-07 0.8978094625160885 4.600998929073789e-07 0.8990361664106589 5.000001758102986e-07 0.8984177073129849 \
5.000003877361149e-07 0.8965103749658082 5.000008115877475e-07 0.892695710271455 5.000012928172893e-07 0.8883646443965901 5.000018222188688e-07 0.8836000301806309 \
5.000024138577025e-07 0.8782752806762187 5.000031297402391e-07 0.8718323378482702 5.000040214704179e-07 0.8638067662390768 5.000051855656758e-07 0.8533299089180234 \
5.000067300393037e-07 0.8394296462657486 5.000090477353378e-07 0.8185703819595179 5.000131021755398e-07 0.7820804201414684 5.000204056090591e-07 0.7163495184672377 \
5.00024709552219e-07 0.6776140300278762 5.000277199251216e-07 0.6505206739058862 5.000310010700411e-07 0.6209903696287848 5.000334899484913e-07 0.5985904635786021 \
5.000356256577758e-07 0.5793690800177949 5.000374059763451e-07 0.5633462128944384 5.000390140106704e-07 0.5488739039651435 5.000404831996955e-07 0.5356512027400909 \
5.000418285509597e-07 0.5235430413622801 5.000430428116061e-07 0.512614695545089 5.000441792238918e-07 0.5023869849741911 5.000452298258402e-07 0.4929315674378034 \
5.000462112660969e-07 0.484098605128202 5.000471240497254e-07 0.4758835524716363 5.00048018804021e-07 0.4678307638102979 5.000488469775522e-07 0.4603772020305483 \
5.000496616407929e-07 0.4530452328630955 5.000505037998778e-07 0.4454658010995214 5.000513926171525e-07 0.4374664456271048 5.000521321735226e-07 0.430810438295329 \
5.000530270092319e-07 0.4227569169129836 5.000541079024271e-07 0.4130288781558488 5.000561152622711e-07 0.3949626395600662 5.00056875998171e-07 0.3881160164607345 \
5.00057811866421e-07 0.3796932022097708 5.000584871463134e-07 0.373615683179101 5.000591594028932e-07 0.3675653739608269 5.000599621211418e-07 0.3603409097239061 \
5.000607194141274e-07 0.3535252728520237 5.000614695536322e-07 0.3467740173091934 5.00062198861823e-07 0.3402102435925485 5.000629171974964e-07 0.3337452225319747 \
5.000635435959067e-07 0.3281076368399389 5.000639489157798e-07 0.3244597579820502 5.000644317377765e-07 0.3201143600118136 5.000648010781158e-07 0.3167902969580316 \
5.00065253165156e-07 0.3127215135955985 5.000656846607823e-07 0.3088380529590536 5.00066036022831e-07 0.3056757945211269 5.000662437559126e-07 0.3038061967869528 \
5.000665313819854e-07 0.3012175621312337 5.000667767138012e-07 0.2990095757891347 5.000670800984489e-07 0.2962791139586973 5.00067337968212e-07 0.2939582860917911 \
5.000675842641366e-07 0.2917416227702929 5.00068012140654e-07 0.2878907341130054 5.000684326169099e-07 0.2841064478110101 5.000689744294793e-07 0.2792301346858994 \
5.000694310496987e-07 0.2751205527117666 5.000698649698748e-07 0.2712152711268295 5.000702762505369e-07 0.2675137451671025 5.000707093494526e-07 0.2636158549267912 \
5.000711257521107e-07 0.2598682310032753 5.000715772789095e-07 0.2558044898132805 5.000720198267563e-07 0.2518215591932373 5.000724867531406e-07 0.2476192217332239 \
5.000729779079944e-07 0.2431988280497077 5.000734969797613e-07 0.2385271821480127 5.000740655752672e-07 0.2334098225947888 5.000746646288799e-07 0.2280183400805964 \
5.000752953396526e-07 0.2223419431252401 5.000760279285459e-07 0.2157486430863834 5.000767372312741e-07 0.2093649185333881 5.000774052783738e-07 0.2033524946355669 \
5.000780314861686e-07 0.1977166244827963 5.000786423893507e-07 0.1922184958436388 5.000792377776885e-07 0.1868600008026635 5.00079853866796e-07 0.1813151988360575 \
5.000804543976034e-07 0.1759104215697842 5.000810467364748e-07 0.1705793717271608 5.000816706037986e-07 0.164964565812095 5.000822539901237e-07 0.1597140888870844 \
5.000827867469318e-07 0.1549192776137643 5.000833311463823e-07 0.1500196825588286 5.000838590783176e-07 0.1452682951413614 5.00084435818527e-07 0.1400776332571309 \
5.000850022377844e-07 0.1349798599404549 5.000855520823249e-07 0.1300312590758997 5.000861686813856e-07 0.1244818675298257 5.000866369972226e-07 0.1202670249965557 \
5.000872299951725e-07 0.114930043447014 5.000876909574825e-07 0.1107813826574622 5.000881066844685e-07 0.1070398397831492 5.00088462796911e-07 0.1038348278011874 \
5.000888104250938e-07 0.1007061741557836 5.000891128590561e-07 0.09798426849538755 5.000894173801862e-07 0.09524357832398211 5.000896897024938e-07 0.09279267755476828 \
5.000899532804389e-07 0.09042047604958559 5.000901972751047e-07 0.08822452405742931 5.000904672234071e-07 0.08579498933604146 5.000907063969493e-07 0.08364242745616901 \
5.000909698641176e-07 0.08127122294071432 5.000912247411013e-07 0.07897733008697083 5.000914549713495e-07 0.07690525785341851 5.000917197517262e-07 0.07452223446371342 \
5.00092001524411e-07 0.07198628030108556 5.000922771037338e-07 0.06950606639574286 5.000926178497145e-07 0.06643935256942901 5.000929047711241e-07 0.06385705988345824 \
5.000932105231113e-07 0.06110529199863279 5.000935025276798e-07 0.0584772508810687 5.000937743584832e-07 0.05603077365032616 5.000940213615499e-07 0.05380774605057426 \
5.000942171920341e-07 0.05204527169284134 5.000943943123614e-07 0.05045118874764443 5.000945695254918e-07 0.04887427057365767 5.000947271734062e-07 0.04745543934452334 \
5.000948749691591e-07 0.04612527756805263 5.000950200501117e-07 0.04481954899450691 5.000951580483332e-07 0.0435775650013065 5.000953003028957e-07 0.04229727393901672 \
5.000954263034713e-07 0.04116326875785103 5.000955598319524e-07 0.03996151242777013 5.000956821020666e-07 0.03886108140050326 5.000958151620154e-07 0.0376635418603275 \
5.000959296039086e-07 0.03663356482247337 5.000960217395757e-07 0.03580434381845876 5.000961185938143e-07 0.03493265567158488 5.000962580032994e-07 0.03367797030500419 \
5.000963723296091e-07 0.03264903351765647 5.000964819349537e-07 0.03166258541696143 5.00096615187473e-07 0.03046331274235659 5.000967280577828e-07 0.02944747995458197 \
5.000968505551189e-07 0.02834500393025741 5.000969864971123e-07 0.02712152598905548 5.000971045042059e-07 0.02605946214676502 5.000972335603972e-07 0.02489795642556891 \
5.000973440508587e-07 0.02390354227171532 5.000974794893149e-07 0.02268459616553509 5.000975991229855e-07 0.02160789312944722 5.000977000043597e-07 0.02069996076227698 \
5.000978203514515e-07 0.01961683693679572 5.000979616112103e-07 0.01834549910740102 5.000981236968955e-07 0.01688672794015589 5.000982728348491e-07 0.01554448635840755 \
5.000984257131347e-07 0.014168581787533 5.000985760067313e-07 0.01281593941858328 5.000987228351462e-07 0.01149448368366224 5.000988791913148e-07 0.01008727816647481 \
5.000989984546065e-07 0.009013908541385951 5.000990930871204e-07 0.008162215916559523 5.000991965644665e-07 0.007230919801462066 5.00099269048437e-07 0.006578564066408443 \
5.00099347396487e-07 0.005873431617253289 5.000994370778812e-07 0.005066299068704372 5.000995698899392e-07 0.003870990547362063 5.000996714898243e-07 0.002956591581575796 \
5.000997774547152e-07 0.002002907563398826 5.000998932860907e-07 0.000960425183447966 5.589900000000112e-07 0 5.599999999999961e-07 0 \
5.600002111634403e-07 0.001900470962571042 5.600004424445472e-07 0.003982000924727166 5.600009050067609e-07 0.008145060849039413 5.600013623206272e-07 0.01226088564504064 \
5.600018368035256e-07 0.01653123172985639 5.600023692993678e-07 0.02132369430982749 5.600030391819417e-07 0.02735263747515369 5.600038962860512e-07 0.03506657446094884 \
5.600050110320462e-07 0.04509928841663746 5.600066320296376e-07 0.05968826673863754 5.600089746991287e-07 0.08077229215837188 5.600136600381108e-07 0.1229403429978405 \
5.600179644652403e-07 0.1616801871633537 5.600218144069514e-07 0.1963296625632528 5.600260784839173e-07 0.2347063552562001 5.600291484812914e-07 0.2623363316230807 \
5.60031611421446e-07 0.2845027930151538 5.600335732345164e-07 0.3021591106476817 5.600352830299905e-07 0.3175472699147922 5.60036786621731e-07 0.3310795955797556 \
5.600381257194662e-07 0.3431314751960884 5.600393723992328e-07 0.3543515930958913 5.600405143389069e-07 0.3646290501629268 5.60041572311447e-07 0.3741508030226791 \
5.600425813571894e-07 0.3832322147042228 5.600436002602279e-07 0.3924023420515681 5.60044556738474e-07 0.4010106462662745 5.600455045718661e-07 0.4095411467944404 \
5.600463681471743e-07 0.4173133245688312 5.60047110848452e-07 0.423997636067712 5.600477705629023e-07 0.4299350661209142 5.600484650928601e-07 0.4361858357407548 \
5.600491344399725e-07 0.4422099597530631 5.600497450055524e-07 0.4477050499714701 5.600505211590361e-07 0.454690431324675 5.600515775830366e-07 0.4641982473299416 \
5.600525733032824e-07 0.4731597295416305 5.600534391469966e-07 0.4809523229693754 5.600543752979998e-07 0.4893776819979773 5.600551017667355e-07 0.4959159006203305 \
5.600557679847268e-07 0.5019118625413875 5.600563829589108e-07 0.5074466301974319 5.600571676584685e-07 0.5145089262167936 5.600578769318572e-07 0.5208923867144013 \
5.60058576728557e-07 0.5271905570126808 5.600592411431324e-07 0.5331702881913303 5.600598964737336e-07 0.539068263602977 5.600605357980541e-07 0.5448221824871196 \
5.600611259457622e-07 0.5501335118600457 5.600616532498142e-07 0.5548792483285057 5.60062030104965e-07 0.5582709446854013 5.600624256351613e-07 0.5618307164525158 \
5.600627887403595e-07 0.5650986632355098 5.600631651750106e-07 0.5684865750957045 5.600635131548222e-07 0.5716183933999566 5.600637778468606e-07 0.5740006217454657 \
5.600640429855227e-07 0.5763868697045537 5.600645732628469e-07 0.5811593656227293 5.60064959313826e-07 0.5846338244342608 5.600653682102066e-07 0.5883138918597329 \
5.600658706357605e-07 0.5928357218442383 5.600664556501199e-07 0.5981008510799999 5.60066996785185e-07 0.6029710666652875 5.600674171443549e-07 0.6067542991940013 \
5.600678249828083e-07 0.6104248452748176 5.600682323094902e-07 0.6140907854118068 5.60068642157613e-07 0.6177794185173828 5.600690657994417e-07 0.62159219497586 \
5.600695100372108e-07 0.6255903348973357 5.600699667685954e-07 0.6297009173589793 5.600704445460431e-07 0.6340009143882042 5.600709750893296e-07 0.6387758039669345 \
5.600715414714156e-07 0.6438732427407217 5.600721454221392e-07 0.6493087992533674 5.600727933816249e-07 0.6551404346247349 5.600735057626028e-07 0.6615518634257037 \
5.600741684590509e-07 0.6675161314588195 5.600747811668178e-07 0.6730305013601764 5.600753590579442e-07 0.6782315214975446 5.600759217368732e-07 0.6832956318592801 \
5.600764833427613e-07 0.6883500848513783 5.600770748832362e-07 0.6936739491264482 5.600776559936408e-07 0.6989039427675531 5.600782307479106e-07 0.7040767311958204 \
5.600788319459405e-07 0.7094875134645067 5.600793248111816e-07 0.7139233006347314 5.600797518350405e-07 0.7177665153653698 5.600801538732531e-07 0.7213848592781456 \
5.600805379778643e-07 0.7248418007795954 5.600808980818888e-07 0.728082736999342 5.60081290978388e-07 0.731618805492268 5.600813508037621e-07 0.7321572338590965 \
5.600814704545103e-07 0.7332340905927537 5.600817097560066e-07 0.735387804060068 5.600819763221002e-07 0.7377868989013747 5.600822730492613e-07 0.7404574433520882 \
5.600827293899446e-07 0.7445645095019819 5.600831296418575e-07 0.7481667767176134 5.600835424114e-07 0.7518817026010159 5.600839113289174e-07 0.7552019602568045 \
5.600843349197573e-07 0.7590142778153435 5.600847045294426e-07 0.762340764983916 5.6008510473479e-07 0.7659426131102501 5.600854349382552e-07 0.7689144442964062 \
5.600857004950037e-07 0.7713044550329466 5.600859702562257e-07 0.7737323060316124 5.600863809870304e-07 0.7774288832736076 5.600866758593504e-07 0.7800827341539526 \
5.600870783969926e-07 0.7837055729337647 5.600874215941338e-07 0.786794347204456 5.600877744196534e-07 0.7899697768807414 5.60088101708689e-07 0.7929153782018739 \
5.600884210221113e-07 0.7957891990026931 5.600887276009603e-07 0.798548408642265 5.600890258756652e-07 0.8012328809879466 5.600893208487066e-07 0.8038876383597224 \
5.600895914592768e-07 0.8063231334915267 5.600898680486028e-07 0.808812437424818 5.600901524731702e-07 0.8113722585315476 5.600903934753628e-07 0.813541278265291 \
5.600906657780451e-07 0.8159920024070124 5.600909709274073e-07 0.8187383466657218 5.600912712185588e-07 0.8214409670293247 5.600915764870574e-07 0.8241883835163635 \
5.600918710679869e-07 0.8268396118826479 5.600921931045281e-07 0.8297379407530008 5.600924326540276e-07 0.8318938862491163 5.600926881285841e-07 0.8341931572572034 \
5.60092950748264e-07 0.8365567343768243 5.600931961574212e-07 0.8387654167908133 5.600934307182284e-07 0.8408764640555111 5.600936347744432e-07 0.8427129699896301 \
5.600938453663158e-07 0.8446082968424707 5.600940560049604e-07 0.8465040446443356 5.600942446553632e-07 0.8482018982687493 5.600944193128329e-07 0.8497738154964893 \
5.600945992789182e-07 0.8513935102645009 5.600947626880761e-07 0.8528641926851036 5.600949366307779e-07 0.854429677001575 5.600950916494697e-07 0.8558248452281332 \
5.600952586949032e-07 0.8573282541293438 5.600954170395381e-07 0.8587533558427882 5.600955855613502e-07 0.8602700521522246 5.600957427758094e-07 0.8616849822849083 \
5.600958614491536e-07 0.8627530423825936 5.600960118679143e-07 0.8641068112286804 5.600961364949332e-07 0.865228454399422 5.600962976891307e-07 0.8666792021766703 \
5.600964544667706e-07 0.8680902009355517 5.600965801168532e-07 0.8692210516792804 5.600967240522226e-07 0.8705164700033486 5.600968895884348e-07 0.8720062959137309 \
5.600970590539522e-07 0.8735314855691456 5.600972244384113e-07 0.8750199457013955 5.600973973536489e-07 0.8765761828405442 5.600975486087818e-07 0.8779374790365844 \
5.600977054558351e-07 0.8793491025165162 5.60097837560426e-07 0.8805380438351178 5.600979511689023e-07 0.8815605201209382 5.60098066732818e-07 0.8826005953617506 \
5.600981739445151e-07 0.8835655006364479 5.600982519496393e-07 0.8842675467541018 5.600983692038793e-07 0.8853228349141965 5.600984696135191e-07 0.886226521672304 \
5.600985772876734e-07 0.8871955890613133 5.600986534523481e-07 0.8878810711332904 5.600987609073831e-07 0.8888481664483866 5.600988542308148e-07 0.8896880773334693 \
5.60098954910124e-07 0.8905941911166799 5.600990497073693e-07 0.8914473663235497 5.600991358736902e-07 0.8922228632126831 5.600992263281601e-07 0.8930369534412941 \
5.600993660170764e-07 0.8942941536875396 5.60099486829852e-07 0.8953814686688766 5.600996124592936e-07 0.8965121336427553 5.600997566069462e-07 0.8978094625160885 \
5.600998929073789e-07 0.8990361664106589 6.000001758102986e-07 0.8984177073129849 6.000003877361148e-07 0.8965103749658082 6.000008115877475e-07 0.892695710271455 \
6.000012928172893e-07 0.8883646443965901 6.000018222188688e-07 0.8836000301806309 6.000024138577025e-07 0.8782752806762187 6.00003129740239e-07 0.8718323378482702 \
6.000040214704179e-07 0.8638067662390768 6.000051855656757e-07 0.8533299089180234 6.000067300393037e-07 0.8394296462657486 6.000090477353378e-07 0.8185703819595179 \
6.000131021755398e-07 0.7820804201414684 6.000204056090592e-07 0.7163495184672377 6.00024709552219e-07 0.6776140300278762 6.000277199251216e-07 0.6505206739058862 \
6.000310010700411e-07 0.6209903696287848 6.000334899484913e-07 0.5985904635786021 6.000356256577757e-07 0.5793690800177949 6.00037405976345e-07 0.5633462128944384 \
6.000390140106704e-07 0.5488739039651435 6.000404831996955e-07 0.5356512027400909 6.000418285509597e-07 0.5235430413622801 6.00043042811606e-07 0.512614695545089 \
6.000441792238918e-07 0.5023869849741911 6.000452298258402e-07 0.4929315674378034 6.000462112660969e-07 0.484098605128202 6.000471240497254e-07 0.4758835524716363 \
6.000480188040211e-07 0.4678307638102979 6.000488469775522e-07 0.4603772020305483 6.000496616407929e-07 0.4530452328630955 6.000505037998778e-07 0.4454658010995214 \
6.000513926171525e-07 0.4374664456271048 6.000521321735227e-07 0.430810438295329 6.000530270092319e-07 0.4227569169129836 6.00054107902427e-07 0.4130288781558488 \
6.000561152622711e-07 0.3949626395600662 6.00056875998171e-07 0.3881160164607345 6.00057811866421e-07 0.3796932022097708 6.000584871463134e-07 0.373615683179101 \
6.000591594028932e-07 0.3675653739608269 6.000599621211418e-07 0.3603409097239061 6.000607194141274e-07 0.3535252728520237 6.000614695536322e-07 0.3467740173091934 \
6.00062198861823e-07 0.3402102435925485 6.000629171974964e-07 0.3337452225319747 6.000635435959067e-07 0.3281076368399389 6.000639489157798e-07 0.3244597579820502 \
6.000644317377765e-07 0.3201143600118136 6.000648010781158e-07 0.3167902969580316 6.00065253165156e-07 0.3127215135955985 6.000656846607823e-07 0.3088380529590536 \
6.000660360228309e-07 0.3056757945211269 6.000662437559126e-07 0.3038061967869528 6.000665313819854e-07 0.3012175621312337 6.000667767138012e-07 0.2990095757891347 \
6.000670800984489e-07 0.2962791139586973 6.00067337968212e-07 0.2939582860917911 6.000675842641366e-07 0.2917416227702929 6.00068012140654e-07 0.2878907341130054 \
6.000684326169099e-07 0.2841064478110101 6.000689744294793e-07 0.2792301346858994 6.000694310496987e-07 0.2751205527117666 6.000698649698748e-07 0.2712152711268295 \
6.000702762505369e-07 0.2675137451671025 6.000707093494526e-07 0.2636158549267912 6.000711257521107e-07 0.2598682310032753 6.000715772789096e-07 0.2558044898132805 \
6.000720198267563e-07 0.2518215591932373 6.000724867531406e-07 0.2476192217332239 6.000729779079944e-07 0.2431988280497077 6.000734969797613e-07 0.2385271821480127 \
6.000740655752672e-07 0.2334098225947888 6.000746646288799e-07 0.2280183400805964 6.000752953396526e-07 0.2223419431252401 6.000760279285459e-07 0.2157486430863834 \
6.000767372312741e-07 0.2093649185333881 6.000774052783737e-07 0.2033524946355669 6.000780314861686e-07 0.1977166244827963 6.000786423893507e-07 0.1922184958436388 \
6.000792377776886e-07 0.1868600008026635 6.00079853866796e-07 0.1813151988360575 6.000804543976034e-07 0.1759104215697842 6.000810467364748e-07 0.1705793717271608 \
6.000816706037987e-07 0.164964565812095 6.000822539901237e-07 0.1597140888870844 6.000827867469318e-07 0.1549192776137643 6.000833311463823e-07 0.1500196825588286 \
6.000838590783176e-07 0.1452682951413614 6.00084435818527e-07 0.1400776332571309 6.000850022377844e-07 0.1349798599404549 6.000855520823249e-07 0.1300312590758997 \
6.000861686813856e-07 0.1244818675298257 6.000866369972226e-07 0.1202670249965557 6.000872299951725e-07 0.114930043447014 6.000876909574825e-07 0.1107813826574622 \
6.000881066844685e-07 0.1070398397831492 6.00088462796911e-07 0.1038348278011874 6.000888104250938e-07 0.1007061741557836 6.00089112859056e-07 0.09798426849538755 \
6.000894173801862e-07 0.09524357832398211 6.000896897024939e-07 0.09279267755476828 6.000899532804389e-07 0.09042047604958559 6.000901972751046e-07 0.08822452405742931 \
6.000904672234071e-07 0.08579498933604146 6.000907063969492e-07 0.08364242745616901 6.000909698641176e-07 0.08127122294071432 6.000912247411014e-07 0.07897733008697083 \
6.000914549713495e-07 0.07690525785341851 6.000917197517262e-07 0.07452223446371342 6.00092001524411e-07 0.07198628030108556 6.000922771037338e-07 0.06950606639574286 \
6.000926178497144e-07 0.06643935256942901 6.00092904771124e-07 0.06385705988345824 6.000932105231113e-07 0.06110529199863279 6.000935025276798e-07 0.0584772508810687 \
6.000937743584832e-07 0.05603077365032616 6.000940213615499e-07 0.05380774605057426 6.000942171920341e-07 0.05204527169284134 6.000943943123614e-07 0.05045118874764443 \
6.000945695254918e-07 0.04887427057365767 6.000947271734062e-07 0.04745543934452334 6.00094874969159e-07 0.04612527756805263 6.000950200501117e-07 0.04481954899450691 \
6.000951580483332e-07 0.0435775650013065 6.000953003028957e-07 0.04229727393901672 6.000954263034713e-07 0.04116326875785103 6.000955598319524e-07 0.03996151242777013 \
6.000956821020666e-07 0.03886108140050326 6.000958151620155e-07 0.0376635418603275 6.000959296039086e-07 0.03663356482247337 6.000960217395756e-07 0.03580434381845876 \
6.000961185938142e-07 0.03493265567158488 6.000962580032994e-07 0.03367797030500419 6.000963723296091e-07 0.03264903351765647 6.000964819349537e-07 0.03166258541696143 \
6.00096615187473e-07 0.03046331274235659 6.000967280577828e-07 0.02944747995458197 6.000968505551189e-07 0.02834500393025741 6.000969864971123e-07 0.02712152598905548 \
6.000971045042058e-07 0.02605946214676502 6.000972335603972e-07 0.02489795642556891 6.000973440508587e-07 0.02390354227171532 6.000974794893149e-07 0.02268459616553509 \
6.000975991229855e-07 0.02160789312944722 6.000977000043597e-07 0.02069996076227698 6.000978203514515e-07 0.01961683693679572 6.000979616112103e-07 0.01834549910740102 \
6.000981236968955e-07 0.01688672794015589 6.000982728348491e-07 0.01554448635840755 6.000984257131347e-07 0.014168581787533 6.000985760067313e-07 0.01281593941858328 \
6.000987228351463e-07 0.01149448368366224 6.000988791913148e-07 0.01008727816647481 6.000989984546064e-07 0.009013908541385951 6.000990930871204e-07 0.008162215916559523 \
6.000991965644665e-07 0.007230919801462066 6.000992690484371e-07 0.006578564066408443 6.00099347396487e-07 0.005873431617253289 6.000994370778812e-07 0.005066299068704372 \
6.000995698899392e-07 0.003870990547362063 6.000996714898243e-07 0.002956591581575796 6.000997774547152e-07 0.002002907563398826 6.000998932860907e-07 0.000960425183447966 \
6.589900000000113e-07 0 6.599999999999961e-07 0 6.600002111634403e-07 0.001900470962571042 6.600004424445472e-07 0.003982000924727166 \
6.600009050067609e-07 0.008145060849039413 6.600013623206272e-07 0.01226088564504064 6.600018368035255e-07 0.01653123172985639 6.600023692993678e-07 0.02132369430982749 \
6.600030391819417e-07 0.02735263747515369 6.600038962860512e-07 0.03506657446094884 6.600050110320462e-07 0.04509928841663746 6.600066320296376e-07 0.05968826673863754 \
6.600089746991287e-07 0.08077229215837188 6.600136600381108e-07 0.1229403429978405 6.600179644652403e-07 0.1616801871633537 6.600218144069514e-07 0.1963296625632528 \
6.600260784839173e-07 0.2347063552562001 6.600291484812914e-07 0.2623363316230807 6.600316114214461e-07 0.2845027930151538 6.600335732345164e-07 0.3021591106476817 \
6.600352830299905e-07 0.3175472699147922 6.60036786621731e-07 0.3310795955797556 6.600381257194662e-07 0.3431314751960884 6.600393723992328e-07 0.3543515930958913 \
6.600405143389069e-07 0.3646290501629268 6.600415723114469e-07 0.3741508030226791 6.600425813571894e-07 0.3832322147042228 6.600436002602279e-07 0.3924023420515681 \
6.60044556738474e-07 0.4010106462662745 6.60045504571866e-07 0.4095411467944404 6.600463681471743e-07 0.4173133245688312 6.60047110848452e-07 0.423997636067712 \
6.600477705629023e-07 0.4299350661209142 6.600484650928601e-07 0.4361858357407548 6.600491344399725e-07 0.4422099597530631 6.600497450055524e-07 0.4477050499714701 \
6.600505211590361e-07 0.454690431324675 6.600515775830366e-07 0.4641982473299416 6.600525733032823e-07 0.4731597295416305 6.600534391469966e-07 0.4809523229693754 \
6.600543752979998e-07 0.4893776819979773 6.600551017667356e-07 0.4959159006203305 6.600557679847268e-07 0.5019118625413875 6.600563829589108e-07 0.5074466301974319 \
6.600571676584685e-07 0.5145089262167936 6.600578769318571e-07 0.5208923867144013 6.600585767285569e-07 0.5271905570126808 6.600592411431324e-07 0.5331702881913303 \
6.600598964737336e-07 0.539068263602977 6.60060535798054e-07 0.5448221824871196 6.600611259457622e-07 0.5501335118600457 6.600616532498142e-07 0.5548792483285057 \
6.60062030104965e-07 0.5582709446854013 6.600624256351613e-07 0.5618307164525158 6.600627887403595e-07 0.5650986632355098 6.600631651750106e-07 0.5684865750957045 \
6.600635131548222e-07 0.5716183933999566 6.600637778468606e-07 0.5740006217454657 6.600640429855227e-07 0.5763868697045537 6.60064573262847e-07 0.5811593656227293 \
6.60064959313826e-07 0.5846338244342608 6.600653682102066e-07 0.5883138918597329 6.600658706357604e-07 0.5928357218442383 6.600664556501199e-07 0.5981008510799999 \
6.60066996785185e-07 0.6029710666652875 6.600674171443549e-07 0.6067542991940013 6.600678249828083e-07 0.6104248452748176 6.600682323094902e-07 0.6140907854118068 \
6.60068642157613e-07 0.6177794185173828 6.600690657994417e-07 0.62159219497586 6.600695100372108e-07 0.6255903348973357 6.600699667685954e-07 0.6297009173589793 \
6.600704445460432e-07 0.6340009143882042 6.600709750893297e-07 0.6387758039669345 6.600715414714156e-07 0.6438732427407217 6.600721454221392e-07 0.6493087992533674 \
6.600727933816249e-07 0.6551404346247349 6.600735057626028e-07 0.6615518634257037 6.600741684590509e-07 0.6675161314588195 6.600747811668178e-07 0.6730305013601764 \
6.600753590579442e-07 0.6782315214975446 6.600759217368732e-07 0.6832956318592801 6.600764833427613e-07 0.6883500848513783 6.600770748832363e-07 0.6936739491264482 \
6.600776559936408e-07 0.6989039427675531 6.600782307479107e-07 0.7040767311958204 6.600788319459405e-07 0.7094875134645067 6.600793248111816e-07 0.7139233006347314 \
6.600797518350406e-07 0.7177665153653698 6.600801538732531e-07 0.7213848592781456 6.600805379778643e-07 0.7248418007795954 6.600808980818888e-07 0.728082736999342 \
6.60081290978388e-07 0.731618805492268 6.600813508037621e-07 0.7321572338590965 6.600814704545103e-07 0.7332340905927537 6.600817097560066e-07 0.735387804060068 \
6.600819763221001e-07 0.7377868989013747 6.600822730492613e-07 0.7404574433520882 6.600827293899446e-07 0.7445645095019819 6.600831296418575e-07 0.7481667767176134 \
6.600835424114e-07 0.7518817026010159 6.600839113289174e-07 0.7552019602568045 6.600843349197573e-07 0.7590142778153435 6.600847045294426e-07 0.762340764983916 \
6.6008510473479e-07 0.7659426131102501 6.600854349382552e-07 0.7689144442964062 6.600857004950037e-07 0.7713044550329466 6.600859702562257e-07 0.7737323060316124 \
6.600863809870303e-07 0.7774288832736076 6.600866758593504e-07 0.7800827341539526 6.600870783969927e-07 0.7837055729337647 6.600874215941338e-07 0.786794347204456 \
6.600877744196534e-07 0.7899697768807414 6.60088101708689e-07 0.7929153782018739 6.600884210221113e-07 0.7957891990026931 6.600887276009603e-07 0.798548408642265 \
6.600890258756653e-07 0.8012328809879466 6.600893208487066e-07 0.8038876383597224 6.600895914592768e-07 0.8063231334915267 6.600898680486027e-07 0.808812437424818 \
6.600901524731702e-07 0.8113722585315476 6.600903934753628e-07 0.813541278265291 6.600906657780452e-07 0.8159920024070124 6.600909709274073e-07 0.8187383466657218 \
6.600912712185588e-07 0.8214409670293247 6.600915764870574e-07 0.8241883835163635 6.60091871067987e-07 0.8268396118826479 6.600921931045281e-07 0.8297379407530008 \
6.600924326540276e-07 0.8318938862491163 6.600926881285841e-07 0.8341931572572034 6.60092950748264e-07 0.8365567343768243 6.600931961574212e-07 0.8387654167908133 \
6.600934307182284e-07 0.8408764640555111 6.600936347744433e-07 0.8427129699896301 6.600938453663158e-07 0.8446082968424707 6.600940560049604e-07 0.8465040446443356 \
6.600942446553632e-07 0.8482018982687493 6.600944193128329e-07 0.8497738154964893 6.600945992789182e-07 0.8513935102645009 6.600947626880761e-07 0.8528641926851036 \
6.600949366307779e-07 0.854429677001575 6.600950916494697e-07 0.8558248452281332 6.600952586949033e-07 0.8573282541293438 6.600954170395381e-07 0.8587533558427882 \
6.600955855613502e-07 0.8602700521522246 6.600957427758094e-07 0.8616849822849083 6.600958614491536e-07 0.8627530423825936 6.600960118679143e-07 0.8641068112286804 \
6.600961364949332e-07 0.865228454399422 6.600962976891307e-07 0.8666792021766703 6.600964544667706e-07 0.8680902009355517 6.600965801168532e-07 0.8692210516792804 \
6.600967240522226e-07 0.8705164700033486 6.600968895884348e-07 0.8720062959137309 6.60097059053952e-07 0.8735314855691456 6.600972244384113e-07 0.8750199457013955 \
6.600973973536489e-07 0.8765761828405442 6.600975486087818e-07 0.8779374790365844 6.600977054558351e-07 0.8793491025165162 6.600978375604261e-07 0.8805380438351178 \
6.600979511689023e-07 0.8815605201209382 6.60098066732818e-07 0.8826005953617506 6.600981739445151e-07 0.8835655006364479 6.600982519496393e-07 0.8842675467541018 \
6.600983692038793e-07 0.8853228349141965 6.600984696135191e-07 0.886226521672304 6.600985772876734e-07 0.8871955890613133 6.600986534523481e-07 0.8878810711332904 \
6.600987609073831e-07 0.8888481664483866 6.600988542308148e-07 0.8896880773334693 6.60098954910124e-07 0.8905941911166799 6.600990497073693e-07 0.8914473663235497 \
6.600991358736903e-07 0.8922228632126831 6.600992263281601e-07 0.8930369534412941 6.600993660170764e-07 0.8942941536875396 6.60099486829852e-07 0.8953814686688766 \
6.600996124592936e-07 0.8965121336427553 6.600997566069462e-07 0.8978094625160885 6.600998929073789e-07 0.8990361664106589 7.000001758102986e-07 0.8984177073129849 \
7.000003877361149e-07 0.8965103749658082 7.000008115877475e-07 0.892695710271455 7.000012928172893e-07 0.8883646443965901 7.000018222188688e-07 0.8836000301806309 \
7.000024138577025e-07 0.8782752806762187 7.000031297402391e-07 0.8718323378482702 7.000040214704179e-07 0.8638067662390768 7.000051855656757e-07 0.8533299089180234 \
7.000067300393037e-07 0.8394296462657486 7.000090477353377e-07 0.8185703819595179 7.000131021755398e-07 0.7820804201414684 7.000204056090591e-07 0.7163495184672377 \
7.00024709552219e-07 0.6776140300278762 7.000277199251216e-07 0.6505206739058862 7.000310010700411e-07 0.6209903696287848 7.000334899484913e-07 0.5985904635786021 \
7.000356256577757e-07 0.5793690800177949 7.00037405976345e-07 0.5633462128944384 7.000390140106704e-07 0.5488739039651435 7.000404831996955e-07 0.5356512027400909 \
7.000418285509596e-07 0.5235430413622801 7.00043042811606e-07 0.512614695545089 7.000441792238918e-07 0.5023869849741911 7.000452298258402e-07 0.4929315674378034 \
7.000462112660969e-07 0.484098605128202 7.000471240497254e-07 0.4758835524716363 7.00048018804021e-07 0.4678307638102979 7.000488469775522e-07 0.4603772020305483 \
7.000496616407929e-07 0.4530452328630955 7.000505037998778e-07 0.4454658010995214 7.000513926171525e-07 0.4374664456271048 7.000521321735226e-07 0.430810438295329 \
7.000530270092319e-07 0.4227569169129836 7.00054107902427e-07 0.4130288781558488 7.000561152622711e-07 0.3949626395600662 7.00056875998171e-07 0.3881160164607345 \
7.00057811866421e-07 0.3796932022097708 7.000584871463133e-07 0.373615683179101 7.000591594028932e-07 0.3675653739608269 7.000599621211418e-07 0.3603409097239061 \
7.000607194141274e-07 0.3535252728520237 7.000614695536322e-07 0.3467740173091934 7.00062198861823e-07 0.3402102435925485 7.000629171974963e-07 0.3337452225319747 \
7.000635435959067e-07 0.3281076368399389 7.000639489157798e-07 0.3244597579820502 7.000644317377765e-07 0.3201143600118136 7.000648010781158e-07 0.3167902969580316 \
7.00065253165156e-07 0.3127215135955985 7.000656846607823e-07 0.3088380529590536 7.000660360228309e-07 0.3056757945211269 7.000662437559126e-07 0.3038061967869528 \
7.000665313819854e-07 0.3012175621312337 7.000667767138012e-07 0.2990095757891347 7.000670800984489e-07 0.2962791139586973 7.00067337968212e-07 0.2939582860917911 \
7.000675842641365e-07 0.2917416227702929 7.00068012140654e-07 0.2878907341130054 7.000684326169099e-07 0.2841064478110101 7.000689744294792e-07 0.2792301346858994 \
7.000694310496986e-07 0.2751205527117666 7.000698649698748e-07 0.2712152711268295 7.000702762505369e-07 0.2675137451671025 7.000707093494526e-07 0.2636158549267912 \
7.000711257521107e-07 0.2598682310032753 7.000715772789095e-07 0.2558044898132805 7.000720198267563e-07 0.2518215591932373 7.000724867531406e-07 0.2476192217332239 \
7.000729779079944e-07 0.2431988280497077 7.000734969797613e-07 0.2385271821480127 7.000740655752672e-07 0.2334098225947888 7.000746646288799e-07 0.2280183400805964 \
7.000752953396526e-07 0.2223419431252401 7.000760279285459e-07 0.2157486430863834 7.000767372312741e-07 0.2093649185333881 7.000774052783737e-07 0.2033524946355669 \
7.000780314861685e-07 0.1977166244827963 7.000786423893507e-07 0.1922184958436388 7.000792377776885e-07 0.1868600008026635 7.00079853866796e-07 0.1813151988360575 \
7.000804543976034e-07 0.1759104215697842 7.000810467364748e-07 0.1705793717271608 7.000816706037986e-07 0.164964565812095 7.000822539901237e-07 0.1597140888870844 \
7.000827867469318e-07 0.1549192776137643 7.000833311463823e-07 0.1500196825588286 7.000838590783176e-07 0.1452682951413614 7.00084435818527e-07 0.1400776332571309 \
7.000850022377844e-07 0.1349798599404549 7.000855520823249e-07 0.1300312590758997 7.000861686813856e-07 0.1244818675298257 7.000866369972226e-07 0.1202670249965557 \
7.000872299951725e-07 0.114930043447014 7.000876909574824e-07 0.1107813826574622 7.000881066844685e-07 0.1070398397831492 7.00088462796911e-07 0.1038348278011874 \
7.000888104250938e-07 0.1007061741557836 7.000891128590561e-07 0.09798426849538755 7.000894173801862e-07 0.09524357832398211 7.000896897024938e-07 0.09279267755476828 \
7.000899532804389e-07 0.09042047604958559 7.000901972751046e-07 0.08822452405742931 7.000904672234071e-07 0.08579498933604146 7.000907063969493e-07 0.08364242745616901 \
7.000909698641176e-07 0.08127122294071432 7.000912247411013e-07 0.07897733008697083 7.000914549713495e-07 0.07690525785341851 7.000917197517262e-07 0.07452223446371342 \
7.00092001524411e-07 0.07198628030108556 7.000922771037338e-07 0.06950606639574286 7.000926178497145e-07 0.06643935256942901 7.00092904771124e-07 0.06385705988345824 \
7.000932105231113e-07 0.06110529199863279 7.000935025276798e-07 0.0584772508810687 7.000937743584832e-07 0.05603077365032616 7.000940213615499e-07 0.05380774605057426 \
7.000942171920341e-07 0.05204527169284134 7.000943943123614e-07 0.05045118874764443 7.000945695254918e-07 0.04887427057365767 7.000947271734062e-07 0.04745543934452334 \
7.000948749691591e-07 0.04612527756805263 7.000950200501117e-07 0.04481954899450691 7.000951580483332e-07 0.0435775650013065 7.000953003028957e-07 0.04229727393901672 \
7.000954263034713e-07 0.04116326875785103 7.000955598319524e-07 0.03996151242777013 7.000956821020666e-07 0.03886108140050326 7.000958151620154e-07 0.0376635418603275 \
7.000959296039086e-07 0.03663356482247337 7.000960217395756e-07 0.03580434381845876 7.000961185938143e-07 0.03493265567158488 7.000962580032994e-07 0.03367797030500419 \
7.000963723296091e-07 0.03264903351765647 7.000964819349537e-07 0.03166258541696143 7.00096615187473e-07 0.03046331274235659 7.000967280577828e-07 0.02944747995458197 \
7.000968505551189e-07 0.02834500393025741 7.000969864971123e-07 0.02712152598905548 7.000971045042058e-07 0.02605946214676502 7.000972335603972e-07 0.02489795642556891 \
7.000973440508587e-07 0.02390354227171532 7.000974794893149e-07 0.02268459616553509 7.000975991229855e-07 0.02160789312944722 7.000977000043597e-07 0.02069996076227698 \
7.000978203514514e-07 0.01961683693679572 7.000979616112103e-07 0.01834549910740102 7.000981236968955e-07 0.01688672794015589 7.000982728348491e-07 0.01554448635840755 \
7.000984257131347e-07 0.014168581787533 7.000985760067313e-07 0.01281593941858328 7.000987228351462e-07 0.01149448368366224 7.000988791913148e-07 0.01008727816647481 \
7.000989984546064e-07 0.009013908541385951 7.000990930871204e-07 0.008162215916559523 7.000991965644665e-07 0.007230919801462066 7.00099269048437e-07 0.006578564066408443 \
7.00099347396487e-07 0.005873431617253289 7.000994370778812e-07 0.005066299068704372 7.000995698899392e-07 0.003870990547362063 7.000996714898243e-07 0.002956591581575796 \
7.000997774547151e-07 0.002002907563398826 7.000998932860907e-07 0.000960425183447966 7.589900000000112e-07 0 7.599999999999961e-07 0 \
7.600002111634402e-07 0.001900470962571042 7.600004424445472e-07 0.003982000924727166 7.600009050067609e-07 0.008145060849039413 7.600013623206272e-07 0.01226088564504064 \
7.600018368035255e-07 0.01653123172985639 7.600023692993677e-07 0.02132369430982749 7.600030391819417e-07 0.02735263747515369 7.600038962860512e-07 0.03506657446094884 \
7.600050110320462e-07 0.04509928841663746 7.600066320296376e-07 0.05968826673863754 7.600089746991287e-07 0.08077229215837188 7.600136600381108e-07 0.1229403429978405 \
7.600179644652403e-07 0.1616801871633537 7.600218144069514e-07 0.1963296625632528 7.600260784839173e-07 0.2347063552562001 7.600291484812914e-07 0.2623363316230807 \
7.60031611421446e-07 0.2845027930151538 7.600335732345164e-07 0.3021591106476817 7.600352830299905e-07 0.3175472699147922 7.60036786621731e-07 0.3310795955797556 \
7.600381257194662e-07 0.3431314751960884 7.600393723992328e-07 0.3543515930958913 7.600405143389069e-07 0.3646290501629268 7.60041572311447e-07 0.3741508030226791 \
7.600425813571894e-07 0.3832322147042228 7.600436002602279e-07 0.3924023420515681 7.60044556738474e-07 0.4010106462662745 7.600455045718661e-07 0.4095411467944404 \
7.600463681471743e-07 0.4173133245688312 7.60047110848452e-07 0.423997636067712 7.600477705629023e-07 0.4299350661209142 7.600484650928601e-07 0.4361858357407548 \
7.600491344399725e-07 0.4422099597530631 7.600497450055524e-07 0.4477050499714701 7.600505211590361e-07 0.454690431324675 7.600515775830366e-07 0.4641982473299416 \
7.600525733032824e-07 0.4731597295416305 7.600534391469965e-07 0.4809523229693754 7.600543752979998e-07 0.4893776819979773 7.600551017667355e-07 0.4959159006203305 \
7.600557679847268e-07 0.5019118625413875 7.600563829589107e-07 0.5074466301974319 7.600571676584685e-07 0.5145089262167936 7.600578769318572e-07 0.5208923867144013 \
7.60058576728557e-07 0.5271905570126808 7.600592411431324e-07 0.5331702881913303 7.600598964737336e-07 0.539068263602977 7.600605357980541e-07 0.5448221824871196 \
7.600611259457622e-07 0.5501335118600457 7.600616532498142e-07 0.5548792483285057 7.60062030104965e-07 0.5582709446854013 7.600624256351613e-07 0.5618307164525158 \
7.600627887403595e-07 0.5650986632355098 7.600631651750106e-07 0.5684865750957045 7.600635131548222e-07 0.5716183933999566 7.600637778468606e-07 0.5740006217454657 \
7.600640429855227e-07 0.5763868697045537 7.600645732628469e-07 0.5811593656227293 7.60064959313826e-07 0.5846338244342608 7.600653682102066e-07 0.5883138918597329 \
7.600658706357605e-07 0.5928357218442383 7.600664556501199e-07 0.5981008510799999 7.60066996785185e-07 0.6029710666652875 7.600674171443549e-07 0.6067542991940013 \
7.600678249828083e-07 0.6104248452748176 7.600682323094902e-07 0.6140907854118068 7.60068642157613e-07 0.6177794185173828 7.600690657994417e-07 0.62159219497586 \
7.600695100372108e-07 0.6255903348973357 7.600699667685954e-07 0.6297009173589793 7.60070444546043e-07 0.6340009143882042 7.600709750893296e-07 0.6387758039669345 \
7.600715414714156e-07 0.6438732427407217 7.600721454221392e-07 0.6493087992533674 7.600727933816249e-07 0.6551404346247349 7.600735057626028e-07 0.6615518634257037 \
7.600741684590509e-07 0.6675161314588195 7.600747811668178e-07 0.6730305013601764 7.600753590579442e-07 0.6782315214975446 7.600759217368732e-07 0.6832956318592801 \
7.600764833427613e-07 0.6883500848513783 7.600770748832362e-07 0.6936739491264482 7.600776559936408e-07 0.6989039427675531 7.600782307479106e-07 0.7040767311958204 \
7.600788319459405e-07 0.7094875134645067 7.600793248111816e-07 0.7139233006347314 7.600797518350405e-07 0.7177665153653698 7.600801538732531e-07 0.7213848592781456 \
7.600805379778643e-07 0.7248418007795954 7.600808980818888e-07 0.728082736999342 7.60081290978388e-07 0.731618805492268 7.600813508037621e-07 0.7321572338590965 \
7.600814704545103e-07 0.7332340905927537 7.600817097560066e-07 0.735387804060068 7.600819763221001e-07 0.7377868989013747 7.600822730492613e-07 0.7404574433520882 \
7.600827293899446e-07 0.7445645095019819 7.600831296418575e-07 0.7481667767176134 7.600835424114e-07 0.7518817026010159 7.600839113289174e-07 0.7552019602568045 \
7.600843349197572e-07 0.7590142778153435 7.600847045294426e-07 0.762340764983916 7.6008510473479e-07 0.7659426131102501 7.600854349382551e-07 0.7689144442964062 \
7.600857004950037e-07 0.7713044550329466 7.600859702562257e-07 0.7737323060316124 7.600863809870304e-07 0.7774288832736076 7.600866758593504e-07 0.7800827341539526 \
7.600870783969926e-07 0.7837055729337647 7.600874215941338e-07 0.786794347204456 7.600877744196534e-07 0.7899697768807414 7.60088101708689e-07 0.7929153782018739 \
7.600884210221113e-07 0.7957891990026931 7.600887276009603e-07 0.798548408642265 7.600890258756652e-07 0.8012328809879466 7.600893208487066e-07 0.8038876383597224 \
7.600895914592768e-07 0.8063231334915267 7.600898680486028e-07 0.808812437424818 7.600901524731702e-07 0.8113722585315476 7.600903934753627e-07 0.813541278265291 \
7.600906657780451e-07 0.8159920024070124 7.600909709274073e-07 0.8187383466657218 7.600912712185588e-07 0.8214409670293247 7.600915764870574e-07 0.8241883835163635 \
7.600918710679869e-07 0.8268396118826479 7.600921931045281e-07 0.8297379407530008 7.600924326540276e-07 0.8318938862491163 7.600926881285841e-07 0.8341931572572034 \
7.60092950748264e-07 0.8365567343768243 7.600931961574212e-07 0.8387654167908133 7.600934307182284e-07 0.8408764640555111 7.600936347744432e-07 0.8427129699896301 \
7.600938453663158e-07 0.8446082968424707 7.600940560049604e-07 0.8465040446443356 7.600942446553632e-07 0.8482018982687493 7.600944193128329e-07 0.8497738154964893 \
7.600945992789182e-07 0.8513935102645009 7.600947626880761e-07 0.8528641926851036 7.600949366307779e-07 0.854429677001575 7.600950916494697e-07 0.8558248452281332 \
7.600952586949032e-07 0.8573282541293438 7.600954170395381e-07 0.8587533558427882 7.600955855613502e-07 0.8602700521522246 7.600957427758094e-07 0.8616849822849083 \
7.600958614491536e-07 0.8627530423825936 7.600960118679143e-07 0.8641068112286804 7.600961364949332e-07 0.865228454399422 7.600962976891307e-07 0.8666792021766703 \
7.600964544667706e-07 0.8680902009355517 7.600965801168532e-07 0.8692210516792804 7.600967240522226e-07 0.8705164700033486 7.600968895884348e-07 0.8720062959137309 \
7.600970590539521e-07 0.8735314855691456 7.600972244384113e-07 0.8750199457013955 7.600973973536489e-07 0.8765761828405442 7.600975486087818e-07 0.8779374790365844 \
7.600977054558351e-07 0.8793491025165162 7.60097837560426e-07 0.8805380438351178 7.600979511689023e-07 0.8815605201209382 7.60098066732818e-07 0.8826005953617506 \
7.600981739445151e-07 0.8835655006364479 7.600982519496393e-07 0.8842675467541018 7.600983692038793e-07 0.8853228349141965 7.600984696135191e-07 0.886226521672304 \
7.600985772876734e-07 0.8871955890613133 7.600986534523481e-07 0.8878810711332904 7.600987609073831e-07 0.8888481664483866 7.600988542308148e-07 0.8896880773334693 \
7.60098954910124e-07 0.8905941911166799 7.600990497073693e-07 0.8914473663235497 7.600991358736902e-07 0.8922228632126831 7.600992263281601e-07 0.8930369534412941 \
7.600993660170764e-07 0.8942941536875396 7.60099486829852e-07 0.8953814686688766 7.600996124592936e-07 0.8965121336427553 7.600997566069462e-07 0.8978094625160885 \
7.600998929073789e-07 0.8990361664106589 8.000001758102986e-07 0.8984177073129849 8.000003877361148e-07 0.8965103749658082 8.000008115877475e-07 0.892695710271455 \
8.000012928172893e-07 0.8883646443965901 8.000018222188688e-07 0.8836000301806309 8.000024138577025e-07 0.8782752806762187 8.00003129740239e-07 0.8718323378482702 \
8.000040214704179e-07 0.8638067662390768 8.000051855656757e-07 0.8533299089180234 8.000067300393037e-07 0.8394296462657486 8.000090477353377e-07 0.8185703819595179 \
8.000131021755398e-07 0.7820804201414684 8.000204056090592e-07 0.7163495184672377 8.00024709552219e-07 0.6776140300278762 8.000277199251216e-07 0.6505206739058862 \
8.000310010700411e-07 0.6209903696287848 8.000334899484913e-07 0.5985904635786021 8.000356256577757e-07 0.5793690800177949 8.00037405976345e-07 0.5633462128944384 \
8.000390140106704e-07 0.5488739039651435 8.000404831996955e-07 0.5356512027400909 8.000418285509596e-07 0.5235430413622801 8.00043042811606e-07 0.512614695545089 \
8.000441792238918e-07 0.5023869849741911 8.000452298258402e-07 0.4929315674378034 8.000462112660969e-07 0.484098605128202 8.000471240497254e-07 0.4758835524716363 \
8.000480188040211e-07 0.4678307638102979 8.000488469775522e-07 0.4603772020305483 8.000496616407929e-07 0.4530452328630955 8.000505037998778e-07 0.4454658010995214 \
8.000513926171525e-07 0.4374664456271048 8.000521321735227e-07 0.430810438295329 8.000530270092319e-07 0.4227569169129836 8.00054107902427e-07 0.4130288781558488 \
8.000561152622711e-07 0.3949626395600662 8.00056875998171e-07 0.3881160164607345 8.00057811866421e-07 0.3796932022097708 8.000584871463133e-07 0.373615683179101 \
8.000591594028932e-07 0.3675653739608269 8.000599621211418e-07 0.3603409097239061 8.000607194141274e-07 0.3535252728520237 8.000614695536322e-07 0.3467740173091934 \
8.000621988618229e-07 0.3402102435925485 8.000629171974963e-07 0.3337452225319747 8.000635435959067e-07 0.3281076368399389 8.000639489157798e-07 0.3244597579820502 \
8.000644317377765e-07 0.3201143600118136 8.000648010781158e-07 0.3167902969580316 8.00065253165156e-07 0.3127215135955985 8.000656846607823e-07 0.3088380529590536 \
8.000660360228309e-07 0.3056757945211269 8.000662437559126e-07 0.3038061967869528 8.000665313819854e-07 0.3012175621312337 8.000667767138012e-07 0.2990095757891347 \
8.000670800984489e-07 0.2962791139586973 8.00067337968212e-07 0.2939582860917911 8.000675842641365e-07 0.2917416227702929 8.00068012140654e-07 0.2878907341130054 \
8.000684326169099e-07 0.2841064478110101 8.000689744294792e-07 0.2792301346858994 8.000694310496986e-07 0.2751205527117666 8.000698649698748e-07 0.2712152711268295 \
8.000702762505369e-07 0.2675137451671025 8.000707093494526e-07 0.2636158549267912 8.000711257521107e-07 0.2598682310032753 8.000715772789096e-07 0.2558044898132805 \
8.000720198267563e-07 0.2518215591932373 8.000724867531406e-07 0.2476192217332239 8.000729779079944e-07 0.2431988280497077 8.000734969797613e-07 0.2385271821480127 \
8.000740655752672e-07 0.2334098225947888 8.000746646288799e-07 0.2280183400805964 8.000752953396526e-07 0.2223419431252401 8.000760279285459e-07 0.2157486430863834 \
8.000767372312741e-07 0.2093649185333881 8.000774052783737e-07 0.2033524946355669 8.000780314861685e-07 0.1977166244827963 8.000786423893507e-07 0.1922184958436388 \
8.000792377776886e-07 0.1868600008026635 8.00079853866796e-07 0.1813151988360575 8.000804543976034e-07 0.1759104215697842 8.000810467364748e-07 0.1705793717271608 \
8.000816706037987e-07 0.164964565812095 8.000822539901237e-07 0.1597140888870844 8.000827867469318e-07 0.1549192776137643 8.000833311463823e-07 0.1500196825588286 \
8.000838590783176e-07 0.1452682951413614 8.000844358185269e-07 0.1400776332571309 8.000850022377844e-07 0.1349798599404549 8.000855520823249e-07 0.1300312590758997 \
8.000861686813856e-07 0.1244818675298257 8.000866369972226e-07 0.1202670249965557 8.000872299951725e-07 0.114930043447014 8.000876909574824e-07 0.1107813826574622 \
8.000881066844685e-07 0.1070398397831492 8.00088462796911e-07 0.1038348278011874 8.000888104250938e-07 0.1007061741557836 8.00089112859056e-07 0.09798426849538755 \
8.000894173801862e-07 0.09524357832398211 8.000896897024939e-07 0.09279267755476828 8.000899532804389e-07 0.09042047604958559 8.000901972751046e-07 0.08822452405742931 \
8.000904672234071e-07 0.08579498933604146 8.000907063969492e-07 0.08364242745616901 8.000909698641176e-07 0.08127122294071432 8.000912247411014e-07 0.07897733008697083 \
8.000914549713495e-07 0.07690525785341851 8.000917197517262e-07 0.07452223446371342 8.00092001524411e-07 0.07198628030108556 8.000922771037338e-07 0.06950606639574286 \
8.000926178497144e-07 0.06643935256942901 8.00092904771124e-07 0.06385705988345824 8.000932105231113e-07 0.06110529199863279 8.000935025276798e-07 0.0584772508810687 \
8.000937743584832e-07 0.05603077365032616 8.000940213615499e-07 0.05380774605057426 8.000942171920341e-07 0.05204527169284134 8.000943943123614e-07 0.05045118874764443 \
8.000945695254918e-07 0.04887427057365767 8.000947271734062e-07 0.04745543934452334 8.00094874969159e-07 0.04612527756805263 8.000950200501116e-07 0.04481954899450691 \
8.000951580483332e-07 0.0435775650013065 8.000953003028957e-07 0.04229727393901672 8.000954263034713e-07 0.04116326875785103 8.000955598319524e-07 0.03996151242777013 \
8.000956821020666e-07 0.03886108140050326 8.000958151620155e-07 0.0376635418603275 8.000959296039086e-07 0.03663356482247337 8.000960217395756e-07 0.03580434381845876 \
8.000961185938142e-07 0.03493265567158488 8.000962580032994e-07 0.03367797030500419 8.00096372329609e-07 0.03264903351765647 8.000964819349537e-07 0.03166258541696143 \
8.00096615187473e-07 0.03046331274235659 8.000967280577827e-07 0.02944747995458197 8.000968505551189e-07 0.02834500393025741 8.000969864971123e-07 0.02712152598905548 \
8.000971045042058e-07 0.02605946214676502 8.000972335603972e-07 0.02489795642556891 8.000973440508587e-07 0.02390354227171532 8.000974794893149e-07 0.02268459616553509 \
8.000975991229855e-07 0.02160789312944722 8.000977000043597e-07 0.02069996076227698 8.000978203514514e-07 0.01961683693679572 8.000979616112103e-07 0.01834549910740102 \
8.000981236968954e-07 0.01688672794015589 8.000982728348491e-07 0.01554448635840755 8.000984257131347e-07 0.014168581787533 8.000985760067313e-07 0.01281593941858328 \
8.000987228351463e-07 0.01149448368366224 8.000988791913148e-07 0.01008727816647481 8.000989984546064e-07 0.009013908541385951 8.000990930871204e-07 0.008162215916559523 \
8.000991965644665e-07 0.007230919801462066 8.000992690484371e-07 0.006578564066408443 8.000993473964869e-07 0.005873431617253289 8.000994370778812e-07 0.005066299068704372 \
8.000995698899392e-07 0.003870990547362063 8.000996714898243e-07 0.002956591581575796 8.000997774547151e-07 0.002002907563398826 8.000998932860907e-07 0.000960425183447966 \
8.589900000000113e-07 0 8.599999999999961e-07 0 8.600002111634402e-07 0.001900470962571042 8.600004424445472e-07 0.003982000924727166 \
8.600009050067609e-07 0.008145060849039413 8.600013623206272e-07 0.01226088564504064 8.600018368035255e-07 0.01653123172985639 8.600023692993677e-07 0.02132369430982749 \
8.600030391819417e-07 0.02735263747515369 8.600038962860511e-07 0.03506657446094884 8.600050110320462e-07 0.04509928841663746 8.600066320296376e-07 0.05968826673863754 \
8.600089746991287e-07 0.08077229215837188 8.600136600381108e-07 0.1229403429978405 8.600179644652403e-07 0.1616801871633537 8.600218144069514e-07 0.1963296625632528 \
8.600260784839173e-07 0.2347063552562001 8.600291484812914e-07 0.2623363316230807 8.600316114214461e-07 0.2845027930151538 8.600335732345164e-07 0.3021591106476817 \
8.600352830299905e-07 0.3175472699147922 8.60036786621731e-07 0.3310795955797556 8.600381257194662e-07 0.3431314751960884 8.600393723992328e-07 0.3543515930958913 \
8.600405143389069e-07 0.3646290501629268 8.600415723114469e-07 0.3741508030226791 8.600425813571894e-07 0.3832322147042228 8.600436002602279e-07 0.3924023420515681 \
8.60044556738474e-07 0.4010106462662745 8.60045504571866e-07 0.4095411467944404 8.600463681471743e-07 0.4173133245688312 8.60047110848452e-07 0.423997636067712 \
8.600477705629023e-07 0.4299350661209142 8.600484650928601e-07 0.4361858357407548 8.600491344399725e-07 0.4422099597530631 8.600497450055524e-07 0.4477050499714701 \
8.600505211590361e-07 0.454690431324675 8.600515775830366e-07 0.4641982473299416 8.600525733032823e-07 0.4731597295416305 8.600534391469965e-07 0.4809523229693754 \
8.600543752979998e-07 0.4893776819979773 8.600551017667356e-07 0.4959159006203305 8.600557679847268e-07 0.5019118625413875 8.600563829589107e-07 0.5074466301974319 \
8.600571676584685e-07 0.5145089262167936 8.600578769318571e-07 0.5208923867144013 8.600585767285569e-07 0.5271905570126808 8.600592411431324e-07 0.5331702881913303 \
8.600598964737336e-07 0.539068263602977 8.60060535798054e-07 0.5448221824871196 8.600611259457622e-07 0.5501335118600457 8.600616532498142e-07 0.5548792483285057 \
8.60062030104965e-07 0.5582709446854013 8.600624256351613e-07 0.5618307164525158 8.600627887403595e-07 0.5650986632355098 8.600631651750106e-07 0.5684865750957045 \
8.600635131548222e-07 0.5716183933999566 8.600637778468606e-07 0.5740006217454657 8.600640429855227e-07 0.5763868697045537 8.60064573262847e-07 0.5811593656227293 \
8.60064959313826e-07 0.5846338244342608 8.600653682102066e-07 0.5883138918597329 8.600658706357604e-07 0.5928357218442383 8.600664556501199e-07 0.5981008510799999 \
8.60066996785185e-07 0.6029710666652875 8.600674171443548e-07 0.6067542991940013 8.600678249828083e-07 0.6104248452748176 8.600682323094902e-07 0.6140907854118068 \
8.60068642157613e-07 0.6177794185173828 8.600690657994417e-07 0.62159219497586 8.600695100372108e-07 0.6255903348973357 8.600699667685954e-07 0.6297009173589793 \
8.600704445460431e-07 0.6340009143882042 8.600709750893297e-07 0.6387758039669345 8.600715414714156e-07 0.6438732427407217 8.600721454221392e-07 0.6493087992533674 \
8.600727933816249e-07 0.6551404346247349 8.600735057626028e-07 0.6615518634257037 8.600741684590509e-07 0.6675161314588195 8.600747811668178e-07 0.6730305013601764 \
8.600753590579442e-07 0.6782315214975446 8.600759217368732e-07 0.6832956318592801 8.600764833427613e-07 0.6883500848513783 8.600770748832363e-07 0.6936739491264482 \
8.600776559936408e-07 0.6989039427675531 8.600782307479107e-07 0.7040767311958204 8.600788319459405e-07 0.7094875134645067 8.600793248111816e-07 0.7139233006347314 \
8.600797518350406e-07 0.7177665153653698 8.600801538732531e-07 0.7213848592781456 8.600805379778643e-07 0.7248418007795954 8.600808980818888e-07 0.728082736999342 \
8.60081290978388e-07 0.731618805492268 8.600813508037621e-07 0.7321572338590965 8.600814704545103e-07 0.7332340905927537 8.600817097560066e-07 0.735387804060068 \
8.600819763221001e-07 0.7377868989013747 8.600822730492613e-07 0.7404574433520882 8.600827293899446e-07 0.7445645095019819 8.600831296418575e-07 0.7481667767176134 \
8.600835424114e-07 0.7518817026010159 8.600839113289174e-07 0.7552019602568045 8.600843349197572e-07 0.7590142778153435 8.600847045294426e-07 0.762340764983916 \
8.6008510473479e-07 0.7659426131102501 8.600854349382551e-07 0.7689144442964062 8.600857004950037e-07 0.7713044550329466 8.600859702562257e-07 0.7737323060316124 \
8.600863809870303e-07 0.7774288832736076 8.600866758593504e-07 0.7800827341539526 8.600870783969927e-07 0.7837055729337647 8.600874215941338e-07 0.786794347204456 \
8.600877744196534e-07 0.7899697768807414 8.60088101708689e-07 0.7929153782018739 8.600884210221113e-07 0.7957891990026931 8.600887276009602e-07 0.798548408642265 \
8.600890258756653e-07 0.8012328809879466 8.600893208487066e-07 0.8038876383597224 8.600895914592768e-07 0.8063231334915267 8.600898680486027e-07 0.808812437424818 \
8.600901524731702e-07 0.8113722585315476 8.600903934753627e-07 0.813541278265291 8.600906657780452e-07 0.8159920024070124 8.600909709274073e-07 0.8187383466657218 \
8.600912712185588e-07 0.8214409670293247 8.600915764870574e-07 0.8241883835163635 8.60091871067987e-07 0.8268396118826479 8.600921931045281e-07 0.8297379407530008 \
8.600924326540276e-07 0.8318938862491163 8.600926881285841e-07 0.8341931572572034 8.60092950748264e-07 0.8365567343768243 8.600931961574212e-07 0.8387654167908133 \
8.600934307182284e-07 0.8408764640555111 8.600936347744433e-07 0.8427129699896301 8.600938453663157e-07 0.8446082968424707 8.600940560049604e-07 0.8465040446443356 \
8.600942446553632e-07 0.8482018982687493 8.600944193128329e-07 0.8497738154964893 8.600945992789182e-07 0.8513935102645009 8.600947626880761e-07 0.8528641926851036 \
8.600949366307779e-07 0.854429677001575 8.600950916494697e-07 0.8558248452281332 8.600952586949033e-07 0.8573282541293438 8.60095417039538e-07 0.8587533558427882 \
8.600955855613502e-07 0.8602700521522246 8.600957427758094e-07 0.8616849822849083 8.600958614491536e-07 0.8627530423825936 8.600960118679143e-07 0.8641068112286804 \
8.600961364949332e-07 0.865228454399422 8.600962976891307e-07 0.8666792021766703 8.600964544667706e-07 0.8680902009355517 8.600965801168532e-07 0.8692210516792804 \
8.600967240522226e-07 0.8705164700033486 8.600968895884348e-07 0.8720062959137309 8.60097059053952e-07 0.8735314855691456 8.600972244384113e-07 0.8750199457013955 \
8.600973973536489e-07 0.8765761828405442 8.600975486087818e-07 0.8779374790365844 8.600977054558351e-07 0.8793491025165162 8.600978375604261e-07 0.8805380438351178 \
8.600979511689023e-07 0.8815605201209382 8.60098066732818e-07 0.8826005953617506 8.600981739445151e-07 0.8835655006364479 8.600982519496393e-07 0.8842675467541018 \
8.600983692038793e-07 0.8853228349141965 8.600984696135191e-07 0.886226521672304 8.600985772876734e-07 0.8871955890613133 8.600986534523481e-07 0.8878810711332904 \
8.600987609073831e-07 0.8888481664483866 8.600988542308148e-07 0.8896880773334693 8.60098954910124e-07 0.8905941911166799 8.600990497073693e-07 0.8914473663235497 \
8.600991358736903e-07 0.8922228632126831 8.600992263281601e-07 0.8930369534412941 8.600993660170764e-07 0.8942941536875396 8.60099486829852e-07 0.8953814686688766 \
8.600996124592936e-07 0.8965121336427553 8.600997566069462e-07 0.8978094625160885 8.600998929073789e-07 0.8990361664106589 9.000001758102986e-07 0.8984177073129849 \
9.000003877361149e-07 0.8965103749658082 9.000008115877475e-07 0.892695710271455 9.000012928172893e-07 0.8883646443965901 9.000018222188688e-07 0.8836000301806309 \
9.000024138577025e-07 0.8782752806762187 9.000031297402391e-07 0.8718323378482702 9.000040214704179e-07 0.8638067662390768 9.000051855656757e-07 0.8533299089180234 \
9.000067300393037e-07 0.8394296462657486 9.000090477353377e-07 0.8185703819595179 9.000131021755398e-07 0.7820804201414684 9.000204056090591e-07 0.7163495184672377 \
9.00024709552219e-07 0.6776140300278762 9.000277199251216e-07 0.6505206739058862 9.000310010700411e-07 0.6209903696287848 9.000334899484913e-07 0.5985904635786021 \
9.000356256577757e-07 0.5793690800177949 9.00037405976345e-07 0.5633462128944384 9.000390140106704e-07 0.5488739039651435 9.000404831996955e-07 0.5356512027400909 \
9.000418285509596e-07 0.5235430413622801 9.00043042811606e-07 0.512614695545089 9.000441792238918e-07 0.5023869849741911 9.000452298258402e-07 0.4929315674378034 \
9.000462112660969e-07 0.484098605128202 9.000471240497254e-07 0.4758835524716363 9.00048018804021e-07 0.4678307638102979 9.000488469775522e-07 0.4603772020305483 \
9.000496616407929e-07 0.4530452328630955 9.000505037998778e-07 0.4454658010995214 9.000513926171525e-07 0.4374664456271048 9.000521321735226e-07 0.430810438295329 \
9.000530270092318e-07 0.4227569169129836 9.00054107902427e-07 0.4130288781558488 9.000561152622711e-07 0.3949626395600662 9.00056875998171e-07 0.3881160164607345 \
9.00057811866421e-07 0.3796932022097708 9.000584871463133e-07 0.373615683179101 9.000591594028932e-07 0.3675653739608269 9.000599621211418e-07 0.3603409097239061 \
9.000607194141274e-07 0.3535252728520237 9.000614695536322e-07 0.3467740173091934 9.000621988618229e-07 0.3402102435925485 9.000629171974963e-07 0.3337452225319747 \
9.000635435959067e-07 0.3281076368399389 9.000639489157798e-07 0.3244597579820502 9.000644317377765e-07 0.3201143600118136 9.000648010781158e-07 0.3167902969580316 \
9.00065253165156e-07 0.3127215135955985 9.000656846607823e-07 0.3088380529590536 9.000660360228309e-07 0.3056757945211269 9.000662437559125e-07 0.3038061967869528 \
9.000665313819854e-07 0.3012175621312337 9.000667767138012e-07 0.2990095757891347 9.000670800984489e-07 0.2962791139586973 9.00067337968212e-07 0.2939582860917911 \
9.000675842641365e-07 0.2917416227702929 9.00068012140654e-07 0.2878907341130054 9.000684326169099e-07 0.2841064478110101 9.000689744294792e-07 0.2792301346858994 \
9.000694310496986e-07 0.2751205527117666 9.000698649698748e-07 0.2712152711268295 9.000702762505369e-07 0.2675137451671025 9.000707093494526e-07 0.2636158549267912 \
9.000711257521107e-07 0.2598682310032753 9.000715772789095e-07 0.2558044898132805 9.000720198267563e-07 0.2518215591932373 9.000724867531406e-07 0.2476192217332239 \
9.000729779079944e-07 0.2431988280497077 9.000734969797613e-07 0.2385271821480127 9.000740655752672e-07 0.2334098225947888 9.000746646288799e-07 0.2280183400805964 \
9.000752953396526e-07 0.2223419431252401 9.000760279285459e-07 0.2157486430863834 9.000767372312741e-07 0.2093649185333881 9.000774052783737e-07 0.2033524946355669 \
9.000780314861685e-07 0.1977166244827963 9.000786423893507e-07 0.1922184958436388 9.000792377776885e-07 0.1868600008026635 9.00079853866796e-07 0.1813151988360575 \
9.000804543976034e-07 0.1759104215697842 9.000810467364747e-07 0.1705793717271608 9.000816706037986e-07 0.164964565812095 9.000822539901237e-07 0.1597140888870844 \
9.000827867469318e-07 0.1549192776137643 9.000833311463823e-07 0.1500196825588286 9.000838590783176e-07 0.1452682951413614 9.000844358185269e-07 0.1400776332571309 \
9.000850022377844e-07 0.1349798599404549 9.000855520823249e-07 0.1300312590758997 9.000861686813856e-07 0.1244818675298257 9.000866369972226e-07 0.1202670249965557 \
9.000872299951725e-07 0.114930043447014 9.000876909574824e-07 0.1107813826574622 9.000881066844685e-07 0.1070398397831492 9.00088462796911e-07 0.1038348278011874 \
9.000888104250938e-07 0.1007061741557836 9.000891128590561e-07 0.09798426849538755 9.000894173801862e-07 0.09524357832398211 9.000896897024938e-07 0.09279267755476828 \
9.000899532804389e-07 0.09042047604958559 9.000901972751046e-07 0.08822452405742931 9.000904672234071e-07 0.08579498933604146 9.000907063969493e-07 0.08364242745616901 \
9.000909698641176e-07 0.08127122294071432 9.000912247411013e-07 0.07897733008697083 9.000914549713495e-07 0.07690525785341851 9.000917197517262e-07 0.07452223446371342 \
9.00092001524411e-07 0.07198628030108556 9.000922771037338e-07 0.06950606639574286 9.000926178497145e-07 0.06643935256942901 9.00092904771124e-07 0.06385705988345824 \
9.000932105231112e-07 0.06110529199863279 9.000935025276798e-07 0.0584772508810687 9.000937743584832e-07 0.05603077365032616 9.000940213615499e-07 0.05380774605057426 \
9.000942171920341e-07 0.05204527169284134 9.000943943123614e-07 0.05045118874764443 9.000945695254918e-07 0.04887427057365767 9.000947271734062e-07 0.04745543934452334 \
9.000948749691591e-07 0.04612527756805263 9.000950200501116e-07 0.04481954899450691 9.000951580483332e-07 0.0435775650013065 9.000953003028957e-07 0.04229727393901672 \
9.000954263034713e-07 0.04116326875785103 9.000955598319524e-07 0.03996151242777013 9.000956821020666e-07 0.03886108140050326 9.000958151620154e-07 0.0376635418603275 \
9.000959296039086e-07 0.03663356482247337 9.000960217395756e-07 0.03580434381845876 9.000961185938143e-07 0.03493265567158488 9.000962580032994e-07 0.03367797030500419 \
9.00096372329609e-07 0.03264903351765647 9.000964819349537e-07 0.03166258541696143 9.00096615187473e-07 0.03046331274235659 9.000967280577827e-07 0.02944747995458197 \
9.000968505551189e-07 0.02834500393025741 9.000969864971122e-07 0.02712152598905548 9.000971045042058e-07 0.02605946214676502 9.000972335603972e-07 0.02489795642556891 \
9.000973440508587e-07 0.02390354227171532 9.000974794893149e-07 0.02268459616553509 9.000975991229855e-07 0.02160789312944722 9.000977000043597e-07 0.02069996076227698 \
9.000978203514514e-07 0.01961683693679572 9.000979616112103e-07 0.01834549910740102 9.000981236968954e-07 0.01688672794015589 9.000982728348491e-07 0.01554448635840755 \
9.000984257131347e-07 0.014168581787533 9.000985760067313e-07 0.01281593941858328 9.000987228351462e-07 0.01149448368366224 9.000988791913148e-07 0.01008727816647481 \
9.000989984546064e-07 0.009013908541385951 9.000990930871204e-07 0.008162215916559523 9.000991965644665e-07 0.007230919801462066 9.00099269048437e-07 0.006578564066408443 \
9.000993473964869e-07 0.005873431617253289 9.000994370778812e-07 0.005066299068704372 9.000995698899392e-07 0.003870990547362063 9.000996714898243e-07 0.002956591581575796 \
9.000997774547151e-07 0.002002907563398826 9.000998932860907e-07 0.000960425183447966 9.589900000000112e-07 0 9.599999999999961e-07 0 \
9.600002111634402e-07 0.001900470962571042 9.600004424445471e-07 0.003982000924727166 9.600009050067609e-07 0.008145060849039413 9.600013623206272e-07 0.01226088564504064 \
9.600018368035255e-07 0.01653123172985639 9.600023692993676e-07 0.02132369430982749 9.600030391819417e-07 0.02735263747515369 9.600038962860511e-07 0.03506657446094884 \
9.600050110320462e-07 0.04509928841663746 9.600066320296375e-07 0.05968826673863754 9.600089746991286e-07 0.08077229215837188 9.600136600381109e-07 0.1229403429978405 \
9.600179644652403e-07 0.1616801871633537 9.600218144069513e-07 0.1963296625632528 9.600260784839174e-07 0.2347063552562001 9.600291484812913e-07 0.2623363316230807 \
9.60031611421446e-07 0.2845027930151538 9.600335732345164e-07 0.3021591106476817 9.600352830299906e-07 0.3175472699147922 9.60036786621731e-07 0.3310795955797556 \
9.600381257194662e-07 0.3431314751960884 9.600393723992329e-07 0.3543515930958913 9.600405143389069e-07 0.3646290501629268 9.60041572311447e-07 0.3741508030226791 \
9.600425813571892e-07 0.3832322147042228 9.600436002602279e-07 0.3924023420515681 9.60044556738474e-07 0.4010106462662745 9.600455045718661e-07 0.4095411467944404 \
9.600463681471743e-07 0.4173133245688312 9.600471108484519e-07 0.423997636067712 9.600477705629023e-07 0.4299350661209142 9.600484650928601e-07 0.4361858357407548 \
9.600491344399725e-07 0.4422099597530631 9.600497450055524e-07 0.4477050499714701 9.600505211590361e-07 0.454690431324675 9.600515775830366e-07 0.4641982473299416 \
9.600525733032824e-07 0.4731597295416305 9.600534391469965e-07 0.4809523229693754 9.600543752979996e-07 0.4893776819979773 9.600551017667355e-07 0.4959159006203305 \
9.600557679847267e-07 0.5019118625413875 9.600563829589108e-07 0.5074466301974319 9.600571676584685e-07 0.5145089262167936 9.600578769318572e-07 0.5208923867144013 \
9.60058576728557e-07 0.5271905570126808 9.600592411431322e-07 0.5331702881913303 9.600598964737336e-07 0.539068263602977 9.600605357980541e-07 0.5448221824871196 \
9.600611259457621e-07 0.5501335118600457 9.600616532498142e-07 0.5548792483285057 9.60062030104965e-07 0.5582709446854013 9.600624256351613e-07 0.5618307164525158 \
9.600627887403593e-07 0.5650986632355098 9.600631651750106e-07 0.5684865750957045 9.600635131548222e-07 0.5716183933999566 9.600637778468605e-07 0.5740006217454657 \
9.600640429855228e-07 0.5763868697045537 9.600645732628469e-07 0.5811593656227293 9.600649593138259e-07 0.5846338244342608 9.600653682102066e-07 0.5883138918597329 \
9.600658706357605e-07 0.5928357218442383 9.600664556501199e-07 0.5981008510799999 9.60066996785185e-07 0.6029710666652875 9.600674171443549e-07 0.6067542991940013 \
9.600678249828082e-07 0.6104248452748176 9.6006823230949e-07 0.6140907854118068 9.60068642157613e-07 0.6177794185173828 9.600690657994418e-07 0.62159219497586 \
9.600695100372109e-07 0.6255903348973357 9.600699667685954e-07 0.6297009173589793 9.60070444546043e-07 0.6340009143882042 9.600709750893296e-07 0.6387758039669345 \
9.600715414714157e-07 0.6438732427407217 9.600721454221392e-07 0.6493087992533674 9.60072793381625e-07 0.6551404346247349 9.600735057626029e-07 0.6615518634257037 \
9.60074168459051e-07 0.6675161314588195 9.600747811668177e-07 0.6730305013601764 9.60075359057944e-07 0.6782315214975446 9.600759217368733e-07 0.6832956318592801 \
9.600764833427613e-07 0.6883500848513783 9.600770748832362e-07 0.6936739491264482 9.600776559936409e-07 0.6989039427675531 9.600782307479105e-07 0.7040767311958204 \
9.600788319459405e-07 0.7094875134645067 9.600793248111815e-07 0.7139233006347314 9.600797518350405e-07 0.7177665153653698 9.600801538732531e-07 0.7213848592781456 \
9.600805379778643e-07 0.7248418007795954 9.600808980818887e-07 0.728082736999342 9.600812909783879e-07 0.731618805492268 9.600813508037621e-07 0.7321572338590965 \
9.600814704545103e-07 0.7332340905927537 9.600817097560067e-07 0.735387804060068 9.600819763221001e-07 0.7377868989013747 9.600822730492612e-07 0.7404574433520882 \
9.600827293899446e-07 0.7445645095019819 9.600831296418575e-07 0.7481667767176134 9.600835424114e-07 0.7518817026010159 9.600839113289174e-07 0.7552019602568045 \
9.600843349197571e-07 0.7590142778153435 9.600847045294425e-07 0.762340764983916 9.6008510473479e-07 0.7659426131102501 9.60085434938255e-07 0.7689144442964062 \
9.600857004950037e-07 0.7713044550329466 9.600859702562256e-07 0.7737323060316124 9.600863809870304e-07 0.7774288832736076 9.600866758593505e-07 0.7800827341539526 \
9.600870783969925e-07 0.7837055729337647 9.600874215941338e-07 0.786794347204456 9.600877744196534e-07 0.7899697768807414 9.60088101708689e-07 0.7929153782018739 \
9.600884210221113e-07 0.7957891990026931 9.600887276009601e-07 0.798548408642265 9.600890258756652e-07 0.8012328809879466 9.600893208487066e-07 0.8038876383597224 \
9.600895914592769e-07 0.8063231334915267 9.600898680486028e-07 0.808812437424818 9.600901524731702e-07 0.8113722585315476 9.600903934753628e-07 0.813541278265291 \
9.600906657780451e-07 0.8159920024070124 9.600909709274073e-07 0.8187383466657218 9.600912712185588e-07 0.8214409670293247 9.600915764870574e-07 0.8241883835163635 \
9.600918710679869e-07 0.8268396118826479 9.60092193104528e-07 0.8297379407530008 9.600924326540276e-07 0.8318938862491163 9.600926881285841e-07 0.8341931572572034 \
9.60092950748264e-07 0.8365567343768243 9.600931961574211e-07 0.8387654167908133 9.600934307182283e-07 0.8408764640555111 9.600936347744432e-07 0.8427129699896301 \
9.600938453663159e-07 0.8446082968424707 9.600940560049604e-07 0.8465040446443356 9.600942446553632e-07 0.8482018982687493 9.600944193128329e-07 0.8497738154964893 \
9.600945992789181e-07 0.8513935102645009 9.60094762688076e-07 0.8528641926851036 9.60094936630778e-07 0.854429677001575 9.600950916494697e-07 0.8558248452281332 \
9.600952586949032e-07 0.8573282541293438 9.600954170395379e-07 0.8587533558427882 9.600955855613502e-07 0.8602700521522246 9.600957427758095e-07 0.8616849822849083 \
9.600958614491537e-07 0.8627530423825936 9.600960118679142e-07 0.8641068112286804 9.600961364949333e-07 0.865228454399422 9.600962976891307e-07 0.8666792021766703 \
9.600964544667706e-07 0.8680902009355517 9.600965801168533e-07 0.8692210516792804 9.600967240522224e-07 0.8705164700033486 9.600968895884348e-07 0.8720062959137309 \
9.600970590539521e-07 0.8735314855691456 9.600972244384111e-07 0.8750199457013955 9.600973973536489e-07 0.8765761828405442 9.600975486087818e-07 0.8779374790365844 \
9.600977054558352e-07 0.8793491025165162 9.60097837560426e-07 0.8805380438351178 9.600979511689022e-07 0.8815605201209382 9.600980667328179e-07 0.8826005953617506 \
9.600981739445152e-07 0.8835655006364479 9.600982519496394e-07 0.8842675467541018 9.600983692038794e-07 0.8853228349141965 9.600984696135191e-07 0.886226521672304 \
9.600985772876735e-07 0.8871955890613133 9.60098653452348e-07 0.8878810711332904 9.600987609073831e-07 0.8888481664483866 9.600988542308148e-07 0.8896880773334693 \
9.600989549101239e-07 0.8905941911166799 9.600990497073693e-07 0.8914473663235497 9.600991358736902e-07 0.8922228632126831 9.600992263281601e-07 0.8930369534412941 \
9.600993660170763e-07 0.8942941536875396 9.600994868298521e-07 0.8953814686688766 9.600996124592937e-07 0.8965121336427553 9.600997566069462e-07 0.8978094625160885 \
9.600998929073789e-07 0.8990361664106589 1.000000175810298e-06 0.8984177073129849 1.000000387736115e-06 0.8965103749658082 1.000000811587748e-06 0.892695710271455 \
1.000001292817289e-06 0.8883646443965901 1.000001822218869e-06 0.8836000301806309 1.000002413857703e-06 0.8782752806762187 1.000003129740239e-06 0.8718323378482702 \
1.000004021470418e-06 0.8638067662390768 1.000005185565676e-06 0.8533299089180234 1.000006730039304e-06 0.8394296462657486 1.000009047735338e-06 0.8185703819595179 \
1.00001310217554e-06 0.7820804201414684 1.000020405609059e-06 0.7163495184672377 1.000024709552219e-06 0.6776140300278762 1.000027719925122e-06 0.6505206739058862 \
1.000031001070041e-06 0.6209903696287848 1.000033489948491e-06 0.5985904635786021 1.000035625657776e-06 0.5793690800177949 1.000037405976345e-06 0.5633462128944384 \
1.000039014010671e-06 0.5488739039651435 1.000040483199695e-06 0.5356512027400909 1.00004182855096e-06 0.5235430413622801 1.000043042811606e-06 0.512614695545089 \
1.000044179223892e-06 0.5023869849741911 1.00004522982584e-06 0.4929315674378034 1.000046211266097e-06 0.484098605128202 1.000047124049725e-06 0.4758835524716363 \
1.000048018804021e-06 0.4678307638102979 1.000048846977552e-06 0.4603772020305483 1.000049661640793e-06 0.4530452328630955 1.000050503799878e-06 0.4454658010995214 \
1.000051392617152e-06 0.4374664456271048 1.000052132173523e-06 0.430810438295329 1.000053027009232e-06 0.4227569169129836 1.000054107902427e-06 0.4130288781558488 \
1.000056115262271e-06 0.3949626395600662 1.000056875998171e-06 0.3881160164607345 1.000057811866421e-06 0.3796932022097708 1.000058487146313e-06 0.373615683179101 \
1.000059159402893e-06 0.3675653739608269 1.000059962121142e-06 0.3603409097239061 1.000060719414127e-06 0.3535252728520237 1.000061469553632e-06 0.3467740173091934 \
1.000062198861823e-06 0.3402102435925485 1.000062917197496e-06 0.3337452225319747 1.000063543595907e-06 0.3281076368399389 1.00006394891578e-06 0.3244597579820502 \
1.000064431737776e-06 0.3201143600118136 1.000064801078116e-06 0.3167902969580316 1.000065253165156e-06 0.3127215135955985 1.000065684660782e-06 0.3088380529590536 \
1.000066036022831e-06 0.3056757945211269 1.000066243755913e-06 0.3038061967869528 1.000066531381985e-06 0.3012175621312337 1.000066776713801e-06 0.2990095757891347 \
1.000067080098449e-06 0.2962791139586973 1.000067337968212e-06 0.2939582860917911 1.000067584264137e-06 0.2917416227702929 1.000068012140654e-06 0.2878907341130054 \
1.00006843261691e-06 0.2841064478110101 1.000068974429479e-06 0.2792301346858994 1.000069431049699e-06 0.2751205527117666 1.000069864969875e-06 0.2712152711268295 \
1.000070276250537e-06 0.2675137451671025 1.000070709349453e-06 0.2636158549267912 1.000071125752111e-06 0.2598682310032753 1.00007157727891e-06 0.2558044898132805 \
1.000072019826756e-06 0.2518215591932373 1.000072486753141e-06 0.2476192217332239 1.000072977907994e-06 0.2431988280497077 1.000073496979761e-06 0.2385271821480127 \
1.000074065575267e-06 0.2334098225947888 1.00007466462888e-06 0.2280183400805964 1.000075295339653e-06 0.2223419431252401 1.000076027928546e-06 0.2157486430863834 \
1.000076737231274e-06 0.2093649185333881 1.000077405278374e-06 0.2033524946355669 1.000078031486169e-06 0.1977166244827963 1.000078642389351e-06 0.1922184958436388 \
1.000079237777689e-06 0.1868600008026635 1.000079853866796e-06 0.1813151988360575 1.000080454397603e-06 0.1759104215697842 1.000081046736475e-06 0.1705793717271608 \
1.000081670603799e-06 0.164964565812095 1.000082253990124e-06 0.1597140888870844 1.000082786746932e-06 0.1549192776137643 1.000083331146382e-06 0.1500196825588286 \
1.000083859078317e-06 0.1452682951413614 1.000084435818527e-06 0.1400776332571309 1.000085002237784e-06 0.1349798599404549 1.000085552082325e-06 0.1300312590758997 \
1.000086168681385e-06 0.1244818675298257 1.000086636997223e-06 0.1202670249965557 1.000087229995172e-06 0.114930043447014 1.000087690957482e-06 0.1107813826574622 \
1.000088106684468e-06 0.1070398397831492 1.000088462796911e-06 0.1038348278011874 1.000088810425094e-06 0.1007061741557836 1.000089112859056e-06 0.09798426849538755 \
1.000089417380186e-06 0.09524357832398211 1.000089689702494e-06 0.09279267755476828 1.000089953280439e-06 0.09042047604958559 1.000090197275105e-06 0.08822452405742931 \
1.000090467223407e-06 0.08579498933604146 1.000090706396949e-06 0.08364242745616901 1.000090969864118e-06 0.08127122294071432 1.000091224741101e-06 0.07897733008697083 \
1.00009145497135e-06 0.07690525785341851 1.000091719751726e-06 0.07452223446371342 1.000092001524411e-06 0.07198628030108556 1.000092277103734e-06 0.06950606639574286 \
1.000092617849714e-06 0.06643935256942901 1.000092904771124e-06 0.06385705988345824 1.000093210523111e-06 0.06110529199863279 1.00009350252768e-06 0.0584772508810687 \
1.000093774358483e-06 0.05603077365032616 1.00009402136155e-06 0.05380774605057426 1.000094217192034e-06 0.05204527169284134 1.000094394312361e-06 0.05045118874764443 \
1.000094569525492e-06 0.04887427057365767 1.000094727173406e-06 0.04745543934452334 1.000094874969159e-06 0.04612527756805263 1.000095020050112e-06 0.04481954899450691 \
1.000095158048333e-06 0.0435775650013065 1.000095300302896e-06 0.04229727393901672 1.000095426303471e-06 0.04116326875785103 1.000095559831952e-06 0.03996151242777013 \
1.000095682102067e-06 0.03886108140050326 1.000095815162016e-06 0.0376635418603275 1.000095929603909e-06 0.03663356482247337 1.000096021739576e-06 0.03580434381845876 \
1.000096118593814e-06 0.03493265567158488 1.000096258003299e-06 0.03367797030500419 1.000096372329609e-06 0.03264903351765647 1.000096481934954e-06 0.03166258541696143 \
1.000096615187473e-06 0.03046331274235659 1.000096728057783e-06 0.02944747995458197 1.000096850555119e-06 0.02834500393025741 1.000096986497112e-06 0.02712152598905548 \
1.000097104504206e-06 0.02605946214676502 1.000097233560397e-06 0.02489795642556891 1.000097344050859e-06 0.02390354227171532 1.000097479489315e-06 0.02268459616553509 \
1.000097599122986e-06 0.02160789312944722 1.00009770000436e-06 0.02069996076227698 1.000097820351451e-06 0.01961683693679572 1.00009796161121e-06 0.01834549910740102 \
1.000098123696896e-06 0.01688672794015589 1.000098272834849e-06 0.01554448635840755 1.000098425713135e-06 0.014168581787533 1.000098576006731e-06 0.01281593941858328 \
1.000098722835146e-06 0.01149448368366224 1.000098879191315e-06 0.01008727816647481 1.000098998454607e-06 0.009013908541385951 1.00009909308712e-06 0.008162215916559523 \
1.000099196564466e-06 0.007230919801462066 1.000099269048437e-06 0.006578564066408443 1.000099347396487e-06 0.005873431617253289 1.000099437077881e-06 0.005066299068704372 \
1.000099569889939e-06 0.003870990547362063 1.000099671489824e-06 0.002956591581575796 1.000099777454715e-06 0.002002907563398826 1.000099893286091e-06 0.000960425183447966 \
1.058990000000011e-06 0 1.059999999999996e-06 0 1.06000021116344e-06 0.001900470962571042 1.060000442444547e-06 0.003982000924727166 \
1.060000905006761e-06 0.008145060849039413 1.060001362320627e-06 0.01226088564504064 1.060001836803525e-06 0.01653123172985639 1.060002369299368e-06 0.02132369430982749 \
1.060003039181942e-06 0.02735263747515369 1.060003896286051e-06 0.03506657446094884 1.060005011032046e-06 0.04509928841663746 1.060006632029638e-06 0.05968826673863754 \
1.060008974699129e-06 0.08077229215837188 1.060013660038111e-06 0.1229403429978405 1.06001796446524e-06 0.1616801871633537 1.060021814406951e-06 0.1963296625632528 \
1.060026078483917e-06 0.2347063552562001 1.060029148481291e-06 0.2623363316230807 1.060031611421446e-06 0.2845027930151538 1.060033573234516e-06 0.3021591106476817 \
1.06003528302999e-06 0.3175472699147922 1.060036786621731e-06 0.3310795955797556 1.060038125719466e-06 0.3431314751960884 1.060039372399233e-06 0.3543515930958913 \
1.060040514338907e-06 0.3646290501629268 1.060041572311447e-06 0.3741508030226791 1.060042581357189e-06 0.3832322147042228 1.060043600260228e-06 0.3924023420515681 \
1.060044556738474e-06 0.4010106462662745 1.060045504571866e-06 0.4095411467944404 1.060046368147174e-06 0.4173133245688312 1.060047110848452e-06 0.423997636067712 \
1.060047770562902e-06 0.4299350661209142 1.06004846509286e-06 0.4361858357407548 1.060049134439973e-06 0.4422099597530631 1.060049745005552e-06 0.4477050499714701 \
1.060050521159036e-06 0.454690431324675 1.060051577583037e-06 0.4641982473299416 1.060052573303282e-06 0.4731597295416305 1.060053439146997e-06 0.4809523229693754 \
1.060054375298e-06 0.4893776819979773 1.060055101766736e-06 0.4959159006203305 1.060055767984727e-06 0.5019118625413875 1.060056382958911e-06 0.5074466301974319 \
1.060057167658469e-06 0.5145089262167936 1.060057876931857e-06 0.5208923867144013 1.060058576728557e-06 0.5271905570126808 1.060059241143132e-06 0.5331702881913303 \
1.060059896473734e-06 0.539068263602977 1.060060535798054e-06 0.5448221824871196 1.060061125945762e-06 0.5501335118600457 1.060061653249814e-06 0.5548792483285057 \
1.060062030104965e-06 0.5582709446854013 1.060062425635161e-06 0.5618307164525158 1.060062788740359e-06 0.5650986632355098 1.06006316517501e-06 0.5684865750957045 \
1.060063513154822e-06 0.5716183933999566 1.060063777846861e-06 0.5740006217454657 1.060064042985523e-06 0.5763868697045537 1.060064573262847e-06 0.5811593656227293 \
1.060064959313826e-06 0.5846338244342608 1.060065368210207e-06 0.5883138918597329 1.06006587063576e-06 0.5928357218442383 1.06006645565012e-06 0.5981008510799999 \
1.060066996785185e-06 0.6029710666652875 1.060067417144355e-06 0.6067542991940013 1.060067824982808e-06 0.6104248452748176 1.06006823230949e-06 0.6140907854118068 \
1.060068642157613e-06 0.6177794185173828 1.060069065799442e-06 0.62159219497586 1.060069510037211e-06 0.6255903348973357 1.060069966768595e-06 0.6297009173589793 \
1.060070444546043e-06 0.6340009143882042 1.06007097508933e-06 0.6387758039669345 1.060071541471416e-06 0.6438732427407217 1.060072145422139e-06 0.6493087992533674 \
1.060072793381625e-06 0.6551404346247349 1.060073505762603e-06 0.6615518634257037 1.060074168459051e-06 0.6675161314588195 1.060074781166818e-06 0.6730305013601764 \
1.060075359057944e-06 0.6782315214975446 1.060075921736873e-06 0.6832956318592801 1.060076483342761e-06 0.6883500848513783 1.060077074883236e-06 0.6936739491264482 \
1.060077655993641e-06 0.6989039427675531 1.060078230747911e-06 0.7040767311958204 1.06007883194594e-06 0.7094875134645067 1.060079324811182e-06 0.7139233006347314 \
1.060079751835041e-06 0.7177665153653698 1.060080153873253e-06 0.7213848592781456 1.060080537977864e-06 0.7248418007795954 1.060080898081889e-06 0.728082736999342 \
1.060081290978388e-06 0.731618805492268 1.060081350803762e-06 0.7321572338590965 1.06008147045451e-06 0.7332340905927537 1.060081709756007e-06 0.735387804060068 \
1.0600819763221e-06 0.7377868989013747 1.060082273049261e-06 0.7404574433520882 1.060082729389945e-06 0.7445645095019819 1.060083129641858e-06 0.7481667767176134 \
1.0600835424114e-06 0.7518817026010159 1.060083911328917e-06 0.7552019602568045 1.060084334919757e-06 0.7590142778153435 1.060084704529443e-06 0.762340764983916 \
1.06008510473479e-06 0.7659426131102501 1.060085434938255e-06 0.7689144442964062 1.060085700495004e-06 0.7713044550329466 1.060085970256226e-06 0.7737323060316124 \
1.06008638098703e-06 0.7774288832736076 1.06008667585935e-06 0.7800827341539526 1.060087078396993e-06 0.7837055729337647 1.060087421594134e-06 0.786794347204456 \
1.060087774419653e-06 0.7899697768807414 1.060088101708689e-06 0.7929153782018739 1.060088421022111e-06 0.7957891990026931 1.06008872760096e-06 0.798548408642265 \
1.060089025875665e-06 0.8012328809879466 1.060089320848707e-06 0.8038876383597224 1.060089591459277e-06 0.8063231334915267 1.060089868048603e-06 0.808812437424818 \
1.06009015247317e-06 0.8113722585315476 1.060090393475363e-06 0.813541278265291 1.060090665778045e-06 0.8159920024070124 1.060090970927407e-06 0.8187383466657218 \
1.060091271218559e-06 0.8214409670293247 1.060091576487057e-06 0.8241883835163635 1.060091871067987e-06 0.8268396118826479 1.060092193104528e-06 0.8297379407530008 \
1.060092432654028e-06 0.8318938862491163 1.060092688128584e-06 0.8341931572572034 1.060092950748264e-06 0.8365567343768243 1.060093196157421e-06 0.8387654167908133 \
1.060093430718228e-06 0.8408764640555111 1.060093634774443e-06 0.8427129699896301 1.060093845366316e-06 0.8446082968424707 1.06009405600496e-06 0.8465040446443356 \
1.060094244655363e-06 0.8482018982687493 1.060094419312833e-06 0.8497738154964893 1.060094599278918e-06 0.8513935102645009 1.060094762688076e-06 0.8528641926851036 \
1.060094936630778e-06 0.854429677001575 1.06009509164947e-06 0.8558248452281332 1.060095258694903e-06 0.8573282541293438 1.060095417039538e-06 0.8587533558427882 \
1.06009558556135e-06 0.8602700521522246 1.060095742775809e-06 0.8616849822849083 1.060095861449154e-06 0.8627530423825936 1.060096011867914e-06 0.8641068112286804 \
1.060096136494933e-06 0.865228454399422 1.060096297689131e-06 0.8666792021766703 1.060096454466771e-06 0.8680902009355517 1.060096580116853e-06 0.8692210516792804 \
1.060096724052223e-06 0.8705164700033486 1.060096889588435e-06 0.8720062959137309 1.060097059053952e-06 0.8735314855691456 1.060097224438411e-06 0.8750199457013955 \
1.060097397353649e-06 0.8765761828405442 1.060097548608782e-06 0.8779374790365844 1.060097705455835e-06 0.8793491025165162 1.060097837560426e-06 0.8805380438351178 \
1.060097951168902e-06 0.8815605201209382 1.060098066732818e-06 0.8826005953617506 1.060098173944515e-06 0.8835655006364479 1.060098251949639e-06 0.8842675467541018 \
1.060098369203879e-06 0.8853228349141965 1.060098469613519e-06 0.886226521672304 1.060098577287673e-06 0.8871955890613133 1.060098653452348e-06 0.8878810711332904 \
1.060098760907383e-06 0.8888481664483866 1.060098854230815e-06 0.8896880773334693 1.060098954910124e-06 0.8905941911166799 1.060099049707369e-06 0.8914473663235497 \
1.06009913587369e-06 0.8922228632126831 1.06009922632816e-06 0.8930369534412941 1.060099366017076e-06 0.8942941536875396 1.060099486829852e-06 0.8953814686688766 \
1.060099612459294e-06 0.8965121336427553 1.060099756606946e-06 0.8978094625160885 1.060099892907379e-06 0.8990361664106589 1.100000175810299e-06 0.8984177073129849 \
1.100000387736115e-06 0.8965103749658082 1.100000811587748e-06 0.892695710271455 1.100001292817289e-06 0.8883646443965901 1.100001822218869e-06 0.8836000301806309 \
1.100002413857703e-06 0.8782752806762187 1.100003129740239e-06 0.8718323378482702 1.100004021470418e-06 0.8638067662390768 1.100005185565676e-06 0.8533299089180234 \
1.100006730039304e-06 0.8394296462657486 1.100009047735338e-06 0.8185703819595179 1.10001310217554e-06 0.7820804201414684 1.100020405609059e-06 0.7163495184672377 \
1.100024709552219e-06 0.6776140300278762 1.100027719925121e-06 0.6505206739058862 1.100031001070041e-06 0.6209903696287848 1.100033489948491e-06 0.5985904635786021 \
1.100035625657776e-06 0.5793690800177949 1.100037405976345e-06 0.5633462128944384 1.10003901401067e-06 0.5488739039651435 1.100040483199695e-06 0.5356512027400909 \
1.10004182855096e-06 0.5235430413622801 1.100043042811606e-06 0.512614695545089 1.100044179223892e-06 0.5023869849741911 1.10004522982584e-06 0.4929315674378034 \
1.100046211266097e-06 0.484098605128202 1.100047124049725e-06 0.4758835524716363 1.100048018804021e-06 0.4678307638102979 1.100048846977552e-06 0.4603772020305483 \
1.100049661640793e-06 0.4530452328630955 1.100050503799878e-06 0.4454658010995214 1.100051392617152e-06 0.4374664456271048 1.100052132173523e-06 0.430810438295329 \
1.100053027009232e-06 0.4227569169129836 1.100054107902427e-06 0.4130288781558488 1.100056115262271e-06 0.3949626395600662 1.100056875998171e-06 0.3881160164607345 \
1.100057811866421e-06 0.3796932022097708 1.100058487146313e-06 0.373615683179101 1.100059159402893e-06 0.3675653739608269 1.100059962121142e-06 0.3603409097239061 \
1.100060719414128e-06 0.3535252728520237 1.100061469553632e-06 0.3467740173091934 1.100062198861823e-06 0.3402102435925485 1.100062917197496e-06 0.3337452225319747 \
1.100063543595907e-06 0.3281076368399389 1.10006394891578e-06 0.3244597579820502 1.100064431737776e-06 0.3201143600118136 1.100064801078116e-06 0.3167902969580316 \
1.100065253165156e-06 0.3127215135955985 1.100065684660782e-06 0.3088380529590536 1.100066036022831e-06 0.3056757945211269 1.100066243755913e-06 0.3038061967869528 \
1.100066531381985e-06 0.3012175621312337 1.100066776713801e-06 0.2990095757891347 1.100067080098449e-06 0.2962791139586973 1.100067337968212e-06 0.2939582860917911 \
1.100067584264137e-06 0.2917416227702929 1.100068012140654e-06 0.2878907341130054 1.10006843261691e-06 0.2841064478110101 1.100068974429479e-06 0.2792301346858994 \
1.100069431049699e-06 0.2751205527117666 1.100069864969875e-06 0.2712152711268295 1.100070276250537e-06 0.2675137451671025 1.100070709349453e-06 0.2636158549267912 \
1.100071125752111e-06 0.2598682310032753 1.10007157727891e-06 0.2558044898132805 1.100072019826756e-06 0.2518215591932373 1.100072486753141e-06 0.2476192217332239 \
1.100072977907995e-06 0.2431988280497077 1.100073496979761e-06 0.2385271821480127 1.100074065575267e-06 0.2334098225947888 1.10007466462888e-06 0.2280183400805964 \
1.100075295339653e-06 0.2223419431252401 1.100076027928546e-06 0.2157486430863834 1.100076737231274e-06 0.2093649185333881 1.100077405278374e-06 0.2033524946355669 \
1.100078031486169e-06 0.1977166244827963 1.100078642389351e-06 0.1922184958436388 1.100079237777689e-06 0.1868600008026635 1.100079853866796e-06 0.1813151988360575 \
1.100080454397603e-06 0.1759104215697842 1.100081046736475e-06 0.1705793717271608 1.100081670603799e-06 0.164964565812095 1.100082253990124e-06 0.1597140888870844 \
1.100082786746932e-06 0.1549192776137643 1.100083331146382e-06 0.1500196825588286 1.100083859078318e-06 0.1452682951413614 1.100084435818527e-06 0.1400776332571309 \
1.100085002237784e-06 0.1349798599404549 1.100085552082325e-06 0.1300312590758997 1.100086168681386e-06 0.1244818675298257 1.100086636997223e-06 0.1202670249965557 \
1.100087229995172e-06 0.114930043447014 1.100087690957483e-06 0.1107813826574622 1.100088106684468e-06 0.1070398397831492 1.100088462796911e-06 0.1038348278011874 \
1.100088810425094e-06 0.1007061741557836 1.100089112859056e-06 0.09798426849538755 1.100089417380186e-06 0.09524357832398211 1.100089689702494e-06 0.09279267755476828 \
1.100089953280439e-06 0.09042047604958559 1.100090197275105e-06 0.08822452405742931 1.100090467223407e-06 0.08579498933604146 1.100090706396949e-06 0.08364242745616901 \
1.100090969864118e-06 0.08127122294071432 1.100091224741101e-06 0.07897733008697083 1.10009145497135e-06 0.07690525785341851 1.100091719751726e-06 0.07452223446371342 \
1.100092001524411e-06 0.07198628030108556 1.100092277103734e-06 0.06950606639574286 1.100092617849715e-06 0.06643935256942901 1.100092904771124e-06 0.06385705988345824 \
1.100093210523111e-06 0.06110529199863279 1.10009350252768e-06 0.0584772508810687 1.100093774358483e-06 0.05603077365032616 1.10009402136155e-06 0.05380774605057426 \
1.100094217192034e-06 0.05204527169284134 1.100094394312361e-06 0.05045118874764443 1.100094569525492e-06 0.04887427057365767 1.100094727173406e-06 0.04745543934452334 \
1.100094874969159e-06 0.04612527756805263 1.100095020050112e-06 0.04481954899450691 1.100095158048333e-06 0.0435775650013065 1.100095300302896e-06 0.04229727393901672 \
1.100095426303471e-06 0.04116326875785103 1.100095559831953e-06 0.03996151242777013 1.100095682102066e-06 0.03886108140050326 1.100095815162015e-06 0.0376635418603275 \
1.100095929603908e-06 0.03663356482247337 1.100096021739576e-06 0.03580434381845876 1.100096118593814e-06 0.03493265567158488 1.100096258003299e-06 0.03367797030500419 \
1.100096372329609e-06 0.03264903351765647 1.100096481934954e-06 0.03166258541696143 1.100096615187473e-06 0.03046331274235659 1.100096728057783e-06 0.02944747995458197 \
1.100096850555119e-06 0.02834500393025741 1.100096986497112e-06 0.02712152598905548 1.100097104504206e-06 0.02605946214676502 1.100097233560397e-06 0.02489795642556891 \
1.100097344050859e-06 0.02390354227171532 1.100097479489315e-06 0.02268459616553509 1.100097599122986e-06 0.02160789312944722 1.10009770000436e-06 0.02069996076227698 \
1.100097820351452e-06 0.01961683693679572 1.10009796161121e-06 0.01834549910740102 1.100098123696895e-06 0.01688672794015589 1.100098272834849e-06 0.01554448635840755 \
1.100098425713135e-06 0.014168581787533 1.100098576006731e-06 0.01281593941858328 1.100098722835146e-06 0.01149448368366224 1.100098879191315e-06 0.01008727816647481 \
1.100098998454606e-06 0.009013908541385951 1.10009909308712e-06 0.008162215916559523 1.100099196564466e-06 0.007230919801462066 1.100099269048437e-06 0.006578564066408443 \
1.100099347396487e-06 0.005873431617253289 1.100099437077881e-06 0.005066299068704372 1.100099569889939e-06 0.003870990547362063 1.100099671489824e-06 0.002956591581575796 \
1.100099777454715e-06 0.002002907563398826 1.100099893286091e-06 0.000960425183447966 1.158990000000011e-06 0 1.159999999999996e-06 0 \
1.16000021116344e-06 0.001900470962571042 1.160000442444547e-06 0.003982000924727166 1.160000905006761e-06 0.008145060849039413 1.160001362320627e-06 0.01226088564504064 \
1.160001836803526e-06 0.01653123172985639 1.160002369299368e-06 0.02132369430982749 1.160003039181942e-06 0.02735263747515369 1.160003896286051e-06 0.03506657446094884 \
1.160005011032046e-06 0.04509928841663746 1.160006632029638e-06 0.05968826673863754 1.160008974699129e-06 0.08077229215837188 1.160013660038111e-06 0.1229403429978405 \
1.16001796446524e-06 0.1616801871633537 1.160021814406952e-06 0.1963296625632528 1.160026078483917e-06 0.2347063552562001 1.160029148481292e-06 0.2623363316230807 \
1.160031611421446e-06 0.2845027930151538 1.160033573234516e-06 0.3021591106476817 1.160035283029991e-06 0.3175472699147922 1.160036786621731e-06 0.3310795955797556 \
1.160038125719466e-06 0.3431314751960884 1.160039372399233e-06 0.3543515930958913 1.160040514338907e-06 0.3646290501629268 1.160041572311447e-06 0.3741508030226791 \
1.160042581357189e-06 0.3832322147042228 1.160043600260228e-06 0.3924023420515681 1.160044556738474e-06 0.4010106462662745 1.160045504571866e-06 0.4095411467944404 \
1.160046368147174e-06 0.4173133245688312 1.160047110848452e-06 0.423997636067712 1.160047770562902e-06 0.4299350661209142 1.16004846509286e-06 0.4361858357407548 \
1.160049134439973e-06 0.4422099597530631 1.160049745005552e-06 0.4477050499714701 1.160050521159036e-06 0.454690431324675 1.160051577583037e-06 0.4641982473299416 \
1.160052573303282e-06 0.4731597295416305 1.160053439146997e-06 0.4809523229693754 1.160054375298e-06 0.4893776819979773 1.160055101766736e-06 0.4959159006203305 \
1.160055767984727e-06 0.5019118625413875 1.160056382958911e-06 0.5074466301974319 1.160057167658469e-06 0.5145089262167936 1.160057876931857e-06 0.5208923867144013 \
1.160058576728557e-06 0.5271905570126808 1.160059241143132e-06 0.5331702881913303 1.160059896473734e-06 0.539068263602977 1.160060535798054e-06 0.5448221824871196 \
1.160061125945762e-06 0.5501335118600457 1.160061653249814e-06 0.5548792483285057 1.160062030104965e-06 0.5582709446854013 1.160062425635162e-06 0.5618307164525158 \
1.16006278874036e-06 0.5650986632355098 1.160063165175011e-06 0.5684865750957045 1.160063513154822e-06 0.5716183933999566 1.160063777846861e-06 0.5740006217454657 \
1.160064042985523e-06 0.5763868697045537 1.160064573262847e-06 0.5811593656227293 1.160064959313826e-06 0.5846338244342608 1.160065368210207e-06 0.5883138918597329 \
1.16006587063576e-06 0.5928357218442383 1.16006645565012e-06 0.5981008510799999 1.160066996785185e-06 0.6029710666652875 1.160067417144355e-06 0.6067542991940013 \
1.160067824982808e-06 0.6104248452748176 1.16006823230949e-06 0.6140907854118068 1.160068642157613e-06 0.6177794185173828 1.160069065799442e-06 0.62159219497586 \
1.160069510037211e-06 0.6255903348973357 1.160069966768595e-06 0.6297009173589793 1.160070444546043e-06 0.6340009143882042 1.16007097508933e-06 0.6387758039669345 \
1.160071541471416e-06 0.6438732427407217 1.160072145422139e-06 0.6493087992533674 1.160072793381625e-06 0.6551404346247349 1.160073505762603e-06 0.6615518634257037 \
1.160074168459051e-06 0.6675161314588195 1.160074781166818e-06 0.6730305013601764 1.160075359057944e-06 0.6782315214975446 1.160075921736873e-06 0.6832956318592801 \
1.160076483342761e-06 0.6883500848513783 1.160077074883236e-06 0.6936739491264482 1.160077655993641e-06 0.6989039427675531 1.160078230747911e-06 0.7040767311958204 \
1.160078831945941e-06 0.7094875134645067 1.160079324811182e-06 0.7139233006347314 1.160079751835041e-06 0.7177665153653698 1.160080153873253e-06 0.7213848592781456 \
1.160080537977865e-06 0.7248418007795954 1.160080898081889e-06 0.728082736999342 1.160081290978388e-06 0.731618805492268 1.160081350803762e-06 0.7321572338590965 \
1.16008147045451e-06 0.7332340905927537 1.160081709756007e-06 0.735387804060068 1.1600819763221e-06 0.7377868989013747 1.160082273049261e-06 0.7404574433520882 \
1.160082729389945e-06 0.7445645095019819 1.160083129641858e-06 0.7481667767176134 1.1600835424114e-06 0.7518817026010159 1.160083911328917e-06 0.7552019602568045 \
1.160084334919757e-06 0.7590142778153435 1.160084704529443e-06 0.762340764983916 1.16008510473479e-06 0.7659426131102501 1.160085434938255e-06 0.7689144442964062 \
1.160085700495004e-06 0.7713044550329466 1.160085970256226e-06 0.7737323060316124 1.16008638098703e-06 0.7774288832736076 1.16008667585935e-06 0.7800827341539526 \
1.160087078396993e-06 0.7837055729337647 1.160087421594134e-06 0.786794347204456 1.160087774419653e-06 0.7899697768807414 1.160088101708689e-06 0.7929153782018739 \
1.160088421022112e-06 0.7957891990026931 1.16008872760096e-06 0.798548408642265 1.160089025875665e-06 0.8012328809879466 1.160089320848707e-06 0.8038876383597224 \
1.160089591459277e-06 0.8063231334915267 1.160089868048603e-06 0.808812437424818 1.16009015247317e-06 0.8113722585315476 1.160090393475363e-06 0.813541278265291 \
1.160090665778045e-06 0.8159920024070124 1.160090970927407e-06 0.8187383466657218 1.160091271218559e-06 0.8214409670293247 1.160091576487057e-06 0.8241883835163635 \
1.160091871067987e-06 0.8268396118826479 1.160092193104528e-06 0.8297379407530008 1.160092432654028e-06 0.8318938862491163 1.160092688128584e-06 0.8341931572572034 \
1.160092950748264e-06 0.8365567343768243 1.160093196157421e-06 0.8387654167908133 1.160093430718228e-06 0.8408764640555111 1.160093634774443e-06 0.8427129699896301 \
1.160093845366316e-06 0.8446082968424707 1.160094056004961e-06 0.8465040446443356 1.160094244655363e-06 0.8482018982687493 1.160094419312833e-06 0.8497738154964893 \
1.160094599278918e-06 0.8513935102645009 1.160094762688076e-06 0.8528641926851036 1.160094936630778e-06 0.854429677001575 1.16009509164947e-06 0.8558248452281332 \
1.160095258694903e-06 0.8573282541293438 1.160095417039538e-06 0.8587533558427882 1.16009558556135e-06 0.8602700521522246 1.160095742775809e-06 0.8616849822849083 \
1.160095861449154e-06 0.8627530423825936 1.160096011867914e-06 0.8641068112286804 1.160096136494933e-06 0.865228454399422 1.160096297689131e-06 0.8666792021766703 \
1.160096454466771e-06 0.8680902009355517 1.160096580116853e-06 0.8692210516792804 1.160096724052223e-06 0.8705164700033486 1.160096889588435e-06 0.8720062959137309 \
1.160097059053952e-06 0.8735314855691456 1.160097224438411e-06 0.8750199457013955 1.160097397353649e-06 0.8765761828405442 1.160097548608782e-06 0.8779374790365844 \
1.160097705455835e-06 0.8793491025165162 1.160097837560426e-06 0.8805380438351178 1.160097951168902e-06 0.8815605201209382 1.160098066732818e-06 0.8826005953617506 \
1.160098173944515e-06 0.8835655006364479 1.160098251949639e-06 0.8842675467541018 1.160098369203879e-06 0.8853228349141965 1.160098469613519e-06 0.886226521672304 \
1.160098577287674e-06 0.8871955890613133 1.160098653452348e-06 0.8878810711332904 1.160098760907383e-06 0.8888481664483866 1.160098854230815e-06 0.8896880773334693 \
1.160098954910124e-06 0.8905941911166799 1.160099049707369e-06 0.8914473663235497 1.16009913587369e-06 0.8922228632126831 1.16009922632816e-06 0.8930369534412941 \
1.160099366017076e-06 0.8942941536875396 1.160099486829852e-06 0.8953814686688766 1.160099612459294e-06 0.8965121336427553 1.160099756606946e-06 0.8978094625160885 \
1.160099892907379e-06 0.8990361664106589 1.200000175810299e-06 0.8984177073129849 1.200000387736115e-06 0.8965103749658082 1.200000811587748e-06 0.892695710271455 \
1.200001292817289e-06 0.8883646443965901 1.200001822218869e-06 0.8836000301806309 1.200002413857703e-06 0.8782752806762187 1.200003129740239e-06 0.8718323378482702 \
1.200004021470418e-06 0.8638067662390768 1.200005185565676e-06 0.8533299089180234 1.200006730039304e-06 0.8394296462657486 1.200009047735338e-06 0.8185703819595179 \
1.20001310217554e-06 0.7820804201414684 1.200020405609059e-06 0.7163495184672377 1.200024709552219e-06 0.6776140300278762 1.200027719925122e-06 0.6505206739058862 \
1.200031001070041e-06 0.6209903696287848 1.200033489948491e-06 0.5985904635786021 1.200035625657776e-06 0.5793690800177949 1.200037405976345e-06 0.5633462128944384 \
1.200039014010671e-06 0.5488739039651435 1.200040483199696e-06 0.5356512027400909 1.20004182855096e-06 0.5235430413622801 1.200043042811606e-06 0.512614695545089 \
1.200044179223892e-06 0.5023869849741911 1.20004522982584e-06 0.4929315674378034 1.200046211266097e-06 0.484098605128202 1.200047124049725e-06 0.4758835524716363 \
1.200048018804021e-06 0.4678307638102979 1.200048846977552e-06 0.4603772020305483 1.200049661640793e-06 0.4530452328630955 1.200050503799878e-06 0.4454658010995214 \
1.200051392617152e-06 0.4374664456271048 1.200052132173523e-06 0.430810438295329 1.200053027009232e-06 0.4227569169129836 1.200054107902427e-06 0.4130288781558488 \
1.200056115262271e-06 0.3949626395600662 1.200056875998171e-06 0.3881160164607345 1.200057811866421e-06 0.3796932022097708 1.200058487146314e-06 0.373615683179101 \
1.200059159402893e-06 0.3675653739608269 1.200059962121142e-06 0.3603409097239061 1.200060719414128e-06 0.3535252728520237 1.200061469553632e-06 0.3467740173091934 \
1.200062198861823e-06 0.3402102435925485 1.200062917197497e-06 0.3337452225319747 1.200063543595907e-06 0.3281076368399389 1.20006394891578e-06 0.3244597579820502 \
1.200064431737776e-06 0.3201143600118136 1.200064801078116e-06 0.3167902969580316 1.200065253165156e-06 0.3127215135955985 1.200065684660782e-06 0.3088380529590536 \
1.200066036022831e-06 0.3056757945211269 1.200066243755913e-06 0.3038061967869528 1.200066531381985e-06 0.3012175621312337 1.200066776713801e-06 0.2990095757891347 \
1.200067080098449e-06 0.2962791139586973 1.200067337968212e-06 0.2939582860917911 1.200067584264137e-06 0.2917416227702929 1.200068012140654e-06 0.2878907341130054 \
1.20006843261691e-06 0.2841064478110101 1.200068974429479e-06 0.2792301346858994 1.200069431049699e-06 0.2751205527117666 1.200069864969875e-06 0.2712152711268295 \
1.200070276250537e-06 0.2675137451671025 1.200070709349453e-06 0.2636158549267912 1.200071125752111e-06 0.2598682310032753 1.20007157727891e-06 0.2558044898132805 \
1.200072019826756e-06 0.2518215591932373 1.200072486753141e-06 0.2476192217332239 1.200072977907995e-06 0.2431988280497077 1.200073496979761e-06 0.2385271821480127 \
1.200074065575267e-06 0.2334098225947888 1.20007466462888e-06 0.2280183400805964 1.200075295339653e-06 0.2223419431252401 1.200076027928546e-06 0.2157486430863834 \
1.200076737231274e-06 0.2093649185333881 1.200077405278374e-06 0.2033524946355669 1.200078031486169e-06 0.1977166244827963 1.200078642389351e-06 0.1922184958436388 \
1.200079237777689e-06 0.1868600008026635 1.200079853866796e-06 0.1813151988360575 1.200080454397603e-06 0.1759104215697842 1.200081046736475e-06 0.1705793717271608 \
1.200081670603799e-06 0.164964565812095 1.200082253990124e-06 0.1597140888870844 1.200082786746932e-06 0.1549192776137643 1.200083331146382e-06 0.1500196825588286 \
1.200083859078318e-06 0.1452682951413614 1.200084435818527e-06 0.1400776332571309 1.200085002237784e-06 0.1349798599404549 1.200085552082325e-06 0.1300312590758997 \
1.200086168681386e-06 0.1244818675298257 1.200086636997223e-06 0.1202670249965557 1.200087229995173e-06 0.114930043447014 1.200087690957483e-06 0.1107813826574622 \
1.200088106684468e-06 0.1070398397831492 1.200088462796911e-06 0.1038348278011874 1.200088810425094e-06 0.1007061741557836 1.200089112859056e-06 0.09798426849538755 \
1.200089417380186e-06 0.09524357832398211 1.200089689702494e-06 0.09279267755476828 1.200089953280439e-06 0.09042047604958559 1.200090197275105e-06 0.08822452405742931 \
1.200090467223407e-06 0.08579498933604146 1.200090706396949e-06 0.08364242745616901 1.200090969864118e-06 0.08127122294071432 1.200091224741101e-06 0.07897733008697083 \
1.20009145497135e-06 0.07690525785341851 1.200091719751726e-06 0.07452223446371342 1.200092001524411e-06 0.07198628030108556 1.200092277103734e-06 0.06950606639574286 \
1.200092617849715e-06 0.06643935256942901 1.200092904771124e-06 0.06385705988345824 1.200093210523111e-06 0.06110529199863279 1.20009350252768e-06 0.0584772508810687 \
1.200093774358483e-06 0.05603077365032616 1.20009402136155e-06 0.05380774605057426 1.200094217192034e-06 0.05204527169284134 1.200094394312362e-06 0.05045118874764443 \
1.200094569525492e-06 0.04887427057365767 1.200094727173406e-06 0.04745543934452334 1.200094874969159e-06 0.04612527756805263 1.200095020050112e-06 0.04481954899450691 \
1.200095158048333e-06 0.0435775650013065 1.200095300302896e-06 0.04229727393901672 1.200095426303471e-06 0.04116326875785103 1.200095559831953e-06 0.03996151242777013 \
1.200095682102067e-06 0.03886108140050326 1.200095815162016e-06 0.0376635418603275 1.200095929603909e-06 0.03663356482247337 1.200096021739576e-06 0.03580434381845876 \
1.200096118593814e-06 0.03493265567158488 1.2000962580033e-06 0.03367797030500419 1.200096372329609e-06 0.03264903351765647 1.200096481934954e-06 0.03166258541696143 \
1.200096615187473e-06 0.03046331274235659 1.200096728057783e-06 0.02944747995458197 1.200096850555119e-06 0.02834500393025741 1.200096986497112e-06 0.02712152598905548 \
1.200097104504206e-06 0.02605946214676502 1.200097233560397e-06 0.02489795642556891 1.200097344050859e-06 0.02390354227171532 1.200097479489315e-06 0.02268459616553509 \
1.200097599122986e-06 0.02160789312944722 1.20009770000436e-06 0.02069996076227698 1.200097820351452e-06 0.01961683693679572 1.20009796161121e-06 0.01834549910740102 \
1.200098123696896e-06 0.01688672794015589 1.200098272834849e-06 0.01554448635840755 1.200098425713135e-06 0.014168581787533 1.200098576006731e-06 0.01281593941858328 \
1.200098722835146e-06 0.01149448368366224 1.200098879191315e-06 0.01008727816647481 1.200098998454607e-06 0.009013908541385951 1.20009909308712e-06 0.008162215916559523 \
1.200099196564467e-06 0.007230919801462066 1.200099269048437e-06 0.006578564066408443 1.200099347396487e-06 0.005873431617253289 1.200099437077881e-06 0.005066299068704372 \
1.200099569889939e-06 0.003870990547362063 1.200099671489824e-06 0.002956591581575796 1.200099777454715e-06 0.002002907563398826 1.200099893286091e-06 0.000960425183447966 \
1.258990000000011e-06 0 1.259999999999996e-06 0 1.26000021116344e-06 0.001900470962571042 1.260000442444547e-06 0.003982000924727166 \
1.260000905006761e-06 0.008145060849039413 1.260001362320627e-06 0.01226088564504064 1.260001836803525e-06 0.01653123172985639 1.260002369299368e-06 0.02132369430982749 \
1.260003039181942e-06 0.02735263747515369 1.260003896286051e-06 0.03506657446094884 1.260005011032046e-06 0.04509928841663746 1.260006632029638e-06 0.05968826673863754 \
1.260008974699129e-06 0.08077229215837188 1.260013660038111e-06 0.1229403429978405 1.26001796446524e-06 0.1616801871633537 1.260021814406951e-06 0.1963296625632528 \
1.260026078483917e-06 0.2347063552562001 1.260029148481291e-06 0.2623363316230807 1.260031611421446e-06 0.2845027930151538 1.260033573234516e-06 0.3021591106476817 \
1.26003528302999e-06 0.3175472699147922 1.260036786621731e-06 0.3310795955797556 1.260038125719466e-06 0.3431314751960884 1.260039372399233e-06 0.3543515930958913 \
1.260040514338907e-06 0.3646290501629268 1.260041572311447e-06 0.3741508030226791 1.260042581357189e-06 0.3832322147042228 1.260043600260228e-06 0.3924023420515681 \
1.260044556738474e-06 0.4010106462662745 1.260045504571866e-06 0.4095411467944404 1.260046368147174e-06 0.4173133245688312 1.260047110848452e-06 0.423997636067712 \
1.260047770562902e-06 0.4299350661209142 1.26004846509286e-06 0.4361858357407548 1.260049134439973e-06 0.4422099597530631 1.260049745005552e-06 0.4477050499714701 \
1.260050521159036e-06 0.454690431324675 1.260051577583037e-06 0.4641982473299416 1.260052573303282e-06 0.4731597295416305 1.260053439146997e-06 0.4809523229693754 \
1.260054375298e-06 0.4893776819979773 1.260055101766736e-06 0.4959159006203305 1.260055767984727e-06 0.5019118625413875 1.260056382958911e-06 0.5074466301974319 \
1.260057167658469e-06 0.5145089262167936 1.260057876931857e-06 0.5208923867144013 1.260058576728557e-06 0.5271905570126808 1.260059241143132e-06 0.5331702881913303 \
1.260059896473734e-06 0.539068263602977 1.260060535798054e-06 0.5448221824871196 1.260061125945762e-06 0.5501335118600457 1.260061653249814e-06 0.5548792483285057 \
1.260062030104965e-06 0.5582709446854013 1.260062425635161e-06 0.5618307164525158 1.260062788740359e-06 0.5650986632355098 1.260063165175011e-06 0.5684865750957045 \
1.260063513154822e-06 0.5716183933999566 1.260063777846861e-06 0.5740006217454657 1.260064042985523e-06 0.5763868697045537 1.260064573262847e-06 0.5811593656227293 \
1.260064959313826e-06 0.5846338244342608 1.260065368210207e-06 0.5883138918597329 1.26006587063576e-06 0.5928357218442383 1.26006645565012e-06 0.5981008510799999 \
1.260066996785185e-06 0.6029710666652875 1.260067417144355e-06 0.6067542991940013 1.260067824982808e-06 0.6104248452748176 1.26006823230949e-06 0.6140907854118068 \
1.260068642157613e-06 0.6177794185173828 1.260069065799442e-06 0.62159219497586 1.260069510037211e-06 0.6255903348973357 1.260069966768595e-06 0.6297009173589793 \
1.260070444546043e-06 0.6340009143882042 1.26007097508933e-06 0.6387758039669345 1.260071541471416e-06 0.6438732427407217 1.260072145422139e-06 0.6493087992533674 \
1.260072793381625e-06 0.6551404346247349 1.260073505762603e-06 0.6615518634257037 1.260074168459051e-06 0.6675161314588195 1.260074781166818e-06 0.6730305013601764 \
1.260075359057944e-06 0.6782315214975446 1.260075921736873e-06 0.6832956318592801 1.260076483342761e-06 0.6883500848513783 1.260077074883236e-06 0.6936739491264482 \
1.260077655993641e-06 0.6989039427675531 1.260078230747911e-06 0.7040767311958204 1.260078831945941e-06 0.7094875134645067 1.260079324811182e-06 0.7139233006347314 \
1.260079751835041e-06 0.7177665153653698 1.260080153873253e-06 0.7213848592781456 1.260080537977864e-06 0.7248418007795954 1.260080898081889e-06 0.728082736999342 \
1.260081290978388e-06 0.731618805492268 1.260081350803762e-06 0.7321572338590965 1.26008147045451e-06 0.7332340905927537 1.260081709756007e-06 0.735387804060068 \
1.2600819763221e-06 0.7377868989013747 1.260082273049261e-06 0.7404574433520882 1.260082729389945e-06 0.7445645095019819 1.260083129641858e-06 0.7481667767176134 \
1.2600835424114e-06 0.7518817026010159 1.260083911328917e-06 0.7552019602568045 1.260084334919757e-06 0.7590142778153435 1.260084704529443e-06 0.762340764983916 \
1.26008510473479e-06 0.7659426131102501 1.260085434938255e-06 0.7689144442964062 1.260085700495004e-06 0.7713044550329466 1.260085970256226e-06 0.7737323060316124 \
1.26008638098703e-06 0.7774288832736076 1.26008667585935e-06 0.7800827341539526 1.260087078396993e-06 0.7837055729337647 1.260087421594134e-06 0.786794347204456 \
1.260087774419653e-06 0.7899697768807414 1.260088101708689e-06 0.7929153782018739 1.260088421022111e-06 0.7957891990026931 1.26008872760096e-06 0.798548408642265 \
1.260089025875665e-06 0.8012328809879466 1.260089320848706e-06 0.8038876383597224 1.260089591459277e-06 0.8063231334915267 1.260089868048603e-06 0.808812437424818 \
1.26009015247317e-06 0.8113722585315476 1.260090393475363e-06 0.813541278265291 1.260090665778045e-06 0.8159920024070124 1.260090970927407e-06 0.8187383466657218 \
1.260091271218559e-06 0.8214409670293247 1.260091576487057e-06 0.8241883835163635 1.260091871067987e-06 0.8268396118826479 1.260092193104528e-06 0.8297379407530008 \
1.260092432654028e-06 0.8318938862491163 1.260092688128584e-06 0.8341931572572034 1.260092950748264e-06 0.8365567343768243 1.260093196157421e-06 0.8387654167908133 \
1.260093430718228e-06 0.8408764640555111 1.260093634774443e-06 0.8427129699896301 1.260093845366316e-06 0.8446082968424707 1.26009405600496e-06 0.8465040446443356 \
1.260094244655363e-06 0.8482018982687493 1.260094419312833e-06 0.8497738154964893 1.260094599278918e-06 0.8513935102645009 1.260094762688076e-06 0.8528641926851036 \
1.260094936630778e-06 0.854429677001575 1.26009509164947e-06 0.8558248452281332 1.260095258694903e-06 0.8573282541293438 1.260095417039538e-06 0.8587533558427882 \
1.26009558556135e-06 0.8602700521522246 1.260095742775809e-06 0.8616849822849083 1.260095861449154e-06 0.8627530423825936 1.260096011867914e-06 0.8641068112286804 \
1.260096136494933e-06 0.865228454399422 1.260096297689131e-06 0.8666792021766703 1.26009645446677e-06 0.8680902009355517 1.260096580116853e-06 0.8692210516792804 \
1.260096724052223e-06 0.8705164700033486 1.260096889588435e-06 0.8720062959137309 1.260097059053952e-06 0.8735314855691456 1.260097224438411e-06 0.8750199457013955 \
1.260097397353649e-06 0.8765761828405442 1.260097548608782e-06 0.8779374790365844 1.260097705455835e-06 0.8793491025165162 1.260097837560426e-06 0.8805380438351178 \
1.260097951168902e-06 0.8815605201209382 1.260098066732818e-06 0.8826005953617506 1.260098173944515e-06 0.8835655006364479 1.260098251949639e-06 0.8842675467541018 \
1.260098369203879e-06 0.8853228349141965 1.260098469613519e-06 0.886226521672304 1.260098577287673e-06 0.8871955890613133 1.260098653452348e-06 0.8878810711332904 \
1.260098760907383e-06 0.8888481664483866 1.260098854230815e-06 0.8896880773334693 1.260098954910124e-06 0.8905941911166799 1.260099049707369e-06 0.8914473663235497 \
1.26009913587369e-06 0.8922228632126831 1.26009922632816e-06 0.8930369534412941 1.260099366017076e-06 0.8942941536875396 1.260099486829852e-06 0.8953814686688766 \
1.260099612459294e-06 0.8965121336427553 1.260099756606946e-06 0.8978094625160885 1.260099892907379e-06 0.8990361664106589 1.300000175810299e-06 0.8984177073129849 \
1.300000387736115e-06 0.8965103749658082 1.300000811587748e-06 0.892695710271455 1.300001292817289e-06 0.8883646443965901 1.300001822218869e-06 0.8836000301806309 \
1.300002413857703e-06 0.8782752806762187 1.300003129740239e-06 0.8718323378482702 1.300004021470418e-06 0.8638067662390768 1.300005185565676e-06 0.8533299089180234 \
1.300006730039304e-06 0.8394296462657486 1.300009047735338e-06 0.8185703819595179 1.30001310217554e-06 0.7820804201414684 1.300020405609059e-06 0.7163495184672377 \
1.300024709552219e-06 0.6776140300278762 1.300027719925121e-06 0.6505206739058862 1.300031001070041e-06 0.6209903696287848 1.300033489948491e-06 0.5985904635786021 \
1.300035625657776e-06 0.5793690800177949 1.300037405976345e-06 0.5633462128944384 1.30003901401067e-06 0.5488739039651435 1.300040483199695e-06 0.5356512027400909 \
1.30004182855096e-06 0.5235430413622801 1.300043042811606e-06 0.512614695545089 1.300044179223892e-06 0.5023869849741911 1.30004522982584e-06 0.4929315674378034 \
1.300046211266097e-06 0.484098605128202 1.300047124049725e-06 0.4758835524716363 1.300048018804021e-06 0.4678307638102979 1.300048846977552e-06 0.4603772020305483 \
1.300049661640793e-06 0.4530452328630955 1.300050503799878e-06 0.4454658010995214 1.300051392617152e-06 0.4374664456271048 1.300052132173523e-06 0.430810438295329 \
1.300053027009232e-06 0.4227569169129836 1.300054107902427e-06 0.4130288781558488 1.300056115262271e-06 0.3949626395600662 1.300056875998171e-06 0.3881160164607345 \
1.300057811866421e-06 0.3796932022097708 1.300058487146313e-06 0.373615683179101 1.300059159402893e-06 0.3675653739608269 1.300059962121142e-06 0.3603409097239061 \
1.300060719414128e-06 0.3535252728520237 1.300061469553632e-06 0.3467740173091934 1.300062198861823e-06 0.3402102435925485 1.300062917197496e-06 0.3337452225319747 \
1.300063543595907e-06 0.3281076368399389 1.30006394891578e-06 0.3244597579820502 1.300064431737776e-06 0.3201143600118136 1.300064801078116e-06 0.3167902969580316 \
1.300065253165156e-06 0.3127215135955985 1.300065684660782e-06 0.3088380529590536 1.300066036022831e-06 0.3056757945211269 1.300066243755913e-06 0.3038061967869528 \
1.300066531381985e-06 0.3012175621312337 1.300066776713801e-06 0.2990095757891347 1.300067080098449e-06 0.2962791139586973 1.300067337968212e-06 0.2939582860917911 \
1.300067584264137e-06 0.2917416227702929 1.300068012140654e-06 0.2878907341130054 1.30006843261691e-06 0.2841064478110101 1.300068974429479e-06 0.2792301346858994 \
1.300069431049699e-06 0.2751205527117666 1.300069864969875e-06 0.2712152711268295 1.300070276250537e-06 0.2675137451671025 1.300070709349453e-06 0.2636158549267912 \
1.300071125752111e-06 0.2598682310032753 1.300071577278909e-06 0.2558044898132805 1.300072019826756e-06 0.2518215591932373 1.300072486753141e-06 0.2476192217332239 \
1.300072977907995e-06 0.2431988280497077 1.300073496979761e-06 0.2385271821480127 1.300074065575267e-06 0.2334098225947888 1.30007466462888e-06 0.2280183400805964 \
1.300075295339653e-06 0.2223419431252401 1.300076027928546e-06 0.2157486430863834 1.300076737231274e-06 0.2093649185333881 1.300077405278374e-06 0.2033524946355669 \
1.300078031486169e-06 0.1977166244827963 1.300078642389351e-06 0.1922184958436388 1.300079237777688e-06 0.1868600008026635 1.300079853866796e-06 0.1813151988360575 \
1.300080454397603e-06 0.1759104215697842 1.300081046736475e-06 0.1705793717271608 1.300081670603799e-06 0.164964565812095 1.300082253990124e-06 0.1597140888870844 \
1.300082786746932e-06 0.1549192776137643 1.300083331146382e-06 0.1500196825588286 1.300083859078318e-06 0.1452682951413614 1.300084435818527e-06 0.1400776332571309 \
1.300085002237784e-06 0.1349798599404549 1.300085552082325e-06 0.1300312590758997 1.300086168681386e-06 0.1244818675298257 1.300086636997223e-06 0.1202670249965557 \
1.300087229995172e-06 0.114930043447014 1.300087690957483e-06 0.1107813826574622 1.300088106684468e-06 0.1070398397831492 1.300088462796911e-06 0.1038348278011874 \
1.300088810425094e-06 0.1007061741557836 1.300089112859056e-06 0.09798426849538755 1.300089417380186e-06 0.09524357832398211 1.300089689702494e-06 0.09279267755476828 \
1.300089953280439e-06 0.09042047604958559 1.300090197275105e-06 0.08822452405742931 1.300090467223407e-06 0.08579498933604146 1.300090706396949e-06 0.08364242745616901 \
1.300090969864118e-06 0.08127122294071432 1.300091224741101e-06 0.07897733008697083 1.30009145497135e-06 0.07690525785341851 1.300091719751726e-06 0.07452223446371342 \
1.300092001524411e-06 0.07198628030108556 1.300092277103734e-06 0.06950606639574286 1.300092617849715e-06 0.06643935256942901 1.300092904771124e-06 0.06385705988345824 \
1.300093210523111e-06 0.06110529199863279 1.30009350252768e-06 0.0584772508810687 1.300093774358483e-06 0.05603077365032616 1.30009402136155e-06 0.05380774605057426 \
1.300094217192034e-06 0.05204527169284134 1.300094394312361e-06 0.05045118874764443 1.300094569525492e-06 0.04887427057365767 1.300094727173406e-06 0.04745543934452334 \
1.300094874969159e-06 0.04612527756805263 1.300095020050112e-06 0.04481954899450691 1.300095158048333e-06 0.0435775650013065 1.300095300302896e-06 0.04229727393901672 \
1.300095426303471e-06 0.04116326875785103 1.300095559831953e-06 0.03996151242777013 1.300095682102066e-06 0.03886108140050326 1.300095815162015e-06 0.0376635418603275 \
1.300095929603908e-06 0.03663356482247337 1.300096021739576e-06 0.03580434381845876 1.300096118593814e-06 0.03493265567158488 1.300096258003299e-06 0.03367797030500419 \
1.300096372329609e-06 0.03264903351765647 1.300096481934954e-06 0.03166258541696143 1.300096615187473e-06 0.03046331274235659 1.300096728057783e-06 0.02944747995458197 \
1.300096850555119e-06 0.02834500393025741 1.300096986497112e-06 0.02712152598905548 1.300097104504206e-06 0.02605946214676502 1.300097233560397e-06 0.02489795642556891 \
1.300097344050859e-06 0.02390354227171532 1.300097479489315e-06 0.02268459616553509 1.300097599122986e-06 0.02160789312944722 1.30009770000436e-06 0.02069996076227698 \
1.300097820351452e-06 0.01961683693679572 1.30009796161121e-06 0.01834549910740102 1.300098123696895e-06 0.01688672794015589 1.300098272834849e-06 0.01554448635840755 \
1.300098425713135e-06 0.014168581787533 1.300098576006731e-06 0.01281593941858328 1.300098722835146e-06 0.01149448368366224 1.300098879191315e-06 0.01008727816647481 \
1.300098998454606e-06 0.009013908541385951 1.30009909308712e-06 0.008162215916559523 1.300099196564466e-06 0.007230919801462066 1.300099269048437e-06 0.006578564066408443 \
1.300099347396487e-06 0.005873431617253289 1.300099437077881e-06 0.005066299068704372 1.300099569889939e-06 0.003870990547362063 1.300099671489824e-06 0.002956591581575796 \
1.300099777454715e-06 0.002002907563398826 1.300099893286091e-06 0.000960425183447966 1.358990000000011e-06 0 1.359999999999996e-06 0 \
1.36000021116344e-06 0.001900470962571042 1.360000442444547e-06 0.003982000924727166 1.360000905006761e-06 0.008145060849039413 1.360001362320627e-06 0.01226088564504064 \
1.360001836803525e-06 0.01653123172985639 1.360002369299368e-06 0.02132369430982749 1.360003039181941e-06 0.02735263747515369 1.360003896286051e-06 0.03506657446094884 \
1.360005011032046e-06 0.04509928841663746 1.360006632029637e-06 0.05968826673863754 1.360008974699129e-06 0.08077229215837188 1.360013660038111e-06 0.1229403429978405 \
1.36001796446524e-06 0.1616801871633537 1.360021814406951e-06 0.1963296625632528 1.360026078483917e-06 0.2347063552562001 1.360029148481291e-06 0.2623363316230807 \
1.360031611421446e-06 0.2845027930151538 1.360033573234516e-06 0.3021591106476817 1.36003528302999e-06 0.3175472699147922 1.360036786621731e-06 0.3310795955797556 \
1.360038125719466e-06 0.3431314751960884 1.360039372399233e-06 0.3543515930958913 1.360040514338907e-06 0.3646290501629268 1.360041572311447e-06 0.3741508030226791 \
1.360042581357189e-06 0.3832322147042228 1.360043600260228e-06 0.3924023420515681 1.360044556738474e-06 0.4010106462662745 1.360045504571866e-06 0.4095411467944404 \
1.360046368147174e-06 0.4173133245688312 1.360047110848452e-06 0.423997636067712 1.360047770562902e-06 0.4299350661209142 1.36004846509286e-06 0.4361858357407548 \
1.360049134439972e-06 0.4422099597530631 1.360049745005552e-06 0.4477050499714701 1.360050521159036e-06 0.454690431324675 1.360051577583036e-06 0.4641982473299416 \
1.360052573303282e-06 0.4731597295416305 1.360053439146997e-06 0.4809523229693754 1.360054375298e-06 0.4893776819979773 1.360055101766735e-06 0.4959159006203305 \
1.360055767984727e-06 0.5019118625413875 1.360056382958911e-06 0.5074466301974319 1.360057167658468e-06 0.5145089262167936 1.360057876931857e-06 0.5208923867144013 \
1.360058576728557e-06 0.5271905570126808 1.360059241143132e-06 0.5331702881913303 1.360059896473734e-06 0.539068263602977 1.360060535798054e-06 0.5448221824871196 \
1.360061125945762e-06 0.5501335118600457 1.360061653249814e-06 0.5548792483285057 1.360062030104965e-06 0.5582709446854013 1.360062425635161e-06 0.5618307164525158 \
1.360062788740359e-06 0.5650986632355098 1.360063165175011e-06 0.5684865750957045 1.360063513154822e-06 0.5716183933999566 1.36006377784686e-06 0.5740006217454657 \
1.360064042985523e-06 0.5763868697045537 1.360064573262847e-06 0.5811593656227293 1.360064959313826e-06 0.5846338244342608 1.360065368210207e-06 0.5883138918597329 \
1.36006587063576e-06 0.5928357218442383 1.36006645565012e-06 0.5981008510799999 1.360066996785185e-06 0.6029710666652875 1.360067417144355e-06 0.6067542991940013 \
1.360067824982808e-06 0.6104248452748176 1.36006823230949e-06 0.6140907854118068 1.360068642157613e-06 0.6177794185173828 1.360069065799442e-06 0.62159219497586 \
1.360069510037211e-06 0.6255903348973357 1.360069966768595e-06 0.6297009173589793 1.360070444546043e-06 0.6340009143882042 1.36007097508933e-06 0.6387758039669345 \
1.360071541471415e-06 0.6438732427407217 1.360072145422139e-06 0.6493087992533674 1.360072793381625e-06 0.6551404346247349 1.360073505762603e-06 0.6615518634257037 \
1.360074168459051e-06 0.6675161314588195 1.360074781166818e-06 0.6730305013601764 1.360075359057944e-06 0.6782315214975446 1.360075921736873e-06 0.6832956318592801 \
1.360076483342761e-06 0.6883500848513783 1.360077074883236e-06 0.6936739491264482 1.360077655993641e-06 0.6989039427675531 1.360078230747911e-06 0.7040767311958204 \
1.36007883194594e-06 0.7094875134645067 1.360079324811182e-06 0.7139233006347314 1.36007975183504e-06 0.7177665153653698 1.360080153873253e-06 0.7213848592781456 \
1.360080537977864e-06 0.7248418007795954 1.360080898081889e-06 0.728082736999342 1.360081290978388e-06 0.731618805492268 1.360081350803762e-06 0.7321572338590965 \
1.36008147045451e-06 0.7332340905927537 1.360081709756006e-06 0.735387804060068 1.3600819763221e-06 0.7377868989013747 1.360082273049261e-06 0.7404574433520882 \
1.360082729389945e-06 0.7445645095019819 1.360083129641857e-06 0.7481667767176134 1.3600835424114e-06 0.7518817026010159 1.360083911328917e-06 0.7552019602568045 \
1.360084334919757e-06 0.7590142778153435 1.360084704529443e-06 0.762340764983916 1.36008510473479e-06 0.7659426131102501 1.360085434938255e-06 0.7689144442964062 \
1.360085700495003e-06 0.7713044550329466 1.360085970256226e-06 0.7737323060316124 1.36008638098703e-06 0.7774288832736076 1.36008667585935e-06 0.7800827341539526 \
1.360087078396993e-06 0.7837055729337647 1.360087421594134e-06 0.786794347204456 1.360087774419653e-06 0.7899697768807414 1.360088101708689e-06 0.7929153782018739 \
1.360088421022111e-06 0.7957891990026931 1.36008872760096e-06 0.798548408642265 1.360089025875665e-06 0.8012328809879466 1.360089320848706e-06 0.8038876383597224 \
1.360089591459277e-06 0.8063231334915267 1.360089868048603e-06 0.808812437424818 1.36009015247317e-06 0.8113722585315476 1.360090393475363e-06 0.813541278265291 \
1.360090665778045e-06 0.8159920024070124 1.360090970927407e-06 0.8187383466657218 1.360091271218559e-06 0.8214409670293247 1.360091576487057e-06 0.8241883835163635 \
1.360091871067987e-06 0.8268396118826479 1.360092193104528e-06 0.8297379407530008 1.360092432654028e-06 0.8318938862491163 1.360092688128584e-06 0.8341931572572034 \
1.360092950748264e-06 0.8365567343768243 1.360093196157421e-06 0.8387654167908133 1.360093430718228e-06 0.8408764640555111 1.360093634774443e-06 0.8427129699896301 \
1.360093845366316e-06 0.8446082968424707 1.36009405600496e-06 0.8465040446443356 1.360094244655363e-06 0.8482018982687493 1.360094419312833e-06 0.8497738154964893 \
1.360094599278918e-06 0.8513935102645009 1.360094762688076e-06 0.8528641926851036 1.360094936630778e-06 0.854429677001575 1.36009509164947e-06 0.8558248452281332 \
1.360095258694903e-06 0.8573282541293438 1.360095417039538e-06 0.8587533558427882 1.36009558556135e-06 0.8602700521522246 1.360095742775809e-06 0.8616849822849083 \
1.360095861449153e-06 0.8627530423825936 1.360096011867914e-06 0.8641068112286804 1.360096136494933e-06 0.865228454399422 1.360096297689131e-06 0.8666792021766703 \
1.36009645446677e-06 0.8680902009355517 1.360096580116853e-06 0.8692210516792804 1.360096724052222e-06 0.8705164700033486 1.360096889588435e-06 0.8720062959137309 \
1.360097059053952e-06 0.8735314855691456 1.360097224438411e-06 0.8750199457013955 1.360097397353649e-06 0.8765761828405442 1.360097548608782e-06 0.8779374790365844 \
1.360097705455835e-06 0.8793491025165162 1.360097837560426e-06 0.8805380438351178 1.360097951168902e-06 0.8815605201209382 1.360098066732818e-06 0.8826005953617506 \
1.360098173944515e-06 0.8835655006364479 1.360098251949639e-06 0.8842675467541018 1.360098369203879e-06 0.8853228349141965 1.360098469613519e-06 0.886226521672304 \
1.360098577287673e-06 0.8871955890613133 1.360098653452348e-06 0.8878810711332904 1.360098760907383e-06 0.8888481664483866 1.360098854230815e-06 0.8896880773334693 \
1.360098954910124e-06 0.8905941911166799 1.360099049707369e-06 0.8914473663235497 1.36009913587369e-06 0.8922228632126831 1.36009922632816e-06 0.8930369534412941 \
1.360099366017076e-06 0.8942941536875396 1.360099486829852e-06 0.8953814686688766 1.360099612459293e-06 0.8965121336427553 1.360099756606946e-06 0.8978094625160885 \
1.360099892907379e-06 0.8990361664106589 1.400000175810298e-06 0.8984177073129849 1.400000387736115e-06 0.8965103749658082 1.400000811587747e-06 0.892695710271455 \
1.400001292817289e-06 0.8883646443965901 1.400001822218869e-06 0.8836000301806309 1.400002413857702e-06 0.8782752806762187 1.400003129740239e-06 0.8718323378482702 \
1.400004021470418e-06 0.8638067662390768 1.400005185565676e-06 0.8533299089180234 1.400006730039304e-06 0.8394296462657486 1.400009047735338e-06 0.8185703819595179 \
1.40001310217554e-06 0.7820804201414684 1.400020405609059e-06 0.7163495184672377 1.400024709552219e-06 0.6776140300278762 1.400027719925121e-06 0.6505206739058862 \
1.400031001070041e-06 0.6209903696287848 1.400033489948491e-06 0.5985904635786021 1.400035625657776e-06 0.5793690800177949 1.400037405976345e-06 0.5633462128944384 \
1.40003901401067e-06 0.5488739039651435 1.400040483199695e-06 0.5356512027400909 1.40004182855096e-06 0.5235430413622801 1.400043042811606e-06 0.512614695545089 \
1.400044179223892e-06 0.5023869849741911 1.40004522982584e-06 0.4929315674378034 1.400046211266097e-06 0.484098605128202 1.400047124049725e-06 0.4758835524716363 \
1.400048018804021e-06 0.4678307638102979 1.400048846977552e-06 0.4603772020305483 1.400049661640793e-06 0.4530452328630955 1.400050503799878e-06 0.4454658010995214 \
1.400051392617152e-06 0.4374664456271048 1.400052132173522e-06 0.430810438295329 1.400053027009232e-06 0.4227569169129836 1.400054107902427e-06 0.4130288781558488 \
1.400056115262271e-06 0.3949626395600662 1.400056875998171e-06 0.3881160164607345 1.400057811866421e-06 0.3796932022097708 1.400058487146313e-06 0.373615683179101 \
1.400059159402893e-06 0.3675653739608269 1.400059962121142e-06 0.3603409097239061 1.400060719414127e-06 0.3535252728520237 1.400061469553632e-06 0.3467740173091934 \
1.400062198861823e-06 0.3402102435925485 1.400062917197496e-06 0.3337452225319747 1.400063543595906e-06 0.3281076368399389 1.40006394891578e-06 0.3244597579820502 \
1.400064431737776e-06 0.3201143600118136 1.400064801078116e-06 0.3167902969580316 1.400065253165156e-06 0.3127215135955985 1.400065684660782e-06 0.3088380529590536 \
1.400066036022831e-06 0.3056757945211269 1.400066243755913e-06 0.3038061967869528 1.400066531381985e-06 0.3012175621312337 1.400066776713801e-06 0.2990095757891347 \
1.400067080098449e-06 0.2962791139586973 1.400067337968212e-06 0.2939582860917911 1.400067584264137e-06 0.2917416227702929 1.400068012140654e-06 0.2878907341130054 \
1.40006843261691e-06 0.2841064478110101 1.400068974429479e-06 0.2792301346858994 1.400069431049699e-06 0.2751205527117666 1.400069864969875e-06 0.2712152711268295 \
1.400070276250537e-06 0.2675137451671025 1.400070709349452e-06 0.2636158549267912 1.400071125752111e-06 0.2598682310032753 1.400071577278909e-06 0.2558044898132805 \
1.400072019826756e-06 0.2518215591932373 1.40007248675314e-06 0.2476192217332239 1.400072977907994e-06 0.2431988280497077 1.400073496979761e-06 0.2385271821480127 \
1.400074065575267e-06 0.2334098225947888 1.40007466462888e-06 0.2280183400805964 1.400075295339653e-06 0.2223419431252401 1.400076027928546e-06 0.2157486430863834 \
1.400076737231274e-06 0.2093649185333881 1.400077405278374e-06 0.2033524946355669 1.400078031486169e-06 0.1977166244827963 1.400078642389351e-06 0.1922184958436388 \
1.400079237777688e-06 0.1868600008026635 1.400079853866796e-06 0.1813151988360575 1.400080454397603e-06 0.1759104215697842 1.400081046736475e-06 0.1705793717271608 \
1.400081670603798e-06 0.164964565812095 1.400082253990124e-06 0.1597140888870844 1.400082786746932e-06 0.1549192776137643 1.400083331146382e-06 0.1500196825588286 \
1.400083859078317e-06 0.1452682951413614 1.400084435818527e-06 0.1400776332571309 1.400085002237784e-06 0.1349798599404549 1.400085552082325e-06 0.1300312590758997 \
1.400086168681385e-06 0.1244818675298257 1.400086636997222e-06 0.1202670249965557 1.400087229995172e-06 0.114930043447014 1.400087690957482e-06 0.1107813826574622 \
1.400088106684468e-06 0.1070398397831492 1.400088462796911e-06 0.1038348278011874 1.400088810425094e-06 0.1007061741557836 1.400089112859056e-06 0.09798426849538755 \
1.400089417380186e-06 0.09524357832398211 1.400089689702494e-06 0.09279267755476828 1.400089953280439e-06 0.09042047604958559 1.400090197275105e-06 0.08822452405742931 \
1.400090467223407e-06 0.08579498933604146 1.400090706396949e-06 0.08364242745616901 1.400090969864118e-06 0.08127122294071432 1.400091224741101e-06 0.07897733008697083 \
1.40009145497135e-06 0.07690525785341851 1.400091719751726e-06 0.07452223446371342 1.400092001524411e-06 0.07198628030108556 1.400092277103734e-06 0.06950606639574286 \
1.400092617849714e-06 0.06643935256942901 1.400092904771124e-06 0.06385705988345824 1.400093210523111e-06 0.06110529199863279 1.40009350252768e-06 0.0584772508810687 \
1.400093774358483e-06 0.05603077365032616 1.40009402136155e-06 0.05380774605057426 1.400094217192034e-06 0.05204527169284134 1.400094394312361e-06 0.05045118874764443 \
1.400094569525492e-06 0.04887427057365767 1.400094727173406e-06 0.04745543934452334 1.400094874969159e-06 0.04612527756805263 1.400095020050112e-06 0.04481954899450691 \
1.400095158048333e-06 0.0435775650013065 1.400095300302895e-06 0.04229727393901672 1.400095426303471e-06 0.04116326875785103 1.400095559831952e-06 0.03996151242777013 \
1.400095682102066e-06 0.03886108140050326 1.400095815162015e-06 0.0376635418603275 1.400095929603908e-06 0.03663356482247337 1.400096021739576e-06 0.03580434381845876 \
1.400096118593814e-06 0.03493265567158488 1.400096258003299e-06 0.03367797030500419 1.400096372329609e-06 0.03264903351765647 1.400096481934953e-06 0.03166258541696143 \
1.400096615187473e-06 0.03046331274235659 1.400096728057783e-06 0.02944747995458197 1.400096850555119e-06 0.02834500393025741 1.400096986497112e-06 0.02712152598905548 \
1.400097104504206e-06 0.02605946214676502 1.400097233560397e-06 0.02489795642556891 1.400097344050858e-06 0.02390354227171532 1.400097479489315e-06 0.02268459616553509 \
1.400097599122985e-06 0.02160789312944722 1.40009770000436e-06 0.02069996076227698 1.400097820351451e-06 0.01961683693679572 1.40009796161121e-06 0.01834549910740102 \
1.400098123696895e-06 0.01688672794015589 1.400098272834849e-06 0.01554448635840755 1.400098425713134e-06 0.014168581787533 1.400098576006731e-06 0.01281593941858328 \
1.400098722835146e-06 0.01149448368366224 1.400098879191315e-06 0.01008727816647481 1.400098998454606e-06 0.009013908541385951 1.40009909308712e-06 0.008162215916559523 \
1.400099196564466e-06 0.007230919801462066 1.400099269048437e-06 0.006578564066408443 1.400099347396487e-06 0.005873431617253289 1.400099437077881e-06 0.005066299068704372 \
1.400099569889939e-06 0.003870990547362063 1.400099671489824e-06 0.002956591581575796 1.400099777454715e-06 0.002002907563398826 1.400099893286091e-06 0.000960425183447966 \
1.458990000000011e-06 0 1.459999999999996e-06 0 1.46000021116344e-06 0.001900470962571042 1.460000442444547e-06 0.003982000924727166 \
1.460000905006761e-06 0.008145060849039413 1.460001362320627e-06 0.01226088564504064 1.460001836803525e-06 0.01653123172985639 1.460002369299368e-06 0.02132369430982749 \
1.460003039181942e-06 0.02735263747515369 1.460003896286051e-06 0.03506657446094884 1.460005011032046e-06 0.04509928841663746 1.460006632029638e-06 0.05968826673863754 \
1.460008974699129e-06 0.08077229215837188 1.460013660038111e-06 0.1229403429978405 1.46001796446524e-06 0.1616801871633537 1.460021814406951e-06 0.1963296625632528 \
1.460026078483917e-06 0.2347063552562001 1.460029148481291e-06 0.2623363316230807 1.460031611421446e-06 0.2845027930151538 1.460033573234516e-06 0.3021591106476817 \
1.46003528302999e-06 0.3175472699147922 1.460036786621731e-06 0.3310795955797556 1.460038125719466e-06 0.3431314751960884 1.460039372399233e-06 0.3543515930958913 \
1.460040514338907e-06 0.3646290501629268 1.460041572311447e-06 0.3741508030226791 1.460042581357189e-06 0.3832322147042228 1.460043600260228e-06 0.3924023420515681 \
1.460044556738474e-06 0.4010106462662745 1.460045504571866e-06 0.4095411467944404 1.460046368147174e-06 0.4173133245688312 1.460047110848452e-06 0.423997636067712 \
1.460047770562902e-06 0.4299350661209142 1.46004846509286e-06 0.4361858357407548 1.460049134439973e-06 0.4422099597530631 1.460049745005552e-06 0.4477050499714701 \
1.460050521159036e-06 0.454690431324675 1.460051577583036e-06 0.4641982473299416 1.460052573303282e-06 0.4731597295416305 1.460053439146997e-06 0.4809523229693754 \
1.460054375298e-06 0.4893776819979773 1.460055101766736e-06 0.4959159006203305 1.460055767984727e-06 0.5019118625413875 1.460056382958911e-06 0.5074466301974319 \
1.460057167658469e-06 0.5145089262167936 1.460057876931857e-06 0.5208923867144013 1.460058576728557e-06 0.5271905570126808 1.460059241143132e-06 0.5331702881913303 \
1.460059896473734e-06 0.539068263602977 1.460060535798054e-06 0.5448221824871196 1.460061125945762e-06 0.5501335118600457 1.460061653249814e-06 0.5548792483285057 \
1.460062030104965e-06 0.5582709446854013 1.460062425635161e-06 0.5618307164525158 1.460062788740359e-06 0.5650986632355098 1.46006316517501e-06 0.5684865750957045 \
1.460063513154822e-06 0.5716183933999566 1.460063777846861e-06 0.5740006217454657 1.460064042985523e-06 0.5763868697045537 1.460064573262847e-06 0.5811593656227293 \
1.460064959313826e-06 0.5846338244342608 1.460065368210207e-06 0.5883138918597329 1.46006587063576e-06 0.5928357218442383 1.46006645565012e-06 0.5981008510799999 \
1.460066996785185e-06 0.6029710666652875 1.460067417144355e-06 0.6067542991940013 1.460067824982808e-06 0.6104248452748176 1.46006823230949e-06 0.6140907854118068 \
1.460068642157613e-06 0.6177794185173828 1.460069065799442e-06 0.62159219497586 1.460069510037211e-06 0.6255903348973357 1.460069966768595e-06 0.6297009173589793 \
1.460070444546043e-06 0.6340009143882042 1.46007097508933e-06 0.6387758039669345 1.460071541471416e-06 0.6438732427407217 1.460072145422139e-06 0.6493087992533674 \
1.460072793381625e-06 0.6551404346247349 1.460073505762603e-06 0.6615518634257037 1.460074168459051e-06 0.6675161314588195 1.460074781166818e-06 0.6730305013601764 \
1.460075359057944e-06 0.6782315214975446 1.460075921736873e-06 0.6832956318592801 1.460076483342761e-06 0.6883500848513783 1.460077074883236e-06 0.6936739491264482 \
1.460077655993641e-06 0.6989039427675531 1.460078230747911e-06 0.7040767311958204 1.46007883194594e-06 0.7094875134645067 1.460079324811182e-06 0.7139233006347314 \
1.460079751835041e-06 0.7177665153653698 1.460080153873253e-06 0.7213848592781456 1.460080537977864e-06 0.7248418007795954 1.460080898081889e-06 0.728082736999342 \
1.460081290978388e-06 0.731618805492268 1.460081350803762e-06 0.7321572338590965 1.46008147045451e-06 0.7332340905927537 1.460081709756007e-06 0.735387804060068 \
1.4600819763221e-06 0.7377868989013747 1.460082273049261e-06 0.7404574433520882 1.460082729389945e-06 0.7445645095019819 1.460083129641858e-06 0.7481667767176134 \
1.4600835424114e-06 0.7518817026010159 1.460083911328917e-06 0.7552019602568045 1.460084334919757e-06 0.7590142778153435 1.460084704529443e-06 0.762340764983916 \
1.46008510473479e-06 0.7659426131102501 1.460085434938255e-06 0.7689144442964062 1.460085700495004e-06 0.7713044550329466 1.460085970256226e-06 0.7737323060316124 \
1.46008638098703e-06 0.7774288832736076 1.46008667585935e-06 0.7800827341539526 1.460087078396993e-06 0.7837055729337647 1.460087421594134e-06 0.786794347204456 \
1.460087774419653e-06 0.7899697768807414 1.460088101708689e-06 0.7929153782018739 1.460088421022111e-06 0.7957891990026931 1.46008872760096e-06 0.798548408642265 \
1.460089025875665e-06 0.8012328809879466 1.460089320848706e-06 0.8038876383597224 1.460089591459277e-06 0.8063231334915267 1.460089868048603e-06 0.808812437424818 \
1.46009015247317e-06 0.8113722585315476 1.460090393475363e-06 0.813541278265291 1.460090665778045e-06 0.8159920024070124 1.460090970927407e-06 0.8187383466657218 \
1.460091271218559e-06 0.8214409670293247 1.460091576487057e-06 0.8241883835163635 1.460091871067987e-06 0.8268396118826479 1.460092193104528e-06 0.8297379407530008 \
1.460092432654028e-06 0.8318938862491163 1.460092688128584e-06 0.8341931572572034 1.460092950748264e-06 0.8365567343768243 1.460093196157421e-06 0.8387654167908133 \
1.460093430718228e-06 0.8408764640555111 1.460093634774443e-06 0.8427129699896301 1.460093845366316e-06 0.8446082968424707 1.46009405600496e-06 0.8465040446443356 \
1.460094244655363e-06 0.8482018982687493 1.460094419312833e-06 0.8497738154964893 1.460094599278918e-06 0.8513935102645009 1.460094762688076e-06 0.8528641926851036 \
1.460094936630778e-06 0.854429677001575 1.46009509164947e-06 0.8558248452281332 1.460095258694903e-06 0.8573282541293438 1.460095417039538e-06 0.8587533558427882 \
1.46009558556135e-06 0.8602700521522246 1.460095742775809e-06 0.8616849822849083 1.460095861449154e-06 0.8627530423825936 1.460096011867914e-06 0.8641068112286804 \
1.460096136494933e-06 0.865228454399422 1.460096297689131e-06 0.8666792021766703 1.46009645446677e-06 0.8680902009355517 1.460096580116853e-06 0.8692210516792804 \
1.460096724052223e-06 0.8705164700033486 1.460096889588435e-06 0.8720062959137309 1.460097059053952e-06 0.8735314855691456 1.460097224438411e-06 0.8750199457013955 \
1.460097397353649e-06 0.8765761828405442 1.460097548608782e-06 0.8779374790365844 1.460097705455835e-06 0.8793491025165162 1.460097837560426e-06 0.8805380438351178 \
1.460097951168902e-06 0.8815605201209382 1.460098066732818e-06 0.8826005953617506 1.460098173944515e-06 0.8835655006364479 1.460098251949639e-06 0.8842675467541018 \
1.460098369203879e-06 0.8853228349141965 1.460098469613519e-06 0.886226521672304 1.460098577287673e-06 0.8871955890613133 1.460098653452348e-06 0.8878810711332904 \
1.460098760907383e-06 0.8888481664483866 1.460098854230815e-06 0.8896880773334693 1.460098954910124e-06 0.8905941911166799 1.460099049707369e-06 0.8914473663235497 \
1.46009913587369e-06 0.8922228632126831 1.46009922632816e-06 0.8930369534412941 1.460099366017076e-06 0.8942941536875396 1.460099486829852e-06 0.8953814686688766 \
1.460099612459294e-06 0.8965121336427553 1.460099756606946e-06 0.8978094625160885 1.460099892907379e-06 0.8990361664106589 1.500000175810299e-06 0.8984177073129849 \
1.500000387736115e-06 0.8965103749658082 1.500000811587748e-06 0.892695710271455 1.500001292817289e-06 0.8883646443965901 1.500001822218869e-06 0.8836000301806309 \
1.500002413857703e-06 0.8782752806762187 1.500003129740239e-06 0.8718323378482702 1.500004021470418e-06 0.8638067662390768 1.500005185565676e-06 0.8533299089180234 \
1.500006730039304e-06 0.8394296462657486 1.500009047735338e-06 0.8185703819595179 1.50001310217554e-06 0.7820804201414684 1.500020405609059e-06 0.7163495184672377 \
1.500024709552219e-06 0.6776140300278762 1.500027719925121e-06 0.6505206739058862 1.500031001070041e-06 0.6209903696287848 1.500033489948491e-06 0.5985904635786021 \
1.500035625657776e-06 0.5793690800177949 1.500037405976345e-06 0.5633462128944384 1.50003901401067e-06 0.5488739039651435 1.500040483199695e-06 0.5356512027400909 \
1.50004182855096e-06 0.5235430413622801 1.500043042811606e-06 0.512614695545089 1.500044179223892e-06 0.5023869849741911 1.50004522982584e-06 0.4929315674378034 \
1.500046211266097e-06 0.484098605128202 1.500047124049725e-06 0.4758835524716363 1.500048018804021e-06 0.4678307638102979 1.500048846977552e-06 0.4603772020305483 \
1.500049661640793e-06 0.4530452328630955 1.500050503799878e-06 0.4454658010995214 1.500051392617152e-06 0.4374664456271048 1.500052132173523e-06 0.430810438295329 \
1.500053027009232e-06 0.4227569169129836 1.500054107902427e-06 0.4130288781558488 1.500056115262271e-06 0.3949626395600662 1.500056875998171e-06 0.3881160164607345 \
1.500057811866421e-06 0.3796932022097708 1.500058487146313e-06 0.373615683179101 1.500059159402893e-06 0.3675653739608269 1.500059962121142e-06 0.3603409097239061 \
1.500060719414127e-06 0.3535252728520237 1.500061469553632e-06 0.3467740173091934 1.500062198861823e-06 0.3402102435925485 1.500062917197496e-06 0.3337452225319747 \
1.500063543595907e-06 0.3281076368399389 1.50006394891578e-06 0.3244597579820502 1.500064431737776e-06 0.3201143600118136 1.500064801078116e-06 0.3167902969580316 \
1.500065253165156e-06 0.3127215135955985 1.500065684660782e-06 0.3088380529590536 1.500066036022831e-06 0.3056757945211269 1.500066243755913e-06 0.3038061967869528 \
1.500066531381985e-06 0.3012175621312337 1.500066776713801e-06 0.2990095757891347 1.500067080098449e-06 0.2962791139586973 1.500067337968212e-06 0.2939582860917911 \
1.500067584264137e-06 0.2917416227702929 1.500068012140654e-06 0.2878907341130054 1.50006843261691e-06 0.2841064478110101 1.500068974429479e-06 0.2792301346858994 \
1.500069431049699e-06 0.2751205527117666 1.500069864969875e-06 0.2712152711268295 1.500070276250537e-06 0.2675137451671025 1.500070709349453e-06 0.2636158549267912 \
1.500071125752111e-06 0.2598682310032753 1.500071577278909e-06 0.2558044898132805 1.500072019826756e-06 0.2518215591932373 1.500072486753141e-06 0.2476192217332239 \
1.500072977907995e-06 0.2431988280497077 1.500073496979761e-06 0.2385271821480127 1.500074065575267e-06 0.2334098225947888 1.50007466462888e-06 0.2280183400805964 \
1.500075295339653e-06 0.2223419431252401 1.500076027928546e-06 0.2157486430863834 1.500076737231274e-06 0.2093649185333881 1.500077405278374e-06 0.2033524946355669 \
1.500078031486169e-06 0.1977166244827963 1.500078642389351e-06 0.1922184958436388 1.500079237777688e-06 0.1868600008026635 1.500079853866796e-06 0.1813151988360575 \
1.500080454397603e-06 0.1759104215697842 1.500081046736475e-06 0.1705793717271608 1.500081670603799e-06 0.164964565812095 1.500082253990124e-06 0.1597140888870844 \
1.500082786746932e-06 0.1549192776137643 1.500083331146382e-06 0.1500196825588286 1.500083859078318e-06 0.1452682951413614 1.500084435818527e-06 0.1400776332571309 \
1.500085002237784e-06 0.1349798599404549 1.500085552082325e-06 0.1300312590758997 1.500086168681386e-06 0.1244818675298257 1.500086636997223e-06 0.1202670249965557 \
1.500087229995172e-06 0.114930043447014 1.500087690957483e-06 0.1107813826574622 1.500088106684468e-06 0.1070398397831492 1.500088462796911e-06 0.1038348278011874 \
1.500088810425094e-06 0.1007061741557836 1.500089112859056e-06 0.09798426849538755 1.500089417380186e-06 0.09524357832398211 1.500089689702494e-06 0.09279267755476828 \
1.500089953280439e-06 0.09042047604958559 1.500090197275105e-06 0.08822452405742931 1.500090467223407e-06 0.08579498933604146 1.500090706396949e-06 0.08364242745616901 \
1.500090969864118e-06 0.08127122294071432 1.500091224741101e-06 0.07897733008697083 1.50009145497135e-06 0.07690525785341851 1.500091719751726e-06 0.07452223446371342 \
1.500092001524411e-06 0.07198628030108556 1.500092277103734e-06 0.06950606639574286 1.500092617849714e-06 0.06643935256942901 1.500092904771124e-06 0.06385705988345824 \
1.500093210523111e-06 0.06110529199863279 1.50009350252768e-06 0.0584772508810687 1.500093774358483e-06 0.05603077365032616 1.50009402136155e-06 0.05380774605057426 \
1.500094217192034e-06 0.05204527169284134 1.500094394312361e-06 0.05045118874764443 1.500094569525492e-06 0.04887427057365767 1.500094727173406e-06 0.04745543934452334 \
1.500094874969159e-06 0.04612527756805263 1.500095020050112e-06 0.04481954899450691 1.500095158048333e-06 0.0435775650013065 1.500095300302896e-06 0.04229727393901672 \
1.500095426303471e-06 0.04116326875785103 1.500095559831953e-06 0.03996151242777013 1.500095682102066e-06 0.03886108140050326 1.500095815162015e-06 0.0376635418603275 \
1.500095929603908e-06 0.03663356482247337 1.500096021739576e-06 0.03580434381845876 1.500096118593814e-06 0.03493265567158488 1.500096258003299e-06 0.03367797030500419 \
1.500096372329609e-06 0.03264903351765647 1.500096481934954e-06 0.03166258541696143 1.500096615187473e-06 0.03046331274235659 1.500096728057783e-06 0.02944747995458197 \
1.500096850555119e-06 0.02834500393025741 1.500096986497112e-06 0.02712152598905548 1.500097104504206e-06 0.02605946214676502 1.500097233560397e-06 0.02489795642556891 \
1.500097344050859e-06 0.02390354227171532 1.500097479489315e-06 0.02268459616553509 1.500097599122985e-06 0.02160789312944722 1.50009770000436e-06 0.02069996076227698 \
1.500097820351452e-06 0.01961683693679572 1.50009796161121e-06 0.01834549910740102 1.500098123696895e-06 0.01688672794015589 1.500098272834849e-06 0.01554448635840755 \
1.500098425713135e-06 0.014168581787533 1.500098576006731e-06 0.01281593941858328 1.500098722835146e-06 0.01149448368366224 1.500098879191315e-06 0.01008727816647481 \
1.500098998454606e-06 0.009013908541385951 1.50009909308712e-06 0.008162215916559523 1.500099196564466e-06 0.007230919801462066 1.500099269048437e-06 0.006578564066408443 \
1.500099347396487e-06 0.005873431617253289 1.500099437077881e-06 0.005066299068704372 1.500099569889939e-06 0.003870990547362063 1.500099671489824e-06 0.002956591581575796 \
1.500099777454715e-06 0.002002907563398826 1.500099893286091e-06 0.000960425183447966 1.558990000000011e-06 0 1.559999999999996e-06 0 \
1.56000021116344e-06 0.001900470962571042 1.560000442444547e-06 0.003982000924727166 1.560000905006761e-06 0.008145060849039413 1.560001362320627e-06 0.01226088564504064 \
1.560001836803526e-06 0.01653123172985639 1.560002369299368e-06 0.02132369430982749 1.560003039181942e-06 0.02735263747515369 1.560003896286051e-06 0.03506657446094884 \
1.560005011032046e-06 0.04509928841663746 1.560006632029638e-06 0.05968826673863754 1.560008974699129e-06 0.08077229215837188 1.560013660038111e-06 0.1229403429978405 \
1.56001796446524e-06 0.1616801871633537 1.560021814406952e-06 0.1963296625632528 1.560026078483917e-06 0.2347063552562001 1.560029148481291e-06 0.2623363316230807 \
1.560031611421446e-06 0.2845027930151538 1.560033573234516e-06 0.3021591106476817 1.560035283029991e-06 0.3175472699147922 1.560036786621731e-06 0.3310795955797556 \
1.560038125719466e-06 0.3431314751960884 1.560039372399233e-06 0.3543515930958913 1.560040514338907e-06 0.3646290501629268 1.560041572311447e-06 0.3741508030226791 \
1.560042581357189e-06 0.3832322147042228 1.560043600260228e-06 0.3924023420515681 1.560044556738474e-06 0.4010106462662745 1.560045504571866e-06 0.4095411467944404 \
1.560046368147174e-06 0.4173133245688312 1.560047110848452e-06 0.423997636067712 1.560047770562902e-06 0.4299350661209142 1.56004846509286e-06 0.4361858357407548 \
1.560049134439973e-06 0.4422099597530631 1.560049745005552e-06 0.4477050499714701 1.560050521159036e-06 0.454690431324675 1.560051577583037e-06 0.4641982473299416 \
1.560052573303282e-06 0.4731597295416305 1.560053439146997e-06 0.4809523229693754 1.560054375298e-06 0.4893776819979773 1.560055101766736e-06 0.4959159006203305 \
1.560055767984727e-06 0.5019118625413875 1.560056382958911e-06 0.5074466301974319 1.560057167658469e-06 0.5145089262167936 1.560057876931857e-06 0.5208923867144013 \
1.560058576728557e-06 0.5271905570126808 1.560059241143132e-06 0.5331702881913303 1.560059896473734e-06 0.539068263602977 1.560060535798054e-06 0.5448221824871196 \
1.560061125945762e-06 0.5501335118600457 1.560061653249814e-06 0.5548792483285057 1.560062030104965e-06 0.5582709446854013 1.560062425635161e-06 0.5618307164525158 \
1.56006278874036e-06 0.5650986632355098 1.560063165175011e-06 0.5684865750957045 1.560063513154822e-06 0.5716183933999566 1.560063777846861e-06 0.5740006217454657 \
1.560064042985523e-06 0.5763868697045537 1.560064573262847e-06 0.5811593656227293 1.560064959313826e-06 0.5846338244342608 1.560065368210207e-06 0.5883138918597329 \
1.56006587063576e-06 0.5928357218442383 1.56006645565012e-06 0.5981008510799999 1.560066996785185e-06 0.6029710666652875 1.560067417144355e-06 0.6067542991940013 \
1.560067824982808e-06 0.6104248452748176 1.56006823230949e-06 0.6140907854118068 1.560068642157613e-06 0.6177794185173828 1.560069065799442e-06 0.62159219497586 \
1.560069510037211e-06 0.6255903348973357 1.560069966768595e-06 0.6297009173589793 1.560070444546043e-06 0.6340009143882042 1.56007097508933e-06 0.6387758039669345 \
1.560071541471416e-06 0.6438732427407217 1.560072145422139e-06 0.6493087992533674 1.560072793381625e-06 0.6551404346247349 1.560073505762603e-06 0.6615518634257037 \
1.560074168459051e-06 0.6675161314588195 1.560074781166818e-06 0.6730305013601764 1.560075359057944e-06 0.6782315214975446 1.560075921736873e-06 0.6832956318592801 \
1.560076483342761e-06 0.6883500848513783 1.560077074883236e-06 0.6936739491264482 1.560077655993641e-06 0.6989039427675531 1.560078230747911e-06 0.7040767311958204 \
1.560078831945941e-06 0.7094875134645067 1.560079324811182e-06 0.7139233006347314 1.560079751835041e-06 0.7177665153653698 1.560080153873253e-06 0.7213848592781456 \
1.560080537977865e-06 0.7248418007795954 1.560080898081889e-06 0.728082736999342 1.560081290978388e-06 0.731618805492268 1.560081350803762e-06 0.7321572338590965 \
1.56008147045451e-06 0.7332340905927537 1.560081709756007e-06 0.735387804060068 1.5600819763221e-06 0.7377868989013747 1.560082273049261e-06 0.7404574433520882 \
1.560082729389945e-06 0.7445645095019819 1.560083129641858e-06 0.7481667767176134 1.5600835424114e-06 0.7518817026010159 1.560083911328917e-06 0.7552019602568045 \
1.560084334919757e-06 0.7590142778153435 1.560084704529443e-06 0.762340764983916 1.56008510473479e-06 0.7659426131102501 1.560085434938255e-06 0.7689144442964062 \
1.560085700495004e-06 0.7713044550329466 1.560085970256226e-06 0.7737323060316124 1.56008638098703e-06 0.7774288832736076 1.56008667585935e-06 0.7800827341539526 \
1.560087078396993e-06 0.7837055729337647 1.560087421594134e-06 0.786794347204456 1.560087774419653e-06 0.7899697768807414 1.560088101708689e-06 0.7929153782018739 \
1.560088421022112e-06 0.7957891990026931 1.56008872760096e-06 0.798548408642265 1.560089025875665e-06 0.8012328809879466 1.560089320848707e-06 0.8038876383597224 \
1.560089591459277e-06 0.8063231334915267 1.560089868048603e-06 0.808812437424818 1.56009015247317e-06 0.8113722585315476 1.560090393475363e-06 0.813541278265291 \
1.560090665778045e-06 0.8159920024070124 1.560090970927407e-06 0.8187383466657218 1.560091271218559e-06 0.8214409670293247 1.560091576487057e-06 0.8241883835163635 \
1.560091871067987e-06 0.8268396118826479 1.560092193104528e-06 0.8297379407530008 1.560092432654028e-06 0.8318938862491163 1.560092688128584e-06 0.8341931572572034 \
1.560092950748264e-06 0.8365567343768243 1.560093196157421e-06 0.8387654167908133 1.560093430718228e-06 0.8408764640555111 1.560093634774443e-06 0.8427129699896301 \
1.560093845366316e-06 0.8446082968424707 1.560094056004961e-06 0.8465040446443356 1.560094244655363e-06 0.8482018982687493 1.560094419312833e-06 0.8497738154964893 \
1.560094599278918e-06 0.8513935102645009 1.560094762688076e-06 0.8528641926851036 1.560094936630778e-06 0.854429677001575 1.56009509164947e-06 0.8558248452281332 \
1.560095258694903e-06 0.8573282541293438 1.560095417039538e-06 0.8587533558427882 1.56009558556135e-06 0.8602700521522246 1.560095742775809e-06 0.8616849822849083 \
1.560095861449154e-06 0.8627530423825936 1.560096011867914e-06 0.8641068112286804 1.560096136494933e-06 0.865228454399422 1.560096297689131e-06 0.8666792021766703 \
1.560096454466771e-06 0.8680902009355517 1.560096580116853e-06 0.8692210516792804 1.560096724052223e-06 0.8705164700033486 1.560096889588435e-06 0.8720062959137309 \
1.560097059053952e-06 0.8735314855691456 1.560097224438411e-06 0.8750199457013955 1.560097397353649e-06 0.8765761828405442 1.560097548608782e-06 0.8779374790365844 \
1.560097705455835e-06 0.8793491025165162 1.560097837560426e-06 0.8805380438351178 1.560097951168902e-06 0.8815605201209382 1.560098066732818e-06 0.8826005953617506 \
1.560098173944515e-06 0.8835655006364479 1.560098251949639e-06 0.8842675467541018 1.560098369203879e-06 0.8853228349141965 1.560098469613519e-06 0.886226521672304 \
1.560098577287673e-06 0.8871955890613133 1.560098653452348e-06 0.8878810711332904 1.560098760907383e-06 0.8888481664483866 1.560098854230815e-06 0.8896880773334693 \
1.560098954910124e-06 0.8905941911166799 1.560099049707369e-06 0.8914473663235497 1.56009913587369e-06 0.8922228632126831 1.56009922632816e-06 0.8930369534412941 \
1.560099366017076e-06 0.8942941536875396 1.560099486829852e-06 0.8953814686688766 1.560099612459294e-06 0.8965121336427553 1.560099756606946e-06 0.8978094625160885 \
1.560099892907379e-06 0.8990361664106589 1.600000175810299e-06 0.8984177073129849 1.600000387736115e-06 0.8965103749658082 1.600000811587748e-06 0.892695710271455 \
1.600001292817289e-06 0.8883646443965901 1.600001822218869e-06 0.8836000301806309 1.600002413857703e-06 0.8782752806762187 1.600003129740239e-06 0.8718323378482702 \
1.600004021470418e-06 0.8638067662390768 1.600005185565676e-06 0.8533299089180234 1.600006730039304e-06 0.8394296462657486 1.600009047735338e-06 0.8185703819595179 \
1.60001310217554e-06 0.7820804201414684 1.600020405609059e-06 0.7163495184672377 1.600024709552219e-06 0.6776140300278762 1.600027719925122e-06 0.6505206739058862 \
1.600031001070041e-06 0.6209903696287848 1.600033489948491e-06 0.5985904635786021 1.600035625657776e-06 0.5793690800177949 1.600037405976345e-06 0.5633462128944384 \
1.60003901401067e-06 0.5488739039651435 1.600040483199696e-06 0.5356512027400909 1.60004182855096e-06 0.5235430413622801 1.600043042811606e-06 0.512614695545089 \
1.600044179223892e-06 0.5023869849741911 1.60004522982584e-06 0.4929315674378034 1.600046211266097e-06 0.484098605128202 1.600047124049725e-06 0.4758835524716363 \
1.600048018804021e-06 0.4678307638102979 1.600048846977552e-06 0.4603772020305483 1.600049661640793e-06 0.4530452328630955 1.600050503799878e-06 0.4454658010995214 \
1.600051392617152e-06 0.4374664456271048 1.600052132173523e-06 0.430810438295329 1.600053027009232e-06 0.4227569169129836 1.600054107902427e-06 0.4130288781558488 \
1.600056115262271e-06 0.3949626395600662 1.600056875998171e-06 0.3881160164607345 1.600057811866421e-06 0.3796932022097708 1.600058487146314e-06 0.373615683179101 \
1.600059159402893e-06 0.3675653739608269 1.600059962121142e-06 0.3603409097239061 1.600060719414128e-06 0.3535252728520237 1.600061469553632e-06 0.3467740173091934 \
1.600062198861823e-06 0.3402102435925485 1.600062917197497e-06 0.3337452225319747 1.600063543595907e-06 0.3281076368399389 1.60006394891578e-06 0.3244597579820502 \
1.600064431737776e-06 0.3201143600118136 1.600064801078116e-06 0.3167902969580316 1.600065253165156e-06 0.3127215135955985 1.600065684660782e-06 0.3088380529590536 \
1.600066036022831e-06 0.3056757945211269 1.600066243755913e-06 0.3038061967869528 1.600066531381985e-06 0.3012175621312337 1.600066776713801e-06 0.2990095757891347 \
1.600067080098449e-06 0.2962791139586973 1.600067337968212e-06 0.2939582860917911 1.600067584264137e-06 0.2917416227702929 1.600068012140654e-06 0.2878907341130054 \
1.60006843261691e-06 0.2841064478110101 1.600068974429479e-06 0.2792301346858994 1.600069431049699e-06 0.2751205527117666 1.600069864969875e-06 0.2712152711268295 \
1.600070276250537e-06 0.2675137451671025 1.600070709349453e-06 0.2636158549267912 1.600071125752111e-06 0.2598682310032753 1.60007157727891e-06 0.2558044898132805 \
1.600072019826756e-06 0.2518215591932373 1.600072486753141e-06 0.2476192217332239 1.600072977907995e-06 0.2431988280497077 1.600073496979761e-06 0.2385271821480127 \
1.600074065575267e-06 0.2334098225947888 1.60007466462888e-06 0.2280183400805964 1.600075295339653e-06 0.2223419431252401 1.600076027928546e-06 0.2157486430863834 \
1.600076737231274e-06 0.2093649185333881 1.600077405278374e-06 0.2033524946355669 1.600078031486169e-06 0.1977166244827963 1.600078642389351e-06 0.1922184958436388 \
1.600079237777689e-06 0.1868600008026635 1.600079853866796e-06 0.1813151988360575 1.600080454397603e-06 0.1759104215697842 1.600081046736475e-06 0.1705793717271608 \
1.600081670603799e-06 0.164964565812095 1.600082253990124e-06 0.1597140888870844 1.600082786746932e-06 0.1549192776137643 1.600083331146382e-06 0.1500196825588286 \
1.600083859078318e-06 0.1452682951413614 1.600084435818527e-06 0.1400776332571309 1.600085002237784e-06 0.1349798599404549 1.600085552082325e-06 0.1300312590758997 \
1.600086168681386e-06 0.1244818675298257 1.600086636997223e-06 0.1202670249965557 1.600087229995173e-06 0.114930043447014 1.600087690957483e-06 0.1107813826574622 \
1.600088106684468e-06 0.1070398397831492 1.600088462796911e-06 0.1038348278011874 1.600088810425094e-06 0.1007061741557836 1.600089112859056e-06 0.09798426849538755 \
1.600089417380186e-06 0.09524357832398211 1.600089689702494e-06 0.09279267755476828 1.600089953280439e-06 0.09042047604958559 1.600090197275105e-06 0.08822452405742931 \
1.600090467223407e-06 0.08579498933604146 1.600090706396949e-06 0.08364242745616901 1.600090969864118e-06 0.08127122294071432 1.600091224741101e-06 0.07897733008697083 \
1.60009145497135e-06 0.07690525785341851 1.600091719751726e-06 0.07452223446371342 1.600092001524411e-06 0.07198628030108556 1.600092277103734e-06 0.06950606639574286 \
1.600092617849715e-06 0.06643935256942901 1.600092904771124e-06 0.06385705988345824 1.600093210523111e-06 0.06110529199863279 1.60009350252768e-06 0.0584772508810687 \
1.600093774358483e-06 0.05603077365032616 1.60009402136155e-06 0.05380774605057426 1.600094217192034e-06 0.05204527169284134 1.600094394312362e-06 0.05045118874764443 \
1.600094569525492e-06 0.04887427057365767 1.600094727173406e-06 0.04745543934452334 1.600094874969159e-06 0.04612527756805263 1.600095020050112e-06 0.04481954899450691 \
1.600095158048333e-06 0.0435775650013065 1.600095300302896e-06 0.04229727393901672 1.600095426303471e-06 0.04116326875785103 1.600095559831953e-06 0.03996151242777013 \
1.600095682102067e-06 0.03886108140050326 1.600095815162015e-06 0.0376635418603275 1.600095929603909e-06 0.03663356482247337 1.600096021739576e-06 0.03580434381845876 \
1.600096118593814e-06 0.03493265567158488 1.6000962580033e-06 0.03367797030500419 1.600096372329609e-06 0.03264903351765647 1.600096481934954e-06 0.03166258541696143 \
1.600096615187473e-06 0.03046331274235659 1.600096728057783e-06 0.02944747995458197 1.600096850555119e-06 0.02834500393025741 1.600096986497112e-06 0.02712152598905548 \
1.600097104504206e-06 0.02605946214676502 1.600097233560397e-06 0.02489795642556891 1.600097344050859e-06 0.02390354227171532 1.600097479489315e-06 0.02268459616553509 \
1.600097599122986e-06 0.02160789312944722 1.60009770000436e-06 0.02069996076227698 1.600097820351452e-06 0.01961683693679572 1.60009796161121e-06 0.01834549910740102 \
1.600098123696896e-06 0.01688672794015589 1.600098272834849e-06 0.01554448635840755 1.600098425713135e-06 0.014168581787533 1.600098576006731e-06 0.01281593941858328 \
1.600098722835146e-06 0.01149448368366224 1.600098879191315e-06 0.01008727816647481 1.600098998454607e-06 0.009013908541385951 1.60009909308712e-06 0.008162215916559523 \
1.600099196564467e-06 0.007230919801462066 1.600099269048437e-06 0.006578564066408443 1.600099347396487e-06 0.005873431617253289 1.600099437077881e-06 0.005066299068704372 \
1.600099569889939e-06 0.003870990547362063 1.600099671489824e-06 0.002956591581575796 1.600099777454715e-06 0.002002907563398826 1.600099893286091e-06 0.000960425183447966 \
1.658990000000011e-06 0 1.659999999999996e-06 0 1.66000021116344e-06 0.001900470962571042 1.660000442444547e-06 0.003982000924727166 \
1.660000905006761e-06 0.008145060849039413 1.660001362320627e-06 0.01226088564504064 1.660001836803525e-06 0.01653123172985639 1.660002369299368e-06 0.02132369430982749 \
1.660003039181942e-06 0.02735263747515369 1.660003896286051e-06 0.03506657446094884 1.660005011032046e-06 0.04509928841663746 1.660006632029638e-06 0.05968826673863754 \
1.660008974699129e-06 0.08077229215837188 1.660013660038111e-06 0.1229403429978405 1.66001796446524e-06 0.1616801871633537 1.660021814406951e-06 0.1963296625632528 \
1.660026078483917e-06 0.2347063552562001 1.660029148481291e-06 0.2623363316230807 1.660031611421446e-06 0.2845027930151538 1.660033573234516e-06 0.3021591106476817 \
1.66003528302999e-06 0.3175472699147922 1.660036786621731e-06 0.3310795955797556 1.660038125719466e-06 0.3431314751960884 1.660039372399233e-06 0.3543515930958913 \
1.660040514338907e-06 0.3646290501629268 1.660041572311447e-06 0.3741508030226791 1.660042581357189e-06 0.3832322147042228 1.660043600260228e-06 0.3924023420515681 \
1.660044556738474e-06 0.4010106462662745 1.660045504571866e-06 0.4095411467944404 1.660046368147174e-06 0.4173133245688312 1.660047110848452e-06 0.423997636067712 \
1.660047770562902e-06 0.4299350661209142 1.66004846509286e-06 0.4361858357407548 1.660049134439973e-06 0.4422099597530631 1.660049745005552e-06 0.4477050499714701 \
1.660050521159036e-06 0.454690431324675 1.660051577583036e-06 0.4641982473299416 1.660052573303282e-06 0.4731597295416305 1.660053439146997e-06 0.4809523229693754 \
1.660054375298e-06 0.4893776819979773 1.660055101766736e-06 0.4959159006203305 1.660055767984727e-06 0.5019118625413875 1.660056382958911e-06 0.5074466301974319 \
1.660057167658469e-06 0.5145089262167936 1.660057876931857e-06 0.5208923867144013 1.660058576728557e-06 0.5271905570126808 1.660059241143132e-06 0.5331702881913303 \
1.660059896473734e-06 0.539068263602977 1.660060535798054e-06 0.5448221824871196 1.660061125945762e-06 0.5501335118600457 1.660061653249814e-06 0.5548792483285057 \
1.660062030104965e-06 0.5582709446854013 1.660062425635161e-06 0.5618307164525158 1.660062788740359e-06 0.5650986632355098 1.660063165175011e-06 0.5684865750957045 \
1.660063513154822e-06 0.5716183933999566 1.660063777846861e-06 0.5740006217454657 1.660064042985523e-06 0.5763868697045537 1.660064573262847e-06 0.5811593656227293 \
1.660064959313826e-06 0.5846338244342608 1.660065368210207e-06 0.5883138918597329 1.66006587063576e-06 0.5928357218442383 1.66006645565012e-06 0.5981008510799999 \
1.660066996785185e-06 0.6029710666652875 1.660067417144355e-06 0.6067542991940013 1.660067824982808e-06 0.6104248452748176 1.66006823230949e-06 0.6140907854118068 \
1.660068642157613e-06 0.6177794185173828 1.660069065799442e-06 0.62159219497586 1.660069510037211e-06 0.6255903348973357 1.660069966768595e-06 0.6297009173589793 \
1.660070444546043e-06 0.6340009143882042 1.66007097508933e-06 0.6387758039669345 1.660071541471416e-06 0.6438732427407217 1.660072145422139e-06 0.6493087992533674 \
1.660072793381625e-06 0.6551404346247349 1.660073505762603e-06 0.6615518634257037 1.660074168459051e-06 0.6675161314588195 1.660074781166818e-06 0.6730305013601764 \
1.660075359057944e-06 0.6782315214975446 1.660075921736873e-06 0.6832956318592801 1.660076483342761e-06 0.6883500848513783 1.660077074883236e-06 0.6936739491264482 \
1.660077655993641e-06 0.6989039427675531 1.660078230747911e-06 0.7040767311958204 1.660078831945941e-06 0.7094875134645067 1.660079324811182e-06 0.7139233006347314 \
1.660079751835041e-06 0.7177665153653698 1.660080153873253e-06 0.7213848592781456 1.660080537977864e-06 0.7248418007795954 1.660080898081889e-06 0.728082736999342 \
1.660081290978388e-06 0.731618805492268 1.660081350803762e-06 0.7321572338590965 1.66008147045451e-06 0.7332340905927537 1.660081709756007e-06 0.735387804060068 \
1.6600819763221e-06 0.7377868989013747 1.660082273049261e-06 0.7404574433520882 1.660082729389945e-06 0.7445645095019819 1.660083129641858e-06 0.7481667767176134 \
1.6600835424114e-06 0.7518817026010159 1.660083911328917e-06 0.7552019602568045 1.660084334919757e-06 0.7590142778153435 1.660084704529443e-06 0.762340764983916 \
1.66008510473479e-06 0.7659426131102501 1.660085434938255e-06 0.7689144442964062 1.660085700495004e-06 0.7713044550329466 1.660085970256226e-06 0.7737323060316124 \
1.66008638098703e-06 0.7774288832736076 1.66008667585935e-06 0.7800827341539526 1.660087078396993e-06 0.7837055729337647 1.660087421594134e-06 0.786794347204456 \
1.660087774419653e-06 0.7899697768807414 1.660088101708689e-06 0.7929153782018739 1.660088421022111e-06 0.7957891990026931 1.66008872760096e-06 0.798548408642265 \
1.660089025875665e-06 0.8012328809879466 1.660089320848706e-06 0.8038876383597224 1.660089591459277e-06 0.8063231334915267 1.660089868048603e-06 0.808812437424818 \
1.66009015247317e-06 0.8113722585315476 1.660090393475363e-06 0.813541278265291 1.660090665778045e-06 0.8159920024070124 1.660090970927407e-06 0.8187383466657218 \
1.660091271218559e-06 0.8214409670293247 1.660091576487057e-06 0.8241883835163635 1.660091871067987e-06 0.8268396118826479 1.660092193104528e-06 0.8297379407530008 \
1.660092432654028e-06 0.8318938862491163 1.660092688128584e-06 0.8341931572572034 1.660092950748264e-06 0.8365567343768243 1.660093196157421e-06 0.8387654167908133 \
1.660093430718228e-06 0.8408764640555111 1.660093634774443e-06 0.8427129699896301 1.660093845366316e-06 0.8446082968424707 1.66009405600496e-06 0.8465040446443356 \
1.660094244655363e-06 0.8482018982687493 1.660094419312833e-06 0.8497738154964893 1.660094599278918e-06 0.8513935102645009 1.660094762688076e-06 0.8528641926851036 \
1.660094936630778e-06 0.854429677001575 1.66009509164947e-06 0.8558248452281332 1.660095258694903e-06 0.8573282541293438 1.660095417039538e-06 0.8587533558427882 \
1.66009558556135e-06 0.8602700521522246 1.660095742775809e-06 0.8616849822849083 1.660095861449154e-06 0.8627530423825936 1.660096011867914e-06 0.8641068112286804 \
1.660096136494933e-06 0.865228454399422 1.660096297689131e-06 0.8666792021766703 1.66009645446677e-06 0.8680902009355517 1.660096580116853e-06 0.8692210516792804 \
1.660096724052223e-06 0.8705164700033486 1.660096889588435e-06 0.8720062959137309 1.660097059053952e-06 0.8735314855691456 1.660097224438411e-06 0.8750199457013955 \
1.660097397353649e-06 0.8765761828405442 1.660097548608782e-06 0.8779374790365844 1.660097705455835e-06 0.8793491025165162 1.660097837560426e-06 0.8805380438351178 \
1.660097951168902e-06 0.8815605201209382 1.660098066732818e-06 0.8826005953617506 1.660098173944515e-06 0.8835655006364479 1.660098251949639e-06 0.8842675467541018 \
1.660098369203879e-06 0.8853228349141965 1.660098469613519e-06 0.886226521672304 1.660098577287673e-06 0.8871955890613133 1.660098653452348e-06 0.8878810711332904 \
1.660098760907383e-06 0.8888481664483866 1.660098854230815e-06 0.8896880773334693 1.660098954910124e-06 0.8905941911166799 1.660099049707369e-06 0.8914473663235497 \
1.66009913587369e-06 0.8922228632126831 1.66009922632816e-06 0.8930369534412941 1.660099366017076e-06 0.8942941536875396 1.660099486829852e-06 0.8953814686688766 \
1.660099612459294e-06 0.8965121336427553 1.660099756606946e-06 0.8978094625160885 1.660099892907379e-06 0.8990361664106589 1.700000175810299e-06 0.8984177073129849 \
1.700000387736115e-06 0.8965103749658082 1.700000811587748e-06 0.892695710271455 1.700001292817289e-06 0.8883646443965901 1.700001822218869e-06 0.8836000301806309 \
1.700002413857703e-06 0.8782752806762187 1.700003129740239e-06 0.8718323378482702 1.700004021470418e-06 0.8638067662390768 1.700005185565676e-06 0.8533299089180234 \
1.700006730039304e-06 0.8394296462657486 1.700009047735338e-06 0.8185703819595179 1.70001310217554e-06 0.7820804201414684 1.700020405609059e-06 0.7163495184672377 \
1.700024709552219e-06 0.6776140300278762 1.700027719925121e-06 0.6505206739058862 1.700031001070041e-06 0.6209903696287848 1.700033489948491e-06 0.5985904635786021 \
1.700035625657776e-06 0.5793690800177949 1.700037405976345e-06 0.5633462128944384 1.70003901401067e-06 0.5488739039651435 1.700040483199695e-06 0.5356512027400909 \
1.70004182855096e-06 0.5235430413622801 1.700043042811606e-06 0.512614695545089 1.700044179223892e-06 0.5023869849741911 1.70004522982584e-06 0.4929315674378034 \
1.700046211266097e-06 0.484098605128202 1.700047124049725e-06 0.4758835524716363 1.700048018804021e-06 0.4678307638102979 1.700048846977552e-06 0.4603772020305483 \
1.700049661640793e-06 0.4530452328630955 1.700050503799878e-06 0.4454658010995214 1.700051392617152e-06 0.4374664456271048 1.700052132173523e-06 0.430810438295329 \
1.700053027009232e-06 0.4227569169129836 1.700054107902427e-06 0.4130288781558488 1.700056115262271e-06 0.3949626395600662 1.700056875998171e-06 0.3881160164607345 \
1.700057811866421e-06 0.3796932022097708 1.700058487146313e-06 0.373615683179101 1.700059159402893e-06 0.3675653739608269 1.700059962121142e-06 0.3603409097239061 \
1.700060719414127e-06 0.3535252728520237 1.700061469553632e-06 0.3467740173091934 1.700062198861823e-06 0.3402102435925485 1.700062917197496e-06 0.3337452225319747 \
1.700063543595907e-06 0.3281076368399389 1.70006394891578e-06 0.3244597579820502 1.700064431737776e-06 0.3201143600118136 1.700064801078116e-06 0.3167902969580316 \
1.700065253165156e-06 0.3127215135955985 1.700065684660782e-06 0.3088380529590536 1.700066036022831e-06 0.3056757945211269 1.700066243755913e-06 0.3038061967869528 \
1.700066531381985e-06 0.3012175621312337 1.700066776713801e-06 0.2990095757891347 1.700067080098449e-06 0.2962791139586973 1.700067337968212e-06 0.2939582860917911 \
1.700067584264137e-06 0.2917416227702929 1.700068012140654e-06 0.2878907341130054 1.70006843261691e-06 0.2841064478110101 1.700068974429479e-06 0.2792301346858994 \
1.700069431049699e-06 0.2751205527117666 1.700069864969875e-06 0.2712152711268295 1.700070276250537e-06 0.2675137451671025 1.700070709349453e-06 0.2636158549267912 \
1.700071125752111e-06 0.2598682310032753 1.700071577278909e-06 0.2558044898132805 1.700072019826756e-06 0.2518215591932373 1.700072486753141e-06 0.2476192217332239 \
1.700072977907994e-06 0.2431988280497077 1.700073496979761e-06 0.2385271821480127 1.700074065575267e-06 0.2334098225947888 1.70007466462888e-06 0.2280183400805964 \
1.700075295339653e-06 0.2223419431252401 1.700076027928546e-06 0.2157486430863834 1.700076737231274e-06 0.2093649185333881 1.700077405278374e-06 0.2033524946355669 \
1.700078031486169e-06 0.1977166244827963 1.700078642389351e-06 0.1922184958436388 1.700079237777688e-06 0.1868600008026635 1.700079853866796e-06 0.1813151988360575 \
1.700080454397603e-06 0.1759104215697842 1.700081046736475e-06 0.1705793717271608 1.700081670603799e-06 0.164964565812095 1.700082253990124e-06 0.1597140888870844 \
1.700082786746932e-06 0.1549192776137643 1.700083331146382e-06 0.1500196825588286 1.700083859078318e-06 0.1452682951413614 1.700084435818527e-06 0.1400776332571309 \
1.700085002237784e-06 0.1349798599404549 1.700085552082325e-06 0.1300312590758997 1.700086168681386e-06 0.1244818675298257 1.700086636997223e-06 0.1202670249965557 \
1.700087229995172e-06 0.114930043447014 1.700087690957483e-06 0.1107813826574622 1.700088106684468e-06 0.1070398397831492 1.700088462796911e-06 0.1038348278011874 \
1.700088810425094e-06 0.1007061741557836 1.700089112859056e-06 0.09798426849538755 1.700089417380186e-06 0.09524357832398211 1.700089689702494e-06 0.09279267755476828 \
1.700089953280439e-06 0.09042047604958559 1.700090197275105e-06 0.08822452405742931 1.700090467223407e-06 0.08579498933604146 1.700090706396949e-06 0.08364242745616901 \
1.700090969864118e-06 0.08127122294071432 1.700091224741101e-06 0.07897733008697083 1.70009145497135e-06 0.07690525785341851 1.700091719751726e-06 0.07452223446371342 \
1.700092001524411e-06 0.07198628030108556 1.700092277103734e-06 0.06950606639574286 1.700092617849714e-06 0.06643935256942901 1.700092904771124e-06 0.06385705988345824 \
1.700093210523111e-06 0.06110529199863279 1.70009350252768e-06 0.0584772508810687 1.700093774358483e-06 0.05603077365032616 1.70009402136155e-06 0.05380774605057426 \
1.700094217192034e-06 0.05204527169284134 1.700094394312361e-06 0.05045118874764443 1.700094569525492e-06 0.04887427057365767 1.700094727173406e-06 0.04745543934452334 \
1.700094874969159e-06 0.04612527756805263 1.700095020050112e-06 0.04481954899450691 1.700095158048333e-06 0.0435775650013065 1.700095300302896e-06 0.04229727393901672 \
1.700095426303471e-06 0.04116326875785103 1.700095559831952e-06 0.03996151242777013 1.700095682102066e-06 0.03886108140050326 1.700095815162015e-06 0.0376635418603275 \
1.700095929603908e-06 0.03663356482247337 1.700096021739576e-06 0.03580434381845876 1.700096118593814e-06 0.03493265567158488 1.700096258003299e-06 0.03367797030500419 \
1.700096372329609e-06 0.03264903351765647 1.700096481934954e-06 0.03166258541696143 1.700096615187473e-06 0.03046331274235659 1.700096728057783e-06 0.02944747995458197 \
1.700096850555119e-06 0.02834500393025741 1.700096986497112e-06 0.02712152598905548 1.700097104504206e-06 0.02605946214676502 1.700097233560397e-06 0.02489795642556891 \
1.700097344050859e-06 0.02390354227171532 1.700097479489315e-06 0.02268459616553509 1.700097599122985e-06 0.02160789312944722 1.70009770000436e-06 0.02069996076227698 \
1.700097820351452e-06 0.01961683693679572 1.70009796161121e-06 0.01834549910740102 1.700098123696895e-06 0.01688672794015589 1.700098272834849e-06 0.01554448635840755 \
1.700098425713135e-06 0.014168581787533 1.700098576006731e-06 0.01281593941858328 1.700098722835146e-06 0.01149448368366224 1.700098879191315e-06 0.01008727816647481 \
1.700098998454606e-06 0.009013908541385951 1.70009909308712e-06 0.008162215916559523 1.700099196564466e-06 0.007230919801462066 1.700099269048437e-06 0.006578564066408443 \
1.700099347396487e-06 0.005873431617253289 1.700099437077881e-06 0.005066299068704372 1.700099569889939e-06 0.003870990547362063 1.700099671489824e-06 0.002956591581575796 \
1.700099777454715e-06 0.002002907563398826 1.700099893286091e-06 0.000960425183447966 1.758990000000011e-06 0 1.759999999999996e-06 0 \
1.76000021116344e-06 0.001900470962571042 1.760000442444547e-06 0.003982000924727166 1.760000905006761e-06 0.008145060849039413 1.760001362320627e-06 0.01226088564504064 \
1.760001836803525e-06 0.01653123172985639 1.760002369299368e-06 0.02132369430982749 1.760003039181941e-06 0.02735263747515369 1.760003896286051e-06 0.03506657446094884 \
1.760005011032046e-06 0.04509928841663746 1.760006632029637e-06 0.05968826673863754 1.760008974699129e-06 0.08077229215837188 1.760013660038111e-06 0.1229403429978405 \
1.76001796446524e-06 0.1616801871633537 1.760021814406951e-06 0.1963296625632528 1.760026078483917e-06 0.2347063552562001 1.760029148481291e-06 0.2623363316230807 \
1.760031611421446e-06 0.2845027930151538 1.760033573234516e-06 0.3021591106476817 1.76003528302999e-06 0.3175472699147922 1.760036786621731e-06 0.3310795955797556 \
1.760038125719466e-06 0.3431314751960884 1.760039372399233e-06 0.3543515930958913 1.760040514338907e-06 0.3646290501629268 1.760041572311447e-06 0.3741508030226791 \
1.760042581357189e-06 0.3832322147042228 1.760043600260228e-06 0.3924023420515681 1.760044556738474e-06 0.4010106462662745 1.760045504571866e-06 0.4095411467944404 \
1.760046368147174e-06 0.4173133245688312 1.760047110848452e-06 0.423997636067712 1.760047770562902e-06 0.4299350661209142 1.76004846509286e-06 0.4361858357407548 \
1.760049134439972e-06 0.4422099597530631 1.760049745005552e-06 0.4477050499714701 1.760050521159036e-06 0.454690431324675 1.760051577583036e-06 0.4641982473299416 \
1.760052573303282e-06 0.4731597295416305 1.760053439146997e-06 0.4809523229693754 1.760054375298e-06 0.4893776819979773 1.760055101766735e-06 0.4959159006203305 \
1.760055767984727e-06 0.5019118625413875 1.760056382958911e-06 0.5074466301974319 1.760057167658468e-06 0.5145089262167936 1.760057876931857e-06 0.5208923867144013 \
1.760058576728557e-06 0.5271905570126808 1.760059241143132e-06 0.5331702881913303 1.760059896473734e-06 0.539068263602977 1.760060535798054e-06 0.5448221824871196 \
1.760061125945762e-06 0.5501335118600457 1.760061653249814e-06 0.5548792483285057 1.760062030104965e-06 0.5582709446854013 1.760062425635161e-06 0.5618307164525158 \
1.760062788740359e-06 0.5650986632355098 1.760063165175011e-06 0.5684865750957045 1.760063513154822e-06 0.5716183933999566 1.76006377784686e-06 0.5740006217454657 \
1.760064042985523e-06 0.5763868697045537 1.760064573262847e-06 0.5811593656227293 1.760064959313826e-06 0.5846338244342608 1.760065368210207e-06 0.5883138918597329 \
1.76006587063576e-06 0.5928357218442383 1.76006645565012e-06 0.5981008510799999 1.760066996785185e-06 0.6029710666652875 1.760067417144355e-06 0.6067542991940013 \
1.760067824982808e-06 0.6104248452748176 1.76006823230949e-06 0.6140907854118068 1.760068642157613e-06 0.6177794185173828 1.760069065799442e-06 0.62159219497586 \
1.760069510037211e-06 0.6255903348973357 1.760069966768595e-06 0.6297009173589793 1.760070444546043e-06 0.6340009143882042 1.76007097508933e-06 0.6387758039669345 \
1.760071541471415e-06 0.6438732427407217 1.760072145422139e-06 0.6493087992533674 1.760072793381625e-06 0.6551404346247349 1.760073505762603e-06 0.6615518634257037 \
1.760074168459051e-06 0.6675161314588195 1.760074781166818e-06 0.6730305013601764 1.760075359057944e-06 0.6782315214975446 1.760075921736873e-06 0.6832956318592801 \
1.760076483342761e-06 0.6883500848513783 1.760077074883236e-06 0.6936739491264482 1.760077655993641e-06 0.6989039427675531 1.760078230747911e-06 0.7040767311958204 \
1.76007883194594e-06 0.7094875134645067 1.760079324811181e-06 0.7139233006347314 1.76007975183504e-06 0.7177665153653698 1.760080153873253e-06 0.7213848592781456 \
1.760080537977864e-06 0.7248418007795954 1.760080898081889e-06 0.728082736999342 1.760081290978388e-06 0.731618805492268 1.760081350803762e-06 0.7321572338590965 \
1.76008147045451e-06 0.7332340905927537 1.760081709756006e-06 0.735387804060068 1.7600819763221e-06 0.7377868989013747 1.760082273049261e-06 0.7404574433520882 \
1.760082729389945e-06 0.7445645095019819 1.760083129641857e-06 0.7481667767176134 1.7600835424114e-06 0.7518817026010159 1.760083911328917e-06 0.7552019602568045 \
1.760084334919757e-06 0.7590142778153435 1.760084704529442e-06 0.762340764983916 1.76008510473479e-06 0.7659426131102501 1.760085434938255e-06 0.7689144442964062 \
1.760085700495003e-06 0.7713044550329466 1.760085970256226e-06 0.7737323060316124 1.76008638098703e-06 0.7774288832736076 1.76008667585935e-06 0.7800827341539526 \
1.760087078396993e-06 0.7837055729337647 1.760087421594134e-06 0.786794347204456 1.760087774419653e-06 0.7899697768807414 1.760088101708689e-06 0.7929153782018739 \
1.760088421022111e-06 0.7957891990026931 1.76008872760096e-06 0.798548408642265 1.760089025875665e-06 0.8012328809879466 1.760089320848706e-06 0.8038876383597224 \
1.760089591459277e-06 0.8063231334915267 1.760089868048603e-06 0.808812437424818 1.76009015247317e-06 0.8113722585315476 1.760090393475363e-06 0.813541278265291 \
1.760090665778045e-06 0.8159920024070124 1.760090970927407e-06 0.8187383466657218 1.760091271218559e-06 0.8214409670293247 1.760091576487057e-06 0.8241883835163635 \
1.760091871067987e-06 0.8268396118826479 1.760092193104528e-06 0.8297379407530008 1.760092432654028e-06 0.8318938862491163 1.760092688128584e-06 0.8341931572572034 \
1.760092950748264e-06 0.8365567343768243 1.760093196157421e-06 0.8387654167908133 1.760093430718228e-06 0.8408764640555111 1.760093634774443e-06 0.8427129699896301 \
1.760093845366316e-06 0.8446082968424707 1.76009405600496e-06 0.8465040446443356 1.760094244655363e-06 0.8482018982687493 1.760094419312833e-06 0.8497738154964893 \
1.760094599278918e-06 0.8513935102645009 1.760094762688076e-06 0.8528641926851036 1.760094936630778e-06 0.854429677001575 1.76009509164947e-06 0.8558248452281332 \
1.760095258694903e-06 0.8573282541293438 1.760095417039538e-06 0.8587533558427882 1.76009558556135e-06 0.8602700521522246 1.760095742775809e-06 0.8616849822849083 \
1.760095861449153e-06 0.8627530423825936 1.760096011867914e-06 0.8641068112286804 1.760096136494933e-06 0.865228454399422 1.760096297689131e-06 0.8666792021766703 \
1.76009645446677e-06 0.8680902009355517 1.760096580116853e-06 0.8692210516792804 1.760096724052222e-06 0.8705164700033486 1.760096889588435e-06 0.8720062959137309 \
1.760097059053952e-06 0.8735314855691456 1.760097224438411e-06 0.8750199457013955 1.760097397353649e-06 0.8765761828405442 1.760097548608782e-06 0.8779374790365844 \
1.760097705455835e-06 0.8793491025165162 1.760097837560426e-06 0.8805380438351178 1.760097951168902e-06 0.8815605201209382 1.760098066732818e-06 0.8826005953617506 \
1.760098173944515e-06 0.8835655006364479 1.760098251949639e-06 0.8842675467541018 1.760098369203879e-06 0.8853228349141965 1.760098469613519e-06 0.886226521672304 \
1.760098577287673e-06 0.8871955890613133 1.760098653452348e-06 0.8878810711332904 1.760098760907383e-06 0.8888481664483866 1.760098854230815e-06 0.8896880773334693 \
1.760098954910124e-06 0.8905941911166799 1.760099049707369e-06 0.8914473663235497 1.76009913587369e-06 0.8922228632126831 1.76009922632816e-06 0.8930369534412941 \
1.760099366017076e-06 0.8942941536875396 1.760099486829852e-06 0.8953814686688766 1.760099612459293e-06 0.8965121336427553 1.760099756606946e-06 0.8978094625160885 \
1.760099892907379e-06 0.8990361664106589 1.800000175810298e-06 0.8984177073129849 1.800000387736115e-06 0.8965103749658082 1.800000811587747e-06 0.892695710271455 \
1.800001292817289e-06 0.8883646443965901 1.800001822218869e-06 0.8836000301806309 1.800002413857702e-06 0.8782752806762187 1.800003129740239e-06 0.8718323378482702 \
1.800004021470418e-06 0.8638067662390768 1.800005185565676e-06 0.8533299089180234 1.800006730039304e-06 0.8394296462657486 1.800009047735338e-06 0.8185703819595179 \
1.80001310217554e-06 0.7820804201414684 1.800020405609059e-06 0.7163495184672377 1.800024709552219e-06 0.6776140300278762 1.800027719925121e-06 0.6505206739058862 \
1.800031001070041e-06 0.6209903696287848 1.800033489948491e-06 0.5985904635786021 1.800035625657776e-06 0.5793690800177949 1.800037405976345e-06 0.5633462128944384 \
1.80003901401067e-06 0.5488739039651435 1.800040483199695e-06 0.5356512027400909 1.80004182855096e-06 0.5235430413622801 1.800043042811606e-06 0.512614695545089 \
1.800044179223892e-06 0.5023869849741911 1.80004522982584e-06 0.4929315674378034 1.800046211266097e-06 0.484098605128202 1.800047124049725e-06 0.4758835524716363 \
1.800048018804021e-06 0.4678307638102979 1.800048846977552e-06 0.4603772020305483 1.800049661640793e-06 0.4530452328630955 1.800050503799878e-06 0.4454658010995214 \
1.800051392617152e-06 0.4374664456271048 1.800052132173522e-06 0.430810438295329 1.800053027009232e-06 0.4227569169129836 1.800054107902427e-06 0.4130288781558488 \
1.800056115262271e-06 0.3949626395600662 1.800056875998171e-06 0.3881160164607345 1.800057811866421e-06 0.3796932022097708 1.800058487146313e-06 0.373615683179101 \
1.800059159402893e-06 0.3675653739608269 1.800059962121142e-06 0.3603409097239061 1.800060719414127e-06 0.3535252728520237 1.800061469553632e-06 0.3467740173091934 \
1.800062198861823e-06 0.3402102435925485 1.800062917197496e-06 0.3337452225319747 1.800063543595906e-06 0.3281076368399389 1.80006394891578e-06 0.3244597579820502 \
1.800064431737776e-06 0.3201143600118136 1.800064801078116e-06 0.3167902969580316 1.800065253165156e-06 0.3127215135955985 1.800065684660782e-06 0.3088380529590536 \
1.800066036022831e-06 0.3056757945211269 1.800066243755913e-06 0.3038061967869528 1.800066531381985e-06 0.3012175621312337 1.800066776713801e-06 0.2990095757891347 \
1.800067080098449e-06 0.2962791139586973 1.800067337968212e-06 0.2939582860917911 1.800067584264136e-06 0.2917416227702929 1.800068012140654e-06 0.2878907341130054 \
1.80006843261691e-06 0.2841064478110101 1.800068974429479e-06 0.2792301346858994 1.800069431049698e-06 0.2751205527117666 1.800069864969875e-06 0.2712152711268295 \
1.800070276250537e-06 0.2675137451671025 1.800070709349452e-06 0.2636158549267912 1.800071125752111e-06 0.2598682310032753 1.800071577278909e-06 0.2558044898132805 \
1.800072019826756e-06 0.2518215591932373 1.80007248675314e-06 0.2476192217332239 1.800072977907994e-06 0.2431988280497077 1.800073496979761e-06 0.2385271821480127 \
1.800074065575267e-06 0.2334098225947888 1.80007466462888e-06 0.2280183400805964 1.800075295339653e-06 0.2223419431252401 1.800076027928546e-06 0.2157486430863834 \
1.800076737231274e-06 0.2093649185333881 1.800077405278374e-06 0.2033524946355669 1.800078031486168e-06 0.1977166244827963 1.800078642389351e-06 0.1922184958436388 \
1.800079237777688e-06 0.1868600008026635 1.800079853866796e-06 0.1813151988360575 1.800080454397603e-06 0.1759104215697842 1.800081046736475e-06 0.1705793717271608 \
1.800081670603798e-06 0.164964565812095 1.800082253990124e-06 0.1597140888870844 1.800082786746932e-06 0.1549192776137643 1.800083331146382e-06 0.1500196825588286 \
1.800083859078317e-06 0.1452682951413614 1.800084435818527e-06 0.1400776332571309 1.800085002237784e-06 0.1349798599404549 1.800085552082325e-06 0.1300312590758997 \
1.800086168681385e-06 0.1244818675298257 1.800086636997222e-06 0.1202670249965557 1.800087229995172e-06 0.114930043447014 1.800087690957482e-06 0.1107813826574622 \
1.800088106684468e-06 0.1070398397831492 1.800088462796911e-06 0.1038348278011874 1.800088810425094e-06 0.1007061741557836 1.800089112859056e-06 0.09798426849538755 \
1.800089417380186e-06 0.09524357832398211 1.800089689702494e-06 0.09279267755476828 1.800089953280439e-06 0.09042047604958559 1.800090197275104e-06 0.08822452405742931 \
1.800090467223407e-06 0.08579498933604146 1.800090706396949e-06 0.08364242745616901 1.800090969864117e-06 0.08127122294071432 1.800091224741101e-06 0.07897733008697083 \
1.800091454971349e-06 0.07690525785341851 1.800091719751726e-06 0.07452223446371342 1.800092001524411e-06 0.07198628030108556 1.800092277103734e-06 0.06950606639574286 \
1.800092617849714e-06 0.06643935256942901 1.800092904771124e-06 0.06385705988345824 1.800093210523111e-06 0.06110529199863279 1.80009350252768e-06 0.0584772508810687 \
1.800093774358483e-06 0.05603077365032616 1.80009402136155e-06 0.05380774605057426 1.800094217192034e-06 0.05204527169284134 1.800094394312361e-06 0.05045118874764443 \
1.800094569525492e-06 0.04887427057365767 1.800094727173406e-06 0.04745543934452334 1.800094874969159e-06 0.04612527756805263 1.800095020050112e-06 0.04481954899450691 \
1.800095158048333e-06 0.0435775650013065 1.800095300302895e-06 0.04229727393901672 1.800095426303471e-06 0.04116326875785103 1.800095559831952e-06 0.03996151242777013 \
1.800095682102066e-06 0.03886108140050326 1.800095815162015e-06 0.0376635418603275 1.800095929603908e-06 0.03663356482247337 1.800096021739576e-06 0.03580434381845876 \
1.800096118593814e-06 0.03493265567158488 1.800096258003299e-06 0.03367797030500419 1.800096372329609e-06 0.03264903351765647 1.800096481934953e-06 0.03166258541696143 \
1.800096615187473e-06 0.03046331274235659 1.800096728057783e-06 0.02944747995458197 1.800096850555119e-06 0.02834500393025741 1.800096986497112e-06 0.02712152598905548 \
1.800097104504206e-06 0.02605946214676502 1.800097233560397e-06 0.02489795642556891 1.800097344050858e-06 0.02390354227171532 1.800097479489315e-06 0.02268459616553509 \
1.800097599122985e-06 0.02160789312944722 1.80009770000436e-06 0.02069996076227698 1.800097820351451e-06 0.01961683693679572 1.80009796161121e-06 0.01834549910740102 \
1.800098123696895e-06 0.01688672794015589 1.800098272834849e-06 0.01554448635840755 1.800098425713134e-06 0.014168581787533 1.800098576006731e-06 0.01281593941858328 \
1.800098722835146e-06 0.01149448368366224 1.800098879191315e-06 0.01008727816647481 1.800098998454606e-06 0.009013908541385951 1.80009909308712e-06 0.008162215916559523 \
1.800099196564466e-06 0.007230919801462066 1.800099269048437e-06 0.006578564066408443 1.800099347396487e-06 0.005873431617253289 1.800099437077881e-06 0.005066299068704372 \
1.800099569889939e-06 0.003870990547362063 1.800099671489824e-06 0.002956591581575796 1.800099777454715e-06 0.002002907563398826 1.800099893286091e-06 0.000960425183447966 \
1.858990000000011e-06 0 1.859999999999996e-06 0 1.86000021116344e-06 0.001900470962571042 1.860000442444547e-06 0.003982000924727166 \
1.860000905006761e-06 0.008145060849039413 1.860001362320627e-06 0.01226088564504064 1.860001836803525e-06 0.01653123172985639 1.860002369299368e-06 0.02132369430982749 \
1.860003039181942e-06 0.02735263747515369 1.860003896286051e-06 0.03506657446094884 1.860005011032046e-06 0.04509928841663746 1.860006632029638e-06 0.05968826673863754 \
1.860008974699129e-06 0.08077229215837188 1.860013660038111e-06 0.1229403429978405 1.86001796446524e-06 0.1616801871633537 1.860021814406951e-06 0.1963296625632528 \
1.860026078483917e-06 0.2347063552562001 1.860029148481291e-06 0.2623363316230807 1.860031611421446e-06 0.2845027930151538 1.860033573234516e-06 0.3021591106476817 \
1.86003528302999e-06 0.3175472699147922 1.860036786621731e-06 0.3310795955797556 1.860038125719466e-06 0.3431314751960884 1.860039372399233e-06 0.3543515930958913 \
1.860040514338907e-06 0.3646290501629268 1.860041572311447e-06 0.3741508030226791 1.860042581357189e-06 0.3832322147042228 1.860043600260228e-06 0.3924023420515681 \
1.860044556738474e-06 0.4010106462662745 1.860045504571866e-06 0.4095411467944404 1.860046368147174e-06 0.4173133245688312 1.860047110848452e-06 0.423997636067712 \
1.860047770562902e-06 0.4299350661209142 1.86004846509286e-06 0.4361858357407548 1.860049134439973e-06 0.4422099597530631 1.860049745005552e-06 0.4477050499714701 \
1.860050521159036e-06 0.454690431324675 1.860051577583036e-06 0.4641982473299416 1.860052573303282e-06 0.4731597295416305 1.860053439146997e-06 0.4809523229693754 \
1.860054375298e-06 0.4893776819979773 1.860055101766736e-06 0.4959159006203305 1.860055767984727e-06 0.5019118625413875 1.860056382958911e-06 0.5074466301974319 \
1.860057167658469e-06 0.5145089262167936 1.860057876931857e-06 0.5208923867144013 1.860058576728557e-06 0.5271905570126808 1.860059241143132e-06 0.5331702881913303 \
1.860059896473734e-06 0.539068263602977 1.860060535798054e-06 0.5448221824871196 1.860061125945762e-06 0.5501335118600457 1.860061653249814e-06 0.5548792483285057 \
1.860062030104965e-06 0.5582709446854013 1.860062425635161e-06 0.5618307164525158 1.860062788740359e-06 0.5650986632355098 1.86006316517501e-06 0.5684865750957045 \
1.860063513154822e-06 0.5716183933999566 1.860063777846861e-06 0.5740006217454657 1.860064042985523e-06 0.5763868697045537 1.860064573262847e-06 0.5811593656227293 \
1.860064959313826e-06 0.5846338244342608 1.860065368210207e-06 0.5883138918597329 1.86006587063576e-06 0.5928357218442383 1.86006645565012e-06 0.5981008510799999 \
1.860066996785185e-06 0.6029710666652875 1.860067417144355e-06 0.6067542991940013 1.860067824982808e-06 0.6104248452748176 1.86006823230949e-06 0.6140907854118068 \
1.860068642157613e-06 0.6177794185173828 1.860069065799442e-06 0.62159219497586 1.860069510037211e-06 0.6255903348973357 1.860069966768595e-06 0.6297009173589793 \
1.860070444546043e-06 0.6340009143882042 1.86007097508933e-06 0.6387758039669345 1.860071541471416e-06 0.6438732427407217 1.860072145422139e-06 0.6493087992533674 \
1.860072793381625e-06 0.6551404346247349 1.860073505762603e-06 0.6615518634257037 1.860074168459051e-06 0.6675161314588195 1.860074781166818e-06 0.6730305013601764 \
1.860075359057944e-06 0.6782315214975446 1.860075921736873e-06 0.6832956318592801 1.860076483342761e-06 0.6883500848513783 1.860077074883236e-06 0.6936739491264482 \
1.860077655993641e-06 0.6989039427675531 1.860078230747911e-06 0.7040767311958204 1.86007883194594e-06 0.7094875134645067 1.860079324811182e-06 0.7139233006347314 \
1.860079751835041e-06 0.7177665153653698 1.860080153873253e-06 0.7213848592781456 1.860080537977864e-06 0.7248418007795954 1.860080898081889e-06 0.728082736999342 \
1.860081290978388e-06 0.731618805492268 1.860081350803762e-06 0.7321572338590965 1.86008147045451e-06 0.7332340905927537 1.860081709756007e-06 0.735387804060068 \
1.8600819763221e-06 0.7377868989013747 1.860082273049261e-06 0.7404574433520882 1.860082729389945e-06 0.7445645095019819 1.860083129641858e-06 0.7481667767176134 \
1.8600835424114e-06 0.7518817026010159 1.860083911328917e-06 0.7552019602568045 1.860084334919757e-06 0.7590142778153435 1.860084704529443e-06 0.762340764983916 \
1.86008510473479e-06 0.7659426131102501 1.860085434938255e-06 0.7689144442964062 1.860085700495004e-06 0.7713044550329466 1.860085970256226e-06 0.7737323060316124 \
1.86008638098703e-06 0.7774288832736076 1.86008667585935e-06 0.7800827341539526 1.860087078396993e-06 0.7837055729337647 1.860087421594134e-06 0.786794347204456 \
1.860087774419653e-06 0.7899697768807414 1.860088101708689e-06 0.7929153782018739 1.860088421022111e-06 0.7957891990026931 1.86008872760096e-06 0.798548408642265 \
1.860089025875665e-06 0.8012328809879466 1.860089320848706e-06 0.8038876383597224 1.860089591459277e-06 0.8063231334915267 1.860089868048603e-06 0.808812437424818 \
1.86009015247317e-06 0.8113722585315476 1.860090393475363e-06 0.813541278265291 1.860090665778045e-06 0.8159920024070124 1.860090970927407e-06 0.8187383466657218 \
1.860091271218559e-06 0.8214409670293247 1.860091576487057e-06 0.8241883835163635 1.860091871067987e-06 0.8268396118826479 1.860092193104528e-06 0.8297379407530008 \
1.860092432654028e-06 0.8318938862491163 1.860092688128584e-06 0.8341931572572034 1.860092950748264e-06 0.8365567343768243 1.860093196157421e-06 0.8387654167908133 \
1.860093430718228e-06 0.8408764640555111 1.860093634774443e-06 0.8427129699896301 1.860093845366316e-06 0.8446082968424707 1.86009405600496e-06 0.8465040446443356 \
1.860094244655363e-06 0.8482018982687493 1.860094419312833e-06 0.8497738154964893 1.860094599278918e-06 0.8513935102645009 1.860094762688076e-06 0.8528641926851036 \
1.860094936630778e-06 0.854429677001575 1.86009509164947e-06 0.8558248452281332 1.860095258694903e-06 0.8573282541293438 1.860095417039538e-06 0.8587533558427882 \
1.86009558556135e-06 0.8602700521522246 1.860095742775809e-06 0.8616849822849083 1.860095861449154e-06 0.8627530423825936 1.860096011867914e-06 0.8641068112286804 \
1.860096136494933e-06 0.865228454399422 1.860096297689131e-06 0.8666792021766703 1.86009645446677e-06 0.8680902009355517 1.860096580116853e-06 0.8692210516792804 \
1.860096724052223e-06 0.8705164700033486 1.860096889588435e-06 0.8720062959137309 1.860097059053952e-06 0.8735314855691456 1.860097224438411e-06 0.8750199457013955 \
1.860097397353649e-06 0.8765761828405442 1.860097548608782e-06 0.8779374790365844 1.860097705455835e-06 0.8793491025165162 1.860097837560426e-06 0.8805380438351178 \
1.860097951168902e-06 0.8815605201209382 1.860098066732818e-06 0.8826005953617506 1.860098173944515e-06 0.8835655006364479 1.860098251949639e-06 0.8842675467541018 \
1.860098369203879e-06 0.8853228349141965 1.860098469613519e-06 0.886226521672304 1.860098577287673e-06 0.8871955890613133 1.860098653452348e-06 0.8878810711332904 \
1.860098760907383e-06 0.8888481664483866 1.860098854230815e-06 0.8896880773334693 1.860098954910124e-06 0.8905941911166799 1.860099049707369e-06 0.8914473663235497 \
1.86009913587369e-06 0.8922228632126831 1.86009922632816e-06 0.8930369534412941 1.860099366017076e-06 0.8942941536875396 1.860099486829852e-06 0.8953814686688766 \
1.860099612459294e-06 0.8965121336427553 1.860099756606946e-06 0.8978094625160885 1.860099892907379e-06 0.8990361664106589 1.900000175810299e-06 0.8984177073129849 \
1.900000387736115e-06 0.8965103749658082 1.900000811587748e-06 0.892695710271455 1.900001292817289e-06 0.8883646443965901 1.900001822218869e-06 0.8836000301806309 \
1.900002413857703e-06 0.8782752806762187 1.900003129740239e-06 0.8718323378482702 1.900004021470418e-06 0.8638067662390768 1.900005185565676e-06 0.8533299089180234 \
1.900006730039304e-06 0.8394296462657486 1.900009047735338e-06 0.8185703819595179 1.90001310217554e-06 0.7820804201414684 1.900020405609059e-06 0.7163495184672377 \
1.900024709552219e-06 0.6776140300278762 1.900027719925121e-06 0.6505206739058862 1.900031001070041e-06 0.6209903696287848 1.900033489948491e-06 0.5985904635786021 \
1.900035625657776e-06 0.5793690800177949 1.900037405976345e-06 0.5633462128944384 1.90003901401067e-06 0.5488739039651435 1.900040483199695e-06 0.5356512027400909 \
1.90004182855096e-06 0.5235430413622801 1.900043042811606e-06 0.512614695545089 1.900044179223892e-06 0.5023869849741911 1.90004522982584e-06 0.4929315674378034 \
1.900046211266097e-06 0.484098605128202 1.900047124049725e-06 0.4758835524716363 1.900048018804021e-06 0.4678307638102979 1.900048846977552e-06 0.4603772020305483 \
1.900049661640793e-06 0.4530452328630955 1.900050503799878e-06 0.4454658010995214 1.900051392617152e-06 0.4374664456271048 1.900052132173523e-06 0.430810438295329 \
1.900053027009232e-06 0.4227569169129836 1.900054107902427e-06 0.4130288781558488 1.900056115262271e-06 0.3949626395600662 1.900056875998171e-06 0.3881160164607345 \
1.900057811866421e-06 0.3796932022097708 1.900058487146313e-06 0.373615683179101 1.900059159402893e-06 0.3675653739608269 1.900059962121142e-06 0.3603409097239061 \
1.900060719414127e-06 0.3535252728520237 1.900061469553632e-06 0.3467740173091934 1.900062198861823e-06 0.3402102435925485 1.900062917197496e-06 0.3337452225319747 \
1.900063543595907e-06 0.3281076368399389 1.90006394891578e-06 0.3244597579820502 1.900064431737776e-06 0.3201143600118136 1.900064801078116e-06 0.3167902969580316 \
1.900065253165156e-06 0.3127215135955985 1.900065684660782e-06 0.3088380529590536 1.900066036022831e-06 0.3056757945211269 1.900066243755913e-06 0.3038061967869528 \
1.900066531381985e-06 0.3012175621312337 1.900066776713801e-06 0.2990095757891347 1.900067080098449e-06 0.2962791139586973 1.900067337968212e-06 0.2939582860917911 \
1.900067584264137e-06 0.2917416227702929 1.900068012140654e-06 0.2878907341130054 1.90006843261691e-06 0.2841064478110101 1.900068974429479e-06 0.2792301346858994 \
1.900069431049699e-06 0.2751205527117666 1.900069864969875e-06 0.2712152711268295 1.900070276250537e-06 0.2675137451671025 1.900070709349453e-06 0.2636158549267912 \
1.900071125752111e-06 0.2598682310032753 1.900071577278909e-06 0.2558044898132805 1.900072019826756e-06 0.2518215591932373 1.900072486753141e-06 0.2476192217332239 \
1.900072977907994e-06 0.2431988280497077 1.900073496979761e-06 0.2385271821480127 1.900074065575267e-06 0.2334098225947888 1.90007466462888e-06 0.2280183400805964 \
1.900075295339653e-06 0.2223419431252401 1.900076027928546e-06 0.2157486430863834 1.900076737231274e-06 0.2093649185333881 1.900077405278374e-06 0.2033524946355669 \
1.900078031486169e-06 0.1977166244827963 1.900078642389351e-06 0.1922184958436388 1.900079237777688e-06 0.1868600008026635 1.900079853866796e-06 0.1813151988360575 \
1.900080454397603e-06 0.1759104215697842 1.900081046736475e-06 0.1705793717271608 1.900081670603799e-06 0.164964565812095 1.900082253990124e-06 0.1597140888870844 \
1.900082786746932e-06 0.1549192776137643 1.900083331146382e-06 0.1500196825588286 1.900083859078318e-06 0.1452682951413614 1.900084435818527e-06 0.1400776332571309 \
1.900085002237784e-06 0.1349798599404549 1.900085552082325e-06 0.1300312590758997 1.900086168681386e-06 0.1244818675298257 1.900086636997223e-06 0.1202670249965557 \
1.900087229995172e-06 0.114930043447014 1.900087690957482e-06 0.1107813826574622 1.900088106684468e-06 0.1070398397831492 1.900088462796911e-06 0.1038348278011874 \
1.900088810425094e-06 0.1007061741557836 1.900089112859056e-06 0.09798426849538755 1.900089417380186e-06 0.09524357832398211 1.900089689702494e-06 0.09279267755476828 \
1.900089953280439e-06 0.09042047604958559 1.900090197275105e-06 0.08822452405742931 1.900090467223407e-06 0.08579498933604146 1.900090706396949e-06 0.08364242745616901 \
1.900090969864118e-06 0.08127122294071432 1.900091224741101e-06 0.07897733008697083 1.90009145497135e-06 0.07690525785341851 1.900091719751726e-06 0.07452223446371342 \
1.900092001524411e-06 0.07198628030108556 1.900092277103734e-06 0.06950606639574286 1.900092617849714e-06 0.06643935256942901 1.900092904771124e-06 0.06385705988345824 \
1.900093210523111e-06 0.06110529199863279 1.90009350252768e-06 0.0584772508810687 1.900093774358483e-06 0.05603077365032616 1.90009402136155e-06 0.05380774605057426 \
1.900094217192034e-06 0.05204527169284134 1.900094394312361e-06 0.05045118874764443 1.900094569525492e-06 0.04887427057365767 1.900094727173406e-06 0.04745543934452334 \
1.900094874969159e-06 0.04612527756805263 1.900095020050112e-06 0.04481954899450691 1.900095158048333e-06 0.0435775650013065 1.900095300302896e-06 0.04229727393901672 \
1.900095426303471e-06 0.04116326875785103 1.900095559831952e-06 0.03996151242777013 1.900095682102066e-06 0.03886108140050326 1.900095815162015e-06 0.0376635418603275 \
1.900095929603908e-06 0.03663356482247337 1.900096021739576e-06 0.03580434381845876 1.900096118593814e-06 0.03493265567158488 1.900096258003299e-06 0.03367797030500419 \
1.900096372329609e-06 0.03264903351765647 1.900096481934954e-06 0.03166258541696143 1.900096615187473e-06 0.03046331274235659 1.900096728057783e-06 0.02944747995458197 \
1.900096850555119e-06 0.02834500393025741 1.900096986497112e-06 0.02712152598905548 1.900097104504206e-06 0.02605946214676502 1.900097233560397e-06 0.02489795642556891 \
1.900097344050859e-06 0.02390354227171532 1.900097479489315e-06 0.02268459616553509 1.900097599122985e-06 0.02160789312944722 1.90009770000436e-06 0.02069996076227698 \
1.900097820351452e-06 0.01961683693679572 1.90009796161121e-06 0.01834549910740102 1.900098123696895e-06 0.01688672794015589 1.900098272834849e-06 0.01554448635840755 \
1.900098425713135e-06 0.014168581787533 1.900098576006731e-06 0.01281593941858328 1.900098722835146e-06 0.01149448368366224 1.900098879191315e-06 0.01008727816647481 \
1.900098998454606e-06 0.009013908541385951 1.90009909308712e-06 0.008162215916559523 1.900099196564466e-06 0.007230919801462066 1.900099269048437e-06 0.006578564066408443 \
1.900099347396487e-06 0.005873431617253289 1.900099437077881e-06 0.005066299068704372 1.900099569889939e-06 0.003870990547362063 1.900099671489824e-06 0.002956591581575796 \
1.900099777454715e-06 0.002002907563398826 1.900099893286091e-06 0.000960425183447966 1.958990000000011e-06 0 1.959999999999996e-06 0 \
1.96000021116344e-06 0.001900470962571042 1.960000442444547e-06 0.003982000924727166 1.960000905006761e-06 0.008145060849039413 1.960001362320627e-06 0.01226088564504064 \
1.960001836803526e-06 0.01653123172985639 1.960002369299368e-06 0.02132369430982749 1.960003039181942e-06 0.02735263747515369 1.960003896286051e-06 0.03506657446094884 \
1.960005011032046e-06 0.04509928841663746 1.960006632029637e-06 0.05968826673863754 1.960008974699129e-06 0.08077229215837188 1.960013660038111e-06 0.1229403429978405 \
1.96001796446524e-06 0.1616801871633537 1.960021814406951e-06 0.1963296625632528 1.960026078483917e-06 0.2347063552562001 1.960029148481291e-06 0.2623363316230807 \
1.960031611421446e-06 0.2845027930151538 1.960033573234516e-06 0.3021591106476817 1.960035283029991e-06 0.3175472699147922 1.960036786621731e-06 0.3310795955797556 \
1.960038125719466e-06 0.3431314751960884 1.960039372399233e-06 0.3543515930958913 1.960040514338907e-06 0.3646290501629268 1.960041572311447e-06 0.3741508030226791 \
1.960042581357189e-06 0.3832322147042228 1.960043600260228e-06 0.3924023420515681 1.960044556738474e-06 0.4010106462662745 1.960045504571866e-06 0.4095411467944404 \
1.960046368147174e-06 0.4173133245688312 1.960047110848452e-06 0.423997636067712 1.960047770562902e-06 0.4299350661209142 1.96004846509286e-06 0.4361858357407548 \
1.960049134439973e-06 0.4422099597530631 1.960049745005553e-06 0.4477050499714701 1.960050521159036e-06 0.454690431324675 1.960051577583037e-06 0.4641982473299416 \
1.960052573303283e-06 0.4731597295416305 1.960053439146996e-06 0.4809523229693754 1.960054375298e-06 0.4893776819979773 1.960055101766736e-06 0.4959159006203305 \
1.960055767984727e-06 0.5019118625413875 1.960056382958911e-06 0.5074466301974319 1.960057167658468e-06 0.5145089262167936 1.960057876931857e-06 0.5208923867144013 \
1.960058576728557e-06 0.5271905570126808 1.960059241143132e-06 0.5331702881913303 1.960059896473734e-06 0.539068263602977 1.960060535798054e-06 0.5448221824871196 \
1.960061125945762e-06 0.5501335118600457 1.960061653249814e-06 0.5548792483285057 1.960062030104965e-06 0.5582709446854013 1.960062425635161e-06 0.5618307164525158 \
1.96006278874036e-06 0.5650986632355098 1.960063165175011e-06 0.5684865750957045 1.960063513154822e-06 0.5716183933999566 1.96006377784686e-06 0.5740006217454657 \
1.960064042985523e-06 0.5763868697045537 1.960064573262847e-06 0.5811593656227293 1.960064959313826e-06 0.5846338244342608 1.960065368210207e-06 0.5883138918597329 \
1.960065870635761e-06 0.5928357218442383 1.96006645565012e-06 0.5981008510799999 1.960066996785185e-06 0.6029710666652875 1.960067417144355e-06 0.6067542991940013 \
1.960067824982808e-06 0.6104248452748176 1.96006823230949e-06 0.6140907854118068 1.960068642157613e-06 0.6177794185173828 1.960069065799442e-06 0.62159219497586 \
1.960069510037211e-06 0.6255903348973357 1.960069966768595e-06 0.6297009173589793 1.960070444546043e-06 0.6340009143882042 1.96007097508933e-06 0.6387758039669345 \
1.960071541471416e-06 0.6438732427407217 1.960072145422139e-06 0.6493087992533674 1.960072793381625e-06 0.6551404346247349 1.960073505762603e-06 0.6615518634257037 \
1.960074168459051e-06 0.6675161314588195 1.960074781166818e-06 0.6730305013601764 1.960075359057944e-06 0.6782315214975446 1.960075921736873e-06 0.6832956318592801 \
1.960076483342761e-06 0.6883500848513783 1.960077074883236e-06 0.6936739491264482 1.960077655993641e-06 0.6989039427675531 1.960078230747911e-06 0.7040767311958204 \
1.960078831945941e-06 0.7094875134645067 1.960079324811181e-06 0.7139233006347314 1.960079751835041e-06 0.7177665153653698 1.960080153873253e-06 0.7213848592781456 \
1.960080537977864e-06 0.7248418007795954 1.960080898081889e-06 0.728082736999342 1.960081290978388e-06 0.731618805492268 1.960081350803762e-06 0.7321572338590965 \
1.96008147045451e-06 0.7332340905927537 1.960081709756007e-06 0.735387804060068 1.9600819763221e-06 0.7377868989013747 1.960082273049261e-06 0.7404574433520882 \
1.960082729389945e-06 0.7445645095019819 1.960083129641858e-06 0.7481667767176134 1.9600835424114e-06 0.7518817026010159 1.960083911328918e-06 0.7552019602568045 \
1.960084334919757e-06 0.7590142778153435 1.960084704529443e-06 0.762340764983916 1.96008510473479e-06 0.7659426131102501 1.960085434938255e-06 0.7689144442964062 \
1.960085700495004e-06 0.7713044550329466 1.960085970256226e-06 0.7737323060316124 1.96008638098703e-06 0.7774288832736076 1.960086675859351e-06 0.7800827341539526 \
1.960087078396992e-06 0.7837055729337647 1.960087421594134e-06 0.786794347204456 1.960087774419654e-06 0.7899697768807414 1.960088101708689e-06 0.7929153782018739 \
1.960088421022111e-06 0.7957891990026931 1.96008872760096e-06 0.798548408642265 1.960089025875665e-06 0.8012328809879466 1.960089320848707e-06 0.8038876383597224 \
1.960089591459277e-06 0.8063231334915267 1.960089868048603e-06 0.808812437424818 1.96009015247317e-06 0.8113722585315476 1.960090393475363e-06 0.813541278265291 \
1.960090665778045e-06 0.8159920024070124 1.960090970927407e-06 0.8187383466657218 1.960091271218559e-06 0.8214409670293247 1.960091576487058e-06 0.8241883835163635 \
1.960091871067987e-06 0.8268396118826479 1.960092193104528e-06 0.8297379407530008 1.960092432654028e-06 0.8318938862491163 1.960092688128584e-06 0.8341931572572034 \
1.960092950748264e-06 0.8365567343768243 1.960093196157421e-06 0.8387654167908133 1.960093430718228e-06 0.8408764640555111 1.960093634774443e-06 0.8427129699896301 \
1.960093845366316e-06 0.8446082968424707 1.96009405600496e-06 0.8465040446443356 1.960094244655363e-06 0.8482018982687493 1.960094419312833e-06 0.8497738154964893 \
1.960094599278918e-06 0.8513935102645009 1.960094762688076e-06 0.8528641926851036 1.960094936630778e-06 0.854429677001575 1.96009509164947e-06 0.8558248452281332 \
1.960095258694903e-06 0.8573282541293438 1.960095417039538e-06 0.8587533558427882 1.96009558556135e-06 0.8602700521522246 1.960095742775809e-06 0.8616849822849083 \
1.960095861449154e-06 0.8627530423825936 1.960096011867914e-06 0.8641068112286804 1.960096136494933e-06 0.865228454399422 1.960096297689131e-06 0.8666792021766703 \
1.960096454466771e-06 0.8680902009355517 1.960096580116853e-06 0.8692210516792804 1.960096724052223e-06 0.8705164700033486 1.960096889588435e-06 0.8720062959137309 \
1.960097059053952e-06 0.8735314855691456 1.960097224438411e-06 0.8750199457013955 1.960097397353649e-06 0.8765761828405442 1.960097548608782e-06 0.8779374790365844 \
1.960097705455835e-06 0.8793491025165162 1.960097837560426e-06 0.8805380438351178 1.960097951168902e-06 0.8815605201209382 1.960098066732818e-06 0.8826005953617506 \
1.960098173944515e-06 0.8835655006364479 1.960098251949639e-06 0.8842675467541018 1.96009836920388e-06 0.8853228349141965 1.960098469613519e-06 0.886226521672304 \
1.960098577287673e-06 0.8871955890613133 1.960098653452348e-06 0.8878810711332904 1.960098760907383e-06 0.8888481664483866 1.960098854230815e-06 0.8896880773334693 \
1.960098954910124e-06 0.8905941911166799 1.960099049707369e-06 0.8914473663235497 1.96009913587369e-06 0.8922228632126831 1.96009922632816e-06 0.8930369534412941 \
1.960099366017076e-06 0.8942941536875396 1.960099486829852e-06 0.8953814686688766 1.960099612459294e-06 0.8965121336427553 1.960099756606946e-06 0.8978094625160885 \
1.960099892907379e-06 0.8990361664106589 2.000000175810299e-06 0.8984177073129849 2.000000387736115e-06 0.8965103749658082 2.000000811587748e-06 0.892695710271455 \
2.000001292817289e-06 0.8883646443965901 2.000001822218869e-06 0.8836000301806309 2.000002413857703e-06 0.8782752806762187 2.000003129740239e-06 0.8718323378482702 \
2.000004021470418e-06 0.8638067662390768 2.000005185565676e-06 0.8533299089180234 2.000006730039304e-06 0.8394296462657486 2.000009047735338e-06 0.8185703819595179 \
2.00001310217554e-06 0.7820804201414684 2.000020405609059e-06 0.7163495184672377 2.000024709552219e-06 0.6776140300278762 2.000027719925122e-06 0.6505206739058862 \
2.000031001070041e-06 0.6209903696287848 2.000033489948491e-06 0.5985904635786021 2.000035625657776e-06 0.5793690800177949 2.000037405976345e-06 0.5633462128944384 \
2.000039014010671e-06 0.5488739039651435 2.000040483199696e-06 0.5356512027400909 2.00004182855096e-06 0.5235430413622801 2.000043042811606e-06 0.512614695545089 \
2.000044179223892e-06 0.5023869849741911 2.00004522982584e-06 0.4929315674378034 2.000046211266097e-06 0.484098605128202 2.000047124049725e-06 0.4758835524716363 \
2.000048018804021e-06 0.4678307638102979 2.000048846977552e-06 0.4603772020305483 2.000049661640793e-06 0.4530452328630955 2.000050503799878e-06 0.4454658010995214 \
2.000051392617152e-06 0.4374664456271048 2.000052132173523e-06 0.430810438295329 2.000053027009232e-06 0.4227569169129836 2.000054107902427e-06 0.4130288781558488 \
2.000056115262271e-06 0.3949626395600662 2.000056875998171e-06 0.3881160164607345 2.000057811866421e-06 0.3796932022097708 2.000058487146314e-06 0.373615683179101 \
2.000059159402893e-06 0.3675653739608269 2.000059962121142e-06 0.3603409097239061 2.000060719414128e-06 0.3535252728520237 2.000061469553632e-06 0.3467740173091934 \
2.000062198861823e-06 0.3402102435925485 2.000062917197497e-06 0.3337452225319747 2.000063543595907e-06 0.3281076368399389 2.00006394891578e-06 0.3244597579820502 \
2.000064431737777e-06 0.3201143600118136 2.000064801078116e-06 0.3167902969580316 2.000065253165156e-06 0.3127215135955985 2.000065684660782e-06 0.3088380529590536 \
2.000066036022831e-06 0.3056757945211269 2.000066243755913e-06 0.3038061967869528 2.000066531381986e-06 0.3012175621312337 2.000066776713801e-06 0.2990095757891347 \
2.000067080098449e-06 0.2962791139586973 2.000067337968212e-06 0.2939582860917911 2.000067584264136e-06 0.2917416227702929 2.000068012140654e-06 0.2878907341130054 \
2.00006843261691e-06 0.2841064478110101 2.000068974429479e-06 0.2792301346858994 2.000069431049699e-06 0.2751205527117666 2.000069864969875e-06 0.2712152711268295 \
2.000070276250537e-06 0.2675137451671025 2.000070709349453e-06 0.2636158549267912 2.000071125752111e-06 0.2598682310032753 2.00007157727891e-06 0.2558044898132805 \
2.000072019826756e-06 0.2518215591932373 2.000072486753141e-06 0.2476192217332239 2.000072977907995e-06 0.2431988280497077 2.000073496979761e-06 0.2385271821480127 \
2.000074065575267e-06 0.2334098225947888 2.00007466462888e-06 0.2280183400805964 2.000075295339653e-06 0.2223419431252401 2.000076027928546e-06 0.2157486430863834 \
2.000076737231274e-06 0.2093649185333881 2.000077405278374e-06 0.2033524946355669 2.000078031486169e-06 0.1977166244827963 2.000078642389351e-06 0.1922184958436388 \
2.000079237777689e-06 0.1868600008026635 2.000079853866796e-06 0.1813151988360575 2.000080454397603e-06 0.1759104215697842 2.000081046736475e-06 0.1705793717271608 \
2.000081670603799e-06 0.164964565812095 2.000082253990124e-06 0.1597140888870844 2.000082786746932e-06 0.1549192776137643 2.000083331146382e-06 0.1500196825588286 \
2.000083859078318e-06 0.1452682951413614 2.000084435818527e-06 0.1400776332571309 2.000085002237784e-06 0.1349798599404549 2.000085552082325e-06 0.1300312590758997 \
2.000086168681385e-06 0.1244818675298257 2.000086636997223e-06 0.1202670249965557 2.000087229995173e-06 0.114930043447014 2.000087690957482e-06 0.1107813826574622 \
2.000088106684469e-06 0.1070398397831492 2.000088462796911e-06 0.1038348278011874 2.000088810425094e-06 0.1007061741557836 2.000089112859056e-06 0.09798426849538755 \
2.000089417380186e-06 0.09524357832398211 2.000089689702494e-06 0.09279267755476828 2.000089953280439e-06 0.09042047604958559 2.000090197275105e-06 0.08822452405742931 \
2.000090467223407e-06 0.08579498933604146 2.000090706396949e-06 0.08364242745616901 2.000090969864118e-06 0.08127122294071432 2.000091224741101e-06 0.07897733008697083 \
2.00009145497135e-06 0.07690525785341851 2.000091719751726e-06 0.07452223446371342 2.000092001524411e-06 0.07198628030108556 2.000092277103734e-06 0.06950606639574286 \
2.000092617849715e-06 0.06643935256942901 2.000092904771124e-06 0.06385705988345824 2.000093210523111e-06 0.06110529199863279 2.00009350252768e-06 0.0584772508810687 \
2.000093774358483e-06 0.05603077365032616 2.00009402136155e-06 0.05380774605057426 2.000094217192034e-06 0.05204527169284134 2.000094394312362e-06 0.05045118874764443 \
2.000094569525492e-06 0.04887427057365767 2.000094727173406e-06 0.04745543934452334 2.000094874969159e-06 0.04612527756805263 2.000095020050112e-06 0.04481954899450691 \
2.000095158048333e-06 0.0435775650013065 2.000095300302896e-06 0.04229727393901672 2.000095426303471e-06 0.04116326875785103 2.000095559831953e-06 0.03996151242777013 \
2.000095682102067e-06 0.03886108140050326 2.000095815162016e-06 0.0376635418603275 2.000095929603909e-06 0.03663356482247337 2.000096021739576e-06 0.03580434381845876 \
2.000096118593814e-06 0.03493265567158488 2.0000962580033e-06 0.03367797030500419 2.000096372329609e-06 0.03264903351765647 2.000096481934954e-06 0.03166258541696143 \
2.000096615187473e-06 0.03046331274235659 2.000096728057783e-06 0.02944747995458197 2.000096850555119e-06 0.02834500393025741 2.000096986497112e-06 0.02712152598905548 \
2.000097104504206e-06 0.02605946214676502 2.000097233560397e-06 0.02489795642556891 2.000097344050859e-06 0.02390354227171532 2.000097479489315e-06 0.02268459616553509 \
2.000097599122986e-06 0.02160789312944722 2.00009770000436e-06 0.02069996076227698 2.000097820351452e-06 0.01961683693679572 2.00009796161121e-06 0.01834549910740102 \
2.000098123696896e-06 0.01688672794015589 2.000098272834849e-06 0.01554448635840755 2.000098425713135e-06 0.014168581787533 2.000098576006731e-06 0.01281593941858328 \
2.000098722835146e-06 0.01149448368366224 2.000098879191315e-06 0.01008727816647481 2.000098998454606e-06 0.009013908541385951 2.00009909308712e-06 0.008162215916559523 \
2.000099196564466e-06 0.007230919801462066 2.000099269048437e-06 0.006578564066408443 2.000099347396487e-06 0.005873431617253289 2.000099437077881e-06 0.005066299068704372 \
2.000099569889939e-06 0.003870990547362063 2.000099671489824e-06 0.002956591581575796 2.000099777454715e-06 0.002002907563398826 2.000099893286091e-06 0.000960425183447966 \
2.058990000000011e-06 0 2.059999999999996e-06 0 2.06000021116344e-06 0.001900470962571042 2.060000442444547e-06 0.003982000924727166 \
2.060000905006761e-06 0.008145060849039413 2.060001362320627e-06 0.01226088564504064 2.060001836803526e-06 0.01653123172985639 2.060002369299367e-06 0.02132369430982749 \
2.060003039181942e-06 0.02735263747515369 2.060003896286051e-06 0.03506657446094884 2.060005011032046e-06 0.04509928841663746 2.060006632029637e-06 0.05968826673863754 \
2.060008974699129e-06 0.08077229215837188 2.060013660038111e-06 0.1229403429978405 2.06001796446524e-06 0.1616801871633537 2.060021814406951e-06 0.1963296625632528 \
2.060026078483917e-06 0.2347063552562001 2.060029148481291e-06 0.2623363316230807 2.060031611421446e-06 0.2845027930151538 2.060033573234516e-06 0.3021591106476817 \
2.06003528302999e-06 0.3175472699147922 2.060036786621731e-06 0.3310795955797556 2.060038125719466e-06 0.3431314751960884 2.060039372399233e-06 0.3543515930958913 \
2.060040514338907e-06 0.3646290501629268 2.060041572311447e-06 0.3741508030226791 2.060042581357189e-06 0.3832322147042228 2.060043600260228e-06 0.3924023420515681 \
2.060044556738474e-06 0.4010106462662745 2.060045504571866e-06 0.4095411467944404 2.060046368147174e-06 0.4173133245688312 2.060047110848452e-06 0.423997636067712 \
2.060047770562902e-06 0.4299350661209142 2.06004846509286e-06 0.4361858357407548 2.060049134439973e-06 0.4422099597530631 2.060049745005552e-06 0.4477050499714701 \
2.060050521159036e-06 0.454690431324675 2.060051577583036e-06 0.4641982473299416 2.060052573303282e-06 0.4731597295416305 2.060053439146996e-06 0.4809523229693754 \
2.060054375297999e-06 0.4893776819979773 2.060055101766736e-06 0.4959159006203305 2.060055767984727e-06 0.5019118625413875 2.060056382958911e-06 0.5074466301974319 \
2.060057167658468e-06 0.5145089262167936 2.060057876931857e-06 0.5208923867144013 2.060058576728557e-06 0.5271905570126808 2.060059241143132e-06 0.5331702881913303 \
2.060059896473733e-06 0.539068263602977 2.060060535798054e-06 0.5448221824871196 2.060061125945762e-06 0.5501335118600457 2.060061653249814e-06 0.5548792483285057 \
2.060062030104965e-06 0.5582709446854013 2.060062425635161e-06 0.5618307164525158 2.060062788740359e-06 0.5650986632355098 2.060063165175011e-06 0.5684865750957045 \
2.060063513154822e-06 0.5716183933999566 2.06006377784686e-06 0.5740006217454657 2.060064042985523e-06 0.5763868697045537 2.060064573262847e-06 0.5811593656227293 \
2.060064959313826e-06 0.5846338244342608 2.060065368210207e-06 0.5883138918597329 2.060065870635761e-06 0.5928357218442383 2.06006645565012e-06 0.5981008510799999 \
2.060066996785185e-06 0.6029710666652875 2.060067417144355e-06 0.6067542991940013 2.060067824982808e-06 0.6104248452748176 2.06006823230949e-06 0.6140907854118068 \
2.060068642157613e-06 0.6177794185173828 2.060069065799442e-06 0.62159219497586 2.060069510037211e-06 0.6255903348973357 2.060069966768595e-06 0.6297009173589793 \
2.060070444546043e-06 0.6340009143882042 2.06007097508933e-06 0.6387758039669345 2.060071541471416e-06 0.6438732427407217 2.060072145422139e-06 0.6493087992533674 \
2.060072793381625e-06 0.6551404346247349 2.060073505762603e-06 0.6615518634257037 2.060074168459051e-06 0.6675161314588195 2.060074781166818e-06 0.6730305013601764 \
2.060075359057944e-06 0.6782315214975446 2.060075921736873e-06 0.6832956318592801 2.060076483342761e-06 0.6883500848513783 2.060077074883236e-06 0.6936739491264482 \
2.060077655993641e-06 0.6989039427675531 2.060078230747911e-06 0.7040767311958204 2.060078831945941e-06 0.7094875134645067 2.060079324811181e-06 0.7139233006347314 \
2.060079751835041e-06 0.7177665153653698 2.060080153873253e-06 0.7213848592781456 2.060080537977864e-06 0.7248418007795954 2.060080898081889e-06 0.728082736999342 \
2.060081290978388e-06 0.731618805492268 2.060081350803762e-06 0.7321572338590965 2.06008147045451e-06 0.7332340905927537 2.060081709756007e-06 0.735387804060068 \
2.0600819763221e-06 0.7377868989013747 2.060082273049261e-06 0.7404574433520882 2.060082729389945e-06 0.7445645095019819 2.060083129641858e-06 0.7481667767176134 \
2.0600835424114e-06 0.7518817026010159 2.060083911328917e-06 0.7552019602568045 2.060084334919757e-06 0.7590142778153435 2.060084704529443e-06 0.762340764983916 \
2.06008510473479e-06 0.7659426131102501 2.060085434938255e-06 0.7689144442964062 2.060085700495004e-06 0.7713044550329466 2.060085970256225e-06 0.7737323060316124 \
2.06008638098703e-06 0.7774288832736076 2.060086675859351e-06 0.7800827341539526 2.060087078396992e-06 0.7837055729337647 2.060087421594134e-06 0.786794347204456 \
2.060087774419653e-06 0.7899697768807414 2.060088101708689e-06 0.7929153782018739 2.060088421022111e-06 0.7957891990026931 2.06008872760096e-06 0.798548408642265 \
2.060089025875665e-06 0.8012328809879466 2.060089320848706e-06 0.8038876383597224 2.060089591459277e-06 0.8063231334915267 2.060089868048603e-06 0.808812437424818 \
2.06009015247317e-06 0.8113722585315476 2.060090393475363e-06 0.813541278265291 2.060090665778045e-06 0.8159920024070124 2.060090970927407e-06 0.8187383466657218 \
2.060091271218559e-06 0.8214409670293247 2.060091576487057e-06 0.8241883835163635 2.060091871067987e-06 0.8268396118826479 2.060092193104528e-06 0.8297379407530008 \
2.060092432654028e-06 0.8318938862491163 2.060092688128584e-06 0.8341931572572034 2.060092950748264e-06 0.8365567343768243 2.060093196157421e-06 0.8387654167908133 \
2.060093430718228e-06 0.8408764640555111 2.060093634774443e-06 0.8427129699896301 2.060093845366316e-06 0.8446082968424707 2.06009405600496e-06 0.8465040446443356 \
2.060094244655363e-06 0.8482018982687493 2.060094419312833e-06 0.8497738154964893 2.060094599278918e-06 0.8513935102645009 2.060094762688076e-06 0.8528641926851036 \
2.060094936630778e-06 0.854429677001575 2.06009509164947e-06 0.8558248452281332 2.060095258694903e-06 0.8573282541293438 2.060095417039538e-06 0.8587533558427882 \
2.06009558556135e-06 0.8602700521522246 2.060095742775809e-06 0.8616849822849083 2.060095861449154e-06 0.8627530423825936 2.060096011867914e-06 0.8641068112286804 \
2.060096136494933e-06 0.865228454399422 2.060096297689131e-06 0.8666792021766703 2.060096454466771e-06 0.8680902009355517 2.060096580116853e-06 0.8692210516792804 \
2.060096724052222e-06 0.8705164700033486 2.060096889588435e-06 0.8720062959137309 2.060097059053952e-06 0.8735314855691456 2.060097224438411e-06 0.8750199457013955 \
2.060097397353649e-06 0.8765761828405442 2.060097548608782e-06 0.8779374790365844 2.060097705455835e-06 0.8793491025165162 2.060097837560426e-06 0.8805380438351178 \
2.060097951168902e-06 0.8815605201209382 2.060098066732818e-06 0.8826005953617506 2.060098173944515e-06 0.8835655006364479 2.060098251949639e-06 0.8842675467541018 \
2.060098369203879e-06 0.8853228349141965 2.060098469613519e-06 0.886226521672304 2.060098577287673e-06 0.8871955890613133 2.060098653452348e-06 0.8878810711332904 \
2.060098760907383e-06 0.8888481664483866 2.060098854230815e-06 0.8896880773334693 2.060098954910124e-06 0.8905941911166799 2.060099049707369e-06 0.8914473663235497 \
2.06009913587369e-06 0.8922228632126831 2.06009922632816e-06 0.8930369534412941 2.060099366017076e-06 0.8942941536875396 2.060099486829852e-06 0.8953814686688766 \
2.060099612459294e-06 0.8965121336427553 2.060099756606946e-06 0.8978094625160885 2.060099892907379e-06 0.8990361664106589 2.100000175810299e-06 0.8984177073129849 \
2.100000387736115e-06 0.8965103749658082 2.100000811587748e-06 0.892695710271455 2.100001292817289e-06 0.8883646443965901 2.100001822218868e-06 0.8836000301806309 \
2.100002413857703e-06 0.8782752806762187 2.100003129740239e-06 0.8718323378482702 2.100004021470418e-06 0.8638067662390768 2.100005185565676e-06 0.8533299089180234 \
2.100006730039304e-06 0.8394296462657486 2.100009047735338e-06 0.8185703819595179 2.10001310217554e-06 0.7820804201414684 2.100020405609059e-06 0.7163495184672377 \
2.100024709552219e-06 0.6776140300278762 2.100027719925121e-06 0.6505206739058862 2.100031001070041e-06 0.6209903696287848 2.100033489948491e-06 0.5985904635786021 \
2.100035625657776e-06 0.5793690800177949 2.100037405976345e-06 0.5633462128944384 2.100039014010671e-06 0.5488739039651435 2.100040483199695e-06 0.5356512027400909 \
2.10004182855096e-06 0.5235430413622801 2.100043042811606e-06 0.512614695545089 2.100044179223892e-06 0.5023869849741911 2.10004522982584e-06 0.4929315674378034 \
2.100046211266097e-06 0.484098605128202 2.100047124049725e-06 0.4758835524716363 2.100048018804021e-06 0.4678307638102979 2.100048846977552e-06 0.4603772020305483 \
2.100049661640793e-06 0.4530452328630955 2.100050503799878e-06 0.4454658010995214 2.100051392617152e-06 0.4374664456271048 2.100052132173523e-06 0.430810438295329 \
2.100053027009232e-06 0.4227569169129836 2.100054107902427e-06 0.4130288781558488 2.100056115262271e-06 0.3949626395600662 2.100056875998171e-06 0.3881160164607345 \
2.100057811866421e-06 0.3796932022097708 2.100058487146313e-06 0.373615683179101 2.100059159402893e-06 0.3675653739608269 2.100059962121142e-06 0.3603409097239061 \
2.100060719414127e-06 0.3535252728520237 2.100061469553632e-06 0.3467740173091934 2.100062198861823e-06 0.3402102435925485 2.100062917197496e-06 0.3337452225319747 \
2.100063543595907e-06 0.3281076368399389 2.10006394891578e-06 0.3244597579820502 2.100064431737777e-06 0.3201143600118136 2.100064801078116e-06 0.3167902969580316 \
2.100065253165156e-06 0.3127215135955985 2.100065684660782e-06 0.3088380529590536 2.100066036022831e-06 0.3056757945211269 2.100066243755913e-06 0.3038061967869528 \
2.100066531381985e-06 0.3012175621312337 2.100066776713801e-06 0.2990095757891347 2.100067080098449e-06 0.2962791139586973 2.100067337968212e-06 0.2939582860917911 \
2.100067584264136e-06 0.2917416227702929 2.100068012140654e-06 0.2878907341130054 2.10006843261691e-06 0.2841064478110101 2.100068974429479e-06 0.2792301346858994 \
2.100069431049699e-06 0.2751205527117666 2.100069864969875e-06 0.2712152711268295 2.100070276250537e-06 0.2675137451671025 2.100070709349453e-06 0.2636158549267912 \
2.100071125752111e-06 0.2598682310032753 2.100071577278909e-06 0.2558044898132805 2.100072019826756e-06 0.2518215591932373 2.100072486753141e-06 0.2476192217332239 \
2.100072977907994e-06 0.2431988280497077 2.100073496979761e-06 0.2385271821480127 2.100074065575267e-06 0.2334098225947888 2.10007466462888e-06 0.2280183400805964 \
2.100075295339652e-06 0.2223419431252401 2.100076027928546e-06 0.2157486430863834 2.100076737231274e-06 0.2093649185333881 2.100077405278374e-06 0.2033524946355669 \
2.100078031486169e-06 0.1977166244827963 2.100078642389351e-06 0.1922184958436388 2.100079237777688e-06 0.1868600008026635 2.100079853866796e-06 0.1813151988360575 \
2.100080454397603e-06 0.1759104215697842 2.100081046736475e-06 0.1705793717271608 2.100081670603799e-06 0.164964565812095 2.100082253990123e-06 0.1597140888870844 \
2.100082786746932e-06 0.1549192776137643 2.100083331146382e-06 0.1500196825588286 2.100083859078318e-06 0.1452682951413614 2.100084435818527e-06 0.1400776332571309 \
2.100085002237784e-06 0.1349798599404549 2.100085552082325e-06 0.1300312590758997 2.100086168681385e-06 0.1244818675298257 2.100086636997223e-06 0.1202670249965557 \
2.100087229995172e-06 0.114930043447014 2.100087690957482e-06 0.1107813826574622 2.100088106684469e-06 0.1070398397831492 2.100088462796911e-06 0.1038348278011874 \
2.100088810425094e-06 0.1007061741557836 2.100089112859056e-06 0.09798426849538755 2.100089417380186e-06 0.09524357832398211 2.100089689702494e-06 0.09279267755476828 \
2.100089953280439e-06 0.09042047604958559 2.100090197275105e-06 0.08822452405742931 2.100090467223407e-06 0.08579498933604146 2.100090706396949e-06 0.08364242745616901 \
2.100090969864118e-06 0.08127122294071432 2.100091224741101e-06 0.07897733008697083 2.10009145497135e-06 0.07690525785341851 2.100091719751726e-06 0.07452223446371342 \
2.100092001524411e-06 0.07198628030108556 2.100092277103734e-06 0.06950606639574286 2.100092617849714e-06 0.06643935256942901 2.100092904771124e-06 0.06385705988345824 \
2.100093210523111e-06 0.06110529199863279 2.10009350252768e-06 0.0584772508810687 2.100093774358483e-06 0.05603077365032616 2.10009402136155e-06 0.05380774605057426 \
2.100094217192034e-06 0.05204527169284134 2.100094394312361e-06 0.05045118874764443 2.100094569525492e-06 0.04887427057365767 2.100094727173406e-06 0.04745543934452334 \
2.100094874969159e-06 0.04612527756805263 2.100095020050111e-06 0.04481954899450691 2.100095158048333e-06 0.0435775650013065 2.100095300302896e-06 0.04229727393901672 \
2.100095426303471e-06 0.04116326875785103 2.100095559831952e-06 0.03996151242777013 2.100095682102066e-06 0.03886108140050326 2.100095815162016e-06 0.0376635418603275 \
2.100095929603909e-06 0.03663356482247337 2.100096021739576e-06 0.03580434381845876 2.100096118593814e-06 0.03493265567158488 2.100096258003299e-06 0.03367797030500419 \
2.100096372329609e-06 0.03264903351765647 2.100096481934954e-06 0.03166258541696143 2.100096615187473e-06 0.03046331274235659 2.100096728057783e-06 0.02944747995458197 \
2.100096850555119e-06 0.02834500393025741 2.100096986497112e-06 0.02712152598905548 2.100097104504206e-06 0.02605946214676502 2.100097233560397e-06 0.02489795642556891 \
2.100097344050859e-06 0.02390354227171532 2.100097479489315e-06 0.02268459616553509 2.100097599122986e-06 0.02160789312944722 2.10009770000436e-06 0.02069996076227698 \
2.100097820351451e-06 0.01961683693679572 2.10009796161121e-06 0.01834549910740102 2.100098123696896e-06 0.01688672794015589 2.100098272834849e-06 0.01554448635840755 \
2.100098425713135e-06 0.014168581787533 2.100098576006731e-06 0.01281593941858328 2.100098722835146e-06 0.01149448368366224 2.100098879191315e-06 0.01008727816647481 \
2.100098998454606e-06 0.009013908541385951 2.10009909308712e-06 0.008162215916559523 2.100099196564466e-06 0.007230919801462066 2.100099269048437e-06 0.006578564066408443 \
2.100099347396487e-06 0.005873431617253289 2.100099437077881e-06 0.005066299068704372 2.100099569889939e-06 0.003870990547362063 2.100099671489824e-06 0.002956591581575796 \
2.100099777454715e-06 0.002002907563398826 2.10009989328609e-06 0.000960425183447966 2.158990000000011e-06 0 2.159999999999996e-06 0 \
2.16000021116344e-06 0.001900470962571042 2.160000442444547e-06 0.003982000924727166 2.160000905006761e-06 0.008145060849039413 2.160001362320627e-06 0.01226088564504064 \
2.160001836803525e-06 0.01653123172985639 2.160002369299367e-06 0.02132369430982749 2.160003039181942e-06 0.02735263747515369 2.160003896286051e-06 0.03506657446094884 \
2.160005011032046e-06 0.04509928841663746 2.160006632029637e-06 0.05968826673863754 2.160008974699129e-06 0.08077229215837188 2.160013660038111e-06 0.1229403429978405 \
2.16001796446524e-06 0.1616801871633537 2.160021814406951e-06 0.1963296625632528 2.160026078483917e-06 0.2347063552562001 2.160029148481291e-06 0.2623363316230807 \
2.160031611421446e-06 0.2845027930151538 2.160033573234516e-06 0.3021591106476817 2.16003528302999e-06 0.3175472699147922 2.160036786621731e-06 0.3310795955797556 \
2.160038125719466e-06 0.3431314751960884 2.160039372399233e-06 0.3543515930958913 2.160040514338907e-06 0.3646290501629268 2.160041572311447e-06 0.3741508030226791 \
2.160042581357189e-06 0.3832322147042228 2.160043600260228e-06 0.3924023420515681 2.160044556738474e-06 0.4010106462662745 2.160045504571866e-06 0.4095411467944404 \
2.160046368147174e-06 0.4173133245688312 2.160047110848452e-06 0.423997636067712 2.160047770562902e-06 0.4299350661209142 2.16004846509286e-06 0.4361858357407548 \
2.160049134439972e-06 0.4422099597530631 2.160049745005552e-06 0.4477050499714701 2.160050521159036e-06 0.454690431324675 2.160051577583036e-06 0.4641982473299416 \
2.160052573303282e-06 0.4731597295416305 2.160053439146996e-06 0.4809523229693754 2.160054375297999e-06 0.4893776819979773 2.160055101766735e-06 0.4959159006203305 \
2.160055767984727e-06 0.5019118625413875 2.160056382958911e-06 0.5074466301974319 2.160057167658468e-06 0.5145089262167936 2.160057876931857e-06 0.5208923867144013 \
2.160058576728557e-06 0.5271905570126808 2.160059241143132e-06 0.5331702881913303 2.160059896473733e-06 0.539068263602977 2.160060535798054e-06 0.5448221824871196 \
2.160061125945762e-06 0.5501335118600457 2.160061653249814e-06 0.5548792483285057 2.160062030104965e-06 0.5582709446854013 2.160062425635161e-06 0.5618307164525158 \
2.160062788740359e-06 0.5650986632355098 2.160063165175011e-06 0.5684865750957045 2.160063513154822e-06 0.5716183933999566 2.16006377784686e-06 0.5740006217454657 \
2.160064042985522e-06 0.5763868697045537 2.160064573262847e-06 0.5811593656227293 2.160064959313826e-06 0.5846338244342608 2.160065368210206e-06 0.5883138918597329 \
2.16006587063576e-06 0.5928357218442383 2.16006645565012e-06 0.5981008510799999 2.160066996785185e-06 0.6029710666652875 2.160067417144354e-06 0.6067542991940013 \
2.160067824982808e-06 0.6104248452748176 2.16006823230949e-06 0.6140907854118068 2.160068642157613e-06 0.6177794185173828 2.160069065799442e-06 0.62159219497586 \
2.160069510037211e-06 0.6255903348973357 2.160069966768595e-06 0.6297009173589793 2.160070444546043e-06 0.6340009143882042 2.16007097508933e-06 0.6387758039669345 \
2.160071541471416e-06 0.6438732427407217 2.160072145422139e-06 0.6493087992533674 2.160072793381625e-06 0.6551404346247349 2.160073505762603e-06 0.6615518634257037 \
2.160074168459051e-06 0.6675161314588195 2.160074781166817e-06 0.6730305013601764 2.160075359057944e-06 0.6782315214975446 2.160075921736873e-06 0.6832956318592801 \
2.160076483342761e-06 0.6883500848513783 2.160077074883236e-06 0.6936739491264482 2.160077655993641e-06 0.6989039427675531 2.16007823074791e-06 0.7040767311958204 \
2.16007883194594e-06 0.7094875134645067 2.160079324811181e-06 0.7139233006347314 2.16007975183504e-06 0.7177665153653698 2.160080153873253e-06 0.7213848592781456 \
2.160080537977864e-06 0.7248418007795954 2.160080898081888e-06 0.728082736999342 2.160081290978388e-06 0.731618805492268 2.160081350803762e-06 0.7321572338590965 \
2.16008147045451e-06 0.7332340905927537 2.160081709756006e-06 0.735387804060068 2.1600819763221e-06 0.7377868989013747 2.160082273049261e-06 0.7404574433520882 \
2.160082729389945e-06 0.7445645095019819 2.160083129641857e-06 0.7481667767176134 2.1600835424114e-06 0.7518817026010159 2.160083911328917e-06 0.7552019602568045 \
2.160084334919757e-06 0.7590142778153435 2.160084704529442e-06 0.762340764983916 2.16008510473479e-06 0.7659426131102501 2.160085434938255e-06 0.7689144442964062 \
2.160085700495004e-06 0.7713044550329466 2.160085970256225e-06 0.7737323060316124 2.16008638098703e-06 0.7774288832736076 2.16008667585935e-06 0.7800827341539526 \
2.160087078396992e-06 0.7837055729337647 2.160087421594134e-06 0.786794347204456 2.160087774419653e-06 0.7899697768807414 2.160088101708689e-06 0.7929153782018739 \
2.160088421022111e-06 0.7957891990026931 2.16008872760096e-06 0.798548408642265 2.160089025875665e-06 0.8012328809879466 2.160089320848706e-06 0.8038876383597224 \
2.160089591459276e-06 0.8063231334915267 2.160089868048603e-06 0.808812437424818 2.16009015247317e-06 0.8113722585315476 2.160090393475363e-06 0.813541278265291 \
2.160090665778045e-06 0.8159920024070124 2.160090970927407e-06 0.8187383466657218 2.160091271218559e-06 0.8214409670293247 2.160091576487057e-06 0.8241883835163635 \
2.160091871067987e-06 0.8268396118826479 2.160092193104528e-06 0.8297379407530008 2.160092432654028e-06 0.8318938862491163 2.160092688128584e-06 0.8341931572572034 \
2.160092950748264e-06 0.8365567343768243 2.160093196157421e-06 0.8387654167908133 2.160093430718228e-06 0.8408764640555111 2.160093634774443e-06 0.8427129699896301 \
2.160093845366316e-06 0.8446082968424707 2.16009405600496e-06 0.8465040446443356 2.160094244655363e-06 0.8482018982687493 2.160094419312833e-06 0.8497738154964893 \
2.160094599278918e-06 0.8513935102645009 2.160094762688076e-06 0.8528641926851036 2.160094936630778e-06 0.854429677001575 2.16009509164947e-06 0.8558248452281332 \
2.160095258694903e-06 0.8573282541293438 2.160095417039538e-06 0.8587533558427882 2.16009558556135e-06 0.8602700521522246 2.160095742775809e-06 0.8616849822849083 \
2.160095861449154e-06 0.8627530423825936 2.160096011867914e-06 0.8641068112286804 2.160096136494933e-06 0.865228454399422 2.160096297689131e-06 0.8666792021766703 \
2.160096454466771e-06 0.8680902009355517 2.160096580116853e-06 0.8692210516792804 2.160096724052222e-06 0.8705164700033486 2.160096889588435e-06 0.8720062959137309 \
2.160097059053952e-06 0.8735314855691456 2.160097224438411e-06 0.8750199457013955 2.160097397353649e-06 0.8765761828405442 2.160097548608782e-06 0.8779374790365844 \
2.160097705455835e-06 0.8793491025165162 2.160097837560426e-06 0.8805380438351178 2.160097951168902e-06 0.8815605201209382 2.160098066732818e-06 0.8826005953617506 \
2.160098173944515e-06 0.8835655006364479 2.160098251949639e-06 0.8842675467541018 2.160098369203879e-06 0.8853228349141965 2.160098469613519e-06 0.886226521672304 \
2.160098577287673e-06 0.8871955890613133 2.160098653452348e-06 0.8878810711332904 2.160098760907383e-06 0.8888481664483866 2.160098854230815e-06 0.8896880773334693 \
2.160098954910124e-06 0.8905941911166799 2.160099049707369e-06 0.8914473663235497 2.16009913587369e-06 0.8922228632126831 2.16009922632816e-06 0.8930369534412941 \
2.160099366017076e-06 0.8942941536875396 2.160099486829852e-06 0.8953814686688766 2.160099612459294e-06 0.8965121336427553 2.160099756606946e-06 0.8978094625160885 \
2.160099892907379e-06 0.8990361664106589 2.200000175810298e-06 0.8984177073129849 2.200000387736115e-06 0.8965103749658082 2.200000811587747e-06 0.892695710271455 \
2.200001292817289e-06 0.8883646443965901 2.200001822218868e-06 0.8836000301806309 2.200002413857702e-06 0.8782752806762187 2.200003129740239e-06 0.8718323378482702 \
2.200004021470418e-06 0.8638067662390768 2.200005185565675e-06 0.8533299089180234 2.200006730039304e-06 0.8394296462657486 2.200009047735338e-06 0.8185703819595179 \
2.20001310217554e-06 0.7820804201414684 2.200020405609059e-06 0.7163495184672377 2.200024709552219e-06 0.6776140300278762 2.200027719925121e-06 0.6505206739058862 \
2.200031001070041e-06 0.6209903696287848 2.200033489948491e-06 0.5985904635786021 2.200035625657776e-06 0.5793690800177949 2.200037405976345e-06 0.5633462128944384 \
2.20003901401067e-06 0.5488739039651435 2.200040483199695e-06 0.5356512027400909 2.20004182855096e-06 0.5235430413622801 2.200043042811606e-06 0.512614695545089 \
2.200044179223892e-06 0.5023869849741911 2.20004522982584e-06 0.4929315674378034 2.200046211266097e-06 0.484098605128202 2.200047124049725e-06 0.4758835524716363 \
2.200048018804021e-06 0.4678307638102979 2.200048846977552e-06 0.4603772020305483 2.200049661640793e-06 0.4530452328630955 2.200050503799878e-06 0.4454658010995214 \
2.200051392617152e-06 0.4374664456271048 2.200052132173523e-06 0.430810438295329 2.200053027009232e-06 0.4227569169129836 2.200054107902427e-06 0.4130288781558488 \
2.200056115262271e-06 0.3949626395600662 2.200056875998171e-06 0.3881160164607345 2.200057811866421e-06 0.3796932022097708 2.200058487146313e-06 0.373615683179101 \
2.200059159402893e-06 0.3675653739608269 2.200059962121142e-06 0.3603409097239061 2.200060719414127e-06 0.3535252728520237 2.200061469553632e-06 0.3467740173091934 \
2.200062198861823e-06 0.3402102435925485 2.200062917197496e-06 0.3337452225319747 2.200063543595907e-06 0.3281076368399389 2.200063948915779e-06 0.3244597579820502 \
2.200064431737776e-06 0.3201143600118136 2.200064801078116e-06 0.3167902969580316 2.200065253165156e-06 0.3127215135955985 2.200065684660782e-06 0.3088380529590536 \
2.200066036022831e-06 0.3056757945211269 2.200066243755912e-06 0.3038061967869528 2.200066531381985e-06 0.3012175621312337 2.200066776713801e-06 0.2990095757891347 \
2.200067080098449e-06 0.2962791139586973 2.200067337968212e-06 0.2939582860917911 2.200067584264136e-06 0.2917416227702929 2.200068012140654e-06 0.2878907341130054 \
2.20006843261691e-06 0.2841064478110101 2.200068974429479e-06 0.2792301346858994 2.200069431049698e-06 0.2751205527117666 2.200069864969875e-06 0.2712152711268295 \
2.200070276250537e-06 0.2675137451671025 2.200070709349453e-06 0.2636158549267912 2.200071125752111e-06 0.2598682310032753 2.200071577278909e-06 0.2558044898132805 \
2.200072019826756e-06 0.2518215591932373 2.20007248675314e-06 0.2476192217332239 2.200072977907994e-06 0.2431988280497077 2.200073496979761e-06 0.2385271821480127 \
2.200074065575267e-06 0.2334098225947888 2.20007466462888e-06 0.2280183400805964 2.200075295339652e-06 0.2223419431252401 2.200076027928546e-06 0.2157486430863834 \
2.200076737231274e-06 0.2093649185333881 2.200077405278374e-06 0.2033524946355669 2.200078031486168e-06 0.1977166244827963 2.200078642389351e-06 0.1922184958436388 \
2.200079237777688e-06 0.1868600008026635 2.200079853866796e-06 0.1813151988360575 2.200080454397603e-06 0.1759104215697842 2.200081046736475e-06 0.1705793717271608 \
2.200081670603799e-06 0.164964565812095 2.200082253990123e-06 0.1597140888870844 2.200082786746932e-06 0.1549192776137643 2.200083331146382e-06 0.1500196825588286 \
2.200083859078317e-06 0.1452682951413614 2.200084435818527e-06 0.1400776332571309 2.200085002237784e-06 0.1349798599404549 2.200085552082325e-06 0.1300312590758997 \
2.200086168681385e-06 0.1244818675298257 2.200086636997223e-06 0.1202670249965557 2.200087229995172e-06 0.114930043447014 2.200087690957482e-06 0.1107813826574622 \
2.200088106684468e-06 0.1070398397831492 2.200088462796911e-06 0.1038348278011874 2.200088810425093e-06 0.1007061741557836 2.200089112859056e-06 0.09798426849538755 \
2.200089417380186e-06 0.09524357832398211 2.200089689702494e-06 0.09279267755476828 2.200089953280439e-06 0.09042047604958559 2.200090197275105e-06 0.08822452405742931 \
2.200090467223407e-06 0.08579498933604146 2.200090706396949e-06 0.08364242745616901 2.200090969864118e-06 0.08127122294071432 2.200091224741101e-06 0.07897733008697083 \
2.200091454971349e-06 0.07690525785341851 2.200091719751726e-06 0.07452223446371342 2.200092001524411e-06 0.07198628030108556 2.200092277103734e-06 0.06950606639574286 \
2.200092617849714e-06 0.06643935256942901 2.200092904771124e-06 0.06385705988345824 2.200093210523111e-06 0.06110529199863279 2.20009350252768e-06 0.0584772508810687 \
2.200093774358483e-06 0.05603077365032616 2.20009402136155e-06 0.05380774605057426 2.200094217192034e-06 0.05204527169284134 2.200094394312361e-06 0.05045118874764443 \
2.200094569525492e-06 0.04887427057365767 2.200094727173406e-06 0.04745543934452334 2.200094874969159e-06 0.04612527756805263 2.200095020050111e-06 0.04481954899450691 \
2.200095158048333e-06 0.0435775650013065 2.200095300302895e-06 0.04229727393901672 2.200095426303471e-06 0.04116326875785103 2.200095559831952e-06 0.03996151242777013 \
2.200095682102066e-06 0.03886108140050326 2.200095815162015e-06 0.0376635418603275 2.200095929603909e-06 0.03663356482247337 2.200096021739576e-06 0.03580434381845876 \
2.200096118593814e-06 0.03493265567158488 2.200096258003299e-06 0.03367797030500419 2.200096372329609e-06 0.03264903351765647 2.200096481934953e-06 0.03166258541696143 \
2.200096615187473e-06 0.03046331274235659 2.200096728057783e-06 0.02944747995458197 2.200096850555119e-06 0.02834500393025741 2.200096986497112e-06 0.02712152598905548 \
2.200097104504206e-06 0.02605946214676502 2.200097233560397e-06 0.02489795642556891 2.200097344050858e-06 0.02390354227171532 2.200097479489315e-06 0.02268459616553509 \
2.200097599122986e-06 0.02160789312944722 2.20009770000436e-06 0.02069996076227698 2.200097820351451e-06 0.01961683693679572 2.20009796161121e-06 0.01834549910740102 \
2.200098123696895e-06 0.01688672794015589 2.200098272834849e-06 0.01554448635840755 2.200098425713134e-06 0.014168581787533 2.200098576006731e-06 0.01281593941858328 \
2.200098722835146e-06 0.01149448368366224 2.200098879191314e-06 0.01008727816647481 2.200098998454606e-06 0.009013908541385951 2.20009909308712e-06 0.008162215916559523 \
2.200099196564466e-06 0.007230919801462066 2.200099269048437e-06 0.006578564066408443 2.200099347396487e-06 0.005873431617253289 2.200099437077881e-06 0.005066299068704372 \
2.200099569889939e-06 0.003870990547362063 2.200099671489824e-06 0.002956591581575796 2.200099777454715e-06 0.002002907563398826 2.20009989328609e-06 0.000960425183447966 \
2.258990000000011e-06 0 2.259e-06 0 \
]
VBOOT (SAMPLE_HOLD 0) vsource type=pwl wave=[ \
0 3.130936969575256e-06 6.188340783038533e-08 -0.0008819623910157972 6.188364387923382e-08 -0.001161970612476729 6.188410232556212e-08 -0.001847355627596629 \
6.188434561269729e-08 -0.002293620068582415 6.188459589666454e-08 -0.00281405583725217 6.188484670266814e-08 -0.003393671496214343 6.188515952233049e-08 -0.004199192998005251 \
6.188539773220152e-08 -0.004872003934560885 6.188564418263537e-08 -0.005621391842385397 6.188587592713082e-08 -0.006370319304257691 6.18861831122489e-08 -0.007411941938624838 \
6.188644840618112e-08 -0.008326397880259807 6.188669368580747e-08 -0.009131457988769647 6.18870584173626e-08 -0.01007334593757064 6.188728648853955e-08 -0.01033898456945748 \
6.188761012818185e-08 -0.009994868194499993 6.188781054473512e-08 -0.009187286872421443 6.188804534953236e-08 -0.007487931918614563 6.188822642498763e-08 -0.005544847192362645 \
6.188833286527701e-08 -0.004119573247771668 6.188847115142377e-08 -0.001940540768574745 6.188858217738658e-08 7.563183370691832e-05 6.188870279882089e-08 0.002536824544301687 \
6.188880586400176e-08 0.004857398676819782 6.188894457128676e-08 0.008289235792766818 6.188906568057869e-08 0.01156496544863939 6.188921588438016e-08 0.01596809792775087 \
6.188939752999021e-08 0.02176080367268303 6.18895499652095e-08 0.02698454055473338 6.188972611545408e-08 0.03339084366291074 6.18899251156e-08 0.04103368087207344 \
6.189009478753781e-08 0.04784290449723066 6.189027398151369e-08 0.05527749234857952 6.18904343978791e-08 0.06211990493347131 6.189059619183875e-08 0.06916698107316244 \
6.189075474271928e-08 0.07620053909780501 6.189092193539222e-08 0.08372027851346725 6.189109229331834e-08 0.09147114401158042 6.189127173056545e-08 0.0997240648901548 \
6.189146185309146e-08 0.1085375718081032 6.189166109205316e-08 0.1178373860957827 6.189186506935853e-08 0.1274102212870429 6.189208614422998e-08 0.1378300800073513 \
6.189233180079991e-08 0.1494365474357121 6.189258915104304e-08 0.1616443690283554 6.1892871842139e-08 0.1750899465505063 6.189316989354989e-08 0.1892663579759593 \
6.189351617012162e-08 0.2057792515135755 6.18938828852402e-08 0.2232517522030736 6.18942787974866e-08 0.2421754728923703 6.189471390885343e-08 0.2629945242020292 \
6.189519371884041e-08 0.2859861135989593 6.189571903710051e-08 0.3113450809673837 6.189624357326454e-08 0.3367514755549041 6.18968408927388e-08 0.3658546932050024 \
6.189760771785889e-08 0.4033613755922033 6.189804620679745e-08 0.4246376380793622 6.189852272037719e-08 0.4473946242989675 6.1898972555967e-08 0.4684360091747882 \
6.189952524015891e-08 0.4936960927629759 6.190022323636421e-08 0.5245486808074998 6.190083763847576e-08 0.5507582774516211 6.190140560897812e-08 0.5741722555225199 \
6.190193586224765e-08 0.5952266004882081 6.190239483162828e-08 0.6128068198589096 6.190297799979196e-08 0.6341908714213341 6.190355115770725e-08 0.6541368834277531 \
6.190414184203183e-08 0.6735006351351156 6.19048105153408e-08 0.6939224431220803 6.190546500048684e-08 0.7123419857223411 6.190621863161068e-08 0.7316435145596337 \
6.190713811134916e-08 0.7524771687756806 6.190780711846397e-08 0.7658582308664672 6.190850268484806e-08 0.7783426900018873 6.19092247217994e-08 0.7898435797332509 \
6.190987150506444e-08 0.7989777190578581 6.191068639837282e-08 0.809051394855074 6.19113442910834e-08 0.8161084932798452 6.191210905557679e-08 0.8232971874420545 \
6.191270558893933e-08 0.8281915934352191 6.191333361209515e-08 0.8327857747397983 6.191396400440495e-08 0.8368636793792511 6.191494962664e-08 0.8423301485602825 \
6.191570538069656e-08 0.8458701801587535 6.191646867113155e-08 0.8489683054605098 6.191727701191702e-08 0.8518111549479527 6.19182659033657e-08 0.8547854532963984 \
6.191900895897926e-08 0.8567085856698495 6.191983163616805e-08 0.8585940601366741 6.192061285622346e-08 0.8601698380186774 6.192141645939077e-08 0.8616111415036141 \
6.192220372763764e-08 0.8628649505886673 6.192339573005228e-08 0.8644986110026872 6.192431835203581e-08 0.8655887935537701 6.192537727977187e-08 0.8666437563732095 \
6.192625037049403e-08 0.8673888282159752 6.192701942776437e-08 0.8679394432393451 6.193277608320059e-08 0.8675354626998435 6.193338473660801e-08 0.8669285211992742 \
6.193434863306702e-08 0.8661637309277684 6.193469702712281e-08 0.8657877651307159 6.193586573629727e-08 0.8648718022682493 6.193650743908326e-08 0.8645495171393598 \
6.193772377924263e-08 0.8636149212264693 6.19382109959973e-08 0.8633315979857124 6.194199575151285e-08 0.8637879096652611 6.194280356059356e-08 0.8644940879742092 \
6.194367673131124e-08 0.8654118536506241 6.194452584851994e-08 0.8664722967159353 6.194539432066304e-08 0.8676408136092975 6.194622079948186e-08 0.8688316482847912 \
6.194706727374805e-08 0.8700680498371385 6.194799373166651e-08 0.8714353201417473 6.194892275173785e-08 0.8727967357236968 6.194989037381619e-08 0.874169309418928 \
6.195089285542904e-08 0.8755268793700145 6.195197578621135e-08 0.8769279254876977 6.195315425889733e-08 0.8783524184654903 6.19543673598333e-08 0.8797057189093218 \
6.195569782069181e-08 0.8810544625232946 6.195714653198217e-08 0.8823882385150326 6.195881426677424e-08 0.8837386794148741 6.196044629863945e-08 0.8848798336526329 \
6.196241359083771e-08 0.8860652157953401 6.196459009443497e-08 0.8871729764751287 6.196686224987683e-08 0.8881691778223457 6.196913575495463e-08 0.8889896378135498 \
6.197108766569527e-08 0.8895771814349003 6.19739721002916e-08 0.8902862350409186 6.197683103663527e-08 0.8908501300162286 6.197991332374811e-08 0.8913157385816455 \
6.199173167452977e-08 0.8922670755128276 6.199405831861158e-08 0.8924600956555456 6.200093951742645e-08 0.8933233934443291 6.200293177288248e-08 0.8936033182227321 \
6.20075969639979e-08 0.8943294235126149 6.200993497358108e-08 0.894763749611499 6.201243532077032e-08 0.8952990768365913 6.201490922327405e-08 0.8959385502707948 \
6.201703531802565e-08 0.8965630758105964 6.201962462149393e-08 0.8973958942958599 6.202204864112875e-08 0.8982427248493853 6.202494045555254e-08 0.8993469797885378 \
6.202745012707316e-08 0.9003588137389537 6.203078857032276e-08 0.9017079510157455 6.20338675437542e-08 0.9029423170929788 6.203706062286895e-08 0.9042497182071535 \
6.203965627950789e-08 0.9052493492427333 6.204166453159599e-08 0.9059572885738179 6.204377276048249e-08 0.9066594295388942 6.204646147741756e-08 0.907478492737931 \
6.204891707008089e-08 0.9081366525620301 6.205128159018321e-08 0.9087089258990763 6.20538761545912e-08 0.9092804446275633 6.205624386982481e-08 0.9097121154337445 \
6.206363630953482e-08 0.9105880439508957 6.206694738543053e-08 0.9108097973553667 6.209063110421058e-08 0.9099572430838525 6.209352499406864e-08 0.9096028008700563 \
6.209963372178471e-08 0.9087795762164674 6.210266478493721e-08 0.9083311497095887 6.210902244290148e-08 0.9073557537429059 6.211291638903372e-08 0.906719613226565 \
6.211628935686607e-08 0.9061475060281556 6.211937491472943e-08 0.9055946669458763 6.212312062927743e-08 0.9048996522446952 6.212648701703491e-08 0.9043394102803256 \
6.213407746224113e-08 0.9034499723753743 6.213795347277731e-08 0.9031904105967781 6.216571770886188e-08 0.9022140906736803 6.216949386877865e-08 0.902100877529562 \
6.220091010054627e-08 0.9011025155537421 6.220754519039343e-08 0.9009020504869808 1.001105508058006e-07 0.8999193627810952 1.001107184817901e-07 0.8998913840591389 \
1.00113467033027e-07 0.8989010293823864 1.001135235739822e-07 0.8988795941121664 1.001147681785108e-07 0.8998357618405769 1.00114847007516e-07 0.9000722811707415 \
1.001150289676646e-07 0.9007374088026997 1.001151313078803e-07 0.9011852075627013 1.001153242840606e-07 0.9021545909398002 1.001154126459433e-07 0.9026487433775175 \
1.001155711571976e-07 0.9036053969378676 1.001156830548625e-07 0.9043311123122415 1.001158239719932e-07 0.9052897461292233 1.001159294051442e-07 0.9060407976354218 \
1.001160422821826e-07 0.9068700067857125 1.001161567140189e-07 0.9077320749581511 1.001162779947925e-07 0.9086625635419388 1.001164070303393e-07 0.9096610759972766 \
1.001165295691991e-07 0.9106054665418637 1.001166539241396e-07 0.9115433813509556 1.001167688242373e-07 0.912370851358936 1.00116872924634e-07 0.9130668181210778 \
1.001169805069058e-07 0.9137127811079708 1.001171480071349e-07 0.914504286313051 1.001176193673982e-07 0.9145217838087505 1.001178173163518e-07 0.9131640269569251 \
1.00117978090595e-07 0.9113346267648944 1.001180663953338e-07 0.910041664336402 1.001181539287613e-07 0.908567258693449 1.001182468203066e-07 0.9067913249607207 \
1.001183202627591e-07 0.9052411278657534 1.001184090098811e-07 0.9032017134587504 1.001185466530742e-07 0.8996915735089056 1.001186589946964e-07 0.8965314120175644 \
1.001187822917175e-07 0.892778172623249 1.001189384963758e-07 0.8876402979533503 1.001190620123612e-07 0.8833010177194197 1.001192323837925e-07 0.8769686903427227 \
1.001193800034192e-07 0.8711968848515086 1.001195318545579e-07 0.8650238565011712 1.001196679836116e-07 0.8593172646418706 1.001198100472282e-07 0.8532105227807962 \
1.00119945331887e-07 0.8472784593397693 1.001200839912582e-07 0.8411010749315838 1.001202312982803e-07 0.8344514077702887 1.001203778651285e-07 0.8277635723525925 \
1.001205399445271e-07 0.8202964899226535 1.001206873111724e-07 0.8134532267615989 1.001208588244699e-07 0.8054479178086997 1.001210422474358e-07 0.7968539002302991 \
1.001212447527221e-07 0.7873346372610658 1.001214564023841e-07 0.7773555108975432 1.001216773929431e-07 0.7669228693561837 1.001219065869701e-07 0.7561055044419139 \
1.001221831069208e-07 0.743046509132553 1.001224685936448e-07 0.7295848836660939 1.001227899085387e-07 0.7144535604611002 1.001230793784593e-07 0.7008559708795014 \
1.001233986483168e-07 0.6858669291494816 1.001237196636871e-07 0.6708097907125149 1.001240610997186e-07 0.654842287100785 1.001244537234067e-07 0.6364912117266992 \
1.001248083179959e-07 0.6199451687359452 1.001251731050783e-07 0.602895395464039 1.001255769217898e-07 0.5840362041416589 1.001259404503566e-07 0.56705803755797 \
1.00126371026893e-07 0.546963725974103 1.001267271887658e-07 0.5303181638661557 1.001271001981656e-07 0.5128834705750704 1.001274423832748e-07 0.4969084729771704 \
1.001277621248385e-07 0.4820272854775881 1.001280798688677e-07 0.4673068400017517 1.001283757203102e-07 0.453709089639897 1.001287037441391e-07 0.4388357619204879 \
1.001290132345767e-07 0.4250513307906954 1.001292997339751e-07 0.412542701771394 1.001296120885152e-07 0.3991541929604193 1.001299021997139e-07 0.3870087322563178 \
1.001302156657333e-07 0.3741657412501236 1.001304930286139e-07 0.3630444214925196 1.001307741261109e-07 0.3519744117192101 1.001310056073636e-07 0.3430374849397334 \
1.001312341747562e-07 0.3343354151638595 1.001314740666601e-07 0.3253394991495989 1.001317318484438e-07 0.3158318026516087 1.001319812183577e-07 0.3067925439309827 \
1.00132239531266e-07 0.297589150170473 1.001324860622872e-07 0.2889540805256016 1.001327733570433e-07 0.2790758510850415 1.001329967361242e-07 0.2715471379396955 \
1.001332175314859e-07 0.2642409610398131 1.001334134053201e-07 0.2578652581015776 1.001336001294005e-07 0.2519000449202701 1.001337713205379e-07 0.2465102462678049 \
1.001339463640633e-07 0.2410522141953559 1.001341093819267e-07 0.236036359124031 1.001342707863681e-07 0.2311389431166576 1.001344246037584e-07 0.2265774065811171 \
1.001345765404798e-07 0.2221477024102725 1.001347307634521e-07 0.2177012931700853 1.001349043990521e-07 0.2127672920349684 1.001350545160933e-07 0.2085590788965803 \
1.001351889678134e-07 0.2048346911951331 1.001353338801522e-07 0.2008962005616911 1.001354954147816e-07 0.1965999354189458 1.001356443031983e-07 0.1927083727438147 \
1.001357885433758e-07 0.1889957157254755 1.001359135867135e-07 0.1858267544518093 1.001360106534918e-07 0.183392498065703 1.001361456478894e-07 0.1800503036180525 \
1.001362551622506e-07 0.1773760505692391 1.001363931377783e-07 0.1740872877198338 1.001365131504134e-07 0.1712726271080235 1.001366300320898e-07 0.1685704901364905 \
1.001367566609351e-07 0.1656849030049582 1.001368926752681e-07 0.1626308514974385 1.001370260617698e-07 0.1596764551685698 1.001371530037036e-07 0.1569158519548911 \
1.001372816217377e-07 0.1541678007478876 1.001373955481781e-07 0.1517740356345986 1.001375058591172e-07 0.149496521787741 1.001376190003597e-07 0.1472133997668396 \
1.001377324794356e-07 0.1449590740078549 1.001378578442209e-07 0.1425075003983929 1.001380036381085e-07 0.1397077962434051 1.001381867800951e-07 0.1362681166668699 \
1.001383353874999e-07 0.1335395672637218 1.001384476393218e-07 0.1315146079855561 1.001385769927547e-07 0.1292194206906994 1.001386705289108e-07 0.1275846423925092 \
1.001387793207205e-07 0.1257099890290588 1.001388730748316e-07 0.1241165438085202 1.001389566824356e-07 0.1227229754719547 1.001390763363005e-07 0.1207568051616409 \
1.001392054252614e-07 0.1186746054627577 1.001393222794969e-07 0.1168252031377112 1.001394533685069e-07 0.1147891811469644 1.001395987235226e-07 0.1125787883659796 \
1.001397641334231e-07 0.110121919024741 1.001399328736703e-07 0.1076798417306999 1.001401257538155e-07 0.1049622523271389 1.001402997319429e-07 0.1025767092705754 \
1.001404879183132e-07 0.1000644866129177 1.001406703194106e-07 0.09769892895340802 1.001408499110243e-07 0.09544952095403336 1.00141026408427e-07 0.09330553315647841 \
1.001412109641775e-07 0.09112768523704891 1.001413962096449e-07 0.08900465024544718 1.001415782810569e-07 0.0869768268327742 1.001417743458045e-07 0.08485812802288394 \
1.001419447462217e-07 0.08306894814141007 1.001421229869927e-07 0.08125105909257219 1.001422986795188e-07 0.07951206376949813 1.001424990800232e-07 0.07758728548656671 \
1.00142695934063e-07 0.07575734486890456 1.001428658684993e-07 0.07422427017287291 1.001430365177502e-07 0.07272580243814712 1.00143219642496e-07 0.07116311580983979 \
1.001434132597429e-07 0.06956233824397716 1.001435948467066e-07 0.06811311716920317 1.00143793421027e-07 0.06657819701521293 1.001439499522991e-07 0.06540254085633944 \
1.001441335227451e-07 0.06406078399206196 1.001443064849856e-07 0.06283331112669251 1.001444719953626e-07 0.06169268945721457 1.001446203314103e-07 0.06069691796619666 \
1.00144757229627e-07 0.05979937680937147 1.00144904867328e-07 0.05885633029244827 1.00145037955006e-07 0.05802735218158511 1.001451614741418e-07 0.05727448785321319 \
1.001452775104291e-07 0.05658054160001152 1.001453911236973e-07 0.05591352504042409 1.001455157451721e-07 0.05519553885869784 1.001456365421113e-07 0.05451306145814139 \
1.001457964858298e-07 0.0536298481755812 1.001459318329126e-07 0.05289991373180127 1.001460321524118e-07 0.05236888834064994 1.001461326223724e-07 0.05184552065910697 \
1.001462315654583e-07 0.05133799434906983 1.001464100700205e-07 0.05044349321929222 1.00146509870119e-07 0.04995513630881745 1.001467100355682e-07 0.04899962929156078 \
1.001468009528507e-07 0.04857581029502876 1.001470077462978e-07 0.04763487432244629 1.001471129764305e-07 0.0471681110353394 1.001473093549224e-07 0.04631787013837765 \
1.001473946332178e-07 0.04595693884580357 1.001475750955807e-07 0.04521002446657041 1.001476502601712e-07 0.04490525014776706 1.001478681175704e-07 0.0440422972058082 \
1.001479516361654e-07 0.04372097365614635 1.001481415712709e-07 0.04300637120866019 1.001482663176105e-07 0.04254845761102347 1.001484515435786e-07 0.0418846242551883 \
1.00148554382137e-07 0.04152415866453074 1.001488438948116e-07 0.04053983903151908 1.001489328164065e-07 0.04024621147044882 1.001492414867604e-07 0.03925784365481538 \
1.001492976457642e-07 0.03908306666491448 1.001496112078656e-07 0.03813491809530275 1.001496671638485e-07 0.037970533835152 1.001499940781642e-07 0.03703805601095747 \
1.00150047341397e-07 0.03689043863681411 1.001503532654854e-07 0.03606517121743442 1.001504534292135e-07 0.0358032254974586 1.001507720449093e-07 0.03499570355391716 \
1.00150861523872e-07 0.03477583942316619 1.001512593644584e-07 0.03383675925705845 1.00151377245794e-07 0.03357186655877694 1.001517892479576e-07 0.03268299960645597 \
1.001519496108504e-07 0.03235094877383871 1.001523206292344e-07 0.03161177976826059 1.001525403826856e-07 0.03119164460703521 1.001529837669187e-07 0.03038142203317581 \
1.001532328105506e-07 0.0299476098095271 1.001537326667002e-07 0.02912178892962563 1.001539515582769e-07 0.02877747133829427 1.001544346720837e-07 0.02805819238630505 \
1.001547234993366e-07 0.02765301209416409 1.001554102473024e-07 0.02674723311374961 1.001556997628567e-07 0.02638861276123805 1.001564757361354e-07 0.02548835782609031 \
1.001566471895258e-07 0.02530065249352256 1.001574332713199e-07 0.02449144648051316 1.001576373003535e-07 0.02429465554580218 1.001587468983159e-07 0.02329883562822865 \
1.00158847813389e-07 0.02321388155873386 1.001600394040859e-07 0.02227529349501467 1.001602443122935e-07 0.0221260927003824 1.001616975083642e-07 0.02113958380755909 \
1.001619324927818e-07 0.02098788030205876 1.001634397606963e-07 0.02004942094855779 1.001637600611106e-07 0.01985604392354444 1.001649742394566e-07 0.01910354072181233 \
1.001654475441282e-07 0.01879991394003632 1.001667486779812e-07 0.01794965119692995 1.001671384705681e-07 0.01770179815419311 1.001685370187326e-07 0.01679702456340363 \
1.001688637688126e-07 0.01658609683275075 1.001699811040698e-07 0.01586843585740347 1.001706897903676e-07 0.01544169959229912 1.001724223763659e-07 0.01449858640399567 \
1.001726718388173e-07 0.01436065672582198 1.001744694357164e-07 0.01337694399212387 1.001748121293817e-07 0.01319104500849105 1.001769884628947e-07 0.01225973435293598 \
1.001772733192796e-07 0.01213579497780986 1.001791721626723e-07 0.01126438850740638 1.001796550251297e-07 0.01103474467122418 1.001819275205547e-07 0.01014901321627989 \
1.00182315058726e-07 0.01002270433864562 1.001849665648853e-07 0.009023867700259034 1.001852627688168e-07 0.00890332747207802 1.001876046069907e-07 0.00793111507746596 \
1.001878581913148e-07 0.007825942613114227 1.001908803610572e-07 0.006881067894167194 1.0019112999456e-07 0.006804700431426973 1.001950078918082e-07 0.005817006850260108 \
1.001952350713843e-07 0.005760637946475626 1.001980461896194e-07 0.00490690852483563 1.00198480606374e-07 0.004760206508803379 1.002010103666519e-07 0.003858115577918713 \
1.002014288631811e-07 0.003712016323791173 1.002044535343089e-07 0.00274875962184498 1.00204733759441e-07 0.002664158024812898 1.00208530584646e-07 0.001697446565651876 \
1.002088849639912e-07 0.001621705150764489 1.002144114789964e-07 0.0006347476112661908 1.002147089634815e-07 0.0005888553763099016 1.002222167274473e-07 -0.0003928413941844093 \
1.00222438401114e-07 -0.0004189941252107796 1.002365307848728e-07 -0.001410461992184868 1.00236889612591e-07 -0.001430649730572865 1.002502372454117e-07 -0.0004514903228812461 \
1.002504646425127e-07 -0.0004111859973536986 1.002559156120651e-07 0.0005614551864591434 1.002561788974843e-07 0.0006110884748384679 1.002608108374914e-07 0.001592952619583714 \
1.002611188696391e-07 0.001665522059460669 1.0026495308288e-07 0.002626457037572999 1.002653373828844e-07 0.002733556882532277 1.002690715761655e-07 0.003682507088408038 \
1.002692734414486e-07 0.00374945551670179 1.002728976935381e-07 0.004734851451646972 1.002730926227528e-07 0.004780391513086043 1.002764798221767e-07 0.005766866152453508 \
1.002766719106971e-07 0.005810149709068801 1.00280887542283e-07 0.006750994364636406 1.002812210794924e-07 0.006821678237255247 1.003059485403023e-07 0.005867117768706426 \
1.003062618172084e-07 0.005806676405157672 1.003108931929807e-07 0.004863125825100585 1.003111650442215e-07 0.004806306550559217 1.003161096881006e-07 0.003825328200913169 \
1.003165761419321e-07 0.003739629632037282 1.003224824058496e-07 0.002770751168227681 1.003227761301588e-07 0.002729631326985271 1.003316213590711e-07 0.001738601807147118 \
1.003318081264262e-07 0.001722695496451883 1.003520369591485e-07 0.0007253105668073048 1.003534715984433e-07 0.0006873447391178559 1.589900000000113e-07 3.130932490801775e-06 \
1.618834078303853e-07 -0.0008819623910157972 1.618836438792338e-07 -0.001161970612476729 1.618841023255621e-07 -0.001847355627596629 1.618843456126973e-07 -0.002293620068582415 \
1.618845958966645e-07 -0.00281405583725217 1.618848467026681e-07 -0.003393671496214343 1.618851595223305e-07 -0.004199192998005251 1.618853977322015e-07 -0.004872003934560885 \
1.618856441826354e-07 -0.005621391842385397 1.618858759271308e-07 -0.006370319304257691 1.618861831122489e-07 -0.007411941938624838 1.618864484061811e-07 -0.008326397880259807 \
1.618866936858075e-07 -0.009131457988769647 1.618870584173626e-07 -0.01007334593757064 1.618872864885395e-07 -0.01033898456945748 1.618876101281819e-07 -0.009994868194499993 \
1.618878105447351e-07 -0.009187286872421443 1.618880453495324e-07 -0.007487931918614563 1.618882264249876e-07 -0.005544847192362645 1.61888332865277e-07 -0.004119573247771668 \
1.618884711514238e-07 -0.001940540768574745 1.618885821773866e-07 7.563183370691832e-05 1.618887027988209e-07 0.002536824544301687 1.618888058640018e-07 0.004857398676819782 \
1.618889445712868e-07 0.008289235792766818 1.618890656805787e-07 0.01156496544863939 1.618892158843802e-07 0.01596809792775087 1.618893975299902e-07 0.02176080367268303 \
1.618895499652095e-07 0.02698454055473338 1.618897261154541e-07 0.03339084366291074 1.618899251156e-07 0.04103368087207344 1.618900947875378e-07 0.04784290449723066 \
1.618902739815137e-07 0.05527749234857952 1.618904343978791e-07 0.06211990493347131 1.618905961918387e-07 0.06916698107316244 1.618907547427193e-07 0.07620053909780501 \
1.618909219353922e-07 0.08372027851346725 1.618910922933183e-07 0.09147114401158042 1.618912717305654e-07 0.0997240648901548 1.618914618530914e-07 0.1085375718081032 \
1.618916610920532e-07 0.1178373860957827 1.618918650693585e-07 0.1274102212870429 1.6189208614423e-07 0.1378300800073513 1.618923318007999e-07 0.1494365474357121 \
1.61892589151043e-07 0.1616443690283554 1.61892871842139e-07 0.1750899465505063 1.618931698935499e-07 0.1892663579759593 1.618935161701216e-07 0.2057792515135755 \
1.618938828852402e-07 0.2232517522030736 1.618942787974866e-07 0.2421754728923703 1.618947139088534e-07 0.2629945242020292 1.618951937188404e-07 0.2859861135989593 \
1.618957190371005e-07 0.3113450809673837 1.618962435732645e-07 0.3367514755549041 1.618968408927388e-07 0.3658546932050024 1.618976077178589e-07 0.4033613755922033 \
1.618980462067974e-07 0.4246376380793622 1.618985227203772e-07 0.4473946242989675 1.61898972555967e-07 0.4684360091747882 1.618995252401589e-07 0.4936960927629759 \
1.619002232363642e-07 0.5245486808074998 1.619008376384758e-07 0.5507582774516211 1.619014056089781e-07 0.5741722555225199 1.619019358622476e-07 0.5952266004882081 \
1.619023948316283e-07 0.6128068198589096 1.619029779997919e-07 0.6341908714213341 1.619035511577072e-07 0.6541368834277531 1.619041418420318e-07 0.6735006351351156 \
1.619048105153408e-07 0.6939224431220803 1.619054650004868e-07 0.7123419857223411 1.619062186316107e-07 0.7316435145596337 1.619071381113491e-07 0.7524771687756806 \
1.619078071184639e-07 0.7658582308664672 1.619085026848481e-07 0.7783426900018873 1.619092247217994e-07 0.7898435797332509 1.619098715050644e-07 0.7989777190578581 \
1.619106863983728e-07 0.809051394855074 1.619113442910834e-07 0.8161084932798452 1.619121090555768e-07 0.8232971874420545 1.619127055889393e-07 0.8281915934352191 \
1.619133336120951e-07 0.8327857747397983 1.619139640044049e-07 0.8368636793792511 1.6191494962664e-07 0.8423301485602825 1.619157053806966e-07 0.8458701801587535 \
1.619164686711315e-07 0.8489683054605098 1.61917277011917e-07 0.8518111549479527 1.619182659033657e-07 0.8547854532963984 1.619190089589793e-07 0.8567085856698495 \
1.61919831636168e-07 0.8585940601366741 1.619206128562235e-07 0.8601698380186774 1.619214164593908e-07 0.8616111415036141 1.619222037276376e-07 0.8628649505886673 \
1.619233957300523e-07 0.8644986110026872 1.619243183520358e-07 0.8655887935537701 1.619253772797719e-07 0.8666437563732095 1.61926250370494e-07 0.8673888282159752 \
1.619270194277644e-07 0.8679394432393451 1.619327760832006e-07 0.8675354626998435 1.61933384736608e-07 0.8669285211992742 1.61934348633067e-07 0.8661637309277684 \
1.619346970271228e-07 0.8657877651307159 1.619358657362973e-07 0.8648718022682493 1.619365074390833e-07 0.8645495171393598 1.619377237792426e-07 0.8636149212264693 \
1.619382109959973e-07 0.8633315979857124 1.619419957515128e-07 0.8637879096652611 1.619428035605935e-07 0.8644940879742092 1.619436767313112e-07 0.8654118536506241 \
1.619445258485199e-07 0.8664722967159353 1.61945394320663e-07 0.8676408136092975 1.619462207994819e-07 0.8688316482847912 1.61947067273748e-07 0.8700680498371385 \
1.619479937316665e-07 0.8714353201417473 1.619489227517378e-07 0.8727967357236968 1.619498903738162e-07 0.874169309418928 1.619508928554291e-07 0.8755268793700145 \
1.619519757862113e-07 0.8769279254876977 1.619531542588973e-07 0.8783524184654903 1.619543673598333e-07 0.8797057189093218 1.619556978206918e-07 0.8810544625232946 \
1.619571465319822e-07 0.8823882385150326 1.619588142667742e-07 0.8837386794148741 1.619604462986394e-07 0.8848798336526329 1.619624135908377e-07 0.8860652157953401 \
1.61964590094435e-07 0.8871729764751287 1.619668622498768e-07 0.8881691778223457 1.619691357549546e-07 0.8889896378135498 1.619710876656952e-07 0.8895771814349003 \
1.619739721002916e-07 0.8902862350409186 1.619768310366353e-07 0.8908501300162286 1.619799133237481e-07 0.8913157385816455 1.619917316745298e-07 0.8922670755128276 \
1.619940583186116e-07 0.8924600956555456 1.620009395174264e-07 0.8933233934443291 1.620029317728825e-07 0.8936033182227321 1.620075969639979e-07 0.8943294235126149 \
1.620099349735811e-07 0.894763749611499 1.620124353207703e-07 0.8952990768365913 1.62014909223274e-07 0.8959385502707948 1.620170353180256e-07 0.8965630758105964 \
1.620196246214939e-07 0.8973958942958599 1.620220486411287e-07 0.8982427248493853 1.620249404555525e-07 0.8993469797885378 1.620274501270731e-07 0.9003588137389537 \
1.620307885703228e-07 0.9017079510157455 1.620338675437542e-07 0.9029423170929788 1.620370606228689e-07 0.9042497182071535 1.620396562795079e-07 0.9052493492427333 \
1.62041664531596e-07 0.9059572885738179 1.620437727604825e-07 0.9066594295388942 1.620464614774175e-07 0.907478492737931 1.620489170700809e-07 0.9081366525620301 \
1.620512815901832e-07 0.9087089258990763 1.620538761545912e-07 0.9092804446275633 1.620562438698248e-07 0.9097121154337445 1.620636363095348e-07 0.9105880439508957 \
1.620669473854305e-07 0.9108097973553667 1.620906311042106e-07 0.9099572430838525 1.620935249940686e-07 0.9096028008700563 1.620996337217847e-07 0.9087795762164674 \
1.621026647849372e-07 0.9083311497095887 1.621090224429015e-07 0.9073557537429059 1.621129163890337e-07 0.906719613226565 1.621162893568661e-07 0.9061475060281556 \
1.621193749147294e-07 0.9055946669458763 1.621231206292774e-07 0.9048996522446952 1.621264870170349e-07 0.9043394102803256 1.621340774622411e-07 0.9034499723753743 \
1.621379534727773e-07 0.9031904105967781 1.621657177088619e-07 0.9022140906736803 1.621694938687787e-07 0.902100877529562 1.622009101005463e-07 0.9011025155537421 \
1.622075451903934e-07 0.9009020504869808 2.001105508058006e-07 0.8999193627810952 2.001107184817901e-07 0.8998913840591389 2.00113467033027e-07 0.8989010293823864 \
2.001135235739822e-07 0.8988795941121664 2.001147681785108e-07 0.8998357618405769 2.00114847007516e-07 0.9000722811707415 2.001150289676646e-07 0.9007374088026997 \
2.001151313078803e-07 0.9011852075627013 2.001153242840606e-07 0.9021545909398002 2.001154126459433e-07 0.9026487433775175 2.001155711571976e-07 0.9036053969378676 \
2.001156830548625e-07 0.9043311123122415 2.001158239719932e-07 0.9052897461292233 2.001159294051442e-07 0.9060407976354218 2.001160422821826e-07 0.9068700067857125 \
2.001161567140189e-07 0.9077320749581511 2.001162779947925e-07 0.9086625635419388 2.001164070303393e-07 0.9096610759972766 2.001165295691991e-07 0.9106054665418637 \
2.001166539241396e-07 0.9115433813509556 2.001167688242373e-07 0.912370851358936 2.00116872924634e-07 0.9130668181210778 2.001169805069058e-07 0.9137127811079708 \
2.001171480071349e-07 0.914504286313051 2.001176193673982e-07 0.9145217838087505 2.001178173163518e-07 0.9131640269569251 2.00117978090595e-07 0.9113346267648944 \
2.001180663953338e-07 0.910041664336402 2.001181539287613e-07 0.908567258693449 2.001182468203066e-07 0.9067913249607207 2.001183202627591e-07 0.9052411278657534 \
2.001184090098811e-07 0.9032017134587504 2.001185466530742e-07 0.8996915735089056 2.001186589946964e-07 0.8965314120175644 2.001187822917175e-07 0.892778172623249 \
2.001189384963758e-07 0.8876402979533503 2.001190620123612e-07 0.8833010177194197 2.001192323837925e-07 0.8769686903427227 2.001193800034192e-07 0.8711968848515086 \
2.001195318545579e-07 0.8650238565011712 2.001196679836116e-07 0.8593172646418706 2.001198100472282e-07 0.8532105227807962 2.00119945331887e-07 0.8472784593397693 \
2.001200839912582e-07 0.8411010749315838 2.001202312982803e-07 0.8344514077702887 2.001203778651285e-07 0.8277635723525925 2.001205399445271e-07 0.8202964899226535 \
2.001206873111724e-07 0.8134532267615989 2.001208588244699e-07 0.8054479178086997 2.001210422474358e-07 0.7968539002302991 2.001212447527221e-07 0.7873346372610658 \
2.001214564023841e-07 0.7773555108975432 2.001216773929431e-07 0.7669228693561837 2.001219065869701e-07 0.7561055044419139 2.001221831069208e-07 0.743046509132553 \
2.001224685936448e-07 0.7295848836660939 2.001227899085387e-07 0.7144535604611002 2.001230793784593e-07 0.7008559708795014 2.001233986483168e-07 0.6858669291494816 \
2.001237196636871e-07 0.6708097907125149 2.001240610997186e-07 0.654842287100785 2.001244537234067e-07 0.6364912117266992 2.001248083179959e-07 0.6199451687359452 \
2.001251731050783e-07 0.602895395464039 2.001255769217898e-07 0.5840362041416589 2.001259404503566e-07 0.56705803755797 2.00126371026893e-07 0.546963725974103 \
2.001267271887658e-07 0.5303181638661557 2.001271001981656e-07 0.5128834705750704 2.001274423832748e-07 0.4969084729771704 2.001277621248385e-07 0.4820272854775881 \
2.001280798688677e-07 0.4673068400017517 2.001283757203102e-07 0.453709089639897 2.001287037441391e-07 0.4388357619204879 2.001290132345767e-07 0.4250513307906954 \
2.001292997339751e-07 0.412542701771394 2.001296120885152e-07 0.3991541929604193 2.001299021997139e-07 0.3870087322563178 2.001302156657333e-07 0.3741657412501236 \
2.001304930286139e-07 0.3630444214925196 2.001307741261109e-07 0.3519744117192101 2.001310056073636e-07 0.3430374849397334 2.001312341747562e-07 0.3343354151638595 \
2.001314740666601e-07 0.3253394991495989 2.001317318484438e-07 0.3158318026516087 2.001319812183577e-07 0.3067925439309827 2.00132239531266e-07 0.297589150170473 \
2.001324860622872e-07 0.2889540805256016 2.001327733570433e-07 0.2790758510850415 2.001329967361242e-07 0.2715471379396955 2.001332175314859e-07 0.2642409610398131 \
2.001334134053201e-07 0.2578652581015776 2.001336001294005e-07 0.2519000449202701 2.001337713205379e-07 0.2465102462678049 2.001339463640633e-07 0.2410522141953559 \
2.001341093819267e-07 0.236036359124031 2.001342707863681e-07 0.2311389431166576 2.001344246037584e-07 0.2265774065811171 2.001345765404798e-07 0.2221477024102725 \
2.001347307634521e-07 0.2177012931700853 2.001349043990521e-07 0.2127672920349684 2.001350545160933e-07 0.2085590788965803 2.001351889678134e-07 0.2048346911951331 \
2.001353338801522e-07 0.2008962005616911 2.001354954147816e-07 0.1965999354189458 2.001356443031983e-07 0.1927083727438147 2.001357885433758e-07 0.1889957157254755 \
2.001359135867135e-07 0.1858267544518093 2.001360106534918e-07 0.183392498065703 2.001361456478894e-07 0.1800503036180525 2.001362551622506e-07 0.1773760505692391 \
2.001363931377783e-07 0.1740872877198338 2.001365131504134e-07 0.1712726271080235 2.001366300320898e-07 0.1685704901364905 2.001367566609351e-07 0.1656849030049582 \
2.001368926752681e-07 0.1626308514974385 2.001370260617698e-07 0.1596764551685698 2.001371530037036e-07 0.1569158519548911 2.001372816217377e-07 0.1541678007478876 \
2.001373955481781e-07 0.1517740356345986 2.001375058591172e-07 0.149496521787741 2.001376190003597e-07 0.1472133997668396 2.001377324794356e-07 0.1449590740078549 \
2.001378578442209e-07 0.1425075003983929 2.001380036381085e-07 0.1397077962434051 2.001381867800951e-07 0.1362681166668699 2.001383353874999e-07 0.1335395672637218 \
2.001384476393218e-07 0.1315146079855561 2.001385769927547e-07 0.1292194206906994 2.001386705289108e-07 0.1275846423925092 2.001387793207205e-07 0.1257099890290588 \
2.001388730748316e-07 0.1241165438085202 2.001389566824356e-07 0.1227229754719547 2.001390763363005e-07 0.1207568051616409 2.001392054252614e-07 0.1186746054627577 \
2.001393222794969e-07 0.1168252031377112 2.001394533685069e-07 0.1147891811469644 2.001395987235226e-07 0.1125787883659796 2.001397641334231e-07 0.110121919024741 \
2.001399328736703e-07 0.1076798417306999 2.001401257538155e-07 0.1049622523271389 2.001402997319429e-07 0.1025767092705754 2.001404879183132e-07 0.1000644866129177 \
2.001406703194106e-07 0.09769892895340802 2.001408499110243e-07 0.09544952095403336 2.00141026408427e-07 0.09330553315647841 2.001412109641775e-07 0.09112768523704891 \
2.001413962096449e-07 0.08900465024544718 2.001415782810569e-07 0.0869768268327742 2.001417743458045e-07 0.08485812802288394 2.001419447462217e-07 0.08306894814141007 \
2.001421229869927e-07 0.08125105909257219 2.001422986795188e-07 0.07951206376949813 2.001424990800232e-07 0.07758728548656671 2.00142695934063e-07 0.07575734486890456 \
2.001428658684993e-07 0.07422427017287291 2.001430365177502e-07 0.07272580243814712 2.00143219642496e-07 0.07116311580983979 2.001434132597429e-07 0.06956233824397716 \
2.001435948467066e-07 0.06811311716920317 2.00143793421027e-07 0.06657819701521293 2.001439499522991e-07 0.06540254085633944 2.001441335227451e-07 0.06406078399206196 \
2.001443064849856e-07 0.06283331112669251 2.001444719953626e-07 0.06169268945721457 2.001446203314103e-07 0.06069691796619666 2.00144757229627e-07 0.05979937680937147 \
2.00144904867328e-07 0.05885633029244827 2.00145037955006e-07 0.05802735218158511 2.001451614741418e-07 0.05727448785321319 2.001452775104291e-07 0.05658054160001152 \
2.001453911236973e-07 0.05591352504042409 2.001455157451721e-07 0.05519553885869784 2.001456365421113e-07 0.05451306145814139 2.001457964858298e-07 0.0536298481755812 \
2.001459318329126e-07 0.05289991373180127 2.001460321524118e-07 0.05236888834064994 2.001461326223724e-07 0.05184552065910697 2.001462315654583e-07 0.05133799434906983 \
2.001464100700205e-07 0.05044349321929222 2.00146509870119e-07 0.04995513630881745 2.001467100355682e-07 0.04899962929156078 2.001468009528507e-07 0.04857581029502876 \
2.001470077462978e-07 0.04763487432244629 2.001471129764305e-07 0.0471681110353394 2.001473093549224e-07 0.04631787013837765 2.001473946332178e-07 0.04595693884580357 \
2.001475750955807e-07 0.04521002446657041 2.001476502601712e-07 0.04490525014776706 2.001478681175704e-07 0.0440422972058082 2.001479516361654e-07 0.04372097365614635 \
2.001481415712709e-07 0.04300637120866019 2.001482663176105e-07 0.04254845761102347 2.001484515435786e-07 0.0418846242551883 2.00148554382137e-07 0.04152415866453074 \
2.001488438948116e-07 0.04053983903151908 2.001489328164065e-07 0.04024621147044882 2.001492414867604e-07 0.03925784365481538 2.001492976457642e-07 0.03908306666491448 \
2.001496112078656e-07 0.03813491809530275 2.001496671638485e-07 0.037970533835152 2.001499940781642e-07 0.03703805601095747 2.00150047341397e-07 0.03689043863681411 \
2.001503532654854e-07 0.03606517121743442 2.001504534292135e-07 0.0358032254974586 2.001507720449093e-07 0.03499570355391716 2.00150861523872e-07 0.03477583942316619 \
2.001512593644584e-07 0.03383675925705845 2.00151377245794e-07 0.03357186655877694 2.001517892479576e-07 0.03268299960645597 2.001519496108504e-07 0.03235094877383871 \
2.001523206292344e-07 0.03161177976826059 2.001525403826856e-07 0.03119164460703521 2.001529837669187e-07 0.03038142203317581 2.001532328105506e-07 0.0299476098095271 \
2.001537326667002e-07 0.02912178892962563 2.001539515582769e-07 0.02877747133829427 2.001544346720837e-07 0.02805819238630505 2.001547234993366e-07 0.02765301209416409 \
2.001554102473024e-07 0.02674723311374961 2.001556997628567e-07 0.02638861276123805 2.001564757361354e-07 0.02548835782609031 2.001566471895258e-07 0.02530065249352256 \
2.001574332713199e-07 0.02449144648051316 2.001576373003535e-07 0.02429465554580218 2.001587468983159e-07 0.02329883562822865 2.00158847813389e-07 0.02321388155873386 \
2.001600394040859e-07 0.02227529349501467 2.001602443122935e-07 0.0221260927003824 2.001616975083642e-07 0.02113958380755909 2.001619324927818e-07 0.02098788030205876 \
2.001634397606963e-07 0.02004942094855779 2.001637600611106e-07 0.01985604392354444 2.001649742394566e-07 0.01910354072181233 2.001654475441282e-07 0.01879991394003632 \
2.001667486779812e-07 0.01794965119692995 2.001671384705681e-07 0.01770179815419311 2.001685370187326e-07 0.01679702456340363 2.001688637688126e-07 0.01658609683275075 \
2.001699811040698e-07 0.01586843585740347 2.001706897903676e-07 0.01544169959229912 2.001724223763659e-07 0.01449858640399567 2.001726718388173e-07 0.01436065672582198 \
2.001744694357164e-07 0.01337694399212387 2.001748121293817e-07 0.01319104500849105 2.001769884628947e-07 0.01225973435293598 2.001772733192796e-07 0.01213579497780986 \
2.001791721626723e-07 0.01126438850740638 2.001796550251297e-07 0.01103474467122418 2.001819275205547e-07 0.01014901321627989 2.00182315058726e-07 0.01002270433864562 \
2.001849665648853e-07 0.009023867700259034 2.001852627688168e-07 0.00890332747207802 2.001876046069907e-07 0.00793111507746596 2.001878581913148e-07 0.007825942613114227 \
2.001908803610572e-07 0.006881067894167194 2.0019112999456e-07 0.006804700431426973 2.001950078918082e-07 0.005817006850260108 2.001952350713843e-07 0.005760637946475626 \
2.001980461896194e-07 0.00490690852483563 2.00198480606374e-07 0.004760206508803379 2.002010103666519e-07 0.003858115577918713 2.002014288631811e-07 0.003712016323791173 \
2.002044535343089e-07 0.00274875962184498 2.00204733759441e-07 0.002664158024812898 2.00208530584646e-07 0.001697446565651876 2.002088849639912e-07 0.001621705150764489 \
2.002144114789964e-07 0.0006347476112661908 2.002147089634815e-07 0.0005888553763099016 2.002222167274473e-07 -0.0003928413941844093 2.00222438401114e-07 -0.0004189941252107796 \
2.002365307848728e-07 -0.001410461992184868 2.00236889612591e-07 -0.001430649730572865 2.002502372454117e-07 -0.0004514903228812461 2.002504646425127e-07 -0.0004111859973536986 \
2.002559156120651e-07 0.0005614551864591434 2.002561788974843e-07 0.0006110884748384679 2.002608108374914e-07 0.001592952619583714 2.002611188696391e-07 0.001665522059460669 \
2.0026495308288e-07 0.002626457037572999 2.002653373828844e-07 0.002733556882532277 2.002690715761655e-07 0.003682507088408038 2.002692734414486e-07 0.00374945551670179 \
2.002728976935381e-07 0.004734851451646972 2.002730926227528e-07 0.004780391513086043 2.002764798221767e-07 0.005766866152453508 2.002766719106971e-07 0.005810149709068801 \
2.00280887542283e-07 0.006750994364636406 2.002812210794924e-07 0.006821678237255247 2.003059485403023e-07 0.005867117768706426 2.003062618172084e-07 0.005806676405157672 \
2.003108931929807e-07 0.004863125825100585 2.003111650442215e-07 0.004806306550559217 2.003161096881006e-07 0.003825328200913169 2.003165761419321e-07 0.003739629632037282 \
2.003224824058496e-07 0.002770751168227681 2.003227761301588e-07 0.002729631326985271 2.003316213590711e-07 0.001738601807147118 2.003318081264262e-07 0.001722695496451883 \
2.003520369591485e-07 0.0007253105668073048 2.003534715984433e-07 0.0006873447391178559 2.589900000000113e-07 3.130932490801775e-06 2.618834078303853e-07 -0.0008819623910157972 \
2.618836438792338e-07 -0.001161970612476729 2.618841023255621e-07 -0.001847355627596629 2.618843456126973e-07 -0.002293620068582415 2.618845958966645e-07 -0.00281405583725217 \
2.618848467026681e-07 -0.003393671496214343 2.618851595223305e-07 -0.004199192998005251 2.618853977322015e-07 -0.004872003934560885 2.618856441826353e-07 -0.005621391842385397 \
2.618858759271308e-07 -0.006370319304257691 2.618861831122489e-07 -0.007411941938624838 2.618864484061811e-07 -0.008326397880259807 2.618866936858075e-07 -0.009131457988769647 \
2.618870584173626e-07 -0.01007334593757064 2.618872864885395e-07 -0.01033898456945748 2.618876101281819e-07 -0.009994868194499993 2.618878105447351e-07 -0.009187286872421443 \
2.618880453495324e-07 -0.007487931918614563 2.618882264249876e-07 -0.005544847192362645 2.61888332865277e-07 -0.004119573247771668 2.618884711514237e-07 -0.001940540768574745 \
2.618885821773866e-07 7.563183370691832e-05 2.618887027988209e-07 0.002536824544301687 2.618888058640017e-07 0.004857398676819782 2.618889445712868e-07 0.008289235792766818 \
2.618890656805787e-07 0.01156496544863939 2.618892158843801e-07 0.01596809792775087 2.618893975299902e-07 0.02176080367268303 2.618895499652095e-07 0.02698454055473338 \
2.618897261154541e-07 0.03339084366291074 2.618899251156e-07 0.04103368087207344 2.618900947875378e-07 0.04784290449723066 2.618902739815137e-07 0.05527749234857952 \
2.618904343978791e-07 0.06211990493347131 2.618905961918387e-07 0.06916698107316244 2.618907547427193e-07 0.07620053909780501 2.618909219353922e-07 0.08372027851346725 \
2.618910922933183e-07 0.09147114401158042 2.618912717305655e-07 0.0997240648901548 2.618914618530914e-07 0.1085375718081032 2.618916610920531e-07 0.1178373860957827 \
2.618918650693585e-07 0.1274102212870429 2.6189208614423e-07 0.1378300800073513 2.618923318007999e-07 0.1494365474357121 2.61892589151043e-07 0.1616443690283554 \
2.61892871842139e-07 0.1750899465505063 2.618931698935499e-07 0.1892663579759593 2.618935161701216e-07 0.2057792515135755 2.618938828852402e-07 0.2232517522030736 \
2.618942787974866e-07 0.2421754728923703 2.618947139088534e-07 0.2629945242020292 2.618951937188404e-07 0.2859861135989593 2.618957190371005e-07 0.3113450809673837 \
2.618962435732645e-07 0.3367514755549041 2.618968408927388e-07 0.3658546932050024 2.618976077178589e-07 0.4033613755922033 2.618980462067975e-07 0.4246376380793622 \
2.618985227203772e-07 0.4473946242989675 2.61898972555967e-07 0.4684360091747882 2.618995252401589e-07 0.4936960927629759 2.619002232363642e-07 0.5245486808074998 \
2.619008376384758e-07 0.5507582774516211 2.619014056089781e-07 0.5741722555225199 2.619019358622476e-07 0.5952266004882081 2.619023948316283e-07 0.6128068198589096 \
2.619029779997919e-07 0.6341908714213341 2.619035511577072e-07 0.6541368834277531 2.619041418420318e-07 0.6735006351351156 2.619048105153408e-07 0.6939224431220803 \
2.619054650004868e-07 0.7123419857223411 2.619062186316106e-07 0.7316435145596337 2.619071381113491e-07 0.7524771687756806 2.619078071184639e-07 0.7658582308664672 \
2.619085026848481e-07 0.7783426900018873 2.619092247217994e-07 0.7898435797332509 2.619098715050644e-07 0.7989777190578581 2.619106863983728e-07 0.809051394855074 \
2.619113442910834e-07 0.8161084932798452 2.619121090555768e-07 0.8232971874420545 2.619127055889393e-07 0.8281915934352191 2.619133336120951e-07 0.8327857747397983 \
2.619139640044049e-07 0.8368636793792511 2.6191494962664e-07 0.8423301485602825 2.619157053806966e-07 0.8458701801587535 2.619164686711315e-07 0.8489683054605098 \
2.61917277011917e-07 0.8518111549479527 2.619182659033657e-07 0.8547854532963984 2.619190089589793e-07 0.8567085856698495 2.61919831636168e-07 0.8585940601366741 \
2.619206128562235e-07 0.8601698380186774 2.619214164593908e-07 0.8616111415036141 2.619222037276376e-07 0.8628649505886673 2.619233957300523e-07 0.8644986110026872 \
2.619243183520358e-07 0.8655887935537701 2.619253772797718e-07 0.8666437563732095 2.61926250370494e-07 0.8673888282159752 2.619270194277643e-07 0.8679394432393451 \
2.619327760832006e-07 0.8675354626998435 2.61933384736608e-07 0.8669285211992742 2.61934348633067e-07 0.8661637309277684 2.619346970271228e-07 0.8657877651307159 \
2.619358657362973e-07 0.8648718022682493 2.619365074390833e-07 0.8645495171393598 2.619377237792426e-07 0.8636149212264693 2.619382109959973e-07 0.8633315979857124 \
2.619419957515128e-07 0.8637879096652611 2.619428035605935e-07 0.8644940879742092 2.619436767313112e-07 0.8654118536506241 2.619445258485199e-07 0.8664722967159353 \
2.61945394320663e-07 0.8676408136092975 2.619462207994818e-07 0.8688316482847912 2.619470672737481e-07 0.8700680498371385 2.619479937316665e-07 0.8714353201417473 \
2.619489227517378e-07 0.8727967357236968 2.619498903738162e-07 0.874169309418928 2.61950892855429e-07 0.8755268793700145 2.619519757862113e-07 0.8769279254876977 \
2.619531542588973e-07 0.8783524184654903 2.619543673598333e-07 0.8797057189093218 2.619556978206918e-07 0.8810544625232946 2.619571465319822e-07 0.8823882385150326 \
2.619588142667742e-07 0.8837386794148741 2.619604462986394e-07 0.8848798336526329 2.619624135908377e-07 0.8860652157953401 2.619645900944349e-07 0.8871729764751287 \
2.619668622498768e-07 0.8881691778223457 2.619691357549546e-07 0.8889896378135498 2.619710876656952e-07 0.8895771814349003 2.619739721002916e-07 0.8902862350409186 \
2.619768310366352e-07 0.8908501300162286 2.619799133237481e-07 0.8913157385816455 2.619917316745298e-07 0.8922670755128276 2.619940583186116e-07 0.8924600956555456 \
2.620009395174264e-07 0.8933233934443291 2.620029317728824e-07 0.8936033182227321 2.620075969639979e-07 0.8943294235126149 2.620099349735811e-07 0.894763749611499 \
2.620124353207703e-07 0.8952990768365913 2.62014909223274e-07 0.8959385502707948 2.620170353180257e-07 0.8965630758105964 2.620196246214939e-07 0.8973958942958599 \
2.620220486411287e-07 0.8982427248493853 2.620249404555525e-07 0.8993469797885378 2.620274501270731e-07 0.9003588137389537 2.620307885703228e-07 0.9017079510157455 \
2.620338675437542e-07 0.9029423170929788 2.620370606228689e-07 0.9042497182071535 2.620396562795079e-07 0.9052493492427333 2.62041664531596e-07 0.9059572885738179 \
2.620437727604825e-07 0.9066594295388942 2.620464614774175e-07 0.907478492737931 2.620489170700809e-07 0.9081366525620301 2.620512815901832e-07 0.9087089258990763 \
2.620538761545912e-07 0.9092804446275633 2.620562438698248e-07 0.9097121154337445 2.620636363095348e-07 0.9105880439508957 2.620669473854305e-07 0.9108097973553667 \
2.620906311042106e-07 0.9099572430838525 2.620935249940686e-07 0.9096028008700563 2.620996337217847e-07 0.9087795762164674 2.621026647849372e-07 0.9083311497095887 \
2.621090224429015e-07 0.9073557537429059 2.621129163890337e-07 0.906719613226565 2.621162893568661e-07 0.9061475060281556 2.621193749147294e-07 0.9055946669458763 \
2.621231206292774e-07 0.9048996522446952 2.621264870170349e-07 0.9043394102803256 2.621340774622411e-07 0.9034499723753743 2.621379534727773e-07 0.9031904105967781 \
2.621657177088619e-07 0.9022140906736803 2.621694938687787e-07 0.902100877529562 2.622009101005463e-07 0.9011025155537421 2.622075451903934e-07 0.9009020504869808 \
3.001105508058006e-07 0.8999193627810952 3.001107184817901e-07 0.8998913840591389 3.00113467033027e-07 0.8989010293823864 3.001135235739822e-07 0.8988795941121664 \
3.001147681785108e-07 0.8998357618405769 3.00114847007516e-07 0.9000722811707415 3.001150289676646e-07 0.9007374088026997 3.001151313078803e-07 0.9011852075627013 \
3.001153242840606e-07 0.9021545909398002 3.001154126459433e-07 0.9026487433775175 3.001155711571976e-07 0.9036053969378676 3.001156830548625e-07 0.9043311123122415 \
3.001158239719932e-07 0.9052897461292233 3.001159294051442e-07 0.9060407976354218 3.001160422821826e-07 0.9068700067857125 3.001161567140189e-07 0.9077320749581511 \
3.001162779947925e-07 0.9086625635419388 3.001164070303393e-07 0.9096610759972766 3.001165295691991e-07 0.9106054665418637 3.001166539241396e-07 0.9115433813509556 \
3.001167688242373e-07 0.912370851358936 3.00116872924634e-07 0.9130668181210778 3.001169805069058e-07 0.9137127811079708 3.001171480071349e-07 0.914504286313051 \
3.001176193673982e-07 0.9145217838087505 3.001178173163518e-07 0.9131640269569251 3.00117978090595e-07 0.9113346267648944 3.001180663953338e-07 0.910041664336402 \
3.001181539287613e-07 0.908567258693449 3.001182468203066e-07 0.9067913249607207 3.001183202627591e-07 0.9052411278657534 3.001184090098811e-07 0.9032017134587504 \
3.001185466530742e-07 0.8996915735089056 3.001186589946964e-07 0.8965314120175644 3.001187822917175e-07 0.892778172623249 3.001189384963758e-07 0.8876402979533503 \
3.001190620123612e-07 0.8833010177194197 3.001192323837925e-07 0.8769686903427227 3.001193800034192e-07 0.8711968848515086 3.001195318545579e-07 0.8650238565011712 \
3.001196679836116e-07 0.8593172646418706 3.001198100472282e-07 0.8532105227807962 3.00119945331887e-07 0.8472784593397693 3.001200839912582e-07 0.8411010749315838 \
3.001202312982803e-07 0.8344514077702887 3.001203778651285e-07 0.8277635723525925 3.001205399445271e-07 0.8202964899226535 3.001206873111724e-07 0.8134532267615989 \
3.001208588244699e-07 0.8054479178086997 3.001210422474358e-07 0.7968539002302991 3.001212447527221e-07 0.7873346372610658 3.001214564023841e-07 0.7773555108975432 \
3.001216773929431e-07 0.7669228693561837 3.001219065869701e-07 0.7561055044419139 3.001221831069208e-07 0.743046509132553 3.001224685936448e-07 0.7295848836660939 \
3.001227899085387e-07 0.7144535604611002 3.001230793784593e-07 0.7008559708795014 3.001233986483168e-07 0.6858669291494816 3.001237196636871e-07 0.6708097907125149 \
3.001240610997186e-07 0.654842287100785 3.001244537234067e-07 0.6364912117266992 3.001248083179959e-07 0.6199451687359452 3.001251731050783e-07 0.602895395464039 \
3.001255769217898e-07 0.5840362041416589 3.001259404503566e-07 0.56705803755797 3.00126371026893e-07 0.546963725974103 3.001267271887658e-07 0.5303181638661557 \
3.001271001981656e-07 0.5128834705750704 3.001274423832748e-07 0.4969084729771704 3.001277621248385e-07 0.4820272854775881 3.001280798688677e-07 0.4673068400017517 \
3.001283757203102e-07 0.453709089639897 3.001287037441391e-07 0.4388357619204879 3.001290132345767e-07 0.4250513307906954 3.001292997339751e-07 0.412542701771394 \
3.001296120885152e-07 0.3991541929604193 3.001299021997139e-07 0.3870087322563178 3.001302156657333e-07 0.3741657412501236 3.001304930286139e-07 0.3630444214925196 \
3.001307741261109e-07 0.3519744117192101 3.001310056073636e-07 0.3430374849397334 3.001312341747562e-07 0.3343354151638595 3.001314740666601e-07 0.3253394991495989 \
3.001317318484438e-07 0.3158318026516087 3.001319812183577e-07 0.3067925439309827 3.00132239531266e-07 0.297589150170473 3.001324860622872e-07 0.2889540805256016 \
3.001327733570433e-07 0.2790758510850415 3.001329967361242e-07 0.2715471379396955 3.001332175314859e-07 0.2642409610398131 3.001334134053201e-07 0.2578652581015776 \
3.001336001294005e-07 0.2519000449202701 3.001337713205379e-07 0.2465102462678049 3.001339463640633e-07 0.2410522141953559 3.001341093819267e-07 0.236036359124031 \
3.001342707863681e-07 0.2311389431166576 3.001344246037584e-07 0.2265774065811171 3.001345765404798e-07 0.2221477024102725 3.001347307634521e-07 0.2177012931700853 \
3.001349043990521e-07 0.2127672920349684 3.001350545160933e-07 0.2085590788965803 3.001351889678134e-07 0.2048346911951331 3.001353338801522e-07 0.2008962005616911 \
3.001354954147816e-07 0.1965999354189458 3.001356443031983e-07 0.1927083727438147 3.001357885433758e-07 0.1889957157254755 3.001359135867135e-07 0.1858267544518093 \
3.001360106534918e-07 0.183392498065703 3.001361456478894e-07 0.1800503036180525 3.001362551622506e-07 0.1773760505692391 3.001363931377783e-07 0.1740872877198338 \
3.001365131504134e-07 0.1712726271080235 3.001366300320898e-07 0.1685704901364905 3.001367566609351e-07 0.1656849030049582 3.001368926752681e-07 0.1626308514974385 \
3.001370260617698e-07 0.1596764551685698 3.001371530037036e-07 0.1569158519548911 3.001372816217377e-07 0.1541678007478876 3.001373955481781e-07 0.1517740356345986 \
3.001375058591172e-07 0.149496521787741 3.001376190003597e-07 0.1472133997668396 3.001377324794356e-07 0.1449590740078549 3.001378578442209e-07 0.1425075003983929 \
3.001380036381085e-07 0.1397077962434051 3.001381867800951e-07 0.1362681166668699 3.001383353874999e-07 0.1335395672637218 3.001384476393218e-07 0.1315146079855561 \
3.001385769927547e-07 0.1292194206906994 3.001386705289108e-07 0.1275846423925092 3.001387793207205e-07 0.1257099890290588 3.001388730748316e-07 0.1241165438085202 \
3.001389566824356e-07 0.1227229754719547 3.001390763363005e-07 0.1207568051616409 3.001392054252614e-07 0.1186746054627577 3.001393222794969e-07 0.1168252031377112 \
3.001394533685069e-07 0.1147891811469644 3.001395987235226e-07 0.1125787883659796 3.001397641334231e-07 0.110121919024741 3.001399328736703e-07 0.1076798417306999 \
3.001401257538155e-07 0.1049622523271389 3.001402997319429e-07 0.1025767092705754 3.001404879183132e-07 0.1000644866129177 3.001406703194106e-07 0.09769892895340802 \
3.001408499110243e-07 0.09544952095403336 3.00141026408427e-07 0.09330553315647841 3.001412109641775e-07 0.09112768523704891 3.001413962096449e-07 0.08900465024544718 \
3.001415782810569e-07 0.0869768268327742 3.001417743458045e-07 0.08485812802288394 3.001419447462217e-07 0.08306894814141007 3.001421229869927e-07 0.08125105909257219 \
3.001422986795188e-07 0.07951206376949813 3.001424990800232e-07 0.07758728548656671 3.00142695934063e-07 0.07575734486890456 3.001428658684993e-07 0.07422427017287291 \
3.001430365177502e-07 0.07272580243814712 3.00143219642496e-07 0.07116311580983979 3.001434132597429e-07 0.06956233824397716 3.001435948467066e-07 0.06811311716920317 \
3.00143793421027e-07 0.06657819701521293 3.001439499522991e-07 0.06540254085633944 3.001441335227451e-07 0.06406078399206196 3.001443064849856e-07 0.06283331112669251 \
3.001444719953626e-07 0.06169268945721457 3.001446203314103e-07 0.06069691796619666 3.00144757229627e-07 0.05979937680937147 3.00144904867328e-07 0.05885633029244827 \
3.00145037955006e-07 0.05802735218158511 3.001451614741418e-07 0.05727448785321319 3.001452775104291e-07 0.05658054160001152 3.001453911236973e-07 0.05591352504042409 \
3.001455157451721e-07 0.05519553885869784 3.001456365421113e-07 0.05451306145814139 3.001457964858298e-07 0.0536298481755812 3.001459318329126e-07 0.05289991373180127 \
3.001460321524118e-07 0.05236888834064994 3.001461326223724e-07 0.05184552065910697 3.001462315654583e-07 0.05133799434906983 3.001464100700205e-07 0.05044349321929222 \
3.00146509870119e-07 0.04995513630881745 3.001467100355682e-07 0.04899962929156078 3.001468009528507e-07 0.04857581029502876 3.001470077462978e-07 0.04763487432244629 \
3.001471129764305e-07 0.0471681110353394 3.001473093549224e-07 0.04631787013837765 3.001473946332178e-07 0.04595693884580357 3.001475750955807e-07 0.04521002446657041 \
3.001476502601712e-07 0.04490525014776706 3.001478681175704e-07 0.0440422972058082 3.001479516361654e-07 0.04372097365614635 3.001481415712709e-07 0.04300637120866019 \
3.001482663176105e-07 0.04254845761102347 3.001484515435786e-07 0.0418846242551883 3.00148554382137e-07 0.04152415866453074 3.001488438948116e-07 0.04053983903151908 \
3.001489328164065e-07 0.04024621147044882 3.001492414867604e-07 0.03925784365481538 3.001492976457642e-07 0.03908306666491448 3.001496112078656e-07 0.03813491809530275 \
3.001496671638485e-07 0.037970533835152 3.001499940781642e-07 0.03703805601095747 3.00150047341397e-07 0.03689043863681411 3.001503532654854e-07 0.03606517121743442 \
3.001504534292135e-07 0.0358032254974586 3.001507720449093e-07 0.03499570355391716 3.00150861523872e-07 0.03477583942316619 3.001512593644584e-07 0.03383675925705845 \
3.00151377245794e-07 0.03357186655877694 3.001517892479576e-07 0.03268299960645597 3.001519496108504e-07 0.03235094877383871 3.001523206292344e-07 0.03161177976826059 \
3.001525403826856e-07 0.03119164460703521 3.001529837669187e-07 0.03038142203317581 3.001532328105506e-07 0.0299476098095271 3.001537326667002e-07 0.02912178892962563 \
3.001539515582769e-07 0.02877747133829427 3.001544346720837e-07 0.02805819238630505 3.001547234993366e-07 0.02765301209416409 3.001554102473024e-07 0.02674723311374961 \
3.001556997628567e-07 0.02638861276123805 3.001564757361354e-07 0.02548835782609031 3.001566471895258e-07 0.02530065249352256 3.001574332713199e-07 0.02449144648051316 \
3.001576373003535e-07 0.02429465554580218 3.001587468983159e-07 0.02329883562822865 3.00158847813389e-07 0.02321388155873386 3.001600394040859e-07 0.02227529349501467 \
3.001602443122935e-07 0.0221260927003824 3.001616975083642e-07 0.02113958380755909 3.001619324927818e-07 0.02098788030205876 3.001634397606963e-07 0.02004942094855779 \
3.001637600611106e-07 0.01985604392354444 3.001649742394566e-07 0.01910354072181233 3.001654475441282e-07 0.01879991394003632 3.001667486779812e-07 0.01794965119692995 \
3.001671384705681e-07 0.01770179815419311 3.001685370187326e-07 0.01679702456340363 3.001688637688126e-07 0.01658609683275075 3.001699811040698e-07 0.01586843585740347 \
3.001706897903676e-07 0.01544169959229912 3.001724223763659e-07 0.01449858640399567 3.001726718388173e-07 0.01436065672582198 3.001744694357164e-07 0.01337694399212387 \
3.001748121293817e-07 0.01319104500849105 3.001769884628947e-07 0.01225973435293598 3.001772733192796e-07 0.01213579497780986 3.001791721626723e-07 0.01126438850740638 \
3.001796550251297e-07 0.01103474467122418 3.001819275205547e-07 0.01014901321627989 3.00182315058726e-07 0.01002270433864562 3.001849665648853e-07 0.009023867700259034 \
3.001852627688168e-07 0.00890332747207802 3.001876046069907e-07 0.00793111507746596 3.001878581913148e-07 0.007825942613114227 3.001908803610572e-07 0.006881067894167194 \
3.0019112999456e-07 0.006804700431426973 3.001950078918082e-07 0.005817006850260108 3.001952350713843e-07 0.005760637946475626 3.001980461896194e-07 0.00490690852483563 \
3.00198480606374e-07 0.004760206508803379 3.002010103666519e-07 0.003858115577918713 3.002014288631811e-07 0.003712016323791173 3.002044535343089e-07 0.00274875962184498 \
3.00204733759441e-07 0.002664158024812898 3.00208530584646e-07 0.001697446565651876 3.002088849639912e-07 0.001621705150764489 3.002144114789964e-07 0.0006347476112661908 \
3.002147089634815e-07 0.0005888553763099016 3.002222167274473e-07 -0.0003928413941844093 3.00222438401114e-07 -0.0004189941252107796 3.002365307848728e-07 -0.001410461992184868 \
3.00236889612591e-07 -0.001430649730572865 3.002502372454117e-07 -0.0004514903228812461 3.002504646425127e-07 -0.0004111859973536986 3.002559156120651e-07 0.0005614551864591434 \
3.002561788974843e-07 0.0006110884748384679 3.002608108374914e-07 0.001592952619583714 3.002611188696391e-07 0.001665522059460669 3.0026495308288e-07 0.002626457037572999 \
3.002653373828844e-07 0.002733556882532277 3.002690715761655e-07 0.003682507088408038 3.002692734414486e-07 0.00374945551670179 3.002728976935381e-07 0.004734851451646972 \
3.002730926227528e-07 0.004780391513086043 3.002764798221767e-07 0.005766866152453508 3.002766719106971e-07 0.005810149709068801 3.00280887542283e-07 0.006750994364636406 \
3.002812210794924e-07 0.006821678237255247 3.003059485403023e-07 0.005867117768706426 3.003062618172084e-07 0.005806676405157672 3.003108931929807e-07 0.004863125825100585 \
3.003111650442215e-07 0.004806306550559217 3.003161096881006e-07 0.003825328200913169 3.003165761419321e-07 0.003739629632037282 3.003224824058496e-07 0.002770751168227681 \
3.003227761301588e-07 0.002729631326985271 3.003316213590711e-07 0.001738601807147118 3.003318081264262e-07 0.001722695496451883 3.003520369591485e-07 0.0007253105668073048 \
3.003534715984433e-07 0.0006873447391178559 3.589900000000113e-07 3.130932490801775e-06 3.618834078303853e-07 -0.0008819623910157972 3.618836438792338e-07 -0.001161970612476729 \
3.618841023255621e-07 -0.001847355627596629 3.618843456126973e-07 -0.002293620068582415 3.618845958966645e-07 -0.00281405583725217 3.618848467026681e-07 -0.003393671496214343 \
3.618851595223305e-07 -0.004199192998005251 3.618853977322015e-07 -0.004872003934560885 3.618856441826353e-07 -0.005621391842385397 3.618858759271308e-07 -0.006370319304257691 \
3.618861831122489e-07 -0.007411941938624838 3.618864484061811e-07 -0.008326397880259807 3.618866936858075e-07 -0.009131457988769647 3.618870584173626e-07 -0.01007334593757064 \
3.618872864885395e-07 -0.01033898456945748 3.618876101281818e-07 -0.009994868194499993 3.618878105447351e-07 -0.009187286872421443 3.618880453495323e-07 -0.007487931918614563 \
3.618882264249876e-07 -0.005544847192362645 3.61888332865277e-07 -0.004119573247771668 3.618884711514237e-07 -0.001940540768574745 3.618885821773866e-07 7.563183370691832e-05 \
3.618887027988209e-07 0.002536824544301687 3.618888058640017e-07 0.004857398676819782 3.618889445712868e-07 0.008289235792766818 3.618890656805787e-07 0.01156496544863939 \
3.618892158843801e-07 0.01596809792775087 3.618893975299902e-07 0.02176080367268303 3.618895499652095e-07 0.02698454055473338 3.618897261154541e-07 0.03339084366291074 \
3.618899251156e-07 0.04103368087207344 3.618900947875378e-07 0.04784290449723066 3.618902739815137e-07 0.05527749234857952 3.618904343978791e-07 0.06211990493347131 \
3.618905961918387e-07 0.06916698107316244 3.618907547427193e-07 0.07620053909780501 3.618909219353922e-07 0.08372027851346725 3.618910922933183e-07 0.09147114401158042 \
3.618912717305655e-07 0.0997240648901548 3.618914618530914e-07 0.1085375718081032 3.618916610920531e-07 0.1178373860957827 3.618918650693585e-07 0.1274102212870429 \
3.6189208614423e-07 0.1378300800073513 3.618923318007999e-07 0.1494365474357121 3.61892589151043e-07 0.1616443690283554 3.61892871842139e-07 0.1750899465505063 \
3.618931698935499e-07 0.1892663579759593 3.618935161701216e-07 0.2057792515135755 3.618938828852402e-07 0.2232517522030736 3.618942787974866e-07 0.2421754728923703 \
3.618947139088534e-07 0.2629945242020292 3.618951937188404e-07 0.2859861135989593 3.618957190371005e-07 0.3113450809673837 3.618962435732645e-07 0.3367514755549041 \
3.618968408927388e-07 0.3658546932050024 3.618976077178589e-07 0.4033613755922033 3.618980462067975e-07 0.4246376380793622 3.618985227203772e-07 0.4473946242989675 \
3.61898972555967e-07 0.4684360091747882 3.618995252401589e-07 0.4936960927629759 3.619002232363642e-07 0.5245486808074998 3.619008376384758e-07 0.5507582774516211 \
3.619014056089781e-07 0.5741722555225199 3.619019358622476e-07 0.5952266004882081 3.619023948316283e-07 0.6128068198589096 3.619029779997919e-07 0.6341908714213341 \
3.619035511577072e-07 0.6541368834277531 3.619041418420318e-07 0.6735006351351156 3.619048105153408e-07 0.6939224431220803 3.619054650004868e-07 0.7123419857223411 \
3.619062186316106e-07 0.7316435145596337 3.619071381113491e-07 0.7524771687756806 3.619078071184639e-07 0.7658582308664672 3.619085026848481e-07 0.7783426900018873 \
3.619092247217994e-07 0.7898435797332509 3.619098715050644e-07 0.7989777190578581 3.619106863983728e-07 0.809051394855074 3.619113442910834e-07 0.8161084932798452 \
3.619121090555768e-07 0.8232971874420545 3.619127055889393e-07 0.8281915934352191 3.619133336120951e-07 0.8327857747397983 3.619139640044049e-07 0.8368636793792511 \
3.6191494962664e-07 0.8423301485602825 3.619157053806966e-07 0.8458701801587535 3.619164686711315e-07 0.8489683054605098 3.61917277011917e-07 0.8518111549479527 \
3.619182659033657e-07 0.8547854532963984 3.619190089589793e-07 0.8567085856698495 3.61919831636168e-07 0.8585940601366741 3.619206128562235e-07 0.8601698380186774 \
3.619214164593908e-07 0.8616111415036141 3.619222037276376e-07 0.8628649505886673 3.619233957300523e-07 0.8644986110026872 3.619243183520358e-07 0.8655887935537701 \
3.619253772797718e-07 0.8666437563732095 3.61926250370494e-07 0.8673888282159752 3.619270194277643e-07 0.8679394432393451 3.619327760832006e-07 0.8675354626998435 \
3.61933384736608e-07 0.8669285211992742 3.61934348633067e-07 0.8661637309277684 3.619346970271228e-07 0.8657877651307159 3.619358657362973e-07 0.8648718022682493 \
3.619365074390833e-07 0.8645495171393598 3.619377237792426e-07 0.8636149212264693 3.619382109959973e-07 0.8633315979857124 3.619419957515128e-07 0.8637879096652611 \
3.619428035605935e-07 0.8644940879742092 3.619436767313112e-07 0.8654118536506241 3.619445258485199e-07 0.8664722967159353 3.61945394320663e-07 0.8676408136092975 \
3.619462207994818e-07 0.8688316482847912 3.619470672737481e-07 0.8700680498371385 3.619479937316665e-07 0.8714353201417473 3.619489227517378e-07 0.8727967357236968 \
3.619498903738162e-07 0.874169309418928 3.61950892855429e-07 0.8755268793700145 3.619519757862113e-07 0.8769279254876977 3.619531542588973e-07 0.8783524184654903 \
3.619543673598333e-07 0.8797057189093218 3.619556978206918e-07 0.8810544625232946 3.619571465319822e-07 0.8823882385150326 3.619588142667742e-07 0.8837386794148741 \
3.619604462986394e-07 0.8848798336526329 3.619624135908377e-07 0.8860652157953401 3.619645900944349e-07 0.8871729764751287 3.619668622498768e-07 0.8881691778223457 \
3.619691357549546e-07 0.8889896378135498 3.619710876656952e-07 0.8895771814349003 3.619739721002916e-07 0.8902862350409186 3.619768310366352e-07 0.8908501300162286 \
3.619799133237481e-07 0.8913157385816455 3.619917316745298e-07 0.8922670755128276 3.619940583186116e-07 0.8924600956555456 3.620009395174264e-07 0.8933233934443291 \
3.620029317728824e-07 0.8936033182227321 3.620075969639979e-07 0.8943294235126149 3.620099349735811e-07 0.894763749611499 3.620124353207703e-07 0.8952990768365913 \
3.62014909223274e-07 0.8959385502707948 3.620170353180257e-07 0.8965630758105964 3.620196246214939e-07 0.8973958942958599 3.620220486411287e-07 0.8982427248493853 \
3.620249404555525e-07 0.8993469797885378 3.620274501270731e-07 0.9003588137389537 3.620307885703228e-07 0.9017079510157455 3.620338675437542e-07 0.9029423170929788 \
3.620370606228689e-07 0.9042497182071535 3.620396562795079e-07 0.9052493492427333 3.62041664531596e-07 0.9059572885738179 3.620437727604825e-07 0.9066594295388942 \
3.620464614774175e-07 0.907478492737931 3.620489170700809e-07 0.9081366525620301 3.620512815901832e-07 0.9087089258990763 3.620538761545912e-07 0.9092804446275633 \
3.620562438698248e-07 0.9097121154337445 3.620636363095348e-07 0.9105880439508957 3.620669473854305e-07 0.9108097973553667 3.620906311042106e-07 0.9099572430838525 \
3.620935249940686e-07 0.9096028008700563 3.620996337217847e-07 0.9087795762164674 3.621026647849372e-07 0.9083311497095887 3.621090224429015e-07 0.9073557537429059 \
3.621129163890337e-07 0.906719613226565 3.62116289356866e-07 0.9061475060281556 3.621193749147294e-07 0.9055946669458763 3.621231206292774e-07 0.9048996522446952 \
3.621264870170349e-07 0.9043394102803256 3.621340774622411e-07 0.9034499723753743 3.621379534727773e-07 0.9031904105967781 3.621657177088619e-07 0.9022140906736803 \
3.621694938687786e-07 0.902100877529562 3.622009101005463e-07 0.9011025155537421 3.622075451903934e-07 0.9009020504869808 4.001105508058006e-07 0.8999193627810952 \
4.001107184817901e-07 0.8998913840591389 4.00113467033027e-07 0.8989010293823864 4.001135235739822e-07 0.8988795941121664 4.001147681785108e-07 0.8998357618405769 \
4.00114847007516e-07 0.9000722811707415 4.001150289676646e-07 0.9007374088026997 4.001151313078803e-07 0.9011852075627013 4.001153242840606e-07 0.9021545909398002 \
4.001154126459433e-07 0.9026487433775175 4.001155711571976e-07 0.9036053969378676 4.001156830548625e-07 0.9043311123122415 4.001158239719932e-07 0.9052897461292233 \
4.001159294051442e-07 0.9060407976354218 4.001160422821826e-07 0.9068700067857125 4.001161567140189e-07 0.9077320749581511 4.001162779947925e-07 0.9086625635419388 \
4.001164070303393e-07 0.9096610759972766 4.001165295691991e-07 0.9106054665418637 4.001166539241396e-07 0.9115433813509556 4.001167688242373e-07 0.912370851358936 \
4.00116872924634e-07 0.9130668181210778 4.001169805069058e-07 0.9137127811079708 4.001171480071349e-07 0.914504286313051 4.001176193673982e-07 0.9145217838087505 \
4.001178173163518e-07 0.9131640269569251 4.00117978090595e-07 0.9113346267648944 4.001180663953338e-07 0.910041664336402 4.001181539287613e-07 0.908567258693449 \
4.001182468203066e-07 0.9067913249607207 4.001183202627591e-07 0.9052411278657534 4.001184090098811e-07 0.9032017134587504 4.001185466530742e-07 0.8996915735089056 \
4.001186589946964e-07 0.8965314120175644 4.001187822917175e-07 0.892778172623249 4.001189384963758e-07 0.8876402979533503 4.001190620123612e-07 0.8833010177194197 \
4.001192323837925e-07 0.8769686903427227 4.001193800034192e-07 0.8711968848515086 4.001195318545579e-07 0.8650238565011712 4.001196679836116e-07 0.8593172646418706 \
4.001198100472282e-07 0.8532105227807962 4.00119945331887e-07 0.8472784593397693 4.001200839912582e-07 0.8411010749315838 4.001202312982803e-07 0.8344514077702887 \
4.001203778651285e-07 0.8277635723525925 4.001205399445271e-07 0.8202964899226535 4.001206873111724e-07 0.8134532267615989 4.001208588244699e-07 0.8054479178086997 \
4.001210422474358e-07 0.7968539002302991 4.001212447527221e-07 0.7873346372610658 4.001214564023841e-07 0.7773555108975432 4.001216773929431e-07 0.7669228693561837 \
4.001219065869701e-07 0.7561055044419139 4.001221831069208e-07 0.743046509132553 4.001224685936448e-07 0.7295848836660939 4.001227899085387e-07 0.7144535604611002 \
4.001230793784593e-07 0.7008559708795014 4.001233986483168e-07 0.6858669291494816 4.001237196636871e-07 0.6708097907125149 4.001240610997186e-07 0.654842287100785 \
4.001244537234067e-07 0.6364912117266992 4.001248083179959e-07 0.6199451687359452 4.001251731050783e-07 0.602895395464039 4.001255769217898e-07 0.5840362041416589 \
4.001259404503566e-07 0.56705803755797 4.00126371026893e-07 0.546963725974103 4.001267271887658e-07 0.5303181638661557 4.001271001981656e-07 0.5128834705750704 \
4.001274423832748e-07 0.4969084729771704 4.001277621248385e-07 0.4820272854775881 4.001280798688677e-07 0.4673068400017517 4.001283757203102e-07 0.453709089639897 \
4.001287037441391e-07 0.4388357619204879 4.001290132345767e-07 0.4250513307906954 4.001292997339751e-07 0.412542701771394 4.001296120885152e-07 0.3991541929604193 \
4.001299021997139e-07 0.3870087322563178 4.001302156657333e-07 0.3741657412501236 4.001304930286139e-07 0.3630444214925196 4.001307741261109e-07 0.3519744117192101 \
4.001310056073636e-07 0.3430374849397334 4.001312341747562e-07 0.3343354151638595 4.001314740666601e-07 0.3253394991495989 4.001317318484438e-07 0.3158318026516087 \
4.001319812183577e-07 0.3067925439309827 4.00132239531266e-07 0.297589150170473 4.001324860622872e-07 0.2889540805256016 4.001327733570433e-07 0.2790758510850415 \
4.001329967361242e-07 0.2715471379396955 4.001332175314859e-07 0.2642409610398131 4.001334134053201e-07 0.2578652581015776 4.001336001294005e-07 0.2519000449202701 \
4.001337713205379e-07 0.2465102462678049 4.001339463640633e-07 0.2410522141953559 4.001341093819267e-07 0.236036359124031 4.001342707863681e-07 0.2311389431166576 \
4.001344246037584e-07 0.2265774065811171 4.001345765404798e-07 0.2221477024102725 4.001347307634521e-07 0.2177012931700853 4.001349043990521e-07 0.2127672920349684 \
4.001350545160933e-07 0.2085590788965803 4.001351889678134e-07 0.2048346911951331 4.001353338801522e-07 0.2008962005616911 4.001354954147816e-07 0.1965999354189458 \
4.001356443031983e-07 0.1927083727438147 4.001357885433758e-07 0.1889957157254755 4.001359135867135e-07 0.1858267544518093 4.001360106534918e-07 0.183392498065703 \
4.001361456478894e-07 0.1800503036180525 4.001362551622506e-07 0.1773760505692391 4.001363931377783e-07 0.1740872877198338 4.001365131504134e-07 0.1712726271080235 \
4.001366300320898e-07 0.1685704901364905 4.001367566609351e-07 0.1656849030049582 4.001368926752681e-07 0.1626308514974385 4.001370260617698e-07 0.1596764551685698 \
4.001371530037036e-07 0.1569158519548911 4.001372816217377e-07 0.1541678007478876 4.001373955481781e-07 0.1517740356345986 4.001375058591172e-07 0.149496521787741 \
4.001376190003597e-07 0.1472133997668396 4.001377324794356e-07 0.1449590740078549 4.001378578442209e-07 0.1425075003983929 4.001380036381085e-07 0.1397077962434051 \
4.001381867800951e-07 0.1362681166668699 4.001383353874999e-07 0.1335395672637218 4.001384476393218e-07 0.1315146079855561 4.001385769927547e-07 0.1292194206906994 \
4.001386705289108e-07 0.1275846423925092 4.001387793207205e-07 0.1257099890290588 4.001388730748316e-07 0.1241165438085202 4.001389566824356e-07 0.1227229754719547 \
4.001390763363005e-07 0.1207568051616409 4.001392054252614e-07 0.1186746054627577 4.001393222794969e-07 0.1168252031377112 4.001394533685069e-07 0.1147891811469644 \
4.001395987235226e-07 0.1125787883659796 4.001397641334231e-07 0.110121919024741 4.001399328736703e-07 0.1076798417306999 4.001401257538155e-07 0.1049622523271389 \
4.001402997319429e-07 0.1025767092705754 4.001404879183132e-07 0.1000644866129177 4.001406703194106e-07 0.09769892895340802 4.001408499110243e-07 0.09544952095403336 \
4.00141026408427e-07 0.09330553315647841 4.001412109641775e-07 0.09112768523704891 4.001413962096449e-07 0.08900465024544718 4.001415782810569e-07 0.0869768268327742 \
4.001417743458045e-07 0.08485812802288394 4.001419447462217e-07 0.08306894814141007 4.001421229869927e-07 0.08125105909257219 4.001422986795188e-07 0.07951206376949813 \
4.001424990800232e-07 0.07758728548656671 4.00142695934063e-07 0.07575734486890456 4.001428658684993e-07 0.07422427017287291 4.001430365177502e-07 0.07272580243814712 \
4.00143219642496e-07 0.07116311580983979 4.001434132597429e-07 0.06956233824397716 4.001435948467066e-07 0.06811311716920317 4.00143793421027e-07 0.06657819701521293 \
4.001439499522991e-07 0.06540254085633944 4.001441335227451e-07 0.06406078399206196 4.001443064849856e-07 0.06283331112669251 4.001444719953626e-07 0.06169268945721457 \
4.001446203314103e-07 0.06069691796619666 4.00144757229627e-07 0.05979937680937147 4.00144904867328e-07 0.05885633029244827 4.00145037955006e-07 0.05802735218158511 \
4.001451614741418e-07 0.05727448785321319 4.001452775104291e-07 0.05658054160001152 4.001453911236973e-07 0.05591352504042409 4.001455157451721e-07 0.05519553885869784 \
4.001456365421113e-07 0.05451306145814139 4.001457964858298e-07 0.0536298481755812 4.001459318329126e-07 0.05289991373180127 4.001460321524118e-07 0.05236888834064994 \
4.001461326223724e-07 0.05184552065910697 4.001462315654583e-07 0.05133799434906983 4.001464100700205e-07 0.05044349321929222 4.00146509870119e-07 0.04995513630881745 \
4.001467100355682e-07 0.04899962929156078 4.001468009528507e-07 0.04857581029502876 4.001470077462978e-07 0.04763487432244629 4.001471129764305e-07 0.0471681110353394 \
4.001473093549224e-07 0.04631787013837765 4.001473946332178e-07 0.04595693884580357 4.001475750955807e-07 0.04521002446657041 4.001476502601712e-07 0.04490525014776706 \
4.001478681175704e-07 0.0440422972058082 4.001479516361654e-07 0.04372097365614635 4.001481415712709e-07 0.04300637120866019 4.001482663176105e-07 0.04254845761102347 \
4.001484515435786e-07 0.0418846242551883 4.00148554382137e-07 0.04152415866453074 4.001488438948116e-07 0.04053983903151908 4.001489328164065e-07 0.04024621147044882 \
4.001492414867604e-07 0.03925784365481538 4.001492976457642e-07 0.03908306666491448 4.001496112078656e-07 0.03813491809530275 4.001496671638485e-07 0.037970533835152 \
4.001499940781642e-07 0.03703805601095747 4.00150047341397e-07 0.03689043863681411 4.001503532654854e-07 0.03606517121743442 4.001504534292135e-07 0.0358032254974586 \
4.001507720449093e-07 0.03499570355391716 4.00150861523872e-07 0.03477583942316619 4.001512593644584e-07 0.03383675925705845 4.00151377245794e-07 0.03357186655877694 \
4.001517892479576e-07 0.03268299960645597 4.001519496108504e-07 0.03235094877383871 4.001523206292344e-07 0.03161177976826059 4.001525403826856e-07 0.03119164460703521 \
4.001529837669187e-07 0.03038142203317581 4.001532328105506e-07 0.0299476098095271 4.001537326667002e-07 0.02912178892962563 4.001539515582769e-07 0.02877747133829427 \
4.001544346720837e-07 0.02805819238630505 4.001547234993366e-07 0.02765301209416409 4.001554102473024e-07 0.02674723311374961 4.001556997628567e-07 0.02638861276123805 \
4.001564757361354e-07 0.02548835782609031 4.001566471895258e-07 0.02530065249352256 4.001574332713199e-07 0.02449144648051316 4.001576373003535e-07 0.02429465554580218 \
4.001587468983159e-07 0.02329883562822865 4.00158847813389e-07 0.02321388155873386 4.001600394040859e-07 0.02227529349501467 4.001602443122935e-07 0.0221260927003824 \
4.001616975083642e-07 0.02113958380755909 4.001619324927818e-07 0.02098788030205876 4.001634397606963e-07 0.02004942094855779 4.001637600611106e-07 0.01985604392354444 \
4.001649742394566e-07 0.01910354072181233 4.001654475441282e-07 0.01879991394003632 4.001667486779812e-07 0.01794965119692995 4.001671384705681e-07 0.01770179815419311 \
4.001685370187326e-07 0.01679702456340363 4.001688637688126e-07 0.01658609683275075 4.001699811040698e-07 0.01586843585740347 4.001706897903676e-07 0.01544169959229912 \
4.001724223763659e-07 0.01449858640399567 4.001726718388173e-07 0.01436065672582198 4.001744694357164e-07 0.01337694399212387 4.001748121293817e-07 0.01319104500849105 \
4.001769884628947e-07 0.01225973435293598 4.001772733192796e-07 0.01213579497780986 4.001791721626723e-07 0.01126438850740638 4.001796550251297e-07 0.01103474467122418 \
4.001819275205547e-07 0.01014901321627989 4.00182315058726e-07 0.01002270433864562 4.001849665648853e-07 0.009023867700259034 4.001852627688168e-07 0.00890332747207802 \
4.001876046069907e-07 0.00793111507746596 4.001878581913148e-07 0.007825942613114227 4.001908803610572e-07 0.006881067894167194 4.0019112999456e-07 0.006804700431426973 \
4.001950078918082e-07 0.005817006850260108 4.001952350713843e-07 0.005760637946475626 4.001980461896194e-07 0.00490690852483563 4.00198480606374e-07 0.004760206508803379 \
4.002010103666519e-07 0.003858115577918713 4.002014288631811e-07 0.003712016323791173 4.002044535343089e-07 0.00274875962184498 4.00204733759441e-07 0.002664158024812898 \
4.00208530584646e-07 0.001697446565651876 4.002088849639912e-07 0.001621705150764489 4.002144114789964e-07 0.0006347476112661908 4.002147089634815e-07 0.0005888553763099016 \
4.002222167274473e-07 -0.0003928413941844093 4.00222438401114e-07 -0.0004189941252107796 4.002365307848728e-07 -0.001410461992184868 4.00236889612591e-07 -0.001430649730572865 \
4.002502372454117e-07 -0.0004514903228812461 4.002504646425127e-07 -0.0004111859973536986 4.002559156120651e-07 0.0005614551864591434 4.002561788974843e-07 0.0006110884748384679 \
4.002608108374914e-07 0.001592952619583714 4.002611188696391e-07 0.001665522059460669 4.0026495308288e-07 0.002626457037572999 4.002653373828844e-07 0.002733556882532277 \
4.002690715761655e-07 0.003682507088408038 4.002692734414486e-07 0.00374945551670179 4.002728976935381e-07 0.004734851451646972 4.002730926227528e-07 0.004780391513086043 \
4.002764798221767e-07 0.005766866152453508 4.002766719106971e-07 0.005810149709068801 4.00280887542283e-07 0.006750994364636406 4.002812210794924e-07 0.006821678237255247 \
4.003059485403023e-07 0.005867117768706426 4.003062618172084e-07 0.005806676405157672 4.003108931929807e-07 0.004863125825100585 4.003111650442215e-07 0.004806306550559217 \
4.003161096881006e-07 0.003825328200913169 4.003165761419321e-07 0.003739629632037282 4.003224824058496e-07 0.002770751168227681 4.003227761301588e-07 0.002729631326985271 \
4.003316213590711e-07 0.001738601807147118 4.003318081264262e-07 0.001722695496451883 4.003520369591485e-07 0.0007253105668073048 4.003534715984433e-07 0.0006873447391178559 \
4.589900000000113e-07 3.130932490801775e-06 4.618834078303853e-07 -0.0008819623910157972 4.618836438792338e-07 -0.001161970612476729 4.618841023255621e-07 -0.001847355627596629 \
4.618843456126973e-07 -0.002293620068582415 4.618845958966645e-07 -0.00281405583725217 4.618848467026681e-07 -0.003393671496214343 4.618851595223305e-07 -0.004199192998005251 \
4.618853977322015e-07 -0.004872003934560885 4.618856441826353e-07 -0.005621391842385397 4.618858759271308e-07 -0.006370319304257691 4.618861831122489e-07 -0.007411941938624838 \
4.618864484061811e-07 -0.008326397880259807 4.618866936858075e-07 -0.009131457988769647 4.618870584173626e-07 -0.01007334593757064 4.618872864885395e-07 -0.01033898456945748 \
4.618876101281818e-07 -0.009994868194499993 4.618878105447351e-07 -0.009187286872421443 4.618880453495323e-07 -0.007487931918614563 4.618882264249876e-07 -0.005544847192362645 \
4.61888332865277e-07 -0.004119573247771668 4.618884711514237e-07 -0.001940540768574745 4.618885821773865e-07 7.563183370691832e-05 4.618887027988209e-07 0.002536824544301687 \
4.618888058640017e-07 0.004857398676819782 4.618889445712868e-07 0.008289235792766818 4.618890656805787e-07 0.01156496544863939 4.618892158843801e-07 0.01596809792775087 \
4.618893975299902e-07 0.02176080367268303 4.618895499652095e-07 0.02698454055473338 4.618897261154541e-07 0.03339084366291074 4.618899251156e-07 0.04103368087207344 \
4.618900947875378e-07 0.04784290449723066 4.618902739815137e-07 0.05527749234857952 4.618904343978791e-07 0.06211990493347131 4.618905961918387e-07 0.06916698107316244 \
4.618907547427192e-07 0.07620053909780501 4.618909219353922e-07 0.08372027851346725 4.618910922933183e-07 0.09147114401158042 4.618912717305655e-07 0.0997240648901548 \
4.618914618530914e-07 0.1085375718081032 4.618916610920531e-07 0.1178373860957827 4.618918650693585e-07 0.1274102212870429 4.6189208614423e-07 0.1378300800073513 \
4.618923318007999e-07 0.1494365474357121 4.61892589151043e-07 0.1616443690283554 4.61892871842139e-07 0.1750899465505063 4.618931698935498e-07 0.1892663579759593 \
4.618935161701216e-07 0.2057792515135755 4.618938828852402e-07 0.2232517522030736 4.618942787974866e-07 0.2421754728923703 4.618947139088534e-07 0.2629945242020292 \
4.618951937188404e-07 0.2859861135989593 4.618957190371005e-07 0.3113450809673837 4.618962435732645e-07 0.3367514755549041 4.618968408927388e-07 0.3658546932050024 \
4.618976077178589e-07 0.4033613755922033 4.618980462067975e-07 0.4246376380793622 4.618985227203772e-07 0.4473946242989675 4.61898972555967e-07 0.4684360091747882 \
4.618995252401589e-07 0.4936960927629759 4.619002232363642e-07 0.5245486808074998 4.619008376384757e-07 0.5507582774516211 4.619014056089781e-07 0.5741722555225199 \
4.619019358622476e-07 0.5952266004882081 4.619023948316283e-07 0.6128068198589096 4.619029779997919e-07 0.6341908714213341 4.619035511577072e-07 0.6541368834277531 \
4.619041418420318e-07 0.6735006351351156 4.619048105153408e-07 0.6939224431220803 4.619054650004868e-07 0.7123419857223411 4.619062186316106e-07 0.7316435145596337 \
4.619071381113491e-07 0.7524771687756806 4.619078071184639e-07 0.7658582308664672 4.619085026848481e-07 0.7783426900018873 4.619092247217994e-07 0.7898435797332509 \
4.619098715050644e-07 0.7989777190578581 4.619106863983728e-07 0.809051394855074 4.619113442910834e-07 0.8161084932798452 4.619121090555768e-07 0.8232971874420545 \
4.619127055889393e-07 0.8281915934352191 4.619133336120951e-07 0.8327857747397983 4.619139640044049e-07 0.8368636793792511 4.6191494962664e-07 0.8423301485602825 \
4.619157053806966e-07 0.8458701801587535 4.619164686711315e-07 0.8489683054605098 4.61917277011917e-07 0.8518111549479527 4.619182659033657e-07 0.8547854532963984 \
4.619190089589793e-07 0.8567085856698495 4.61919831636168e-07 0.8585940601366741 4.619206128562235e-07 0.8601698380186774 4.619214164593908e-07 0.8616111415036141 \
4.619222037276376e-07 0.8628649505886673 4.619233957300523e-07 0.8644986110026872 4.619243183520358e-07 0.8655887935537701 4.619253772797718e-07 0.8666437563732095 \
4.61926250370494e-07 0.8673888282159752 4.619270194277643e-07 0.8679394432393451 4.619327760832006e-07 0.8675354626998435 4.61933384736608e-07 0.8669285211992742 \
4.61934348633067e-07 0.8661637309277684 4.619346970271228e-07 0.8657877651307159 4.619358657362973e-07 0.8648718022682493 4.619365074390832e-07 0.8645495171393598 \
4.619377237792426e-07 0.8636149212264693 4.619382109959973e-07 0.8633315979857124 4.619419957515128e-07 0.8637879096652611 4.619428035605935e-07 0.8644940879742092 \
4.619436767313112e-07 0.8654118536506241 4.619445258485199e-07 0.8664722967159353 4.61945394320663e-07 0.8676408136092975 4.619462207994818e-07 0.8688316482847912 \
4.619470672737481e-07 0.8700680498371385 4.619479937316665e-07 0.8714353201417473 4.619489227517378e-07 0.8727967357236968 4.619498903738162e-07 0.874169309418928 \
4.61950892855429e-07 0.8755268793700145 4.619519757862113e-07 0.8769279254876977 4.619531542588973e-07 0.8783524184654903 4.619543673598333e-07 0.8797057189093218 \
4.619556978206918e-07 0.8810544625232946 4.619571465319822e-07 0.8823882385150326 4.619588142667742e-07 0.8837386794148741 4.619604462986394e-07 0.8848798336526329 \
4.619624135908377e-07 0.8860652157953401 4.619645900944349e-07 0.8871729764751287 4.619668622498768e-07 0.8881691778223457 4.619691357549546e-07 0.8889896378135498 \
4.619710876656952e-07 0.8895771814349003 4.619739721002916e-07 0.8902862350409186 4.619768310366352e-07 0.8908501300162286 4.619799133237481e-07 0.8913157385816455 \
4.619917316745298e-07 0.8922670755128276 4.619940583186116e-07 0.8924600956555456 4.620009395174264e-07 0.8933233934443291 4.620029317728824e-07 0.8936033182227321 \
4.620075969639979e-07 0.8943294235126149 4.620099349735811e-07 0.894763749611499 4.620124353207703e-07 0.8952990768365913 4.62014909223274e-07 0.8959385502707948 \
4.620170353180257e-07 0.8965630758105964 4.620196246214939e-07 0.8973958942958599 4.620220486411287e-07 0.8982427248493853 4.620249404555525e-07 0.8993469797885378 \
4.620274501270731e-07 0.9003588137389537 4.620307885703228e-07 0.9017079510157455 4.620338675437542e-07 0.9029423170929788 4.620370606228689e-07 0.9042497182071535 \
4.620396562795079e-07 0.9052493492427333 4.62041664531596e-07 0.9059572885738179 4.620437727604825e-07 0.9066594295388942 4.620464614774175e-07 0.907478492737931 \
4.620489170700809e-07 0.9081366525620301 4.620512815901832e-07 0.9087089258990763 4.620538761545912e-07 0.9092804446275633 4.620562438698248e-07 0.9097121154337445 \
4.620636363095348e-07 0.9105880439508957 4.620669473854305e-07 0.9108097973553667 4.620906311042106e-07 0.9099572430838525 4.620935249940686e-07 0.9096028008700563 \
4.620996337217847e-07 0.9087795762164674 4.621026647849372e-07 0.9083311497095887 4.621090224429015e-07 0.9073557537429059 4.621129163890337e-07 0.906719613226565 \
4.62116289356866e-07 0.9061475060281556 4.621193749147294e-07 0.9055946669458763 4.621231206292774e-07 0.9048996522446952 4.621264870170349e-07 0.9043394102803256 \
4.621340774622411e-07 0.9034499723753743 4.621379534727773e-07 0.9031904105967781 4.621657177088619e-07 0.9022140906736803 4.621694938687786e-07 0.902100877529562 \
4.622009101005463e-07 0.9011025155537421 4.622075451903934e-07 0.9009020504869808 5.001105508058006e-07 0.8999193627810952 5.001107184817901e-07 0.8998913840591389 \
5.00113467033027e-07 0.8989010293823864 5.001135235739822e-07 0.8988795941121664 5.001147681785108e-07 0.8998357618405769 5.00114847007516e-07 0.9000722811707415 \
5.001150289676646e-07 0.9007374088026997 5.001151313078803e-07 0.9011852075627013 5.001153242840605e-07 0.9021545909398002 5.001154126459433e-07 0.9026487433775175 \
5.001155711571976e-07 0.9036053969378676 5.001156830548624e-07 0.9043311123122415 5.001158239719932e-07 0.9052897461292233 5.001159294051442e-07 0.9060407976354218 \
5.001160422821826e-07 0.9068700067857125 5.001161567140189e-07 0.9077320749581511 5.001162779947925e-07 0.9086625635419388 5.001164070303392e-07 0.9096610759972766 \
5.001165295691991e-07 0.9106054665418637 5.001166539241396e-07 0.9115433813509556 5.001167688242373e-07 0.912370851358936 5.00116872924634e-07 0.9130668181210778 \
