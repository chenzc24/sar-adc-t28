1.414265778963989e-06 0.8973708307079206 1.414265880140003e-06 0.8961049472956977 1.414265963084475e-06 0.8950067229086057 1.414266071529892e-06 0.8934921260891034 \
1.41426617999385e-06 0.8918872687155874 1.414266275049989e-06 0.8904106867557802 1.414266395922641e-06 0.8884444419111864 1.414266516699262e-06 0.8863849482818795 \
1.414266629744433e-06 0.8843763393508186 1.414266732915182e-06 0.8824794505619851 1.414266818515338e-06 0.8808620855018965 1.414266892989399e-06 0.8794251273161163 \
1.414266987312942e-06 0.8775673968166831 1.414267075773858e-06 0.8757888800524039 1.414267154846869e-06 0.8741711975775893 1.414267248834224e-06 0.872216793437976 \
1.414267330179529e-06 0.8704993514258973 1.414267425093555e-06 0.8684673705816817 1.414267518136275e-06 0.8664480751909672 1.414267614922069e-06 0.8643215060814092 \
1.414267738217441e-06 0.8615778533848952 1.414267851664452e-06 0.859022019682563 1.414267977516491e-06 0.8561558571929792 1.414268100844635e-06 0.8533196845306243 \
1.414268230022926e-06 0.850323637950593 1.414268370619783e-06 0.8470370034914 1.414268479399504e-06 0.8444782910716596 1.414268614459257e-06 0.8412850455921466 \
1.414268724119566e-06 0.8386804253780991 1.414268853299345e-06 0.8356002443501571 1.414268979483175e-06 0.8325812421138936 1.41426910657353e-06 0.8295317031556502 \
1.414269235595804e-06 0.826427745883674 1.414269344676045e-06 0.8237985689995477 1.414269484526701e-06 0.8204223029647078 1.414269623954893e-06 0.8170507778356514 \
1.414269756708524e-06 0.8138366863616762 1.414269886777199e-06 0.8106848159989707 1.414270010472645e-06 0.8076853837479523 1.414270147427035e-06 0.8043627031572629 \
1.414270261138882e-06 0.8016030849198694 1.414270388615922e-06 0.7985086235398901 1.414270499416994e-06 0.7958187897651571 1.414270618603452e-06 0.7929254985494992 \
1.414270731982508e-06 0.7901733724735396 1.414270866292901e-06 0.7869138859547327 1.414270973387169e-06 0.7843152933129034 1.414271089404311e-06 0.7815009627552112 \
1.414271218595275e-06 0.778367508739124 1.41427131620771e-06 0.7760002683782802 1.414271421787151e-06 0.773440790716327 1.41427153046932e-06 0.7708069008430674 \
1.414271632885583e-06 0.7683258101021144 1.414271726279241e-06 0.7660641808432364 1.414271845835017e-06 0.7631702213567544 1.414271938307379e-06 0.7609327305817616 \
1.414272030945494e-06 0.7586922094322426 1.414272129370309e-06 0.7563124992069843 1.414272237347961e-06 0.7537030947613649 1.414272333616474e-06 0.7513778334636231 \
1.414272419872877e-06 0.7492952979736797 1.414272522736666e-06 0.7468128004450286 1.414272601580994e-06 0.744910856519283 1.414272702387036e-06 0.7424801602439853 \
1.414272836915276e-06 0.7392377693660663 1.414272974140136e-06 0.7359316755186537 1.414273117619987e-06 0.7324773442723981 1.414273266044177e-06 0.7289066083419234 \
1.414273409305472e-06 0.7254625447335662 1.414273549382451e-06 0.7220977259655398 1.414273705808317e-06 0.7183435968963056 1.414273830210067e-06 0.715360858370426 \
1.414273951271848e-06 0.7124600029613375 1.41427410478411e-06 0.7087850045121084 1.414274239566055e-06 0.7055614325718365 1.414274365665088e-06 0.7025479112911024 \
1.414274508839371e-06 0.6991289103945657 1.414274628921163e-06 0.6962626602560111 1.414274758155491e-06 0.6931807499479741 1.414274864640539e-06 0.6906432840523983 \
1.414274976916361e-06 0.6879696524977363 1.414275073251648e-06 0.6856773754336868 1.41427517606134e-06 0.683232326200841 1.414275270865193e-06 0.6809792012818872 \
1.414275376187123e-06 0.6784784437814733 1.414275484625777e-06 0.6759058899658261 1.414275583635057e-06 0.673558569590366 1.41427570039165e-06 0.6707929011939652 \
1.414275808476928e-06 0.6682347329991606 1.414275918483136e-06 0.6656332609774134 1.414276004570978e-06 0.6635992664604092 1.414276134166118e-06 0.6605400273835189 \
1.414276226767366e-06 0.6583552307294462 1.414276322555092e-06 0.6560965362104854 1.414276407507078e-06 0.6540950852804182 1.414276526801602e-06 0.6512869789851043 \
1.41427661407154e-06 0.6492343850333612 1.414276704778561e-06 0.6471030993779646 1.414276805943536e-06 0.6447280068361273 1.414276885774359e-06 0.6428551652550211 \
1.414276974560194e-06 0.6407732405330839 1.41427705225042e-06 0.6389536101386547 1.414277114019368e-06 0.6375081226244841 1.414277177784013e-06 0.6360167668935747 \
1.414277241018233e-06 0.634538653569437 1.414277280258806e-06 0.6336218002627473 1.414277320897828e-06 0.6326726453797233 1.414277400982362e-06 0.6308039353694699 \
1.414277470886542e-06 0.6291742390428672 1.414277521523257e-06 0.6279942052995945 1.414277560272899e-06 0.6270914175114127 1.414277599267879e-06 0.6261832343283663 \
1.414277643882627e-06 0.6251445623164014 1.414277686739083e-06 0.6241478292286105 1.414277737053687e-06 0.6229782634938205 1.414277788990864e-06 0.6217719122409077 \
1.414277874058449e-06 0.6197972300178722 1.414277934038866e-06 0.6184052992407258 1.414278023826075e-06 0.61632338076978 1.414278100290156e-06 0.6145529519516876 \
1.414278179854447e-06 0.6127119801362371 1.414278260891059e-06 0.6108383709630588 1.414278350105381e-06 0.6087775861620425 1.414278440965394e-06 0.6066826282541496 \
1.414278528184102e-06 0.6046739453334793 1.414278621957293e-06 0.6025158549334848 1.414278723642756e-06 0.6001788642681311 1.414278823240848e-06 0.5978941858483342 \
1.414278935095889e-06 0.5953317151711254 1.414279051129026e-06 0.5926772450523136 1.414279172750132e-06 0.5899020947998995 1.414279277133946e-06 0.5875236635596754 \
1.414279421924166e-06 0.5842296531729801 1.414279534584126e-06 0.5816734289694181 1.414279643596094e-06 0.5792035939892568 1.414279736075537e-06 0.5771100174076607 \
1.414279829526176e-06 0.5749994714793375 1.41427992185204e-06 0.5729181236728181 1.414279994438741e-06 0.571283073141143 1.414280050392967e-06 0.5700232888304386 \
1.414280111461248e-06 0.5686498830286455 1.414280209950764e-06 0.5664400707212188 1.414280273162208e-06 0.5650238531380825 1.414280333588177e-06 0.5636708824310654 \
1.41428041053656e-06 0.5619492451093103 1.414280473695101e-06 0.5605380106414651 1.41428056200871e-06 0.558569506627369 1.414280633210033e-06 0.5569845302974165 \
1.414280719745787e-06 0.555060151797141 1.41428084109856e-06 0.5523665438352664 1.414280969027808e-06 0.5495364947125975 1.414281067158439e-06 0.5473694328713704 \
1.414281180282434e-06 0.5448752016832871 1.414281282350254e-06 0.5426314425864434 1.414281401299124e-06 0.5400217272291628 1.414281504386832e-06 0.5377630705755105 \
1.414281618593986e-06 0.5352670017334624 1.414281732009658e-06 0.532794946211756 1.414281859080713e-06 0.5300302694710822 1.414281982900802e-06 0.5273426867079006 \
1.414282127689607e-06 0.5242103332418484 1.41428226351311e-06 0.5212782585303676 1.414282418567968e-06 0.5179428401013338 1.414282579419853e-06 0.5144913885072363 \
1.4142827581493e-06 0.5106699876709851 1.41428294832834e-06 0.5066200804011861 1.414283158230362e-06 0.5021665212646098 1.414283386936347e-06 0.4973332357952056 \
1.414283640864285e-06 0.4919960258408594 1.41428388179775e-06 0.4869529241725989 1.414284177960236e-06 0.4807889695952298 1.414284467957623e-06 0.4747910561470179 \
1.414284774200956e-06 0.4684976697011882 1.414285094876887e-06 0.4619520863481486 1.414285422744054e-06 0.4553041925245184 1.414285762989109e-06 0.4484521981997251 \
1.414286088414654e-06 0.4419418052309769 1.414286410321802e-06 0.4355465312739703 1.414286740535907e-06 0.4290298934287748 1.414287096528499e-06 0.4220583188787752 \
1.414287415406929e-06 0.4158579595363656 1.414287752858691e-06 0.4093433989943853 1.414288180725407e-06 0.4011531841887147 1.414288529437355e-06 0.3945419525178304 \
1.414288837073319e-06 0.388759214407489 1.414289216899811e-06 0.3816861832573664 1.414289548089372e-06 0.3755780492082042 1.414289831697452e-06 0.370391509977049 \
1.414290142516397e-06 0.3647512908748707 1.414290421833004e-06 0.3597258263082204 1.414290648329152e-06 0.3556836811642302 1.414290864011538e-06 0.3518598964090484 \
1.414291061295543e-06 0.3483842179544538 1.414291266280002e-06 0.3447988491770444 1.414291478501966e-06 0.3411119200457455 1.414291733807154e-06 0.33670771290924 \
1.414291975329403e-06 0.3325734463267218 1.414292206706731e-06 0.3286464933807047 1.414292421559231e-06 0.3250253651850565 1.414292642118388e-06 0.3213332986541765 \
1.414292843544355e-06 0.3179852906236645 1.414293046612606e-06 0.3146379646143546 1.414293244508215e-06 0.3114011111455273 1.414293431469302e-06 0.3083651674074345 \
1.414293625269521e-06 0.3052406640298299 1.414293829186134e-06 0.3019773030815858 1.414294008255468e-06 0.2991336297844484 1.414294243846324e-06 0.2954229173226265 \
1.414294444650423e-06 0.2922868215109002 1.414294645829315e-06 0.2891696385850206 1.414294869639057e-06 0.2857334090862961 1.414295034201803e-06 0.2832271910241367 \
1.414295211129189e-06 0.2805503385691353 1.414295396922194e-06 0.2777610713150803 1.41429557873767e-06 0.2750538970423583 1.414295757762463e-06 0.2724132377985424 \
1.414295925107616e-06 0.2699606650006489 1.414296085536534e-06 0.2676371805838822 1.414296208110285e-06 0.2658719571410424 1.414296357874814e-06 0.2637236906090554 \
1.41429648557194e-06 0.2619099339733745 1.414296592880312e-06 0.2603957336038235 1.414296708880974e-06 0.2587625259947361 1.41429681918957e-06 0.2572125806747212 \
1.414296945068767e-06 0.2554509781935611 1.414297060550618e-06 0.2538402638894013 1.414297195131521e-06 0.2519757335310172 1.414297307194775e-06 0.2504255755821768 \
1.414297457534134e-06 0.2483447107137444 1.414297597159989e-06 0.2464124269747185 1.414297743051809e-06 0.2444035064209518 1.414297876012447e-06 0.2425734862730615 \
1.414297999574161e-06 0.2408709992523319 1.414298146783853e-06 0.2388417729476062 1.414298263370682e-06 0.2372355665500016 1.414298402825831e-06 0.23532008003217 \
1.414298537000301e-06 0.2334768281602104 1.414298662976757e-06 0.2317465561243653 1.41429878237616e-06 0.2301094434087779 1.414298877230585e-06 0.2288105340759602 \
1.414298990368184e-06 0.2272617792622066 1.414299070684642e-06 0.2261626001158484 1.414299158249698e-06 0.2249657246820506 1.414299283786835e-06 0.2232507767215072 \
1.414299389480543e-06 0.2218101326756785 1.414299479135054e-06 0.2205921574607158 1.414299549986253e-06 0.2196300825522397 1.414299593014782e-06 0.2190460135436258 \
1.414299635305326e-06 0.2184724035808872 1.414299677647042e-06 0.2178984240735344 1.414299749842462e-06 0.2169203674089526 1.414299792235817e-06 0.2163464205126744 \
1.414299827490656e-06 0.2158693585303403 1.414299871682239e-06 0.2152716287340076 1.414299941290466e-06 0.2143309212991285 1.414299975633796e-06 0.2138672544767182 \
1.414300020093325e-06 0.2132698436071631 1.414300087771806e-06 0.2123628126304402 1.414300174199065e-06 0.2112058698236149 1.414300248835667e-06 0.2102078598594563 \
1.414300330137675e-06 0.2091219706754807 1.414300427015059e-06 0.2078300362310651 1.414300552998548e-06 0.2061528795789772 1.414300655533384e-06 0.2047906894256944 \
1.414300757016901e-06 0.2034500128132261 1.414300858082597e-06 0.202119416354989 1.414300954696816e-06 0.2008491615811921 1.414301056661239e-06 0.1995112314821507 \
1.414301163383483e-06 0.1981153840927639 1.414301271788623e-06 0.1967018790395962 1.414301383782779e-06 0.1952465002768531 1.414301496249907e-06 0.1937897263683151 \
1.414301608323246e-06 0.1923454332378671 1.41430171621572e-06 0.1909603537828802 1.414301817598649e-06 0.1896629368444172 1.414301909236098e-06 0.1884941330679491 \
1.414302003211707e-06 0.1872990757663449 1.414302074478072e-06 0.1863957871745983 1.41430215115336e-06 0.1854271890400033 1.414302254812475e-06 0.184122202819407 \
1.414302328479595e-06 0.1831974022686171 1.414302401825496e-06 0.1822796569444652 1.414302515215845e-06 0.1808667181969195 1.414302603074485e-06 0.1797760932362061 \
1.414302686923162e-06 0.1787387947787487 1.41430281588559e-06 0.1771515524267008 1.414302917772084e-06 0.1759040172436072 1.414303023472791e-06 0.1746156056808686 \
1.414303125120866e-06 0.1733818993219825 1.414303255982584e-06 0.1718019019596718 1.414303363179221e-06 0.1705140034701537 1.414303492508118e-06 0.168969083715685 \
1.41430360420461e-06 0.167642098072289 1.414303704535188e-06 0.1664555496840579 1.414303800335743e-06 0.1653276075899142 1.414303911148015e-06 0.1640289617085985 \
1.414303998548296e-06 0.1630090521997956 1.414304109869413e-06 0.1617156184952586 1.414304202821272e-06 0.1606409001560029 1.41430429039415e-06 0.1596330843918451 \
1.414304392025023e-06 0.1584700928658864 1.414304476479078e-06 0.1575086241734052 1.414304551583457e-06 0.1566573095634876 1.4143046294057e-06 0.1557789554714152 \
1.414304709763569e-06 0.1548759612316424 1.414304810818399e-06 0.1537464547857493 1.414304893251962e-06 0.1528311848879565 1.414304985556514e-06 0.1518114053368895 \
1.414305062490987e-06 0.150965812476358 1.414305145413557e-06 0.1500585909391909 1.414305216944298e-06 0.1492793026301012 1.414305313327797e-06 0.1482344968214558 \
1.414305383556283e-06 0.1474766665551334 1.414305466536561e-06 0.1465853655470201 1.414305527978824e-06 0.1459298106834085 1.414305599661209e-06 0.1451677491870439 \
1.414305668289752e-06 0.1444408762699853 1.414305718558261e-06 0.1439102090153988 1.414305766138067e-06 0.143409423336876 1.414305820187418e-06 0.1428423132663369 \
1.414305879529516e-06 0.1422216078256897 1.414305947564923e-06 0.1415124633834424 1.414306023828345e-06 0.1407207186008814 1.414306092108144e-06 0.1400161356079559 \
1.414306186894323e-06 0.1390460813732662 1.414306276448135e-06 0.1381341561933974 1.414306348133609e-06 0.1374075731330657 1.414306432085017e-06 0.1365606113096345 \
1.414306497397472e-06 0.1359045398875483 1.414306558840598e-06 0.1352895588344758 1.414306633117097e-06 0.1345490408254265 1.414306695327357e-06 0.1339328028964004 \
1.414306763298365e-06 0.133265236037424 1.414306822505405e-06 0.1326856657519672 1.414306895177878e-06 0.1319767402814105 1.414306970197987e-06 0.1312477270463112 \
1.414307055651411e-06 0.1304208267333309 1.41430714175175e-06 0.1295914604616623 1.414307241877205e-06 0.1286317929389105 1.414307323166875e-06 0.127857435971709 \
1.414307424934223e-06 0.1268981149578782 1.414307509182182e-06 0.1261072369695883 1.414307607998911e-06 0.1251836587365037 1.414307680839455e-06 0.1245055382686853 \
1.414307760865543e-06 0.1237631876254407 1.414307831351338e-06 0.1231117958237987 1.41430790388176e-06 0.1224439308288319 1.414307981350756e-06 0.1217331219782777 \
1.414308088702104e-06 0.1207554316575004 1.414308189340119e-06 0.1198442997624752 1.414308261927673e-06 0.1191899427853172 1.414308330759514e-06 0.1185715582611356 \
1.414308396546334e-06 0.1179824683205609 1.414308466175131e-06 0.1173610347366148 1.414308536558877e-06 0.1167350538439435 1.414308611737249e-06 0.1160688810594495 \
1.414308715991484e-06 0.1151493019715505 1.414308791126138e-06 0.114489769343061 1.414308860041223e-06 0.1138870655592168 1.414308923246094e-06 0.1133369146236164 \
1.41430899278746e-06 0.1127339156958381 1.414309050088964e-06 0.1122385190692166 1.414309121730019e-06 0.1116210355509516 1.414309179565092e-06 0.1111240709857579 \
1.414309251686527e-06 0.1105063809580559 1.41430931410261e-06 0.1099736279351742 1.414309398424131e-06 0.1092565349771765 1.4143094660201e-06 0.1086842173446869 \
1.414309574816032e-06 0.1077671916889585 1.414309679126564e-06 0.1068924975608609 1.414309758614772e-06 0.1062289053282379 1.414309846183182e-06 0.1055008617114655 \
1.414309909639535e-06 0.1049752776433979 1.414309971350652e-06 0.10446579874651 1.414310075190416e-06 0.103612238268202 1.414310157871117e-06 0.1029362225408096 \
1.414310256339144e-06 0.1021348761715451 1.414310340785582e-06 0.101450818648051 1.414310457263062e-06 0.1005121841703865 1.414310591996508e-06 0.09943411943161744 \
1.414310728066044e-06 0.0983541971400249 1.414310842385451e-06 0.09745369041838402 1.414310927852596e-06 0.09678457778867394 1.414311038134269e-06 0.09592640631053104 \
1.414311118922622e-06 0.09530159220710262 1.414311218473493e-06 0.09453592511176086 1.414311308421543e-06 0.09384821103094763 1.414311380924943e-06 0.09329669945188329 \
1.414311462667009e-06 0.09267796846073476 1.414311590787244e-06 0.09171467366828615 1.414311672199308e-06 0.09110674702409056 1.414311746631215e-06 0.09055373306570065 \
1.414311821605099e-06 0.08999936228352182 1.414311901024074e-06 0.08941505746347288 1.414312009684932e-06 0.08862052380504259 1.414312104044903e-06 0.08793517800096999 \
1.414312193440026e-06 0.08728987318634121 1.414312300205742e-06 0.086524181682867 1.414312418708182e-06 0.08568073755029131 1.414312560233253e-06 0.08468224831562859 \
1.414312693371676e-06 0.08375174214918565 1.414312834217007e-06 0.08277682112810406 1.414312983268988e-06 0.08175525972387458 1.414313119066717e-06 0.08083369778093191 \
1.414313260523232e-06 0.0798830809748103 1.414313395783147e-06 0.07898330517332906 1.414313537164988e-06 0.07805242629322809 1.414313684232761e-06 0.07709434677344783 \
1.414313835960902e-06 0.07611680364043326 1.414314001309203e-06 0.07506403321855706 1.414314165176721e-06 0.07403332863189842 1.414314341490648e-06 0.07293832728335037 \
1.41431453092575e-06 0.07177777688466977 1.414314741692455e-06 0.07050569389938771 1.414314961464952e-06 0.06920150027616521 1.414315196433104e-06 0.06783224552442871 \
1.414315455333654e-06 0.06635227408830123 1.414315750264117e-06 0.06470266364809808 1.414316054610178e-06 0.06304001691994518 1.414316416556457e-06 0.06111393619706453 \
1.414316732684212e-06 0.05947639552636011 1.414317174006677e-06 0.0572596911373907 1.414317487572719e-06 0.05573556853365672 1.414317911072189e-06 0.0537382660685313 \
1.414318255024042e-06 0.05216649213267931 1.41431859526531e-06 0.05065508790922631 1.4143189061029e-06 0.04931137323461653 1.414319200574802e-06 0.04807062469528345 \
1.414319494274299e-06 0.04686392507224969 1.414319769145535e-06 0.04576537019482012 1.414320044685701e-06 0.04468949010490332 1.41432030977623e-06 0.04367785045825667 \
1.414320586533311e-06 0.04264571401740119 1.414320869801436e-06 0.04161414314527601 1.414321167794735e-06 0.04055545327485047 1.414321427280131e-06 0.03965542606183669 \
1.414321657303569e-06 0.03887446236327848 1.414321876995156e-06 0.03814321686473518 1.414322101935296e-06 0.0374128399305801 1.41432242218897e-06 0.0363978329183388 \
1.41432270998682e-06 0.03550963653148703 1.414322986382154e-06 0.03467738358988744 1.414323270201283e-06 0.03384352473043348 1.414323508310587e-06 0.03315996078327022 \
1.414323792621371e-06 0.03236211345273886 1.41432403453322e-06 0.03169864947531036 1.414324269673394e-06 0.03106710921041438 1.414324511380923e-06 0.03043352335444016 \
1.414324748333856e-06 0.02982731501219571 1.414324978676274e-06 0.02925002048968134 1.414325192426852e-06 0.02872465224286764 1.414325398273815e-06 0.02822791768061097 \
1.414325790610838e-06 0.02730524204782691 1.414325979002849e-06 0.02687312495148303 1.414326354614307e-06 0.02603163971789 1.414326529081082e-06 0.02564950258131362 \
1.414326953015541e-06 0.02474274850847508 1.414327073769958e-06 0.02449086781212801 1.414327544020721e-06 0.02353384026002922 1.414327693235786e-06 0.02323677291035493 \
1.414328086867998e-06 0.02246740853134286 1.414328257894342e-06 0.02213909006726131 1.414328745173274e-06 0.02121869533024997 1.414328887220983e-06 0.02095326544309953 \
1.414329420237252e-06 0.01997576278857772 1.414329542401289e-06 0.01975737097014436 1.414330064559033e-06 0.01885981776906158 1.414330235137336e-06 0.01857989792133653 \
1.414330722450399e-06 0.01781360777737795 1.414330893973322e-06 0.01755501440977742 1.41433151376008e-06 0.01666567753024489 1.414331684684406e-06 0.0164316648397145 \
1.414332390235396e-06 0.01551160061118263 1.414332552852409e-06 0.01530799450170666 1.414333309745899e-06 0.01439879525764199 1.414333450662544e-06 0.01423641007536438 \
1.414334350661384e-06 0.01324361033368418 1.414334438010634e-06 0.01315122959105692 1.414335342363989e-06 0.01223321097894121 1.414335479555938e-06 0.01209984223734439 \
1.414336450212214e-06 0.01118944790767422 1.414336578130092e-06 0.01107451071402888 1.414337728540039e-06 0.01011008206277823 1.414337822342075e-06 0.01003687265682024 \
1.414339078387887e-06 0.009120584045805383 1.4143392159292e-06 0.009026502753623255 1.414340774683602e-06 0.008029670037698805 1.414340858486287e-06 0.007977066150721189 \
1.414342463865106e-06 0.00699828665725172 1.41434257476345e-06 0.006935886594503895 1.414344507009824e-06 0.005959177461785255 1.414344686714759e-06 0.005876661013304485 \
1.414346798505876e-06 0.004981749118765498 1.414347141291011e-06 0.004848482978762325 1.414349654457045e-06 0.003966891390423618 1.414350124178715e-06 0.003819799497680527 \
1.414353764494989e-06 0.002847564273158896 1.414354280232175e-06 0.002731633924241866 1.414359622062014e-06 0.001773027297371861 1.414359907382299e-06 0.001729522787584184 \
1.414365136030129e-06 0.0007540451492352357 1.414365310176696e-06 0.0007162692714263865 1.417013698769002e-06 -0.0001123232525192561 1.41701387179429e-06 -0.0002901710972538241 \
1.417014491546044e-06 -0.001202022686018724 1.417014580115221e-06 -0.001365806793032466 1.417014941086355e-06 -0.002110727959526865 1.41701506578065e-06 -0.002395793696299351 \
1.417015429622531e-06 -0.003299857180474864 1.417015600898199e-06 -0.003758114451912169 1.417015894896038e-06 -0.004576312838821549 1.417016005104443e-06 -0.004886880824040592 \
1.417016283358441e-06 -0.005643955697619643 1.41701640463225e-06 -0.00594200199557267 1.417017498254348e-06 -0.00517389603226481 1.417017621358228e-06 -0.004409713243767066 \
1.417017744826303e-06 -0.003462788751204457 1.4170178649921e-06 -0.002366010162083454 1.417017962853768e-06 -0.001346276287748183 1.417018069556104e-06 -0.0001076498664581183 \
1.417018181397488e-06 0.001328007358939307 1.417018317371855e-06 0.003256083960376262 1.417018439401011e-06 0.00514709866632534 1.417018627817289e-06 0.008343062029134115 \
1.417018768805819e-06 0.01093380316938193 1.417018921577522e-06 0.01391176330477175 1.41701906428015e-06 0.01683596409946878 1.417019218632387e-06 0.02013443377634912 \
1.417019374426043e-06 0.02358734537610087 1.41701953048334e-06 0.02715365164079262 1.41701967788774e-06 0.03060642997674319 1.417019826504485e-06 0.03415780069914553 \
1.417019981925701e-06 0.03793559522944389 1.417020140311532e-06 0.04184227512730877 1.417020305251154e-06 0.04596085539464361 1.417020479500423e-06 0.05035714787605008 \
1.417020658443539e-06 0.05491177248689325 1.417020847583032e-06 0.0597604232635115 1.41702105036361e-06 0.06498910043066243 1.417021269735637e-06 0.07067233091134768 \
1.417021500572133e-06 0.07667464705993039 1.417021747383969e-06 0.0831083675499642 1.41702201751608e-06 0.09016243555275107 1.417022310704188e-06 0.0978236474935409 \
1.417022634359626e-06 0.1062798466079799 1.417022997926912e-06 0.1157689210849182 1.41702339022043e-06 0.1259925151671456 1.417023838699915e-06 0.1376538644086695 \
1.4170243603994e-06 0.1511757390224034 1.417024972772044e-06 0.1669844191341421 1.417025649417359e-06 0.1843663871188266 1.417026436327649e-06 0.2044554566749352 \
1.417027317548744e-06 0.2267919980918504 1.417028137292384e-06 0.2474048556006221 1.417028865745328e-06 0.2655829647002126 1.417029507221317e-06 0.2814688958417333 \
1.417030083144485e-06 0.2956305456066151 1.417030620401302e-06 0.3087428400511723 1.417031124292597e-06 0.3209487846516751 1.417031601896145e-06 0.3324328152479784 \
1.417032080019379e-06 0.343838772307344 1.417032532118228e-06 0.3545331600964184 1.417033003884519e-06 0.365596737404158 1.41703344758136e-06 0.3759140547845509 \
1.417033969549897e-06 0.3879344734281669 1.41703449708783e-06 0.399956933836353 1.417034876602574e-06 0.4085271910771138 1.417035405564174e-06 0.4203606102508351 \
1.417035874883255e-06 0.4307444005277802 1.417036310038791e-06 0.4402814026247405 1.417036757516117e-06 0.4500002273945978 1.417037197539592e-06 0.4594737646471725 \
1.417037600841335e-06 0.4680814138276727 1.417037919241101e-06 0.4748254127722248 1.417038289219015e-06 0.4826007100982719 1.417038525472097e-06 0.4875314737878706 \
1.417038760543493e-06 0.4924129045770672 1.417039011882831e-06 0.4975994385012801 1.417039318269865e-06 0.5038799449729535 1.417039575228319e-06 0.5091120301871851 \
1.417039783702615e-06 0.5133309170973237 1.417039984084905e-06 0.5173683849445317 1.417040126478606e-06 0.5202244049244739 1.417040275403071e-06 0.5231993726577677 \
1.417040486949329e-06 0.5274019882470222 1.417040713006952e-06 0.5318780389403845 1.417040907549333e-06 0.5357103559602913 1.417041096681229e-06 0.539423417888626 \
1.417041326128277e-06 0.5439012399750046 1.417041508634083e-06 0.5474563135343053 1.417041745996952e-06 0.5520623276458133 1.41704201499126e-06 0.5572695987004129 \
1.41704226390171e-06 0.5620706638085723 1.417042507918531e-06 0.5667633705755619 1.417042780273744e-06 0.5719926523718327 1.417043041669873e-06 0.5769928369418796 \
1.417043299301279e-06 0.5819084237686675 1.417043546144628e-06 0.586601202059797 1.417043791890354e-06 0.5912552023551558 1.417044018467874e-06 0.5955288021520931 \
1.417044249620064e-06 0.5998646534936181 1.417044455900444e-06 0.6037202012184053 1.417044684021204e-06 0.6079592993751251 1.417044906401185e-06 0.6120725203834017 \
1.417045133377667e-06 0.6162454422471376 1.417045348430617e-06 0.6201823359462864 1.41704557780019e-06 0.6243500782103125 1.417045846823065e-06 0.6292041961704016 \
1.417046069836712e-06 0.6331993632081415 1.417046282091289e-06 0.6369772451758789 1.417046493488879e-06 0.6407176358819484 1.417046693558109e-06 0.644236566349866 \
1.417046923151958e-06 0.6482486956559365 1.417047163988886e-06 0.6524328529570182 1.417047345738273e-06 0.6555667906748446 1.4170475342865e-06 0.6588018260593631 \
1.417047687366139e-06 0.6614154033769962 1.417047859374421e-06 0.6643352515471471 1.417048009547239e-06 0.6668697017322168 1.417048146064529e-06 0.6691578850264722 \
1.417048295693716e-06 0.6716547631652277 1.417048423434085e-06 0.673777752640997 1.417048563020223e-06 0.6760856948620949 1.41704868725891e-06 0.6781310478824312 \
1.41704881840875e-06 0.6802827752320969 1.417048942850093e-06 0.6823179209931315 1.417049080080915e-06 0.6845542421253382 1.417049200329086e-06 0.6865048414796368 \
1.417049341660529e-06 0.6887891282595083 1.417049441991641e-06 0.6904033553735033 1.417049563109342e-06 0.6923460943304175 1.417049653886878e-06 0.6937948943079848 \
1.417049751145344e-06 0.6953408241330762 1.417049847353224e-06 0.6968660703265798 1.417049935967068e-06 0.6982647859968389 1.417050033255091e-06 0.6997938110311075 \
1.417050165723729e-06 0.7018622871835729 1.417050320913928e-06 0.7042674555997347 1.417050458791879e-06 0.7063866855441746 1.417050603646153e-06 0.7085960165693863 \
1.41705073070791e-06 0.7105202221428537 1.41705085539347e-06 0.7123960184768648 1.417050968098846e-06 0.7140814553427599 1.41705107988919e-06 0.7157437310299281 \
1.41705118066784e-06 0.7172341607972841 1.417051317946295e-06 0.7192525454101454 1.417051437630367e-06 0.7210013704967912 1.417051557059838e-06 0.7227365757678518 \
1.41705168394306e-06 0.7245692610776365 1.417051808360712e-06 0.7263556789600311 1.417051932093536e-06 0.728121726658988 1.417052058689063e-06 0.7299181396522603 \
1.417052189074464e-06 0.7317573312219798 1.417052311884284e-06 0.7334798522758219 1.417052447320059e-06 0.7353678990088863 1.417052548609838e-06 0.7367723836293941 \
1.417052656232334e-06 0.7382576460517265 1.417052745760416e-06 0.7394878879617913 1.417052860308785e-06 0.7410528648863303 1.417052948337041e-06 0.7422487366778059 \
1.417053055415107e-06 0.7436953530868765 1.4170531854801e-06 0.7454403311053276 1.417053296759795e-06 0.7469230742113165 1.417053401378355e-06 0.7483084058091373 \
1.41705352546134e-06 0.7499400420429273 1.417053673762168e-06 0.7518749696944975 1.417053795162033e-06 0.7534462209622173 1.41705390960278e-06 0.7549170836379747 \
1.417054049940098e-06 0.7567069362027918 1.417054191702981e-06 0.7584995177563068 1.417054309503919e-06 0.759977341175643 1.417054437480785e-06 0.761570846386187 \
1.417054579183209e-06 0.7633205808366864 1.417054696694522e-06 0.7647599110190483 1.417054842299791e-06 0.7665289162262866 1.417054963994099e-06 0.7679951561698679 \
1.417055082724709e-06 0.7694149786178283 1.417055205011304e-06 0.7708662727382939 1.41705533205582e-06 0.77236234268503 1.417055441699792e-06 0.7736439866494906 \
1.417055567386704e-06 0.7751025186690397 1.417055673401805e-06 0.776323977486031 1.417055808987772e-06 0.7778743028704433 1.417055933950769e-06 0.7792913979962601 \
1.417056059856921e-06 0.7807070123991936 1.417056175124167e-06 0.7819915514687489 1.41705628142864e-06 0.7831664991275713 1.417056419833432e-06 0.7846822315516878 \
1.417056569129882e-06 0.7862997378875561 1.417056714637327e-06 0.7878588534534761 1.417056834041839e-06 0.7891257303126159 1.417056969134663e-06 0.7905455128963393 \
1.417057090387826e-06 0.7918076974797237 1.417057233381105e-06 0.7932816011184505 1.41705737758541e-06 0.7947523458802197 1.417057503122239e-06 0.7960199014141693 \
1.417057622168612e-06 0.7972110037065316 1.417057734104495e-06 0.7983213107123885 1.417057838976047e-06 0.7993531099923881 1.417057934226459e-06 0.8002831901653534 \
1.417058070569705e-06 0.8016020813281191 1.417058187393835e-06 0.8027203407102198 1.417058306798445e-06 0.803852171037294 1.417058428905249e-06 0.8049980820693966 \
1.41705855186025e-06 0.8061401395390313 1.417058678828951e-06 0.8073073595000361 1.41705880406856e-06 0.8084467645495962 1.417058934640955e-06 0.8096220968518901 \
1.417059060631473e-06 0.8107441738369082 1.417059188817385e-06 0.8118738099374113 1.417059294347114e-06 0.8127947795787664 1.417059397218887e-06 0.8136847278655364 \
1.417059490214057e-06 0.8144826950388273 1.417059614010659e-06 0.8155354283166244 1.417059701978917e-06 0.8162769513478326 1.417059800709988e-06 0.8171027376706747 \
1.417059943975142e-06 0.8182889948057973 1.417060079253827e-06 0.8193962136425846 1.417060188368449e-06 0.8202800249700468 1.417060336451758e-06 0.8214657808291811 \
1.417060486222685e-06 0.8226492530953341 1.417060611457285e-06 0.8236267526687548 1.417060755448703e-06 0.8247372275730155 1.417060879504774e-06 0.8256825756473101 \
1.417061029968032e-06 0.8268152483647575 1.417061165678884e-06 0.8278240064655301 1.417061290697392e-06 0.828742521381556 1.417061408452322e-06 0.8295983347934622 \
1.417061554429135e-06 0.8306466023667578 1.417061720938452e-06 0.8318251482734692 1.417061851861028e-06 0.8327390940956469 1.417062025288466e-06 0.8339327615268647 \
1.417062193435348e-06 0.8350717495747054 1.417062363270277e-06 0.8362042975620877 1.417062544195048e-06 0.8373912937861997 1.417062687293307e-06 0.8383160748488641 \
1.417062801379198e-06 0.8390446117604563 1.417062931553184e-06 0.8398665237782376 1.417063033394266e-06 0.8405024977857931 1.417063150213615e-06 0.8412243379523001 \
1.417063287078045e-06 0.8420597162999857 1.417063484876668e-06 0.8432475311273343 1.41706367648074e-06 0.8443767279905872 1.417063885921222e-06 0.8455874169714939 \
1.417064067846852e-06 0.8466193100105236 1.417064264979957e-06 0.8477171434207121 1.417064438329848e-06 0.8486653666163242 1.417064621329232e-06 0.8496493024239481 \
1.417064792495495e-06 0.8505537352954988 1.417064967127282e-06 0.8514606693963016 1.417065142389669e-06 0.8523550102558151 1.417065318541784e-06 0.8532381479010797 \
1.417065508812824e-06 0.8541746551565574 1.417065699414774e-06 0.85509499218684 1.417065900062401e-06 0.8560449689899254 1.417066092672966e-06 0.8569390259424264 \
1.417066303330652e-06 0.8578972157030333 1.417066531456051e-06 0.8589122247267402 1.417066797213368e-06 0.8600655879592763 1.417067095837813e-06 0.8613244245924475 \
1.417067372169332e-06 0.862454900702886 1.41706765640239e-06 0.8635842083919951 1.417067930614306e-06 0.8646423892283146 1.417068202842372e-06 0.8656634505877856 \
1.417068473051191e-06 0.8666487272755322 1.417068730204067e-06 0.8675609437488442 1.417069002786335e-06 0.868501515423508 1.417069278771335e-06 0.8694269133137555 \
1.417069548872911e-06 0.8703069289141475 1.417069848734863e-06 0.8712546000783432 1.417070219768993e-06 0.8723856543073821 1.417070514706753e-06 0.8732530157608677 \
1.417070768997535e-06 0.8739790309043101 1.417071067254951e-06 0.8748056771600844 1.417071340863485e-06 0.8755409825400007 1.417071576991549e-06 0.8761583495732972 \
1.41707181733693e-06 0.876770807053994 1.417072039670212e-06 0.8773233906735478 1.41707223367596e-06 0.8777948466981503 1.417072563398506e-06 0.8785737911727464 \
1.417072718571944e-06 0.8789308835864816 1.417073036347473e-06 0.8796437246174529 1.41707321520917e-06 0.8800342982281311 1.417073557671047e-06 0.8807611334253193 \
1.417073741799519e-06 0.8811407335605206 1.417074216677856e-06 0.8820849466541889 1.417074384074053e-06 0.8824061830950772 1.417074849915456e-06 0.8832696475595492 \
1.417075030737665e-06 0.8835931319180218 1.417075524775914e-06 0.8844450822729043 1.417075666124327e-06 0.8846804878101884 1.417076272457385e-06 0.8856498028150036 \
1.417076424526725e-06 0.8858829444029697 1.4170770712152e-06 0.8868329272509302 1.417077199509723e-06 0.8870138524519416 1.417077847626928e-06 0.8878919388991984 \
1.417077977425791e-06 0.8880607713689423 1.417078755627481e-06 0.8890227771434612 1.417078870684414e-06 0.8891574578072456 1.417079726342848e-06 0.8901003239091128 \
1.417079871707615e-06 0.8902505899439886 1.41708085746403e-06 0.8911948786459364 1.41708107856904e-06 0.8913892999646706 1.417082223696019e-06 0.8923206810037944 \
1.417082354912618e-06 0.892422953350996 1.417083696124267e-06 0.8934189515818408 1.417083847523211e-06 0.8935240845833778 1.417085328961459e-06 0.8944568913393511 \
1.417085567840892e-06 0.8945912088657246 1.417087337161074e-06 0.8954685138428928 1.41708772631084e-06 0.895637400736999 1.417090119976628e-06 0.896526474291006 \
1.41709059568945e-06 0.8966764365754722 1.417094011699057e-06 0.8975478548673914 1.417094658849072e-06 0.8976786076740833 1.417102137013678e-06 0.8986646932675814 \
1.417102809590796e-06 0.8987192862546014 1.417195253995367e-06 0.8997188196574962 1.417195917228051e-06 0.8997241906476866 1.417385126389945e-06 0.900686595210158 \
1.417385288462789e-06 0.9007292695325627 1.417387933983676e-06 0.8998161167154269 1.417388102533154e-06 0.8996881690130656 1.417389379285545e-06 0.8987393243250013 \
1.417389581451881e-06 0.8986030018074492 1.417391189561267e-06 0.8976721249252815 1.417391381667192e-06 0.8975774045828077 1.417406495049839e-06 0.8985726115129884 \
1.417406683108756e-06 0.8986004060702872 1.417417988037768e-06 0.8995874924221801 1.417418361423516e-06 0.8996034751727418 1.417907373786698e-06 0.9005892719715856 \
1.417907484554897e-06 0.9006868984798269 1.417908237227259e-06 0.9015617873136611 1.417908339021945e-06 0.9017086238768567 1.41790887442049e-06 0.9025814930725723 \
1.417908976929663e-06 0.9027670217776843 1.417909369148481e-06 0.9035254014384071 1.417909509991429e-06 0.9038129158713877 1.417909951028881e-06 0.9047472953155866 \
1.417910136514484e-06 0.9051402477015744 1.417910652827601e-06 0.9061269394579334 1.417910737502694e-06 0.9062564181617988 1.417911972174744e-06 0.9053011091537977 \
1.417912129388156e-06 0.9045688862145235 1.417912321204817e-06 0.9034162411061901 1.417912488045348e-06 0.9021712267446264 1.417912635003746e-06 0.9008824031243315 \
1.417912749119942e-06 0.8997575350477262 1.417912878992032e-06 0.8983446880789033 1.41791299010955e-06 0.8970273815442567 1.417913082914029e-06 0.8958483937359277 \
1.417913171236719e-06 0.8946639786015808 1.417913274417478e-06 0.8932058048613533 1.417913366625413e-06 0.8918333298588224 1.41791345419561e-06 0.8904732289418564 \
1.417913568189076e-06 0.8886245408236838 1.4179137299935e-06 0.8858564722885236 1.417913914992117e-06 0.8825005184224666 1.417914107151785e-06 0.8788219124347386 \
1.417914308599138e-06 0.874780227084481 1.417914515009728e-06 0.8704697801294994 1.41791470018168e-06 0.8664790122147591 1.417914884689405e-06 0.862405115500708 \
1.417915057841296e-06 0.8585071391690239 1.417915242887321e-06 0.8542751393552932 1.417915420261524e-06 0.8501657390392787 1.417915597007955e-06 0.8460284987362284 \
1.417915763166606e-06 0.8421077870518131 1.417915925211044e-06 0.8382599993991456 1.417916091783925e-06 0.8342839555277276 1.417916250437662e-06 0.8304816347052207 \
1.417916441313687e-06 0.8258903812682129 1.417916616297259e-06 0.8216694867670907 1.417916786243393e-06 0.8175615830390965 1.417916951419567e-06 0.8135626411663678 \
1.417917124611674e-06 0.8093650119631921 1.417917295673877e-06 0.8052155696745213 1.417917463774914e-06 0.801136095357175 1.417917654109863e-06 0.7965156511928794 \
1.417917837691806e-06 0.7920591698039 1.417918045682732e-06 0.7870113041480956 1.417918268259242e-06 0.7816114142545842 1.417918457674258e-06 0.7770174196885687 \
1.417918650984654e-06 0.7723312127316435 1.41791879443024e-06 0.7688556734481145 1.41791894385359e-06 0.7652374066097742 1.417919063006063e-06 0.7623536300085233 \
1.417919175722544e-06 0.7596269484184472 1.417919284997451e-06 0.7569846861296079 1.417919421027209e-06 0.753697254849378 1.417919533823024e-06 0.750972995067179 \
1.41791965602098e-06 0.7480232093637929 1.417919767605752e-06 0.7453311011793381 1.417919892312215e-06 0.7423241425761796 1.417920046694167e-06 0.7386034578119585 \
1.417920213478233e-06 0.7345862494782525 1.417920430642921e-06 0.7293605768817599 1.41792062520351e-06 0.7246835946359503 1.417920785534395e-06 0.7208333202545074 \
1.417920960959998e-06 0.7166251500492028 1.417921150723573e-06 0.7120779400724765 1.417921339451897e-06 0.7075610435995559 1.417921521273264e-06 0.7032145396962334 \
1.417921705870676e-06 0.6988062725207448 1.417921842953811e-06 0.6955348514212173 1.417921996242049e-06 0.6918805091472418 1.417922191613795e-06 0.6872279990818534 \
1.417922347770547e-06 0.6835136309588888 1.417922505722766e-06 0.6797605476340507 1.41792270397403e-06 0.6750570282453686 1.417922897319928e-06 0.6704763548785364 \
1.417923133825274e-06 0.6648822204491218 1.417923320030377e-06 0.6604858901039825 1.417923557652698e-06 0.6548824851665868 1.417923744451452e-06 0.6504854738275335 \
1.417923925009211e-06 0.6462424706993735 1.417924088085156e-06 0.6424159959781919 1.41792423269672e-06 0.6390271817202816 1.41792437329907e-06 0.6357379642635244 \
1.417924500108657e-06 0.632774906490579 1.417924632245193e-06 0.6296924762754078 1.417924758489144e-06 0.6267508340255646 1.417924889752774e-06 0.6236963630311418 \
1.417925018850514e-06 0.6206978048938425 1.417925158276179e-06 0.6174624210713571 1.417925306646171e-06 0.6140261568477932 1.41792550120306e-06 0.6095278574984737 \
1.417925644648937e-06 0.6062198040692683 1.417925879109183e-06 0.6008245134060309 1.417926051007495e-06 0.5968818013610552 1.417926263928033e-06 0.5920102583789468 \
1.417926436394651e-06 0.5880775912131976 1.417926566719197e-06 0.5851108450968721 1.417926698275517e-06 0.5821241897920357 1.417926808505599e-06 0.5796262478458715 \
1.417926904159846e-06 0.5774603558442819 1.417927003393806e-06 0.5752182923213994 1.417927086311907e-06 0.5733484809858778 1.417927165227534e-06 0.5715706040143225 \
1.417927228156309e-06 0.5701535626562365 1.417927293664786e-06 0.5686800671140783 1.417927374150839e-06 0.5668736364148982 1.417927424016846e-06 0.5657560592102344 \
1.417927473205615e-06 0.5646541775062763 1.417927534675401e-06 0.5632780399140616 1.417927582596929e-06 0.5622058085646952 1.417927633441648e-06 0.5610687758404553 \
1.417927692541903e-06 0.5597501790023616 1.41792775115623e-06 0.5584442118409422 1.417927826782323e-06 0.5567607189607793 1.417927897341035e-06 0.5551915720267918 \
1.417927986471042e-06 0.5532116467156011 1.41792807569462e-06 0.5512351177508077 1.41792816099823e-06 0.5493490637975145 1.417928248625197e-06 0.5474138635528197 \
1.41792834562712e-06 0.545274424894262 1.417928449972891e-06 0.5429792414815097 1.417928566264315e-06 0.5404269323775457 1.417928672601932e-06 0.5380963700835184 \
1.417928784310815e-06 0.5356536306660374 1.417928896605295e-06 0.5332047801427824 1.417929023802854e-06 0.5304364255197962 1.417929146572528e-06 0.5277698476303582 \
1.417929288796925e-06 0.5246912237717902 1.417929425160057e-06 0.5217463069543907 1.417929577381123e-06 0.5184691491721333 1.417929737017329e-06 0.5150420887864461 \
1.417929912992521e-06 0.5112761258030903 1.417930101501109e-06 0.5072591542828934 1.41793030856769e-06 0.5028616940969075 1.417930533509662e-06 0.4981043078903621 \
1.417930784905619e-06 0.4928144328841237 1.417931021331185e-06 0.4878598554762091 1.417931318494919e-06 0.4816683149127979 1.417931609172211e-06 0.4756487143466775 \
1.417931917027196e-06 0.469313240945046 1.417932230852953e-06 0.4628991126846517 1.417932559994313e-06 0.4562163541974347 1.417932893372419e-06 0.4494927613461197 \
1.417933224999028e-06 0.4428490490857003 1.417933546548425e-06 0.4364504708187015 1.417933874224238e-06 0.4299742838549845 1.41793422184386e-06 0.4231546934710667 \
1.417934555065174e-06 0.4166645133789623 1.417934900974402e-06 0.4099771621835854 1.417935346388221e-06 0.4014400148089548 1.417935704178092e-06 0.3946500490499754 \
1.417936018334912e-06 0.3887397205534429 1.417936402745391e-06 0.3815756289527631 1.417936732720036e-06 0.3754830843203271 1.417937017930125e-06 0.3702633801070484 \
1.417937326220382e-06 0.3646649204592909 1.417937606017443e-06 0.3596257204303125 1.417937832011793e-06 0.3555880084110294 1.417938046849747e-06 0.3517755993421203 \
1.41793824528482e-06 0.3482769933469286 1.417938449224337e-06 0.3447071465415313 1.417938659760396e-06 0.3410461989361561 1.417938916734521e-06 0.3366091000429626 \
1.417939157995129e-06 0.3324763702393667 1.417939389568845e-06 0.3285420159269506 1.417939604222291e-06 0.3249208057821749 1.417939825046275e-06 0.3212218866489027 \
1.417940026292867e-06 0.3178749657716667 1.41794022938212e-06 0.3145250552959265 1.417940427226991e-06 0.3112865758726304 1.417940614079937e-06 0.3082497660855442 \
1.417940808016662e-06 0.3051208532403978 1.417941011761317e-06 0.30185834615803 1.417941190488583e-06 0.2990186060348319 1.417941428134378e-06 0.2952727068736475 \
1.417941627896611e-06 0.2921508861588616 1.417941829525427e-06 0.2890253490052915 1.417942054991885e-06 0.285561995332 1.417942221086285e-06 0.2830312764183137 \
1.417942399705387e-06 0.2803277612349699 1.417942581409588e-06 0.2775983111934518 1.417942770043305e-06 0.2747882307029562 1.417942947466508e-06 0.2721695222189568 \
1.417943124659645e-06 0.2695724116247911 1.41794328473156e-06 0.2672552081803913 1.417943405132238e-06 0.2655193337608355 1.417943552958303e-06 0.2633957862580221 \
1.417943681588075e-06 0.2615692882062232 1.417943783793658e-06 0.2601227034409412 1.417943902028939e-06 0.2584516051170885 1.4179440224823e-06 0.2567534139348401 \
1.417944146190618e-06 0.2550183706610066 1.417944264442643e-06 0.2533694204037282 1.417944392295773e-06 0.2515887492000971 1.417944512581604e-06 0.249915736161692 \
1.41794466526121e-06 0.2477917697339537 1.417944800173988e-06 0.2459264316518071 1.41794492881341e-06 0.2441493177932957 1.417945086528788e-06 0.2419705448111171 \
1.417945213210091e-06 0.2402201997919771 1.417945348536158e-06 0.2383592392624043 1.417945487448727e-06 0.2364550510890953 1.417945605221031e-06 0.2348405558720491 \
1.417945764491849e-06 0.2326580599570062 1.417945901013704e-06 0.2307878375452989 1.41794604224565e-06 0.2288626996658652 1.417946148058693e-06 0.2274220928889542 \
1.41794627840164e-06 0.2256484734765637 1.417946378112453e-06 0.2242944442559471 1.417946480933888e-06 0.2228991027388591 1.417946554349542e-06 0.2219046249368765 \
1.417946634181104e-06 0.2208265149641777 1.417946704228335e-06 0.2198809561195558 1.417946754631426e-06 0.2192009305305119 1.417946806883225e-06 0.2184966408607167 \
1.417946886120743e-06 0.2174292050927151 1.417946927964696e-06 0.2168658036437602 1.417946967304648e-06 0.216336351877609 1.417947010340057e-06 0.2157575332679269 \
1.417947054507484e-06 0.2151638767852215 1.417947128273223e-06 0.2141731338947761 1.417947163785221e-06 0.2136967174286463 1.417947211500021e-06 0.2130606706933813 \
1.417947272229561e-06 0.2122518321687151 1.417947340486786e-06 0.2113438957752176 1.417947413008566e-06 0.2103801801047663 1.417947485683193e-06 0.2094152724966429 \
1.417947593999181e-06 0.2079788886429202 1.417947691670323e-06 0.20668564243436 1.417947803221819e-06 0.2052110974836689 1.417947901757253e-06 0.2039136008387587 \
1.417948005250393e-06 0.2025572972554956 1.417948101152127e-06 0.2013021587886929 1.417948203780057e-06 0.1999606878451601 1.41794830660317e-06 0.1986207062101238 \
1.417948416722797e-06 0.1971897063011611 1.417948525418353e-06 0.1957815523781236 1.417948645095582e-06 0.1942360962608612 1.41794875537326e-06 0.192818053470401 \
1.41794886343648e-06 0.1914343471929882 1.417948988535148e-06 0.1898375077741012 1.417949078504982e-06 0.1886931806549971 1.417949157191935e-06 0.1876950225942949 \
1.417949234476806e-06 0.1867173468865102 1.417949320985382e-06 0.1856271834369256 1.417949419934593e-06 0.1843848109964498 1.417949490443458e-06 0.1835017733581451 \
1.417949561894511e-06 0.1826096997732476 1.417949667039846e-06 0.1813018727451555 1.417949746279475e-06 0.1803200401832796 1.417949827363369e-06 0.1793174195483187 \
1.41794992085531e-06 0.1781663090788374 1.417950021631284e-06 0.1769308188703378 1.417950171343388e-06 0.175105380089017 1.417950287132704e-06 0.1737009932372819 \
1.41795043813808e-06 0.1718807311127691 1.4179505492465e-06 0.1705485445502526 1.417950691372958e-06 0.168854666407182 1.417950809031379e-06 0.167460358327668 \
1.417950913935975e-06 0.1662230887079887 1.417951008998573e-06 0.1651069099307241 1.417951102429828e-06 0.1640147999883682 1.41795120347649e-06 0.1628388413495604 \
1.417951299823398e-06 0.1617223204899406 1.417951396975644e-06 0.1606011553546776 1.417951480024216e-06 0.1596469772300165 1.41795159006187e-06 0.1583897228513109 \
1.417951672364432e-06 0.1574542248873526 1.417951777364141e-06 0.156267858580057 1.41795185506021e-06 0.1553950893374849 1.417951937879688e-06 0.1544690878994293 \
1.417952019541594e-06 0.1535604570452941 1.417952108890884e-06 0.152571060794856 1.41795218460332e-06 0.1517364980793458 1.417952267165934e-06 0.1508307726525361 \
1.417952343747367e-06 0.1499942554682341 1.417952412035253e-06 0.1492531084507001 1.417952505402265e-06 0.1482449401818621 1.417952574555677e-06 0.1475015570698688 \
1.417952650180008e-06 0.1466917482325688 1.417952711729128e-06 0.1460354497178591 1.417952778977892e-06 0.1453208357145237 1.417952850039892e-06 0.1445684785944268 \
1.41795292553732e-06 0.143772322008306 1.41795298444886e-06 0.1431546944759192 1.41795306112247e-06 0.1423563022825049 1.417953141443211e-06 0.1415233898163201 \
1.417953214594519e-06 0.1407682091691316 1.417953308750941e-06 0.139800669784813 1.417953380355125e-06 0.1390684367429364 1.4179534538159e-06 0.1383201464810226 \
1.417953537327651e-06 0.1374732033664194 1.417953626806795e-06 0.1365744208092838 1.4179536918717e-06 0.1359252211013016 1.417953803997723e-06 0.1348115665849295 \
1.417953869183863e-06 0.1341670699454539 1.417953939222108e-06 0.1334770515823289 1.417953999527163e-06 0.1328849371768329 1.417954054537987e-06 0.1323464455745446 \
1.417954142654965e-06 0.1314871014507438 1.417954183441259e-06 0.131090685705856 1.41795428714401e-06 0.1300923774523848 1.41795433045658e-06 0.1296773144713907 \
1.417954391675178e-06 0.1290920262082728 1.417954436511897e-06 0.1286643765206081 1.417954524107923e-06 0.127831527987147 1.417954565661879e-06 0.1274377589706847 \
1.417954625523389e-06 0.1268718307679372 1.417954697367115e-06 0.1261946708524367 1.417954753579841e-06 0.1256664967939027 1.41795481606734e-06 0.125081039250218 \
1.417954890295323e-06 0.1243877959456236 1.417954964976328e-06 0.1236954937854857 1.417955052159541e-06 0.1228905551604285 1.417955120558092e-06 0.1222610287411191 \
1.417955201128775e-06 0.1215216597888775 1.417955282424256e-06 0.120778012781285 1.417955349340781e-06 0.1201677797529914 1.417955432157726e-06 0.1194156054679852 \
1.417955491346448e-06 0.1188799972037829 1.417955557267448e-06 0.1182853617472536 1.417955637141491e-06 0.1175675408705869 1.41795571363729e-06 0.1168828806096336 \
1.4179557950994e-06 0.1161574242846086 1.417955893570281e-06 0.1152852106851665 1.41795596868063e-06 0.114622623867465 1.41795607166842e-06 0.1137180076826871 \
1.417956145852371e-06 0.1130691786503039 1.417956243471825e-06 0.1122190343868764 1.41795633928278e-06 0.1113890351962442 1.417956435131205e-06 0.110562946039519 \
1.417956516069412e-06 0.1098685209805978 1.417956604452683e-06 0.1091134439098378 1.417956703052661e-06 0.108274944429282 1.417956775836865e-06 0.1076586405352824 \
1.417956865109775e-06 0.1069058608836731 1.417956927091788e-06 0.1063852406583179 1.417956989684955e-06 0.1058613310701875 1.417957074907104e-06 0.105150777260444 \
1.417957180369478e-06 0.1042758147594986 1.417957260199961e-06 0.1036167065755082 1.417957340914214e-06 0.1029530974056021 1.417957423527949e-06 0.1022768941101355 \
1.417957493972562e-06 0.1017026162492672 1.417957597231928e-06 0.1008648142128753 1.417957670072053e-06 0.1002767039768694 1.417957755712335e-06 0.09958839426015198 \
1.417957874514072e-06 0.09863954321822334 1.417957942151898e-06 0.09810250133474645 1.41795801190202e-06 0.09755100310752296 1.417958089237e-06 0.09694230106952094 \
1.417958181657254e-06 0.09621870517595056 1.417958253354782e-06 0.09566033062548993 1.417958339171942e-06 0.09499542738017568 1.417958441597192e-06 0.09420660575030523 \
1.417958534892083e-06 0.09349264652734962 1.417958631208556e-06 0.09276005482712441 1.417958708110817e-06 0.09217843893134048 1.417958801590805e-06 0.09147541043939374 \
1.417958880833232e-06 0.09088281005358793 1.417958995455426e-06 0.0900310686188453 1.417959125063686e-06 0.08907580221142102 1.417959258320876e-06 0.08810234090122065 \
1.417959402350766e-06 0.08705990691030199 1.417959559518909e-06 0.08593388720602639 1.417959709295387e-06 0.08487214151476249 1.417959871762979e-06 0.08373303262435308 \
1.417960014942984e-06 0.08273971668837025 1.417960167622107e-06 0.0816913199659166 1.417960301891878e-06 0.08077856892457436 1.417960443644155e-06 0.07982444400446118 \
1.417960578643816e-06 0.07892500874648442 1.417960720601213e-06 0.07798882638923543 1.417960867448644e-06 0.07703088995320664 1.417961019894053e-06 0.07604750978240994 \
1.417961185112776e-06 0.07499422991502351 1.417961349250621e-06 0.07396067809208305 1.417961526112024e-06 0.07286119333145537 1.41796171645358e-06 0.07169407515132428 \
1.417961927410093e-06 0.07042030845332216 1.417962147819231e-06 0.0691121699798517 1.417962383344393e-06 0.06773900533435212 1.417962643793767e-06 0.0662496528900723 \
1.417962939459177e-06 0.06459579389282195 1.417963244581463e-06 0.06292902455725519 1.417963609576024e-06 0.06098725515092194 1.417964004456839e-06 0.05894944116461652 \
1.417964410847493e-06 0.05692211719668253 1.417964826573035e-06 0.05491854459141238 1.417965189379358e-06 0.0532251207245777 1.417965533980648e-06 0.05166301626031383 \
1.41796584916051e-06 0.05027284652491828 1.417966144689875e-06 0.04900240867073854 1.417966442670382e-06 0.04775344010203557 1.417966718469172e-06 0.04662857640242725 \
1.417966997243768e-06 0.04551884372531381 1.417967261178638e-06 0.04449205559535935 1.417967537201376e-06 0.04344260531795661 1.41796781615763e-06 0.04240676967887352 \
1.417968129850963e-06 0.04127097799875453 1.41796836585125e-06 0.04043636567030678 1.417968621645987e-06 0.03955075129286261 1.417968881769487e-06 0.03867033103466553 \
1.417969151904759e-06 0.03778142289416799 1.417969431124747e-06 0.03688501536902895 1.417969712963396e-06 0.03600226561751176 1.417969989839066e-06 0.03515600409566183 \
1.417970268932665e-06 0.03432349610146775 1.417970501810272e-06 0.03364444121149882 1.417970785646989e-06 0.03283527291840588 1.417971025751923e-06 0.03216626441466421 \
1.417971265550746e-06 0.0315119836023277 1.41797150482792e-06 0.03087436846876356 1.417971740084942e-06 0.03026290129608995 1.417971971011964e-06 0.02967475842909434 \
1.417972186001007e-06 0.02913788335257221 1.417972588155459e-06 0.02816043724496065 1.417972786878278e-06 0.02768988489927659 1.417973160561294e-06 0.0268265706552881 \
1.417973347359617e-06 0.02640514011949098 1.417973694919304e-06 0.02563810810034544 1.417973816848767e-06 0.0253740445387235 1.417974199320207e-06 0.02456430406701914 \
1.417974370028237e-06 0.02421180751242828 1.417974827125621e-06 0.02328894863848502 1.417975012758007e-06 0.0229225623309489 1.41797537621526e-06 0.02221803970155307 \
1.417975596582612e-06 0.02179832126591805 1.417976054308969e-06 0.02093867417890744 1.417976189728599e-06 0.02068687731869814 1.417976719624047e-06 0.01972418011126781 \
1.417976838945017e-06 0.01951377505543128 1.417977404730696e-06 0.01856069823426573 1.417977569110437e-06 0.0182962226476828 1.417978187655734e-06 0.01735107502432094 \
1.417978357709933e-06 0.01710418363667701 1.417978889842166e-06 0.01636278834442301 1.417979086926142e-06 0.01610013864443424 1.417979810045215e-06 0.01517806887136661 \
1.417979974675381e-06 0.01497647803580381 1.417980723800768e-06 0.01409711804523418 1.41798085710012e-06 0.01394643716836554 1.417981717353759e-06 0.01301449210748497 \
1.417981852457379e-06 0.01287422877142914 1.41798279503482e-06 0.01193816285908547 1.417982958630574e-06 0.01178202925388569 1.417983959987201e-06 0.0108653384673985 \
1.417984097529988e-06 0.01074500730514941 1.417985319636371e-06 0.009765086624518643 1.417985426589084e-06 0.00968516078425012 1.417986830780577e-06 0.008707372520026449 \
1.417986935611284e-06 0.008639312158696611 1.417988470448246e-06 0.00767719340797631 1.417988565731547e-06 0.007617466071856052 1.417990174528868e-06 0.006680264535635283 \
1.417990308605608e-06 0.006609506832171614 1.417992405618559e-06 0.005610918814474722 1.417992636163191e-06 0.005510783990371394 1.417994959158435e-06 0.004586584533412417 \
1.417995440488638e-06 0.004413562233393853 1.417998278050269e-06 0.003511943147855551 1.417998822969955e-06 0.003360532104877318 1.418002947178351e-06 0.002408309874554541 \
1.418003490902011e-06 0.002305347543005144 1.418009362191237e-06 0.001333291345955189 1.418009605056421e-06 0.001286469439319215 1.418023932948772e-06 0.0002880570268237783 \
1.418024077507414e-06 0.0002853642807229123 1.420661356428513e-06 -0.0006859155495331031 1.42066149598365e-06 -0.000901903561740745 1.420662005077582e-06 -0.001859438188174024 \
1.420662094565085e-06 -0.002052812934985279 1.420662457959945e-06 -0.00291126965001638 1.420662548982015e-06 -0.003143482006111167 1.420662914420052e-06 -0.004127275145644371 \
1.420663024680619e-06 -0.004436819103926468 1.420663336727774e-06 -0.005309594399865315 1.420663439442621e-06 -0.005584800160857357 1.420663803290477e-06 -0.006384516484886619 \
1.420663968081208e-06 -0.006586298968823262 1.420664547677408e-06 -0.005791490933239759 1.420664722787551e-06 -0.004914057272375438 1.420664839479485e-06 -0.004132845175365214 \
1.420664966064091e-06 -0.003100877896798674 1.420665067873013e-06 -0.002132773363901063 1.420665188361723e-06 -0.0008283127610571584 1.420665278808799e-06 0.0002599396317828252 \
1.42066537669893e-06 0.001541559978017447 1.420665475763239e-06 0.002943971508909197 1.420665646570516e-06 0.005594911825788154 1.420665868338539e-06 0.00944046646559993 \
1.420666064242384e-06 0.01317281463966807 1.420666223123766e-06 0.01639870563256729 1.420666387552263e-06 0.01989779506365397 1.420666541918293e-06 0.02331070396473752 \
1.420666700690818e-06 0.02693200463312963 1.420666847428777e-06 0.03036422445567413 1.420666996052748e-06 0.0339113704936035 1.420667151667245e-06 0.03768995713197771 \
1.420667308909259e-06 0.04156499463828727 1.420667473802057e-06 0.04567927910670353 1.420667647221578e-06 0.05005184210758699 1.420667825915293e-06 0.05459761989277153 \
1.420668014531131e-06 0.05943075613080645 1.420668215431273e-06 0.06460909294799391 1.420668434888064e-06 0.0702927970720964 1.420668664434351e-06 0.07626037976612585 \
1.420668910133291e-06 0.08266408948881369 1.42066917869823e-06 0.08967663153997742 1.420669470040144e-06 0.09728936802005522 1.420669791708172e-06 0.1056939239977524 \
1.420670152022263e-06 0.1150987971742611 1.420670543001701e-06 0.1252892839303718 1.420670986416517e-06 0.1368209045172546 1.420671502729605e-06 0.1502062239570841 \
1.420672108934821e-06 0.16586000516691 1.420672780191848e-06 0.1831102247110778 1.420673559691505e-06 0.20301830483439 1.420674432001389e-06 0.2251413938832897 \
1.420675262336713e-06 0.2460320778586349 1.420675993667063e-06 0.264292249712138 1.420676641612843e-06 0.280346965484095 1.420677224923317e-06 0.29469740877147 \
1.420677760655584e-06 0.3077798509628869 1.420678263914169e-06 0.3199778888071559 1.42067874911767e-06 0.3316516836183861 1.420679228040375e-06 0.3430829066939081 \
1.420679674471008e-06 0.3536501814456421 1.420680148800718e-06 0.3647819492304352 1.420680597991712e-06 0.3752331958288908 1.42068108846397e-06 0.3865396207984229 \
1.420681617036722e-06 0.3985997842463301 1.420681988181062e-06 0.4069920784971888 1.420682515935418e-06 0.4188173133762567 1.420682978292178e-06 0.4290642331729484 \
1.420683450624318e-06 0.4394285229343968 1.420683932409041e-06 0.4498981261869666 1.420683965448159e-06 0.4506126593745911 1.420684003207152e-06 0.45142837879914 \
1.420684078725137e-06 0.4530572051633331 1.420684229761107e-06 0.4563088938659436 1.420684437280373e-06 0.460764549126051 1.420684625319184e-06 0.4647825567212808 \
1.420684844328398e-06 0.469441659996985 1.420685087159409e-06 0.4745824626509371 1.420685386935037e-06 0.4808894567257585 1.420685624728187e-06 0.4858624696070272 \
1.420685887949588e-06 0.4913374535260851 1.420686148847132e-06 0.4967277906005185 1.42068637840122e-06 0.5014431429135263 1.420686601461413e-06 0.506003872007333 \
1.420686803037404e-06 0.5100983586086808 1.420686951867463e-06 0.51310967141356 1.420687196178516e-06 0.5180317772556589 1.420687328783749e-06 0.5206893064287169 \
1.420687468140331e-06 0.5234717264876519 1.420687679105724e-06 0.5276623644271943 1.420687853979606e-06 0.5311266030493931 1.420688122027852e-06 0.5364094032095129 \
1.42068831705351e-06 0.5402319029111832 1.420688496615017e-06 0.5437361368949839 1.420688747571146e-06 0.5486228351952749 1.420689024979257e-06 0.5540035987981641 \
1.420689308928559e-06 0.5594901708581531 1.42068956456585e-06 0.5644152233389156 1.420689855548069e-06 0.570006772487656 1.420690115853754e-06 0.5749917787111524 \
1.420690384297874e-06 0.5801232573974072 1.420690627063004e-06 0.5847450403362237 1.420690883594205e-06 0.5896146675871002 1.420691109757648e-06 0.59388771440121 \
1.420691347099143e-06 0.5983512154742827 1.42069155648786e-06 0.6022720321566808 1.420691770260628e-06 0.6062574570422776 1.420692023713469e-06 0.6109557890491497 \
1.420692226567816e-06 0.6146943332140289 1.420692419372338e-06 0.6182333111593361 1.420692609677365e-06 0.6217090173923294 1.420692800335854e-06 0.6251694921350958 \
1.42069300291378e-06 0.6288260100903066 1.420693265662542e-06 0.6335359534764116 1.420693494630232e-06 0.6376100987349322 1.420693714577867e-06 0.6414991146358265 \
1.42069394026254e-06 0.6454625140719233 1.420694149149966e-06 0.6491091855837361 1.420694370803585e-06 0.652957810138281 1.42069455569301e-06 0.6561429680377227 \
1.420694745707564e-06 0.6594017273991298 1.420694895862686e-06 0.6619630641908443 1.420695070740593e-06 0.6649292185271485 1.420695216461309e-06 0.6673855496832628 \
1.420695352493841e-06 0.6696641287411549 1.420695500856121e-06 0.672138295335571 1.420695630303834e-06 0.6742883907026684 1.420695764169531e-06 0.6764996355878535 \
1.42069589251393e-06 0.6786115243545502 1.420696017902058e-06 0.6806677490053815 1.420696147367755e-06 0.6827843190971332 1.42069627834897e-06 0.6849171426143115 \
1.420696426722072e-06 0.6873221141612875 1.420696534784827e-06 0.6890667486235877 1.420696663316499e-06 0.6911333958680312 1.420696798756283e-06 0.6933004139195943 \
1.420696923690607e-06 0.6952876996714908 1.420697049447875e-06 0.6972799977491608 1.420697155963766e-06 0.6989584331773744 1.420697273081655e-06 0.7007929859467624 \
1.420697391621401e-06 0.7026383448210159 1.420697514924797e-06 0.704545102273978 1.420697618097696e-06 0.7061304255463237 1.420697769068859e-06 0.7084341141567283 \
1.420697885323065e-06 0.7101955266062138 1.420698015883454e-06 0.7121605601685687 1.420698134445982e-06 0.7139335830373704 1.420698240519852e-06 0.7155108922888329 \
1.420698340544791e-06 0.716990346352101 1.420698477870006e-06 0.719009255813789 1.420698596531362e-06 0.7207429633399333 1.420698718230586e-06 0.7225107522614664 \
1.420698843413151e-06 0.7243181860083944 1.420698965432965e-06 0.7260693242762759 1.420699093464718e-06 0.7278954552757622 1.420699217946458e-06 0.7296603419865877 \
1.420699346245781e-06 0.7314685590147565 1.420699473339584e-06 0.7332489547570846 1.420699599364423e-06 0.7350034830462163 1.42069970210311e-06 0.7364262918236342 \
1.420699816775855e-06 0.7380063527755659 1.420699898181918e-06 0.7391232259175492 1.420700017381438e-06 0.7407496908814458 1.420700110023778e-06 0.7420059782745783 \
1.420700248182835e-06 0.7438668850244906 1.420700379238334e-06 0.7456179978167152 1.420700509370502e-06 0.7473439783685625 1.420700614344577e-06 0.7487266533969134 \
1.420700753484419e-06 0.7505456565005918 1.420700907428719e-06 0.7525407731682957 1.420701029372999e-06 0.7541080835708853 1.420701176919359e-06 0.7559892974429111 \
1.420701298924537e-06 0.7575320275232224 1.420701447624466e-06 0.7593968175435225 1.420701581671092e-06 0.7610632318338031 1.420701703924347e-06 0.7625711443351471 \
1.420701816790257e-06 0.763953046884334 1.420701959641225e-06 0.7656882893306027 1.420702086364119e-06 0.7672149413549471 1.420702202168994e-06 0.7685995877768005 \
1.420702331910823e-06 0.7701390587657672 1.42070244764921e-06 0.7715019052061673 1.420702570601637e-06 0.7729391548276606 1.420702688317297e-06 0.7743051053122872 \
1.420702794287273e-06 0.7755262985206828 1.420702910698467e-06 0.7768586864857919 1.4207030173164e-06 0.7780703956921795 1.42070312951512e-06 0.7793369495935717 \
1.420703216183689e-06 0.7803089322889447 1.420703319569181e-06 0.7814603789665585 1.420703432733432e-06 0.7827108149434853 1.420703538380715e-06 0.783868819044773 \
1.420703647720273e-06 0.7850578567336689 1.420703754897288e-06 0.786214126597127 1.420703884303365e-06 0.7875981444497275 1.42070399672075e-06 0.7887899291890393 \
1.42070412010849e-06 0.7900869036018625 1.420704237558825e-06 0.7913106402786101 1.420704381085744e-06 0.7927918312347375 1.420704496005322e-06 0.7939667362870242 \
1.420704634727735e-06 0.7953719780830618 1.420704772759875e-06 0.7967562205547866 1.420704882253029e-06 0.7978444364842524 1.420704983271459e-06 0.7988406866985471 \
1.42070508435942e-06 0.7998302780396641 1.420705216746616e-06 0.8011146558616069 1.420705335472037e-06 0.8022550163876687 1.420705457256542e-06 0.8034134048507504 \
1.420705576346336e-06 0.8045351524060473 1.420705697550853e-06 0.8056657048884367 1.420705829194664e-06 0.8068811249615274 1.420705952212703e-06 0.8080052413861453 \
1.420706079823023e-06 0.8091594649786741 1.420706210891683e-06 0.8103325925767672 1.420706334212046e-06 0.8114249716726942 1.42070644213631e-06 0.8123719892944993 \
1.420706549931703e-06 0.8133095350680949 1.420706631652631e-06 0.8140147772069938 1.420706748520247e-06 0.815015186305849 1.420706839581256e-06 0.8157880755829442 \
1.420706973749887e-06 0.8169164295805346 1.42070711832076e-06 0.8181184617099191 1.420707251823126e-06 0.8192158725965917 1.420707361789037e-06 0.8201107352847025 \
1.420707505654697e-06 0.8212684563313245 1.420707658960262e-06 0.8224861772268215 1.420707786698555e-06 0.8234883060891934 1.420707927340891e-06 0.8245786478120171 \
1.420708053124456e-06 0.8255423809867173 1.420708207742427e-06 0.8267124309768116 1.420708340154193e-06 0.8277017767197102 1.420708466433798e-06 0.8286345641820314 \
1.420708584064113e-06 0.8294941055817234 1.420708732230976e-06 0.8305638349826423 1.420708899375221e-06 0.8317531470681401 1.420709031993881e-06 0.832683775428688 \
1.420709204938569e-06 0.8338803479528284 1.420709373325224e-06 0.8350269493631071 1.420709542859754e-06 0.8361634673386688 1.420709724228909e-06 0.8373596561587384 \
1.420709866861491e-06 0.8382862741713709 1.420709980797339e-06 0.8390176620397163 1.420710111571134e-06 0.8398476357987267 1.420710213225074e-06 0.8404856735008092 \
1.420710329718802e-06 0.8412091703399448 1.420710465236349e-06 0.8420405885319162 1.420710662580143e-06 0.8432318270427018 1.420710853245141e-06 0.8443612543037786 \
1.42071106310198e-06 0.8455804035625291 1.420711244039104e-06 0.8466117334714958 1.420711441374591e-06 0.8477160230260256 1.420711615161427e-06 0.8486711109012058 \
1.420711797742881e-06 0.8496572451898022 1.420711969062461e-06 0.850566499179887 1.420712143447507e-06 0.8514760798656241 1.420712318831052e-06 0.8523748177975867 \
1.420712495063209e-06 0.8532619682996843 1.420712684901452e-06 0.8542000584728613 1.420712875637665e-06 0.8551245802328369 1.420713077434399e-06 0.856083442102113 \
1.420713270127775e-06 0.8569809170305027 1.420713479756076e-06 0.857937542729613 1.42071370919384e-06 0.8589615588718806 1.42071397499048e-06 0.8601183337444025 \
1.420714273565707e-06 0.8613802063570262 1.420714551467221e-06 0.8625196921548358 1.420714835677695e-06 0.8636511027355716 1.420715110089482e-06 0.8647118800460076 \
1.420715382252364e-06 0.8657341977214618 1.420715652421455e-06 0.8667205537246333 1.420715909616139e-06 0.8676338760342862 1.42071618215581e-06 0.868575115807136 \
1.420716458190291e-06 0.8695013130444248 1.420716728342986e-06 0.8703818891200001 1.420717028049787e-06 0.8713292845176382 1.420717398867258e-06 0.8724597217497643 \
1.420717693785921e-06 0.8733269024855727 1.420717948030199e-06 0.8740525764960509 1.420718246254198e-06 0.8748787854419284 1.420718519878969e-06 0.8756137195941651 \
1.420718756017958e-06 0.8762307200963571 1.420718996373686e-06 0.8768427579093606 1.420719218719338e-06 0.8773949085683344 1.420719412723072e-06 0.877865919014753 \
1.420719742447196e-06 0.878644045115768 1.420719897619855e-06 0.8790007149587372 1.420720215373248e-06 0.879712598742095 1.420720394238605e-06 0.8801026384247937 \
1.420720736700093e-06 0.8808283583858193 1.420720920841292e-06 0.8812073588304842 1.420721395746114e-06 0.8821499412898334 1.420721563140601e-06 0.8824705695712217 \
1.420722028971889e-06 0.8833323038036038 1.420722209796771e-06 0.8836551183393088 1.420722703830028e-06 0.8845051821644966 1.420722845172603e-06 0.8847400410050358 \
1.420723451563118e-06 0.8857071861637142 1.420723603635685e-06 0.8859397703602404 1.420724250313758e-06 0.8868873789663725 1.420724378610247e-06 0.8870678433440622 \
1.420725026723245e-06 0.8879435266410994 1.420725156528523e-06 0.8881118897635528 1.420725934785608e-06 0.8890711781604964 1.420726049780422e-06 0.8892053868933587 \
1.420726905511062e-06 0.8901454611437621 1.420727050777629e-06 0.8902951528450479 1.420728036533732e-06 0.8912364417375994 1.420728257640946e-06 0.8914302300078862 \
1.420729402752027e-06 0.892358484239638 1.420729533960174e-06 0.8924604119362172 1.420730875263369e-06 0.8934531785430913 1.42073102665103e-06 0.8935579568409697 \
1.420732508109867e-06 0.8944876667405802 1.420732746990229e-06 0.894621531696939 1.420734516461986e-06 0.8954958910368339 1.420734905568823e-06 0.8956641700186337 \
1.420737299334232e-06 0.8965498195158238 1.420737774894223e-06 0.8966991754584082 1.420741837950387e-06 0.8976977719002629 1.420742329424408e-06 0.8977905759376156 \
1.420750645951487e-06 0.8987839664765119 1.420751565805377e-06 0.8988472044554419 1.420877770945903e-06 0.8998441026240215 1.420878784754255e-06 0.8998514601858095 \
1.421070497347411e-06 0.8990059056521554 1.421070727348974e-06 0.8988405173838494 1.421072342221535e-06 0.8978439928078279 1.421072519935388e-06 0.8977495532019018 \
1.421089285710428e-06 0.8987316330193963 1.421089421698825e-06 0.8987497732072308 1.421104884427938e-06 0.8997471920221268 1.42110515229253e-06 0.8997526389354535 \
1.421588977619798e-06 0.9006560548284696 1.421589098408998e-06 0.9007687033315858 1.421589886180037e-06 0.9017381658104292 1.421590020318756e-06 0.901943163319478 \
1.42159051393353e-06 0.9027850367016239 1.421590658833145e-06 0.9030569221572713 1.42159105464053e-06 0.9038490360455199 1.421591174436184e-06 0.9041001886668685 \
1.421591558609717e-06 0.9049189780371781 1.421591670731365e-06 0.9051556495331843 1.421592178052335e-06 0.9061253139956988 1.421592272051191e-06 0.90626859229291 \
1.421593430700898e-06 0.9055667778886739 1.421593533663832e-06 0.9051589876696525 1.421593617506701e-06 0.9047707260375384 1.421593751246752e-06 0.9040404158978201 \
1.421593851964133e-06 0.9033957423200318 1.421593959579919e-06 0.9026166239542108 1.421594077153173e-06 0.9016533104038295 1.421594165418223e-06 0.90085556431878 \
1.421594285051691e-06 0.8996698288011099 1.421594382373389e-06 0.8986166602050341 1.421594493390827e-06 0.8973222354192386 1.421594595500415e-06 0.8960407982554908 \
1.421594678931815e-06 0.8949326975987755 1.421594783112882e-06 0.8934749428758865 1.421594874199646e-06 0.8921321265381427 1.421594966740432e-06 0.8907058396397178 \
1.42159506189443e-06 0.8891776325191247 1.421595176449407e-06 0.88725933118288 1.421595265292509e-06 0.8857137884271823 1.421595363531691e-06 0.8839502506198179 \
1.421595448901864e-06 0.8823735982707064 1.421595529802107e-06 0.8808434949738935 1.421595602763399e-06 0.8794355441897157 1.421595669782045e-06 0.8781198554636557 \
1.421595738393124e-06 0.8767515715160701 1.421595821888036e-06 0.8750591081124355 1.421595884015366e-06 0.8737811510706814 1.421595946997964e-06 0.8724704924326797 \
1.421596042153715e-06 0.8704632161180945 1.421596142764353e-06 0.8683077530860182 1.421596222643544e-06 0.8665738309361769 1.421596306905814e-06 0.8647250601592834 \
1.421596386016074e-06 0.8629723295901451 1.421596448831519e-06 0.8615696597604833 1.421596536288553e-06 0.8596016864744445 1.421596602182084e-06 0.8581079708060287 \
1.421596670243626e-06 0.856556281928966 1.421596719556134e-06 0.8554267461646872 1.421596774792923e-06 0.85415654045335 1.421596815532529e-06 0.8532164928603474 \
1.421596861834283e-06 0.8521450198670055 1.421596892048343e-06 0.8514441160591502 1.421596921089625e-06 0.8507691938976955 1.42159695172822e-06 0.8500558939662993 \
1.42159701300541e-06 0.8486254874746039 1.421597066077972e-06 0.8473828229799116 1.421597119733165e-06 0.8461232012188223 1.421597182390447e-06 0.8446482873934593 \
1.421597245673395e-06 0.8431545995644786 1.421597336171269e-06 0.8410121009440262 1.421597433169049e-06 0.8387078554355326 1.42159751614655e-06 0.8367307351423475 \
1.421597598150905e-06 0.8347721678896715 1.421597687219306e-06 0.8326403548070889 1.421597771732643e-06 0.8306135893189693 1.421597862591523e-06 0.8284303722590877 \
1.421597954526378e-06 0.8262176456275642 1.421598056957308e-06 0.8237486178045141 1.42159815707534e-06 0.8213320995840899 1.421598271896223e-06 0.8185572053828121 \
1.42159838410276e-06 0.8158423448209959 1.421598509096305e-06 0.8128151787794674 1.421598640356713e-06 0.8096337870015397 1.421598785627755e-06 0.8061104108175116 \
1.421598940135368e-06 0.8023613213197434 1.421599111575989e-06 0.7981999722344618 1.421599275625781e-06 0.794217661721315 1.421599460041203e-06 0.7897413884478564 \
1.421599666533577e-06 0.7847307375046715 1.42159985602742e-06 0.7801344622909899 1.421600049421182e-06 0.775444374634302 1.421600249988037e-06 0.7705834242206392 \
1.421600397552439e-06 0.7670092004965298 1.42160052756389e-06 0.7638619034739171 1.421600662428303e-06 0.7605987503374771 1.421600768918754e-06 0.7580234999254772 \
1.421600900608547e-06 0.7548403390839162 1.421601007032976e-06 0.7522693550468039 1.421601150211605e-06 0.7488125398635642 1.421601311338716e-06 0.7449250928176189 \
1.421601429565533e-06 0.7420746008290786 1.421601599798354e-06 0.7379721584775248 1.421601765724623e-06 0.7339761998059781 1.421601985266954e-06 0.7286940862104242 \
1.421602178454078e-06 0.724050920820232 1.421602353368041e-06 0.719851304223293 1.421602520315139e-06 0.7158476177432674 1.4216027078061e-06 0.711355754450834 \
1.421602895234537e-06 0.7068709122373377 1.421603063571096e-06 0.7028473835914892 1.42160325640163e-06 0.6982428782038785 1.421603396451377e-06 0.694901318858167 \
1.421603552708666e-06 0.6911769338170629 1.421603746878113e-06 0.6865540563080536 1.421603905984601e-06 0.6827702245679255 1.421604064344632e-06 0.679008548037742 \
1.42160425966174e-06 0.6743756772263459 1.421604470090519e-06 0.6693917663527935 1.421604722792664e-06 0.6634173774538097 1.421604902460615e-06 0.6591769455535931 \
1.421605154037489e-06 0.6532475027332399 1.421605354410306e-06 0.6485340174553987 1.421605526064158e-06 0.6445032789616798 1.421605684756275e-06 0.6407814961122935 \
1.421605823964202e-06 0.637522316374186 1.421605960288252e-06 0.6343349641335875 1.421606087501276e-06 0.6313646237382058 1.421606216993833e-06 0.6283457899522861 \
1.421606344985121e-06 0.6253646753452949 1.42160647605963e-06 0.6223174651643489 1.421606606771705e-06 0.6192830747181834 1.421606749379757e-06 0.6159760732208495 \
1.421606892103235e-06 0.612672916206165 1.421607044651037e-06 0.6091471600588 1.421607189155024e-06 0.6058158037532523 1.421607353173272e-06 0.6020406322262999 \
1.421607490637933e-06 0.5988837056407329 1.421607625454949e-06 0.5957940466067043 1.421607746953592e-06 0.5930134750293682 1.421607885803897e-06 0.5898448108574432 \
1.421607999450713e-06 0.5872554148224447 1.421608150860885e-06 0.5838116422847746 1.42160826457956e-06 0.5812320812748947 1.421608383992651e-06 0.5785269636915771 \
1.421608472673178e-06 0.5765205397309219 1.421608563818269e-06 0.5744630259469776 1.421608629157144e-06 0.5729901393713442 1.421608693626847e-06 0.5715377831648228 \
1.421608744447459e-06 0.5703933076453638 1.421608803422398e-06 0.569066051987989 1.421608870867106e-06 0.5675516747474645 1.421608937959298e-06 0.5660472084764079 \
1.421608990879742e-06 0.5648615894615425 1.421609086527225e-06 0.5627204246953637 1.421609143708361e-06 0.5614413394337 1.421609197510977e-06 0.5602399192081799 \
1.421609259253082e-06 0.5588634520375642 1.421609345086214e-06 0.5569525037715509 1.421609427781861e-06 0.5551133137453282 1.421609553910589e-06 0.552313430559463 \
1.421609689009664e-06 0.5493247407981657 1.421609787329828e-06 0.5471534914294828 1.42160989990789e-06 0.5446716589975775 1.421610002452305e-06 0.5424173856211837 \
1.421610122561131e-06 0.5397821662853191 1.421610224248782e-06 0.5375541863492928 1.421610339752745e-06 0.5350300289250629 1.421610454643861e-06 0.5325260225312031 \
1.421610581121134e-06 0.5297740207092871 1.421610706338329e-06 0.5270565158317848 1.421610853184312e-06 0.5238798967507053 1.421610988642446e-06 0.5209557060405445 \
1.421611146203054e-06 0.5175672114705414 1.421611308357229e-06 0.5140875588169389 1.421611489068307e-06 0.5102248342695275 1.42161168131606e-06 0.5061308236654174 \
1.421611894038323e-06 0.5016182665703952 1.421612125943484e-06 0.4967183500883584 1.421612383137188e-06 0.4913135654247419 1.421612622690498e-06 0.4863004534671564 \
1.421612924620373e-06 0.4800178499336004 1.421613212386814e-06 0.4740665530855001 1.421613525189057e-06 0.4676409412178996 1.421613845020806e-06 0.4611139840073785 \
1.421614184657409e-06 0.4542292677834274 1.421614511873228e-06 0.4476411633207955 1.421614847034797e-06 0.4409363684817221 1.421615164291457e-06 0.4346351592989786 \
1.421615498111436e-06 0.4280489847791872 1.42161584979678e-06 0.4211625252737479 1.421616163864498e-06 0.4150547397555842 1.421616486893702e-06 0.4088175946446666 \
1.421616927873099e-06 0.4003732788922496 1.421617270275942e-06 0.3938810608698495 1.42161757072383e-06 0.3882325136127223 1.421617946053401e-06 0.3812375944419973 \
1.42161827612863e-06 0.3751439175705365 1.421618559406411e-06 0.3699597784791666 1.421618859913772e-06 0.3645020109013299 1.421619139561233e-06 0.3594637112692664 \
1.421619363423524e-06 0.3554634414471464 1.421619575274513e-06 0.35170280677964 1.421619777623113e-06 0.3481338771034005 1.421619978758139e-06 0.3446120049995081 \
1.421620184535656e-06 0.3410324794262659 1.421620445514371e-06 0.3365252478245505 1.421620685004553e-06 0.3324209773202946 1.421620917679624e-06 0.3284665339262754 \
1.421621131761216e-06 0.3248537323113044 1.421621352906983e-06 0.3211475567840967 1.421621553789873e-06 0.3178053707831449 1.421621757181075e-06 0.3144500223650613 \
1.421621954849488e-06 0.3112139453100684 1.421622141093175e-06 0.3081862077816076 1.421622336074257e-06 0.3050391973134606 1.421622539536502e-06 0.3017803754370622 \
1.421622717477407e-06 0.2989521325826759 1.421622953201112e-06 0.2952356640875101 1.421623151333965e-06 0.2921385263640672 1.421623352678033e-06 0.2890160050544278 \
1.42162357696723e-06 0.2855690750291008 1.421623741897129e-06 0.2830551950838826 1.421623919525814e-06 0.2803657404651576 1.421624103924961e-06 0.2775946687427531 \
1.421624287746306e-06 0.2748547260732712 1.421624466202978e-06 0.2722194282383935 1.421624638103246e-06 0.2696976713509589 1.421624798643653e-06 0.2673699088296289 \
1.421624920125711e-06 0.265617282026588 1.421625073047238e-06 0.2634201198254058 1.421625200480934e-06 0.2616085083773952 1.421625304654605e-06 0.2601317890528609 \
1.421625421559081e-06 0.2584775571399547 1.421625536570573e-06 0.2568557450124987 1.421625660932803e-06 0.2551103168403305 1.421625776507086e-06 0.2534925198640895 \
1.421625910614607e-06 0.2516172680784447 1.421626025601848e-06 0.2500177396912131 1.421626179351445e-06 0.2478798443778067 1.421626316154646e-06 0.2459790966208961 \
1.421626450740453e-06 0.2441094379339017 1.421626606604589e-06 0.2419575875351012 1.421626731253411e-06 0.2402378086535915 1.421626870468935e-06 0.2383186229544463 \
1.42162700069296e-06 0.236525770455347 1.4216271210458e-06 0.2348769158236033 1.421627256439084e-06 0.233027137746051 1.421627407644063e-06 0.2309620730808924 \
1.421627542400533e-06 0.2291249940296414 1.42162764708672e-06 0.2277003186426776 1.421627769622861e-06 0.2260366668203369 1.42162790456742e-06 0.2242086518061946 \
1.421627999683167e-06 0.2229209267876512 1.421628114943222e-06 0.2213657311907907 1.421628197476202e-06 0.2202562617028589 1.421628268681533e-06 0.2192992955643472 \
1.421628317389017e-06 0.2186449771734718 1.421628364583973e-06 0.2180112263680214 1.421628411132791e-06 0.2173864029843717 1.421628464521355e-06 0.2166701476649976 \
1.421628501898025e-06 0.2161690444847812 1.421628539283138e-06 0.2156680710113931 1.421628579604508e-06 0.2151283464800275 1.421628650854647e-06 0.2141753141901174 \
1.421628685068904e-06 0.2137180869447317 1.421628731463534e-06 0.2131018213873352 1.421628791907201e-06 0.2122998083652294 1.42162886091012e-06 0.2113853596849882 \
1.421628926205072e-06 0.210520730631805 1.421628994183195e-06 0.2096212333552783 1.421629110629525e-06 0.2080823984153433 1.421629200551713e-06 0.2068957989735914 \
1.42162930821762e-06 0.2054771097790837 1.421629404278935e-06 0.2042146625011118 1.421629507657509e-06 0.2028641889872041 1.421629604342544e-06 0.2016026287683381 \
1.421629707152396e-06 0.2002625524503448 1.421629807912368e-06 0.1989526210414513 1.421629919058034e-06 0.1975116692735505 1.421630026097528e-06 0.1961279675313261 \
1.421630144004064e-06 0.1946083430154048 1.421630252114387e-06 0.1932197128021231 1.421630361412987e-06 0.1918224631760269 1.421630482044739e-06 0.1902849927564414 \
1.421630576945331e-06 0.1890796997295432 1.42163070550625e-06 0.18745262875399 1.421630798541038e-06 0.1862801166370808 1.421630900937594e-06 0.1849947785893032 \
1.421630988904886e-06 0.1838942174288659 1.421631087175557e-06 0.182668828510528 1.421631183776179e-06 0.1814691026470878 1.421631270414692e-06 0.1803971466393716 \
1.421631356823704e-06 0.1793305247657973 1.421631452660814e-06 0.1781527189679156 1.421631557387688e-06 0.1768710765218302 1.421631703199975e-06 0.1750963017969037 \
1.421631819167907e-06 0.1736923427161618 1.421631975631711e-06 0.1718092975148396 1.42163208681163e-06 0.1704786474822015 1.421632227061631e-06 0.1688098560703619 \
1.421632350073035e-06 0.1673544160765056 1.421632456564033e-06 0.1661007559767333 1.421632552889491e-06 0.1649724583647661 1.421632650322958e-06 0.1638357962207703 \
1.421632754176237e-06 0.1626293386330815 1.42163284597681e-06 0.1615673458739011 1.421632944364525e-06 0.1604337426303964 1.42163302728317e-06 0.1594828374885931 \
1.421633122651503e-06 0.1583950132920943 1.421633205213851e-06 0.1574587876231885 1.421633307798537e-06 0.1563016192679324 1.421633384076854e-06 0.1554454316211293 \
1.421633472662479e-06 0.1544557264474612 1.421633544831984e-06 0.1536532700165102 1.421633626541473e-06 0.1527486200895024 1.421633700220281e-06 0.1519363404455653 \
1.421633780440409e-06 0.1510573496788611 1.421633852168484e-06 0.1502755532525617 1.421633920425463e-06 0.149534520573691 1.421634018141422e-06 0.1484788062294206 \
1.421634087591606e-06 0.147731872792437 1.421634170343085e-06 0.1468455801890639 1.421634230379995e-06 0.1462052652532956 1.421634300618658e-06 0.1454587420502366 \
1.421634372046193e-06 0.1447037411390827 1.421634452559695e-06 0.1438588888651768 1.421634515822599e-06 0.1431977449412327 1.421634593496578e-06 0.1423892845091393 \
1.421634682806343e-06 0.141463758692191 1.421634752169929e-06 0.1407479403162204 1.421634850118149e-06 0.1397418416088305 1.421634940462669e-06 0.1388188591118084 \
1.421635026242994e-06 0.1379520826379384 1.421635093896779e-06 0.1372719511642241 1.421635160204629e-06 0.1366075914250998 1.421635238824321e-06 0.1358227655030745 \
1.42163531951923e-06 0.135020537018139 1.421635377921894e-06 0.1344419857224206 1.421635438674417e-06 0.1338420332148588 1.421635532580729e-06 0.1329184183639811 \
1.421635574978232e-06 0.1325029080242558 1.421635654222426e-06 0.1317336600863391 1.421635694592584e-06 0.1313430593815061 1.421635784293463e-06 0.130477658168832 \
1.42163582324155e-06 0.1301029732927899 1.421635918857236e-06 0.1291862249441596 1.421635957741065e-06 0.1288146335111444 1.421636050975841e-06 0.1279263274670414 \
1.42163611931843e-06 0.1272775968534341 1.421636171639285e-06 0.1267823325594629 1.421636253739999e-06 0.1260075984242486 1.421636324903378e-06 0.1253406747583812 \
1.421636402856366e-06 0.1246136378429537 1.421636481976102e-06 0.1238779526756392 1.421636560619333e-06 0.1231489004754178 1.421636640654241e-06 0.122409328367501 \
1.421636702388658e-06 0.1218405706457005 1.42163677598364e-06 0.1211645344030958 1.421636859363458e-06 0.120401093559758 1.421636923460189e-06 0.1198161795466899 \
1.421636992898777e-06 0.119184869057559 1.421637065921715e-06 0.1185234239195788 1.421637150796627e-06 0.1177582144838446 1.421637230159478e-06 0.117046673033812 \
1.421637314893136e-06 0.1162898833629492 1.421637405604425e-06 0.1154830714735263 1.421637481187503e-06 0.1148135241260771 1.421637546915428e-06 0.1142333070693714 \
1.421637606975201e-06 0.1137047561823949 1.421637676580917e-06 0.1130943456353956 1.421637742999968e-06 0.1125141752866663 1.421637822411231e-06 0.1118230150855203 \
1.421637912674161e-06 0.1110406875128299 1.421637981718461e-06 0.1104447270551955 1.42163805627358e-06 0.1098035355921305 1.421638144757501e-06 0.1090456469739195 \
1.421638223865648e-06 0.1083709350695736 1.421638293734029e-06 0.1077773127978274 1.421638374743399e-06 0.1070920034756896 1.421638430948212e-06 0.106618206733547 \
1.421638493607492e-06 0.1060916009495399 1.421638558754098e-06 0.105545887371837 1.421638630089726e-06 0.1049504956797945 1.421638750386101e-06 0.1039516085561449 \
1.421638801939673e-06 0.103525508500865 1.421638857088741e-06 0.1030709598036589 1.421638947785925e-06 0.1023262935955709 1.421639030175778e-06 0.1016530765296615 \
1.421639125755585e-06 0.1008759670630478 1.421639232965152e-06 0.1000092507657299 1.421639336624558e-06 0.09917656019160864 1.421639422832161e-06 0.09848810438956324 \
1.421639509074386e-06 0.09780303991321163 1.42163958861546e-06 0.09717448010577609 1.421639668628333e-06 0.09654538840876434 1.421639759916661e-06 0.09583163072761708 \
1.421639841662079e-06 0.09519620281310773 1.421639930588917e-06 0.09450872319168514 1.421640020366224e-06 0.09381864801001834 1.421640097328872e-06 0.09323024625953365 \
1.421640187653689e-06 0.0925435244861572 1.421640251462415e-06 0.09206084550525626 1.421640323925982e-06 0.09151514907748673 1.421640388054635e-06 0.09103438864950099 \
1.421640466302011e-06 0.09045054736970405 1.421640566003292e-06 0.08971110930136832 1.421640640056443e-06 0.08916512281998501 1.421640726664978e-06 0.08852997392441805 \
1.421640872964685e-06 0.08746544055362569 1.421640983676948e-06 0.08666684197409438 1.421641093986626e-06 0.08587717033461532 1.421641236182269e-06 0.08486839672072237 \
1.42164137623472e-06 0.08388450488753585 1.421641518880534e-06 0.08289222299161547 1.421641667651249e-06 0.08186778387581196 1.421641804363935e-06 0.08093569403044946 \
1.421641946484565e-06 0.07997640434545976 1.421642081061545e-06 0.07907728405019222 1.421642221281423e-06 0.07814997945867638 1.421642369028229e-06 0.07718353387841098 \
1.421642518982415e-06 0.07621348085094087 1.421642683698247e-06 0.07516037195605636 1.421642847284363e-06 0.07412732798506308 1.421643021932716e-06 0.07303837372665309 \
1.421643208986408e-06 0.07188781219077654 1.421643418972926e-06 0.0706159374129187 1.421643637046174e-06 0.06931715807027321 1.421643870366327e-06 0.06795188046253516 \
1.421644124845881e-06 0.0664909822812602 1.42164441780254e-06 0.06484528303377844 1.421644719953089e-06 0.06318745987130532 1.421645057674791e-06 0.06138078634948794 \
1.421645452783393e-06 0.05932807220464856 1.421645820234636e-06 0.05747953410674719 1.421646237842402e-06 0.05544691527644593 1.421646582838376e-06 0.0538196438399016 \
1.421646933380665e-06 0.05221302159193914 1.421647248341029e-06 0.0508087490907442 1.421647547582395e-06 0.049508488261462 1.421647846948247e-06 0.04824029756235761 \
1.421648122190958e-06 0.04710512226277328 1.421648405654524e-06 0.04596497870754415 1.421648667254946e-06 0.04493681260994405 1.421648944707071e-06 0.04387103439794762 \
1.421649220766506e-06 0.04283531238677037 1.421649529036243e-06 0.04170718945545093 1.421649751468863e-06 0.0409114719535993 1.421650039009947e-06 0.03990505631995635 \
1.42165027524288e-06 0.0390969788355163 1.421650593704555e-06 0.03803800466874574 1.421650844115589e-06 0.03722710566490722 1.421651167100391e-06 0.03620720400565681 \
1.421651425436406e-06 0.03541203096995557 1.421651715410284e-06 0.03454066075983582 1.421651945205102e-06 0.0338658635512188 1.421652230100444e-06 0.03304787219836024 \
1.421652469846563e-06 0.03237513696606491 1.421652710481132e-06 0.03171392889024889 1.421652949599619e-06 0.03107212555077287 1.42165318553853e-06 0.03045460689686571 \
1.421653416367391e-06 0.02986254663395104 1.421653631393919e-06 0.02932175456294728 1.42165403355976e-06 0.0283374222946415 1.42165423211788e-06 0.02786401170979088 \
1.421654605819066e-06 0.02699470773596776 1.421654792632261e-06 0.02657042318767052 1.421655138633508e-06 0.02580176906824739 1.421655260576946e-06 0.02553595448027303 \
1.421655643429963e-06 0.02472011952872977 1.421655803864149e-06 0.02438657631284594 1.421656246865303e-06 0.02348572425118655 1.421656417479344e-06 0.02314627247835563 \
1.42165673805594e-06 0.02251902970747987 1.421656938340868e-06 0.0221336684630111 1.421657385278801e-06 0.02128811173678137 1.421657513222916e-06 0.02104854104185888 \
1.421658001100276e-06 0.02014826272243131 1.421658136077553e-06 0.01990454278080647 1.421658618329071e-06 0.0190640092473091 1.421658780655186e-06 0.01879235028057063 \
1.421659267049527e-06 0.01801148170254873 1.421659430077186e-06 0.01776103207540622 1.421660110298876e-06 0.01676849304257711 1.421660249382614e-06 0.01657541006259178 \
1.421660981877148e-06 0.01560782569993242 1.42166114077078e-06 0.01540693214221847 1.421661923851867e-06 0.01445869962397344 1.421662069644422e-06 0.01428952172302696 \
1.421662920425781e-06 0.01334248985256295 1.421663031529053e-06 0.01322388191882306 1.421663964823416e-06 0.0122699293983148 1.421664098661466e-06 0.01213902814618388 \
1.421665057199482e-06 0.01123495036716388 1.421665178316551e-06 0.01112486091825863 1.421666300400348e-06 0.01017270671243764 1.421666405901602e-06 0.01008921053061839 \
1.421667734976014e-06 0.009112307258623473 1.421667855180288e-06 0.009029744095492466 1.421669403542048e-06 0.008036808760534916 1.421669484329818e-06 0.007986285493236449 \
1.421671055209352e-06 0.007024564730313319 1.421671122625551e-06 0.006986095570813155 1.421673043392229e-06 0.006001386377072119 1.421673230194113e-06 0.005914747648762168 \
1.42167554560806e-06 0.0049318160947762 1.421675945134908e-06 0.004777795182599986 1.421678508944408e-06 0.003889929704329555 1.421679007815328e-06 0.003736330440833864 \
1.421682637539317e-06 0.002784984367379526 1.421683188233292e-06 0.002663729254427667 1.421688586673671e-06 0.001711392372544448 1.421688899941243e-06 0.001662511220227468 \
1.421693892233791e-06 0.0006970413096974805 1.421694076252826e-06 0.0006571176749162138 1.424342555395609e-06 -0.0002691198397987355 1.424342711454572e-06 -0.0004551674219448388 \
1.424343259438427e-06 -0.001322174727784445 1.42434337237642e-06 -0.001539785040943742 1.42434380163135e-06 -0.002474302920374066 1.424343907888515e-06 -0.002730173903076456 \
1.424344190690666e-06 -0.003454402452283872 1.42434430428521e-06 -0.003760966378165151 1.424344642839789e-06 -0.004705104513819927 1.42434475526375e-06 -0.005021586953003071 \
1.42434508354165e-06 -0.005887841248467669 1.424345191080172e-06 -0.006130875888161453 1.424346071006203e-06 -0.005789627805322099 1.42434624621225e-06 -0.004910736584223327 \
1.424346363043013e-06 -0.004127745010746014 1.424346489910137e-06 -0.00309221842859156 1.424346591442863e-06 -0.002125750314016509 1.424346712864133e-06 -0.0008095618968406578 \
1.424346803029046e-06 0.0002767910803854594 1.424346900212695e-06 0.001550247908954045 1.42434699828696e-06 0.002938803805678211 1.424347165508045e-06 0.005530627736217106 \
1.424347387813323e-06 0.009378371294171852 1.424347573551714e-06 0.01290572951649239 1.424347797633049e-06 0.01747895571448658 1.424347957277782e-06 0.02091945933227325 \
1.424348121767111e-06 0.02459614091902196 1.424348271591569e-06 0.0280452875125503 1.424348420991461e-06 0.03156498790849799 1.424348570522767e-06 0.03515592969144176 \
1.424348724602661e-06 0.03891669635189081 1.424348886786809e-06 0.0429309674228065 1.424349053210035e-06 0.0470989728378523 1.424349229143508e-06 0.05154884981278444 \
1.424349410271779e-06 0.05616867911875007 1.424349602402704e-06 0.06110225049351239 1.424349810098117e-06 0.0664648391313285 1.424350032018198e-06 0.07222051812179281 \
1.42435026721968e-06 0.07834079218654426 1.424350519405989e-06 0.08491829088081257 1.424350795545224e-06 0.09213111703448683 1.424351096666701e-06 0.1000001933597138 \
1.424351428586562e-06 0.1086702418150647 1.42435180590533e-06 0.1185147411083515 1.424352204195386e-06 0.1288888856248832 1.424352673503706e-06 0.1410822143415975 \
1.424353219529231e-06 0.1552200475789812 1.424353854489538e-06 0.1715918832733369 1.424354553890129e-06 0.1895291194622146 1.424355372129055e-06 0.2103807608661494 \
1.424356277823022e-06 0.2332840710921665 1.424357067334088e-06 0.253091928008631 1.424357771092905e-06 0.2706124241987875 1.424358388943719e-06 0.2858796548825839 \
1.424358954567131e-06 0.2997575097153312 1.424359476302405e-06 0.3124620269501652 1.424359974086121e-06 0.3244932238414255 1.424360457724081e-06 0.3360954048923613 \
1.424360914598215e-06 0.3469667650518959 1.424361387439109e-06 0.3581213589834248 1.424361827052466e-06 0.3684065070151987 1.424362314929562e-06 0.379719432411247 \
1.424362845729985e-06 0.3919028193132517 1.424363343625359e-06 0.4032143644097119 1.424363775002613e-06 0.41292177789323 1.424364261889801e-06 0.4237731225600331 \
1.424364761989243e-06 0.4348012155672935 1.424365106609934e-06 0.4423321287141763 1.424365460003777e-06 0.4500000647748709 1.424365887773617e-06 0.4592134948422093 \
1.424366279634688e-06 0.4675816212925634 1.424366579929044e-06 0.4739471552041949 1.424366921860125e-06 0.4811428413521782 1.42436726519457e-06 0.4883132334011818 \
1.424367525955058e-06 0.4937215836208605 1.424367768011587e-06 0.4987106167174703 1.424368034010056e-06 0.5041617362307154 1.424368293498239e-06 0.5094435946950286 \
1.42436848341454e-06 0.5132872703533161 1.424368698649141e-06 0.5176241792560061 1.4243688371999e-06 0.5204025546691405 1.424368982080679e-06 0.5232962183003332 \
1.424369195494746e-06 0.5275364624051522 1.42436939751936e-06 0.5315382148201082 1.424369590248024e-06 0.5353370730264509 1.424369775503404e-06 0.5389735557287745 \
1.424369952500928e-06 0.5424323215059959 1.424370261764263e-06 0.5484573594957171 1.42437052291231e-06 0.5535233414883098 1.42437082473148e-06 0.5593562770234363 \
1.424371080160122e-06 0.5642781701956761 1.424371372515619e-06 0.5698968483756405 1.424371631969813e-06 0.5748654731717864 1.42437190208979e-06 0.5800301911327002 \
1.424372144100348e-06 0.5846380733684551 1.424372401610146e-06 0.5895273573494454 1.424372628054483e-06 0.5938057549890672 1.424372864942965e-06 0.5982619499065401 \
1.424373074987873e-06 0.6021962733001386 1.424373287918585e-06 0.6061670177072124 1.424373541397282e-06 0.6108668889270118 1.424373744692931e-06 0.6146150465592417 \
1.424373936381114e-06 0.6181346807088086 1.424374125007478e-06 0.6215812235468744 1.424374312325416e-06 0.6249823889551316 1.424374517937406e-06 0.6286953279350977 \
1.424374767760625e-06 0.6331759959753138 1.424374971572403e-06 0.6368063379741715 1.424375179211121e-06 0.6404826298163093 1.424375371862737e-06 0.6438748386876914 \
1.42437561647481e-06 0.6481531432733096 1.424375864373313e-06 0.6524620620600715 1.424376044208219e-06 0.6555644139995785 1.424376234982255e-06 0.6588391718544121 \
1.424376388158437e-06 0.6614554104590837 1.424376559827147e-06 0.6643705886591137 1.424376710293968e-06 0.6669108747194671 1.424376846897971e-06 0.6692010654183506 \
1.424376996338372e-06 0.6716954191563786 1.424377124072523e-06 0.6738189269502312 1.42437726394477e-06 0.6761323074508511 1.424377388021905e-06 0.6781756764962316 \
1.42437751938327e-06 0.6803315871556701 1.424377643554731e-06 0.6823627547057004 1.424377781331592e-06 0.6846081866267727 1.424377901575812e-06 0.6865586181592046 \
1.424378043628417e-06 0.6888545186016138 1.424378143856122e-06 0.6904668682779994 1.424378265160113e-06 0.6924123325129877 1.424378356135388e-06 0.6938641504265992 \
1.424378453518671e-06 0.695411869780077 1.424378550601538e-06 0.6969507228893711 1.424378639884158e-06 0.6983595753378042 1.424378737855943e-06 0.699898781449533 \
1.42437886813103e-06 0.7019319515314388 1.424379021543255e-06 0.7043083163565919 1.424379157109067e-06 0.7063909659299702 1.424379301449562e-06 0.708591461371511 \
1.424379427320445e-06 0.710496752775434 1.424379552347831e-06 0.712376488910674 1.424379666630191e-06 0.7140841686551523 1.424379777613335e-06 0.7157331888171029 \
1.424379877308405e-06 0.7172065512867005 1.424380014352622e-06 0.7192196995505324 1.424380133379834e-06 0.7209572005600779 1.424380253677943e-06 0.7227029412191364 \
1.424380380176863e-06 0.7245276185835638 1.424380504108467e-06 0.7263044524160376 1.4243806283948e-06 0.7280754330070212 1.424380754759953e-06 0.7298652243312684 \
1.424380884571694e-06 0.7316925631262517 1.424381008410214e-06 0.7334254795816325 1.4243811411911e-06 0.735272086289578 1.424381242042306e-06 0.7366670415914529 \
1.424381355233975e-06 0.738224777043618 1.424381442019956e-06 0.7394137384482823 1.424381558645253e-06 0.7410021813026957 1.42438164793451e-06 0.7422110784210975 \
1.424381759111394e-06 0.7437075443329063 1.424381888370157e-06 0.7454347509364776 1.424382002229194e-06 0.7469455276109591 1.424382106633406e-06 0.74832188588007 \
1.424382231000437e-06 0.7499498655229884 1.424382378240616e-06 0.7518616907275563 1.424382498520907e-06 0.753411006437983 1.424382614425446e-06 0.7548933175676444 \
1.42438275450129e-06 0.7566706674475765 1.42438289711296e-06 0.7584645678799224 1.424383015067203e-06 0.7599365027959469 1.424383141883712e-06 0.7615071445339606 \
1.424383282766856e-06 0.7632375905494565 1.424383402560354e-06 0.7646969139886852 1.42438354751921e-06 0.7664484133613445 1.424383669077996e-06 0.7679052725436226 \
1.42438378811749e-06 0.7693214142140735 1.424383909748853e-06 0.7707575700077021 1.424384037717831e-06 0.772256936813787 1.424384146933014e-06 0.7735272422640712 \
1.424384271823892e-06 0.774969549136603 1.424384378939953e-06 0.7761978171588899 1.424384512193147e-06 0.7777146071439789 1.424384639296593e-06 0.7791497354387434 \
1.424384761047568e-06 0.7805132846941326 1.424384877632151e-06 0.7818078758210534 1.424384983459753e-06 0.7829735233300771 1.424385122825895e-06 0.7844949153190801 \
1.424385271897694e-06 0.786105286864636 1.424385419626362e-06 0.7876841235632186 1.42438553893224e-06 0.7889471147195867 1.424385672939052e-06 0.7903527806482344 \
1.424385793365227e-06 0.791604423795974 1.424385934910404e-06 0.7930616786923709 1.424386082336416e-06 0.7945638089648995 1.424386206810925e-06 0.7958198087139573 \
1.424386325854918e-06 0.7970105506108808 1.424386437445201e-06 0.7981174590942314 1.42438654267449e-06 0.7991530841216606 1.424386638185594e-06 0.8000862307887144 \
1.424386774247547e-06 0.8014036057482816 1.424386891123681e-06 0.8025237700417888 1.424387010277353e-06 0.8036549841722296 1.424387132589548e-06 0.8048050501807249 \
1.424387255861622e-06 0.8059526272620129 1.424387382358398e-06 0.8071184350969989 1.424387507861062e-06 0.8082633544790385 1.424387638586967e-06 0.8094437311890262 \
1.424387764154939e-06 0.8105658358439867 1.424387893209803e-06 0.8117072367686948 1.42438799906596e-06 0.8126345588578442 1.424388100234836e-06 0.8135133322873783 \
1.424388194854656e-06 0.8143286754242188 1.42438831913574e-06 0.8153900871385379 1.424388408847426e-06 0.816149614585347 1.42438850788495e-06 0.8169816577628611 \
1.424388645662827e-06 0.8181280288377792 1.424388780198677e-06 0.81923501721715 1.424388888604944e-06 0.8201180631035904 1.424389038518447e-06 0.8213254631869725 \
1.424389189097025e-06 0.8225223201378843 1.42438931459218e-06 0.8235077122548546 1.424389458438707e-06 0.8246238332260477 1.42438958302197e-06 0.8255790649890803 \
1.424389731875191e-06 0.8267066458678887 1.424389868023775e-06 0.827725029289517 1.424389993047602e-06 0.8286494160599757 1.424390110754582e-06 0.8295103773055483 \
1.42439025639358e-06 0.8305630309532103 1.424390422774875e-06 0.8317484146982921 1.424390553358565e-06 0.8326660250626342 1.424390726880675e-06 0.8338683097812621 \
1.424390895002577e-06 0.8350147136930499 1.42439106486518e-06 0.8361549927788252 1.424391245766883e-06 0.8373497079260466 1.424391388876165e-06 0.8382806519784776 \
1.424391502965127e-06 0.839013953006387 1.424391633127604e-06 0.8398410866028793 1.424391734972734e-06 0.8404811280669765 1.42439185179894e-06 0.8412075886390841 \
1.42439198869038e-06 0.8420483852080155 1.424392186497604e-06 0.843243620449199 1.42439237812275e-06 0.8443797466267589 1.424392587554618e-06 0.8455974227529048 \
1.4243927695013e-06 0.8466352798309468 1.424392966630154e-06 0.8477391449715804 1.424393139971014e-06 0.8486924050423899 1.424393322979321e-06 0.8496814535024207 \
1.424393494142356e-06 0.8505903669473519 1.42439366877945e-06 0.851501688465695 1.424393844039281e-06 0.8524001683007644 1.42439402018973e-06 0.8532872510191711 \
1.424394210470029e-06 0.8542278331088334 1.42439440106916e-06 0.8551519386507073 1.424394601692395e-06 0.8561055033533737 1.42439479430095e-06 0.8570028516027762 \
1.424395004981641e-06 0.8579644845832216 1.424395233083109e-06 0.8589827023971403 1.424395498871091e-06 0.860139640227508 1.424395797483852e-06 0.8614018215255795 \
1.424396073772491e-06 0.8625348754565382 1.42439635800901e-06 0.8636666213345715 1.42439663221378e-06 0.8647267940813509 1.424396904448638e-06 0.8657495569722869 \
1.42439717465278e-06 0.8667361702337206 1.42439743180839e-06 0.867649441901348 1.424397704388604e-06 0.8685908808535525 1.42439798037489e-06 0.8695169452638583 \
1.424398250477721e-06 0.870397355937691 1.424398550334798e-06 0.8713451925332844 1.424398921362456e-06 0.8724761722512941 1.424399216299766e-06 0.8733433185969293 \
1.424399470589206e-06 0.8740690226522811 1.424399768845991e-06 0.874895168896023 1.424400042455427e-06 0.8756299040683481 1.424400278583914e-06 0.8762466977562872 \
1.424400518929827e-06 0.8768585021646264 1.424400741263492e-06 0.8774104263690854 1.424400935269169e-06 0.8778812671168952 1.424401264991885e-06 0.8786590883967833 \
1.424401420165319e-06 0.8790156160651978 1.424401737941389e-06 0.8797272612331356 1.424401916803032e-06 0.8801171459162566 1.424402259264861e-06 0.8808425821290963 \
1.42440244339302e-06 0.881221400612852 1.424402918270754e-06 0.8821634994206867 1.424403085666965e-06 0.8824839765989225 1.424403551508905e-06 0.8833452998114757 \
1.424403732330957e-06 0.8836679564577563 1.424404226369383e-06 0.8845176198113115 1.424404367718007e-06 0.8847523712107549 1.424404974052073e-06 0.8857188576377059 \
1.424405126121396e-06 0.8859512996759633 1.424405772809558e-06 0.8868983431897121 1.42440590110417e-06 0.8870786909355212 1.424406549221232e-06 0.8879538337624689 \
1.424406679020295e-06 0.8881220828502663 1.424407457223772e-06 0.8890807033877333 1.424407572278734e-06 0.8892148977954012 1.424408427940206e-06 0.8901543051721961 \
1.424408573301076e-06 0.8903040038307473 1.424409559057127e-06 0.8912446482480114 1.424409780162496e-06 0.8914382978987679 1.424410925289423e-06 0.8923659558950503 \
1.424411056506439e-06 0.8924678262926897 1.424412397715013e-06 0.8934599079028542 1.424412549114272e-06 0.8935646301988298 1.424414030551995e-06 0.8944937559627255 \
1.424414269431373e-06 0.8946275407274444 1.424416038746979e-06 0.8955013787854181 1.424416427898191e-06 0.8956696032899972 1.424418821561142e-06 0.8965547188539188 \
1.42441929727014e-06 0.8967039926079825 1.42442336043021e-06 0.8977020505850396 1.424423851854269e-06 0.8977948037134476 1.424432168453822e-06 0.898787348739254 \
1.42443308835295e-06 0.8988506593152591 1.42457657358348e-06 0.8998476076348748 1.424577692016456e-06 0.8998537475785264 1.424782783635956e-06 0.898985773748599 \
1.424783010725457e-06 0.8988224379910277 1.424784620332255e-06 0.8978282360369357 1.424784797740799e-06 0.8977338482811539 1.4248017048891e-06 0.8987315468430059 \
1.424801814328198e-06 0.8987460089186867 1.424817595049444e-06 0.8997418097871094 1.424817891375339e-06 0.8997476966799167 1.425301325027745e-06 0.9007060148833608 \
1.425301454078085e-06 0.9008313386292994 1.42530210422793e-06 0.9016292186224167 1.425302293723661e-06 0.9019133038041363 1.42530279694564e-06 0.9027675859898705 \
1.425302932418299e-06 0.9030208676018907 1.425303332877016e-06 0.9038195223753869 1.425303464814953e-06 0.9040958310886574 1.425303866030016e-06 0.9049509627747726 \
1.425303964290194e-06 0.9051582028152527 1.425304430164004e-06 0.9060587574877488 1.425304591662727e-06 0.9063060456044927 1.42530573567525e-06 0.9055153668657776 \
1.425305880654596e-06 0.9049059606760256 1.425306059207353e-06 0.9039396653125833 1.425306239402631e-06 0.9027054491383806 1.425306382093561e-06 0.9015369228101149 \
1.425306499253164e-06 0.9004524619440171 1.425306588234525e-06 0.8995505656965809 1.425306679878178e-06 0.8985529714258781 1.42530681299011e-06 0.8969831049011855 \
1.425306906711193e-06 0.8957895978311226 1.425306997850002e-06 0.8945634483845346 1.425307111142313e-06 0.8929516940777753 1.425307214251226e-06 0.8913998138690341 \
1.425307310518406e-06 0.8898830246517148 1.425307429655523e-06 0.8879200664089764 1.425307598240771e-06 0.8849885378698126 1.425307760012273e-06 0.8820195265790133 \
1.425307953231332e-06 0.8782956415026882 1.425308138794443e-06 0.8745571577041361 1.425308349060748e-06 0.8701566079887386 1.425308531309788e-06 0.8662213066841463 \
1.425308716173183e-06 0.8621339172744639 1.42530888885833e-06 0.8582419637438897 1.425309074966403e-06 0.8539816046497358 1.425309252782491e-06 0.849858603441091 \
1.425309433499072e-06 0.8456251963850057 1.425309598637331e-06 0.8417258760277182 1.425309763911433e-06 0.837798995916667 1.425309927159096e-06 0.8339004324287677 \
1.425310085749369e-06 0.8300982805770993 1.425310262673771e-06 0.8258418712800655 1.425310459187584e-06 0.8211009660847696 1.425310626744125e-06 0.8170498602679914 \
1.425310793484544e-06 0.8130123908857781 1.425310967908061e-06 0.8087844286215062 1.425311137277684e-06 0.8046757316210446 1.425311305476779e-06 0.8005936994537799 \
1.425311494325046e-06 0.7960093488074458 1.425311685140882e-06 0.7913773844868103 1.425311893523092e-06 0.7863203192056716 1.425312119942597e-06 0.7808277108969495 \
1.425312309142794e-06 0.7762391340290878 1.425312519289483e-06 0.7711455503222944 1.425312668057987e-06 0.7675418410361046 1.425312799050976e-06 0.7643705172588006 \
1.425312936616212e-06 0.7610417440783073 1.425313042367441e-06 0.7584842184275663 1.425313177141075e-06 0.7552262509102785 1.4253132889738e-06 0.7525244432456109 \
1.425313418408964e-06 0.7493992292091655 1.425313573597688e-06 0.7456545577979357 1.425313685233441e-06 0.7429626190147979 1.425313844808055e-06 0.7391166470929011 \
1.425314020129688e-06 0.7348935218456193 1.425314232505151e-06 0.7297828120356423 1.425314425387679e-06 0.7251458607116523 1.425314582088971e-06 0.7213823872711312 \
1.425314768763662e-06 0.716903961299824 1.425314957650011e-06 0.7123775767926828 1.425315148534203e-06 0.70780884692282 1.425315335282138e-06 0.7033444557767304 \
1.425315518366954e-06 0.698972331957095 1.425315655685935e-06 0.6956951921588121 1.425315808928892e-06 0.6920418367118417 1.425316004057543e-06 0.6873949992893974 \
1.425316161351872e-06 0.6836535194673684 1.425316320746467e-06 0.6798660670227984 1.42531651649026e-06 0.6752219404489795 1.425316708689394e-06 0.6706682621108646 \
1.425316943641022e-06 0.6651105611269369 1.42531713111727e-06 0.6606839627962382 1.425317368354404e-06 0.6550894036851447 1.425317557534366e-06 0.6506361170423679 \
1.425317738150178e-06 0.6463915264929231 1.425317901844741e-06 0.6425504277539856 1.42531804639615e-06 0.6391628119244788 1.42531818686792e-06 0.6358764726647652 \
1.425318313968707e-06 0.6329064225879303 1.425318446276183e-06 0.6298198307262635 1.425318572863229e-06 0.626870110582017 1.425318703443497e-06 0.62383130535404 \
1.425318832712896e-06 0.6208285625908692 1.425318971819793e-06 0.6176004736356133 1.425319120330103e-06 0.6141606483517721 1.425319309878658e-06 0.6097777958748198 \
1.425319455581914e-06 0.6064170107178907 1.425319690632478e-06 0.601007464699683 1.425319873631749e-06 0.5968099615921 1.425320097973422e-06 0.5916778694808832 \
1.425320269146671e-06 0.5877753019413697 1.425320401480491e-06 0.5847634284691802 1.42532053327703e-06 0.5817721407249107 1.425320639820933e-06 0.5793579518205488 \
1.425320735711292e-06 0.5771868999037388 1.425320828211542e-06 0.5750974572268882 1.425320920638905e-06 0.5730134868920421 1.425320993067211e-06 0.5713818265150021 \
1.425321048796317e-06 0.5701269325864891 1.425321109905404e-06 0.5687522410723198 1.42532120667008e-06 0.5665806864277688 1.425321268161594e-06 0.5652027770813386 \
1.425321327214216e-06 0.5638802801505602 1.425321402840882e-06 0.5621878686488651 1.42532146986366e-06 0.5606896577364279 1.425321543460769e-06 0.5590483558003441 \
1.425321611066772e-06 0.5575429304381756 1.425321727135829e-06 0.5549610936632026 1.425321827342234e-06 0.5527359403974305 1.425321939349424e-06 0.5502565947066531 \
1.425322033841475e-06 0.5481686943853854 1.425322154996172e-06 0.5454955387196141 1.425322255183939e-06 0.5432910220514219 1.425322371174451e-06 0.5407443765731218 \
1.425322478878288e-06 0.5383833065966291 1.425322588456977e-06 0.5359861028148916 1.42532270057842e-06 0.5335400310751951 1.425322827515604e-06 0.5307765704644959 \
1.425322949665123e-06 0.5281221248815906 1.425323089426038e-06 0.525095489155881 1.425323226564154e-06 0.522132778766487 1.425323376529244e-06 0.5189020692106626 \
1.425323535302247e-06 0.5154923220538846 1.425323709327904e-06 0.511765695450105 1.425323896158028e-06 0.5077823379664483 1.425324101125993e-06 0.5034264211640872 \
1.425324323834942e-06 0.4987133299464507 1.425324576739139e-06 0.4933874474923696 1.425324811693046e-06 0.4884604410272814 1.425325107961308e-06 0.4822828691822955 \
1.425325397751266e-06 0.4762763831984252 1.425325704087085e-06 0.4699660956099861 1.425326016405612e-06 0.4635767846525711 1.425326354971068e-06 0.4566963260653934 \
1.425326678082485e-06 0.4501741115777416 1.425327016477788e-06 0.4433881855507311 1.425327340309053e-06 0.4369378830387565 1.425327664703474e-06 0.4305204627449936 \
1.42532800763776e-06 0.4237851826852676 1.425328346918578e-06 0.4171698123421442 1.425328686393212e-06 0.4105997181257849 1.425329129505058e-06 0.4020958655332711 \
1.425329491573227e-06 0.3952155038183801 1.425329812124964e-06 0.3891775711374149 1.425330199059534e-06 0.3819561902961204 1.425330526929795e-06 0.3758957719299574 \
1.425330812088851e-06 0.3706704968427373 1.425331130457646e-06 0.3648820026298218 1.425331413288573e-06 0.3597820188690578 1.425331641977337e-06 0.3556924369094372 \
1.425331859870141e-06 0.3518226517641353 1.425332055119486e-06 0.3483769517668343 1.425332262027586e-06 0.344751588202948 1.425332476824342e-06 0.3410137651016431 \
1.425332729050892e-06 0.3366564674340092 1.425332971046205e-06 0.3325077909124976 1.425333201898484e-06 0.3285822460490526 1.425333416746675e-06 0.3249550452085373 \
1.425333637103364e-06 0.3212604562488142 1.425333838674264e-06 0.3179050685021769 1.42533404175821e-06 0.3145531374773136 1.425334239655597e-06 0.3113121771742085 \
1.425334426754836e-06 0.3082694484595072 1.425334620655179e-06 0.3051385396431291 1.425334825703514e-06 0.3018527636900292 1.425335005938266e-06 0.2989872106339772 \
1.425335241836277e-06 0.2952669081535775 1.425335443123827e-06 0.2921198200609627 1.425335644514631e-06 0.2889965001417216 1.425335869163794e-06 0.2855437159941698 \
1.425336034543768e-06 0.2830223598911593 1.425336212348105e-06 0.280330186126118 1.425336396004319e-06 0.277570343839212 1.425336581246076e-06 0.2748090658167894 \
1.425336759391454e-06 0.2721781298892599 1.425336932983517e-06 0.2696316866093095 1.42533709334837e-06 0.267306655456324 1.425337214459552e-06 0.2655585721882695 \
1.42533736765434e-06 0.2633570345323199 1.425337494985789e-06 0.2615475749425888 1.425337598313628e-06 0.2600830587034867 1.425337715638424e-06 0.2584225376281647 \
1.425337833445381e-06 0.2567591557214636 1.425337957409147e-06 0.2550199666844239 1.425338074393314e-06 0.2533821414201824 1.425338205189442e-06 0.2515535495016885 \
1.425338322399552e-06 0.2499173892700276 1.425338475652676e-06 0.2477853623028658 1.425338611183197e-06 0.2459029165157107 1.425338742864406e-06 0.244074199323236 \
1.425338899457317e-06 0.2419017673596028 1.425339024653875e-06 0.2401755227310949 1.425339160371501e-06 0.2383060149301216 1.425339292798663e-06 0.2364844144139329 \
1.425339412772324e-06 0.2348355337769661 1.425339575820161e-06 0.232606585912384 1.425339714627252e-06 0.230713852557009 1.425339853100972e-06 0.2288300961780371 \
1.425339958645721e-06 0.2273962817971701 1.425340087007401e-06 0.2256537837490921 1.425340191135024e-06 0.2242444877898851 1.425340291651026e-06 0.222886569499566 \
1.425340366695402e-06 0.2218745444235658 1.425340444028457e-06 0.2208349692306942 1.425340518791637e-06 0.2198305887827458 1.425340596755314e-06 0.218785487158918 \
1.425340651621824e-06 0.2180503923904892 1.4253407081186e-06 0.2172938400168352 1.425340751572119e-06 0.2167123195211523 1.425340791613165e-06 0.2161767335077376 \
1.425340830852113e-06 0.2156521099473339 1.42534087172635e-06 0.2151058606261434 1.42534092587884e-06 0.2143825797409383 1.425340964295971e-06 0.2138698309421548 \
1.425341003584678e-06 0.2133480458229882 1.425341065121386e-06 0.2125332203444249 1.425341127098915e-06 0.2117131287842428 1.425341183575664e-06 0.2109664019951111 \
1.425341248207254e-06 0.2101124842966758 1.425341343715876e-06 0.2088522205996687 1.425341431031607e-06 0.207701294711168 1.425341527641208e-06 0.2064291756790013 \
1.425341624870762e-06 0.2051510266126755 1.425341725717823e-06 0.2038307158897115 1.425341826317594e-06 0.2025192706911573 1.425341922808891e-06 0.2012627769767186 \
1.425342024991065e-06 0.1999338657614989 1.425342128630721e-06 0.1985898465970496 1.425342238404734e-06 0.1971698847140261 1.425342347579759e-06 0.1957617939809042 \
1.425342467677852e-06 0.1942174441246506 1.425342577697376e-06 0.1928086337505992 1.425342685809285e-06 0.1914295694688549 1.425342808837984e-06 0.1898652723262108 \
1.425342898948554e-06 0.1887234630454603 1.425343006314044e-06 0.1873671680421656 1.425343083125352e-06 0.1864004060894758 1.425343166570621e-06 0.1853535952511875 \
1.425343256102432e-06 0.1842338297700716 1.425343340667898e-06 0.1831790839553313 1.425343420384038e-06 0.1821880912968773 1.425343521709242e-06 0.1809331989518758 \
1.425343630056471e-06 0.1795959386230563 1.425343726532169e-06 0.1784102562612937 1.425343851909986e-06 0.1768766438339704 1.425343984693456e-06 0.1752616821119887 \
1.425344102464279e-06 0.1738362801839788 1.425344248115856e-06 0.1720835746408261 1.425344358713008e-06 0.1707596463148658 1.425344500843447e-06 0.1690680578777541 \
1.42534461655307e-06 0.1676985735146403 1.425344722027083e-06 0.166456424915798 1.425344816543742e-06 0.1653485352650968 1.425344912181114e-06 0.1642320043563913 \
1.425345009252958e-06 0.1631032360400927 1.425345108304212e-06 0.161956192050434 1.425345202227769e-06 0.1608730077890209 1.425345287503444e-06 0.1598934595213354 \
1.425345387883236e-06 0.1587475631033795 1.425345472186073e-06 0.1577906478848196 1.425345574585582e-06 0.1566342854655733 1.425345651979844e-06 0.1557646215197878 \
1.425345744324758e-06 0.154731814591042 1.42534581457623e-06 0.1539498814072817 1.425345910750659e-06 0.1528844393027091 1.425345987575322e-06 0.152038051282755 \
1.425346066345474e-06 0.1511758489440315 1.425346140238394e-06 0.150370438825067 1.425346207936138e-06 0.1496353997608715 1.425346304000026e-06 0.1485973848112393 \
1.425346373572453e-06 0.1478489919002561 1.425346457461625e-06 0.1469503328160803 1.425346518593461e-06 0.146298213254472 1.425346590861543e-06 0.1455309799806117 \
1.425346663300106e-06 0.1447677488542132 1.425346744281147e-06 0.1439178685120187 1.425346810355615e-06 0.1432275520600639 1.425346887756114e-06 0.1424219220725307 \
1.42534697713157e-06 0.1414956876531561 1.425347047992216e-06 0.1407644282175171 1.425347146879283e-06 0.1397487730030469 1.425347224198192e-06 0.1389620820751095 \
1.425347306243418e-06 0.1381330876879582 1.42534739435453e-06 0.1372467208126059 1.425347461981677e-06 0.1365690714953818 1.425347542278859e-06 0.1357674830239305 \
1.425347617062888e-06 0.1350239185327315 1.425347685064065e-06 0.1343502586094245 1.425347731746974e-06 0.1338891847862563 1.425347820998567e-06 0.1330118383700247 \
1.425347859221617e-06 0.1326395291833771 1.425347928213527e-06 0.1319690872918072 1.425347980961596e-06 0.1314578750898332 1.425348063954378e-06 0.1306559489775353 \
1.425348104132829e-06 0.1302688434457458 1.425348196650203e-06 0.1293805059784019 1.42534823536857e-06 0.1290098403727171 1.425348309129285e-06 0.1283055160094505 \
1.425348370757287e-06 0.1277188748199021 1.425348442784976e-06 0.1270353589407805 1.425348510952008e-06 0.1263909833196726 1.425348585574169e-06 0.1256908956540175 \
1.425348667426635e-06 0.1249253613889138 1.425348750880797e-06 0.124147338931438 1.425348823832511e-06 0.1234692772477456 1.425348896559441e-06 0.122795332839617 \
1.425348956549435e-06 0.1222410931008323 1.425349042917447e-06 0.121445549533078 1.425349103886164e-06 0.1208856452315438 1.425349162271955e-06 0.1203507897957366 \
1.425349227906619e-06 0.119751336354628 1.425349287260861e-06 0.1192111367930785 1.425349355292642e-06 0.1185941868697126 1.425349452587012e-06 0.11771710490035 \
1.425349531078992e-06 0.1170124163111649 1.425349621315123e-06 0.1162055395685231 1.425349717161808e-06 0.1153523005684616 1.425349792119505e-06 0.1146878351828532 \
1.425349896478921e-06 0.1137670532163148 1.425349983267518e-06 0.1130053589403202 1.425350092924934e-06 0.1120476726212376 1.425350174478997e-06 0.1113387926087848 \
1.425350270092629e-06 0.1105114393564785 1.425350346804822e-06 0.10985058581598 1.425350441723287e-06 0.1090364400125625 1.425350517546392e-06 0.1083889268999046 \
1.425350595246049e-06 0.1077282965354292 1.4253506775775e-06 0.1070311517075373 1.425350737142763e-06 0.1065286079538068 1.425350800900501e-06 0.1059924133642201 \
1.425350861995109e-06 0.1054803128126646 1.425350957858847e-06 0.1046801683739134 1.425351002721942e-06 0.1043071445723913 1.425351085962687e-06 0.1036173314376927 \
1.425351135082509e-06 0.1032117000904133 1.425351244131271e-06 0.1023149933518279 1.425351288967353e-06 0.1019479364619093 1.425351379228585e-06 0.1012117400678687 \
1.425351420105203e-06 0.1008795969612472 1.425351490563617e-06 0.1003088525914566 1.425351576851038e-06 0.09961307626065434 1.425351668628597e-06 0.09887705578174606 \
1.42535173815669e-06 0.09832225024344161 1.425351816683849e-06 0.09769854072774181 1.425351907412525e-06 0.09698178745350861 1.425351983228664e-06 0.09638605854785212 \
1.425352065241407e-06 0.09574500473888557 1.425352146994443e-06 0.09510943278387665 1.425352237502267e-06 0.09440967388330095 1.425352327061564e-06 0.09372126988887708 \
1.425352412671398e-06 0.09306698857649189 1.425352505450896e-06 0.09236212353634379 1.425352586338857e-06 0.0917510971760913 1.425352687467827e-06 0.09099177263830999 \
1.425352767961352e-06 0.09039108594384238 1.425352852204218e-06 0.08976589684797046 1.425352926049265e-06 0.08922077348043934 1.425353002898743e-06 0.08865632925481931 \
1.425353091039112e-06 0.08801255002475737 1.425353171103481e-06 0.08743108261130086 1.425353264139672e-06 0.08675939571108145 1.425353382140385e-06 0.08591369538214398 \
1.425353524513612e-06 0.08490278100234279 1.425353668761962e-06 0.08388867104764453 1.425353811089671e-06 0.08289807427203813 1.425353960667415e-06 0.08186746790234835 \
1.42535409698116e-06 0.08093761126893445 1.425354239101592e-06 0.0799778356000513 1.42535437365502e-06 0.07907840240745091 1.425354514007729e-06 0.07814980287393705 \
1.425354661689802e-06 0.0771833418413561 1.425354811805299e-06 0.07621180464723754 1.425354976525776e-06 0.07515824360926991 1.425355140155128e-06 0.07412455432658185 \
1.425355314933688e-06 0.07303438636984133 1.425355502186304e-06 0.07188220095900363 1.425355712231308e-06 0.07060976590783831 1.425355930441531e-06 0.06930979572898451 \
1.425356163898619e-06 0.06794333957253913 1.425356418744638e-06 0.06648001693367038 1.425356711839195e-06 0.06483321328442151 1.425357014178957e-06 0.06317411115207273 \
1.425357328765832e-06 0.06148945259513613 1.425357725026527e-06 0.05942677493938087 1.425358058743672e-06 0.05774249301432461 1.425358466054501e-06 0.05574994498853819 \
1.42535879393926e-06 0.05419380357502902 1.425359150629899e-06 0.05254809000207299 1.42535946386806e-06 0.05114243792209583 1.425359766835193e-06 0.04981740498512215 \
1.425360064375718e-06 0.04854875663330436 1.425360343155274e-06 0.04739109061078805 1.425360626155169e-06 0.04624570307560639 1.425360887895477e-06 0.04521055793698023 \
1.42536116713437e-06 0.04413130357485813 1.42536143924029e-06 0.0431040186124033 1.425361746607047e-06 0.04197194005652995 1.425361968409948e-06 0.04117329707315532 \
1.425362274870428e-06 0.04009446155587663 1.425362501059881e-06 0.03931650950691581 1.425362739977206e-06 0.03851359500741255 1.425362964401039e-06 0.03777663690506906 \
1.42536316666332e-06 0.03712468825868943 1.425363367705949e-06 0.03648814235703791 1.425363719479983e-06 0.03540095449820539 1.425363969725821e-06 0.03464776841732944 \
1.425364216044101e-06 0.03392252499723709 1.425364497376965e-06 0.03311308780599518 1.42536474046795e-06 0.03242954897046491 1.425364975941701e-06 0.03178112583711486 \
1.425365217601206e-06 0.03113119522156456 1.425365454483483e-06 0.03050988948014832 1.425365685016041e-06 0.02991733361391674 1.425365898984568e-06 0.02937801894285819 \
1.425366104927116e-06 0.02886851641492237 1.425366497651603e-06 0.02792196059063811 1.425366685729283e-06 0.02747992420741849 1.425367061168249e-06 0.02661861215736662 \
1.425367236042477e-06 0.02622659266649364 1.425367659365491e-06 0.02530049759795254 1.425367780614875e-06 0.02504150687334681 1.425368221176528e-06 0.02412433837770948 \
1.425368363674648e-06 0.02383402682615681 1.425368695728157e-06 0.02316883068419595 1.425368878693682e-06 0.02280879143785283 1.425369267997886e-06 0.02205689891561978 \
1.425369436343594e-06 0.02173705378531499 1.425369908457993e-06 0.02085107653961301 1.425370048202727e-06 0.0205916297664938 1.425370543782805e-06 0.01969297428531048 \
1.425370671008237e-06 0.01946923320191776 1.425371238917342e-06 0.01851512288677271 1.42537140317129e-06 0.0182513999453204 1.425372013043028e-06 0.0173209960017622 \
1.425372172728257e-06 0.01708922829277545 1.425372699639798e-06 0.01635462467776483 1.425372904157091e-06 0.01608193551804103 1.425373627634478e-06 0.01515939662837778 \
1.42537379307661e-06 0.01495683325581705 1.425374539636356e-06 0.01408081084911163 1.425374672939569e-06 0.01393008075245666 1.425375533124155e-06 0.01299799962960837 \
1.42537566920557e-06 0.01285670227674402 1.425376609799459e-06 0.01192267652923807 1.425376773572533e-06 0.01176632439256516 1.425377774751464e-06 0.01084959205883911 \
1.425377912229187e-06 0.01072929995296418 1.425379082926798e-06 0.009787962024485789 1.425379175323166e-06 0.009718668544398181 1.425380593399014e-06 0.008725931027897449 \
1.425380680375162e-06 0.00866912727384293 1.425382221370792e-06 0.00770199130002063 1.425382330686807e-06 0.007633428668288294 1.425383973934629e-06 0.006673746291950173 \
1.425384106791908e-06 0.006603544020797993 1.425386201172206e-06 0.005605323336654431 1.425386409576941e-06 0.00551468736035817 1.425388763913366e-06 0.004577307911602986 \
1.425389237472123e-06 0.004407121484391641 1.425392122908979e-06 0.003492041675788492 1.425392652573326e-06 0.00334538389506189 1.425396860800552e-06 0.00237996320858989 \
1.425397374234803e-06 0.002283557532494709 1.425403133485495e-06 0.001325291758975802 1.425403368066713e-06 0.001279502680325907 1.425418035894088e-06 0.0002809017338477542 \
1.42541814896418e-06 0.0002788534805396912 1.42805516904393e-06 -0.0006849217749926401 1.428055335205606e-06 -0.0009443270389602415 1.428055814074993e-06 -0.001850320037528519 \
1.428055906794619e-06 -0.002050462221988249 1.428056272019697e-06 -0.002913187630468476 1.428056363676814e-06 -0.00314709230904735 1.428056729783165e-06 -0.004133001189868674 \
1.428056839930291e-06 -0.004442309109773816 1.428057150668543e-06 -0.005311341427314526 1.428057252407188e-06 -0.005583925258601597 1.428057616111313e-06 -0.00638370916272213 \
1.428057780957636e-06 -0.006585924750287024 1.428058360754957e-06 -0.005792290386912202 1.428058535589415e-06 -0.004916934050781314 1.428058652279015e-06 -0.00413641027497409 \
1.428058778708707e-06 -0.00310656561120747 1.428058880730911e-06 -0.002137079422087956 1.428059000577393e-06 -0.0008406209844352954 1.428059091214629e-06 0.0002489246187367611 \
1.428059189634679e-06 0.001536790859923857 1.428059289358323e-06 0.002948496343048522 1.428059456842332e-06 0.005545701385567424 1.428059675420934e-06 0.009327395936412004 \
1.428059861491256e-06 0.0128572688386996 1.428060082873864e-06 0.01737012273305725 1.428060243533997e-06 0.02082840415615294 1.428060406999647e-06 0.02447866954313523 \
1.428060557635164e-06 0.02794359528291388 1.428060706690917e-06 0.03145289236167962 1.42806085615367e-06 0.03504014479003619 1.428061010184684e-06 0.03879791952579481 \
1.428061172300943e-06 0.04280891157365373 1.428061338330408e-06 0.04696567134311741 1.428061514283228e-06 0.05141478668696391 1.428061694953866e-06 0.05602187592747932 \
1.428061886774812e-06 0.06094655248807559 1.428062093880316e-06 0.06629309753158302 1.428062315452046e-06 0.07203901748582854 1.428062550186215e-06 0.07814662931008168 \
1.428062801725783e-06 0.08470684589377442 1.428063077167849e-06 0.09190125212984442 1.428063377363667e-06 0.09974607960254324 1.428063708295878e-06 0.108390578238945 \
1.428064083962612e-06 0.1181923833971668 1.42806448154548e-06 0.1285487285136021 1.428064948370082e-06 0.1406786766767902 1.428065491362617e-06 0.1547396794802719 \
1.42806612478764e-06 0.1710742296429572 1.428066820727691e-06 0.1889259607126788 1.4280676362848e-06 0.2097135943149445 1.428068546312903e-06 0.2327316641523666 \
1.428069339569124e-06 0.2526372689279454 1.4280700450442e-06 0.2702038474981599 1.428070663988468e-06 0.2855008995781749 1.428071231094408e-06 0.2994177966724069 \
1.428071754174414e-06 0.3121574438576628 1.428072253153207e-06 0.3242197130846058 1.428072737193214e-06 0.3358335658028451 1.428073192420047e-06 0.3466679577370423 \
1.428073666932009e-06 0.3578644504627745 1.428074106840717e-06 0.368158604789619 1.428074592685345e-06 0.3794271463718566 1.428075124288118e-06 0.3916316501999784 \
1.428075626951416e-06 0.4030538969706937 1.42807605602367e-06 0.4127111343288326 1.428076547040338e-06 0.4236561147984291 1.428077048470418e-06 0.434714731975362 \
1.428077395015009e-06 0.442288187401736 1.428077750424385e-06 0.4500000616404133 1.428078177652114e-06 0.4592019891792938 1.428078569851637e-06 0.4675774400278049 \
1.428078870233395e-06 0.4739448723400065 1.428079212045155e-06 0.4811381049525967 1.428079555484969e-06 0.4883107756756314 1.428079816220095e-06 0.4937186470393492 \
1.428080058250048e-06 0.4987071765458648 1.428080324195291e-06 0.5041573145298286 1.428080581464587e-06 0.509394255416739 1.42808077158369e-06 0.5132422368582924 \
1.428080985109851e-06 0.5175451019736222 1.428081124800157e-06 0.5203466115392713 1.428081271000449e-06 0.5232668091041763 1.42808148498835e-06 0.5275186200231483 \
1.428081693004609e-06 0.5316389396023125 1.428081885465879e-06 0.5354321131715788 1.42808207058211e-06 0.5390651926504321 1.428082244955557e-06 0.5424725330931349 \
1.428082549497633e-06 0.5484058192982523 1.428082810056515e-06 0.5534602958276967 1.428083111487545e-06 0.5592859190791987 1.428083365805138e-06 0.5641865993769294 \
1.428083658661328e-06 0.5698153316805189 1.42808391787448e-06 0.5747800306938655 1.428084188950812e-06 0.579963273174682 1.428084430794571e-06 0.5845680738798381 \
1.428084688299729e-06 0.5894577538325241 1.428084915043605e-06 0.5937419314630586 1.428085152044424e-06 0.5982006324572362 1.428085362230986e-06 0.6021379329905048 \
1.42808557499152e-06 0.6061060319396779 1.428085827870286e-06 0.6107954169450593 1.428086031533554e-06 0.6145509252949414 1.428086222250936e-06 0.6180531102377972 \
1.428086409587374e-06 0.6214768531423983 1.428086598465652e-06 0.6249070011644339 1.428086806665447e-06 0.6286671070650327 1.428087050997562e-06 0.6330499453121026 \
1.428087250564095e-06 0.6366057789565548 1.428087454709836e-06 0.6402215701419991 1.42808763934909e-06 0.643474671963314 1.428087908884781e-06 0.6481901084955864 \
1.428088136591637e-06 0.652149230294136 1.428088324263375e-06 0.6553888277830079 1.42808850516352e-06 0.6584949378977958 1.428088664704602e-06 0.661221510907812 \
1.428088835167002e-06 0.6641177016088209 1.428088986918443e-06 0.6666817235716488 1.428089124561455e-06 0.6689905419339194 1.428089273556318e-06 0.6714784915997724 \
1.428089401298182e-06 0.6736028790357499 1.428089544284695e-06 0.675968899142866 1.428089666067751e-06 0.6779749688503388 1.428089802351161e-06 0.6802121872853304 \
1.428089922180062e-06 0.682172759947357 1.428090068775623e-06 0.6845626218370968 1.428090187248565e-06 0.6864845934661837 1.428090283181927e-06 0.6880368302455475 \
1.428090375701511e-06 0.6895284278106264 1.428090480762022e-06 0.6912169000724893 1.428090578843908e-06 0.6927871490736753 1.428090715959225e-06 0.6949707622226827 \
1.428090835157868e-06 0.6968607547931925 1.428090945097838e-06 0.6985951241089645 1.428091082597081e-06 0.7007503743809057 1.428091214026983e-06 0.7027960765825516 \
1.428091346256499e-06 0.7048392108129343 1.428091459433897e-06 0.7065756917706891 1.428091613866752e-06 0.708927873976708 1.428091744646745e-06 0.7109048231498766 \
1.428091867315455e-06 0.7127465601965561 1.428091973583711e-06 0.7143329262278221 1.428092095963735e-06 0.7161490373358268 1.428092197817232e-06 0.7176517022913665 \
1.428092331955131e-06 0.7196190116794019 1.428092452648172e-06 0.7213783352064487 1.42809257178997e-06 0.7231049829175343 1.428092696807984e-06 0.7249059312823601 \
1.42809282664779e-06 0.7267645120560844 1.428092946459962e-06 0.7284691779696002 1.428093075453213e-06 0.730293808329565 1.428093207560277e-06 0.7321507998840678 \
1.428093325866095e-06 0.7338038328985433 1.428093469126786e-06 0.7357927618453034 1.428093571581473e-06 0.7372070005703254 1.428093667788358e-06 0.7385290937783453 \
1.42809377280598e-06 0.7399656334130889 1.428093883577511e-06 0.7414708009413548 1.428093985256052e-06 0.7428439364018735 1.428094088217506e-06 0.7442258341871242 \
1.42809420514366e-06 0.7457850038572696 1.428094333903936e-06 0.747489965072781 1.428094435062908e-06 0.7488201182152049 1.428094583931952e-06 0.7507626302114226 \
1.428094731611489e-06 0.75267249971878 1.428094850976855e-06 0.7542038164026367 1.428094997460699e-06 0.7560679527984652 1.42809512063619e-06 0.7576223900169708 \
1.428095261439864e-06 0.7593848990234215 1.428095398032531e-06 0.7610800595258669 1.428095520190381e-06 0.7625841275516777 1.428095632846779e-06 0.7639610711610054 \
1.42809577457292e-06 0.7656796138775311 1.42809590073942e-06 0.767196844592689 1.428096016156724e-06 0.768574452686535 1.428096146464904e-06 0.7701179991486644 \
1.428096262177572e-06 0.7714782821591826 1.42809638500186e-06 0.7729116492687436 1.428096502846128e-06 0.7742769236963016 1.428096608476118e-06 0.7754922619072108 \
1.428096723849553e-06 0.7768108638983861 1.428096829112716e-06 0.7780056027231214 1.428096940062529e-06 0.7792565499870431 1.42809702646703e-06 0.7802246528436213 \
1.42809713050085e-06 0.7813823422463088 1.428097244396594e-06 0.7826398494046257 1.428097347430013e-06 0.7837684443710583 1.428097455512714e-06 0.7849432998269023 \
1.42809756376437e-06 0.7861107422109641 1.428097699181616e-06 0.7875582910536544 1.428097811855724e-06 0.7887521292973186 1.428097936279784e-06 0.7900592323105087 \
1.428098054252648e-06 0.7912877959129118 1.428098198720602e-06 0.7927781272271259 1.428098316389742e-06 0.7939806363584788 1.428098452269581e-06 0.7953567374150946 \
1.428098587013954e-06 0.7967081403609936 1.428098698084933e-06 0.7978123285366109 1.428098797974273e-06 0.7987978371087655 1.428098899654231e-06 0.7997937268659365 \
1.428099032867897e-06 0.8010867894381996 1.428099151240716e-06 0.8022243628210853 1.42809927278179e-06 0.8033812848148773 1.428099392145442e-06 0.8045065422543012 \
1.428099513276819e-06 0.80563739819571 1.428099644976236e-06 0.8068544426691319 1.428099767984513e-06 0.8079795872959963 1.42809989582812e-06 0.8091371804586788 \
1.42810002673464e-06 0.8103101881504271 1.428100150327798e-06 0.8114062915203997 1.428100257500303e-06 0.8123479140825919 1.428100364929502e-06 0.8132835730547656 \
1.42810044759862e-06 0.8139979974227743 1.42810056531038e-06 0.8150069815425507 1.428100655915986e-06 0.8157770472204025 1.428100786569431e-06 0.8168774959419571 \
1.428100930959301e-06 0.8180800468042847 1.428101064133715e-06 0.8191766687328477 1.428101174025106e-06 0.8200725423139092 1.428101317623991e-06 0.8212302325252553 \
1.428101471014683e-06 0.8224508494407716 1.428101599092908e-06 0.8234574467428303 1.428101738880276e-06 0.8245431382086058 1.428101865129839e-06 0.8255122018650548 \
1.428102019728392e-06 0.8266841987320058 1.428102151939368e-06 0.8276738265999063 1.428102278166151e-06 0.8286078934539939 1.428102395913874e-06 0.8294698388787296 \
1.428102544986667e-06 0.8305480062617677 1.42810271231822e-06 0.8317406852496945 1.428102845539497e-06 0.8326770812274722 1.42810301832082e-06 0.8338744310092966 \
1.428103186826193e-06 0.8350236380668206 1.428103356205492e-06 0.8361608866600232 1.428103537840761e-06 0.8373606451951652 1.428103680174083e-06 0.8382866867625347 \
1.428103794011069e-06 0.8390185116470331 1.428103925192579e-06 0.8398522525089582 1.428104026724794e-06 0.8404903982372576 1.428104143009054e-06 0.8412135669902132 \
1.428104277643808e-06 0.8420406924792603 1.428104474666644e-06 0.8432316292878405 1.428104664772186e-06 0.8443592803112207 1.428104874895499e-06 0.8455816023960827 \
1.428105055213604e-06 0.8466107566581813 1.428105252676705e-06 0.8477171937062282 1.428105426745819e-06 0.8486750118570332 1.42810560906524e-06 0.8496608982186138 \
1.428105780480376e-06 0.8505716849290491 1.428105954593653e-06 0.8514808063694008 1.428106130324621e-06 0.8523822271368225 1.428106306436321e-06 0.8532696099472232 \
1.428106496054173e-06 0.8542074684498208 1.42810668683567e-06 0.8551330189126392 1.428106888431747e-06 0.8560917259710515 1.428107081166005e-06 0.856990088884472 \
1.428107290037825e-06 0.8579439907476532 1.428107520740263e-06 0.8589743400177088 1.428107785183227e-06 0.8601259267840322 1.428108084005915e-06 0.8613896125360476 \
1.428108363960216e-06 0.8625380186322354 1.428108648086082e-06 0.8636694076724545 1.428108922855057e-06 0.8647317823994775 1.428109194712216e-06 0.8657531067718063 \
1.428109465089334e-06 0.8667403371654003 1.428109722167856e-06 0.8676533221001362 1.428109994792686e-06 0.868594905839151 1.428110270759835e-06 0.8695208838709013 \
1.428110540864093e-06 0.8704012674911344 1.428110840740104e-06 0.8713491368600049 1.428111211801162e-06 0.8724801680184872 1.42811150674079e-06 0.8733472453740196 \
1.428111761036548e-06 0.8740729094291386 1.428112059297474e-06 0.8748989982677786 1.428112332904015e-06 0.8756336613858092 1.428112569029958e-06 0.876250392688866 \
1.428112809374056e-06 0.8768621356511911 1.428113031706182e-06 0.8774140071409635 1.428113225712247e-06 0.8778848105679672 1.428113555434997e-06 0.8786625669521169 \
1.428113710608526e-06 0.8790190643519731 1.428114028387606e-06 0.879730644938159 1.428114207248864e-06 0.8801204696806418 1.428114549710761e-06 0.8808457867651537 \
1.428114733837363e-06 0.8812245477320809 1.428115208711942e-06 0.8821665346129511 1.428115376108352e-06 0.8824869809105039 1.428115841951854e-06 0.883348261932613 \
1.428116022773548e-06 0.8836708855253055 1.428116516812651e-06 0.8845204537290557 1.428116658162059e-06 0.8847551796839913 1.428117264500122e-06 0.8857215808967022 \
1.428117416569336e-06 0.8859539944113424 1.428118063256356e-06 0.8869009218298172 1.428118191551239e-06 0.8870812460539503 1.428118839667745e-06 0.8879562712787433 \
1.428118969467641e-06 0.8881245027440973 1.42811974767834e-06 0.8890830197250962 1.428119862725472e-06 0.8892171882189283 1.428120718396314e-06 0.8901564861234483 \
1.428120863744077e-06 0.8903061494816453 1.428121849499649e-06 0.8912466483555094 1.428122070607711e-06 0.8914402669210102 1.428123215727714e-06 0.892367747196105 \
1.428123346939158e-06 0.8924695935232408 1.428124688211624e-06 0.8934615053489913 1.4281248396029e-06 0.8935661991834861 1.42812632105512e-06 0.8944951400107031 \
1.428126559934816e-06 0.8946288932334222 1.428128329356654e-06 0.895502508848118 1.428128718477945e-06 0.895670668133377 1.428131112210654e-06 0.8965556062201232 \
1.428131587750592e-06 0.8967047758494365 1.428135650819817e-06 0.8977025964496719 1.428136142295653e-06 0.8977953148389237 1.428144458892796e-06 0.8987880790885289 \
1.428145378794248e-06 0.8988514070442593 1.428299242370168e-06 0.8998485708192639 1.428302885496457e-06 0.8998628537402877 1.428529614276671e-06 0.8989664306490068 \
1.428529844616583e-06 0.8988008565867064 1.42853145953688e-06 0.897804750401333 1.428531637269166e-06 0.8977103535805105 1.428548403669271e-06 0.8986978311584225 \
1.428548539768402e-06 0.8987160394686986 1.428563710608672e-06 0.8997133888183054 1.428563987713508e-06 0.899719468756186 1.429048028906422e-06 0.9005852143835333 \
1.429048202241039e-06 0.9007408621809421 1.429048862730638e-06 0.9015135064485434 1.42904902879582e-06 0.9017527716291757 1.429049555130528e-06 0.9026184054967997 \
1.429049746244447e-06 0.9029704910143604 1.429050110465499e-06 0.9036902342402512 1.429050289664921e-06 0.9040628043424317 1.429050651551594e-06 0.9048333795345931 \
1.429050846661164e-06 0.9052442844328937 1.429051379059525e-06 0.9062266394381637 1.429051561413164e-06 0.9064623886473868 1.429052553393556e-06 0.905594670761786 \
1.429052714934123e-06 0.9049318860608667 1.429052882926575e-06 0.9040378649110347 1.429053042758061e-06 0.9029782421366458 1.429053180254799e-06 0.9018984154159868 \
1.429053313162111e-06 0.9007052793196499 1.429053439587579e-06 0.8994328447569792 1.429053546986819e-06 0.8982475863895881 1.429053651483477e-06 0.8970047013543965 \
1.429053765533147e-06 0.8955451342423859 1.429053855502734e-06 0.8943225684615312 1.429053960321372e-06 0.8928208677113324 1.429054049769612e-06 0.891473284704788 \
1.429054132145392e-06 0.8901820884368528 1.429054223238392e-06 0.8887006634027688 1.42905436057447e-06 0.8863657732814155 1.429054459067403e-06 0.8846195012157601 \
1.429054571141153e-06 0.8825649218508906 1.429054702024186e-06 0.880080778639088 1.429054838495216e-06 0.8774018563482072 1.429054991949379e-06 0.8742910281085086 \
1.429055151043747e-06 0.8709679977889497 1.429055315327649e-06 0.867445283300377 1.42905547199575e-06 0.8640104344288071 1.429055624086531e-06 0.860615744772629 \
1.429055777800206e-06 0.857132398554192 1.429055937362381e-06 0.853469801378647 1.429056092451083e-06 0.8498714074018293 1.429056266130402e-06 0.8458039138600054 \
1.429056429161269e-06 0.8419559450883216 1.429056590803684e-06 0.8381170660338335 1.429056753450421e-06 0.8342344554797501 1.429056914868927e-06 0.8303657475978833 \
1.429057083463406e-06 0.8263109424305363 1.429057266356504e-06 0.8219002364007665 1.429057434185218e-06 0.8178440888239877 1.429057602471033e-06 0.8137703061148112 \
1.429057773299085e-06 0.8096302849976138 1.429057945473642e-06 0.8054541271740473 1.429058113235561e-06 0.8013830614994394 1.429058296865018e-06 0.7969255463994016 \
1.429058468271496e-06 0.7927646873948894 1.429058653714802e-06 0.7882638003278283 1.429058820385453e-06 0.7842196820467244 1.429058989271585e-06 0.7801233737411432 \
1.429059173427882e-06 0.7756572567105651 1.42905936803791e-06 0.7709405333854473 1.429059515293241e-06 0.7673736106648734 1.429059641923832e-06 0.7643079795643375 \
1.429059783780644e-06 0.7608754495129878 1.429059888184422e-06 0.7583505812556488 1.429060020577074e-06 0.7551502542766809 1.42906013016127e-06 0.7525028097975122 \
1.429060263325923e-06 0.7492875979647342 1.429060419507685e-06 0.7455190770546114 1.429060532737112e-06 0.7427887939149777 1.429060695258476e-06 0.7388718945951063 \
1.429060867439291e-06 0.7347246296492568 1.429061063444044e-06 0.7300078517193382 1.429061227834023e-06 0.7260553905833119 1.429061380230703e-06 0.7223944885043934 \
1.429061543905858e-06 0.718466402706526 1.429061711831558e-06 0.7144406657912139 1.429061891671936e-06 0.7101336212543717 1.429062067965886e-06 0.7059164985576465 \
1.429062239040521e-06 0.7018286413152719 1.429062407358697e-06 0.6978099102718778 1.429062560624829e-06 0.6941537154717222 1.429062722508398e-06 0.6902960245155986 \
1.429062901459938e-06 0.6860364417190952 1.42906303567149e-06 0.6828448068431195 1.429063139177788e-06 0.6803854168085423 1.4290632384622e-06 0.6780286039046017 \
1.429063339916677e-06 0.6756220912380299 1.429063432373275e-06 0.6734303711245889 1.429063516962075e-06 0.6714267031582685 1.429063610539411e-06 0.6692114082407524 \
1.429063727081631e-06 0.6664546942583044 1.429063836559192e-06 0.6638675763958631 1.429063949672203e-06 0.6611971533414394 1.42906407279097e-06 0.6582923426231613 \
1.429064197017283e-06 0.6553636581362478 1.429064367777427e-06 0.6513432847262797 1.429064526226014e-06 0.6476181700514572 1.429064698513837e-06 0.6435738126612673 \
1.429064844491904e-06 0.6401512360303271 1.42906498628512e-06 0.6368325564797357 1.429065117883574e-06 0.6337564355289309 1.429065248046859e-06 0.630718219665797 \
1.429065373571799e-06 0.6277924818644975 1.429065505354707e-06 0.6247239543970449 1.429065635278202e-06 0.6217046839485236 1.429065771586778e-06 0.6185408917806742 \
1.429065916200345e-06 0.615188962872713 1.429066075692536e-06 0.611499189008522 1.429066249152652e-06 0.6074939486938447 1.429066420159954e-06 0.6035554342946753 \
1.429066651528522e-06 0.5982402936372396 1.429066894990528e-06 0.5926661367297537 1.429067069111016e-06 0.5886942528256315 1.429067215383093e-06 0.5853638081576373 \
1.429067349755311e-06 0.58231230528805 1.429067466850207e-06 0.5796585826255305 1.429067562614553e-06 0.5774900935424465 1.429067661461095e-06 0.5752566196463251 \
1.429067745438414e-06 0.5733628024369305 1.429067823052463e-06 0.571614165956722 1.429067884377937e-06 0.5702331258704825 1.429067949058575e-06 0.5687779664863769 \
1.429068030366711e-06 0.5669528575016536 1.429068080436707e-06 0.5658306078972934 1.429068129757269e-06 0.5647256890740617 1.429068191677069e-06 0.5633393552914843 \
1.429068239508894e-06 0.5622690492396486 1.42906829001368e-06 0.5611395143522533 1.429068350075717e-06 0.559799205480933 1.429068409358512e-06 0.5584782058326896 \
1.429068484415226e-06 0.5568072508052372 1.429068554097883e-06 0.5552574373576753 1.429068639686449e-06 0.5533559356568912 1.429068726753821e-06 0.5514265885063823 \
1.429068810416341e-06 0.5495763264044081 1.429068896561366e-06 0.5476734676082877 1.429068992265987e-06 0.5455621222678217 1.429069096550939e-06 0.5432673229847179 \
1.429069211218113e-06 0.5407497407899529 1.429069319936574e-06 0.5383664115638558 1.429069429508814e-06 0.5359693749054023 1.429069541813574e-06 0.5335193270114367 \
1.429069668589195e-06 0.530759392645703 1.429069790866427e-06 0.5281021910076299 1.429069930952405e-06 0.5250685463469849 1.429070067969762e-06 0.5221084647952599 \
1.429070218271135e-06 0.5188705764247719 1.429070377166376e-06 0.5154582091324615 1.429070551500259e-06 0.5117250894133971 1.429070738517481e-06 0.5077378180012799 \
1.429070943835486e-06 0.5033745272871338 1.429071155677679e-06 0.498891131759938 1.429071408479721e-06 0.4935662239713107 1.42907161056737e-06 0.4893264048484654 \
1.429071845160675e-06 0.4844277613141263 1.429072081275272e-06 0.4795194943790256 1.429072334451769e-06 0.474283574581623 1.429072644981732e-06 0.4679020429045382 \
1.42907286303971e-06 0.4634451779596257 1.429073036485344e-06 0.4599153839204358 1.429073212977781e-06 0.4563351808422506 1.429073492459577e-06 0.4506930409909046 \
1.429073724703484e-06 0.4460279192631412 1.429074011797073e-06 0.44029020239849 1.429074229643181e-06 0.435960758243863 1.429074439695768e-06 0.4318042429497612 \
1.429074640893604e-06 0.4278406951573778 1.429074823313765e-06 0.4242617300271556 1.42907499720875e-06 0.4208637793449936 1.429075162072867e-06 0.4176529694331993 \
1.42907532082684e-06 0.4145718140694327 1.429075487073786e-06 0.4113577680628809 1.429075635718993e-06 0.4084923702366076 1.429075788087249e-06 0.4055658186126443 \
1.429075930150432e-06 0.4028468403491589 1.42907609952631e-06 0.3996150665462138 1.42907621990823e-06 0.3973276483660343 1.429076329881494e-06 0.3952449223617059 \
1.429076444806895e-06 0.3930732253581283 1.429076597048475e-06 0.3902080468194818 1.42907670926954e-06 0.3881039677199808 1.429076816462041e-06 0.386098874836553 \
1.42907696899029e-06 0.383254723448244 1.429077097137419e-06 0.380874963946598 1.429077219985412e-06 0.3786015923730871 1.429077399083788e-06 0.375299968600122 \
1.42907754816842e-06 0.3725653942578417 1.429077715875807e-06 0.3695018296724824 1.429077871273442e-06 0.3666748141177644 1.429077995440288e-06 0.3644243980538668 \
1.429078109332155e-06 0.3623666676050148 1.429078230775526e-06 0.3601804966264144 1.429078410927293e-06 0.3569532670533712 1.429078577415113e-06 0.3539878629329621 \
1.429078767834223e-06 0.3506138544217919 1.429078959590818e-06 0.3472380408565978 1.429079142640212e-06 0.344035729794033 1.429079291612276e-06 0.3414435189591631 \
1.429079411552182e-06 0.3393660536257183 1.429079534213665e-06 0.3372483242714233 1.429079657244151e-06 0.3351324902755385 1.429079802148562e-06 0.3326515017845288 \
1.429079905461337e-06 0.3308907757076019 1.429079999190846e-06 0.3292979229163631 1.429080089851148e-06 0.3277620998585528 1.429080200972602e-06 0.3258853746017661 \
1.429080308145579e-06 0.3240820510456246 1.42908040642023e-06 0.3224338250618513 1.429080518824776e-06 0.3205545940512134 1.429080682764676e-06 0.3178277446588927 \
1.429080844402555e-06 0.3151576097143818 1.429080992189301e-06 0.3127316247504084 1.429081154434516e-06 0.3100832165115083 1.429081314465073e-06 0.3074868334344322 \
1.429081466728372e-06 0.3050304870660137 1.429081620100242e-06 0.3025703731928215 1.429081778808771e-06 0.3000411640344692 1.4290819432579e-06 0.297437246442505 \
1.429082110484976e-06 0.2948063590562646 1.429082263596513e-06 0.292412731930112 1.42908244669444e-06 0.2895700146919417 1.429082637002178e-06 0.2866380344427262 \
1.429082785905236e-06 0.2843603072871506 1.429082959842541e-06 0.2817165165722222 1.42908313671993e-06 0.2790484233348025 1.429083284317149e-06 0.2768363681311815 \
1.429083473948849e-06 0.2740172295061162 1.429083623950767e-06 0.2718052906662373 1.429083761060957e-06 0.2697943906627059 1.429083902591401e-06 0.2677397479842996 \
1.42908401605027e-06 0.2661005451260196 1.429084152340596e-06 0.2641384584581135 1.429084282417217e-06 0.2622807416655737 1.42908440067147e-06 0.2606037730704709 \
1.429084518527066e-06 0.2589348966568543 1.429084649420877e-06 0.2570853888657079 1.429084789659635e-06 0.2551145527343576 1.429084905154221e-06 0.2534976852533538 \
1.429085034005598e-06 0.2516957519945816 1.429085149151579e-06 0.2500885525459272 1.429085302462547e-06 0.2479513765689386 1.429085440316308e-06 0.2460367343642474 \
1.42908557977796e-06 0.2441002375748529 1.429085735245815e-06 0.2419427021952501 1.42908586002843e-06 0.2402176526454788 1.429085999893338e-06 0.2382916534360561 \
1.429086128595514e-06 0.2365220787132559 1.429086249554366e-06 0.234860341242685 1.429086366599666e-06 0.2332541163798121 1.42908649260073e-06 0.2315368940272461 \
1.429086589320323e-06 0.2302195772445239 1.429086681409196e-06 0.2289683907689286 1.429086795826667e-06 0.2274152998827935 1.429086894197314e-06 0.2260807986508055 \
1.429087011344108e-06 0.2244933520241092 1.429087114435225e-06 0.2231010305483718 1.429087219949952e-06 0.2216798666278746 1.429087300868012e-06 0.2205933880575098 \
1.429087374539197e-06 0.2196046443759679 1.429087417268434e-06 0.2190314036349237 1.429087460398579e-06 0.2184540235451489 1.429087511196061e-06 0.217774515685755 \
1.429087548370939e-06 0.217277430841393 1.429087589041954e-06 0.2167338127731004 1.429087631833755e-06 0.2161620985357572 1.429087668244897e-06 0.2156758299561118 \
1.429087710169888e-06 0.2151161507306283 1.429087764712098e-06 0.2143884526296278 1.429087803170856e-06 0.2138756926875936 1.429087842797625e-06 0.2133496230586122 \
1.429087904630127e-06 0.212531488259555 1.429087966356579e-06 0.2117156525305126 1.429088022493854e-06 0.210974237875411 1.429088086149084e-06 0.210134110843225 \
1.429088180240117e-06 0.2088936328424611 1.429088267048376e-06 0.2077505933124353 1.42908836100502e-06 0.2065146061917991 1.429088459047254e-06 0.2052266823513323 \
1.429088560634619e-06 0.2038976009052371 1.429088661543568e-06 0.2025832113009377 1.429088758279377e-06 0.2013244528083448 1.429088860404348e-06 0.1999972806373927 \
1.429088963735905e-06 0.1986583046056677 1.429089073618507e-06 0.1972379690671278 1.429089182560765e-06 0.1958337611883887 1.429089302395885e-06 0.1942937175364915 \
1.429089412679751e-06 0.1928822800638286 1.429089520558496e-06 0.191507108810815 1.429089646621254e-06 0.1899051957406391 1.429089736488961e-06 0.1887671190866151 \
1.4290898469673e-06 0.1873723090993208 1.429089924500249e-06 0.1863971337376019 1.429090008823992e-06 0.1853400660204312 1.42909009641205e-06 0.1842452710069853 \
1.429090184204644e-06 0.18315095174413 1.429090265924515e-06 0.1821357652581398 1.429090363486193e-06 0.1809282658474054 1.429090470197344e-06 0.1796118512064394 \
1.429090570679026e-06 0.178377576484793 1.429090694850237e-06 0.1768595317522179 1.429090828741761e-06 0.1752320886156309 1.429090947653953e-06 0.1737937102924047 \
1.429091098054147e-06 0.1719851742607024 1.42909120888924e-06 0.1706594030660365 1.429091348655982e-06 0.168997130456427 1.42909146718129e-06 0.1675953052211382 \
1.429091572608521e-06 0.1663548750207849 1.42909166731838e-06 0.1652455210322802 1.429091760628154e-06 0.1641568522804657 1.42909186153427e-06 0.1629842804551663 \
1.429091956952102e-06 0.1618800504313296 1.429092054143025e-06 0.1607598891027116 1.429092135704507e-06 0.1598237474547246 1.429092241020952e-06 0.1586229753023833 \
1.429092324500658e-06 0.1576763029943549 1.429092426029949e-06 0.1565306813704828 1.429092503260486e-06 0.1556635090415242 1.429092594132523e-06 0.154647919213242 \
1.429092663483833e-06 0.1538765336840219 1.429092748067884e-06 0.1529397840535594 1.429092822461091e-06 0.1521208717489242 1.429092901831293e-06 0.151251902275755 \
1.429092976418964e-06 0.1504388356812226 1.429093045640521e-06 0.1496871728711989 1.429093140321328e-06 0.1486640077242138 1.429093210087093e-06 0.1479134441579097 \
1.429093294531656e-06 0.147008717574758 1.429093356097001e-06 0.1463518850554192 1.429093430139493e-06 0.1455673550676988 1.429093503525017e-06 0.1447940960774066 \
1.429093584960258e-06 0.1439395015691976 1.429093654409405e-06 0.1432139999234875 1.429093729511102e-06 0.1424323701137583 1.429093819423173e-06 0.1415006120834361 \
1.429093896506793e-06 0.1407052977810757 1.429093995617377e-06 0.1396885207473417 1.42909406515744e-06 0.138983077430453 1.429094146475915e-06 0.1381612812129989 \
1.429094216644325e-06 0.1374549162714094 1.429094295612438e-06 0.1366629455350578 1.42909437459072e-06 0.1358740351737466 1.42909444691251e-06 0.1351544405911459 \
1.429094516277969e-06 0.1344667589602006 1.429094564981976e-06 0.1339854049281765 1.429094655744348e-06 0.1330945614011112 1.429094687765876e-06 0.1327823711724506 \
1.429094775869844e-06 0.131925672678654 1.429094808363886e-06 0.1316105445757083 1.429094907031543e-06 0.1306564447580443 1.429094950687519e-06 0.130235859061297 \
1.429095028669336e-06 0.1294866595045693 1.429095066000294e-06 0.1291289430202982 1.429095168151694e-06 0.128153223240932 1.429095235595654e-06 0.1275115375392494 \
1.429095300748611e-06 0.1268935577290946 1.429095366654626e-06 0.1262729746041904 1.429095437806609e-06 0.1256052797936485 1.42909552074397e-06 0.1248293808775363 \
1.429095606139451e-06 0.1240331657139879 1.429095682226844e-06 0.1233259817834828 1.429095762687521e-06 0.1225806238777534 1.429095820771462e-06 0.1220441728027253 \
1.429095892104936e-06 0.1213870835332726 1.429095976893369e-06 0.1206085709991845 1.429096038048402e-06 0.1200487744399507 1.429096108134853e-06 0.1194096117168642 \
1.429096170640142e-06 0.1188419501154776 1.42909623664509e-06 0.1182453094891599 1.429096305417857e-06 0.1176255789053269 1.429096374874481e-06 0.1170017375875525 \
1.429096458038731e-06 0.1162574953874909 1.429096531156255e-06 0.1156056107435251 1.429096601870241e-06 0.1149774116339468 1.429096661221924e-06 0.1144518657417393 \
1.429096766519136e-06 0.1135239342411639 1.42909681238663e-06 0.1131212254602471 1.429096899340683e-06 0.1123603821649216 1.429096942354464e-06 0.1119852310621949 \
1.429096987221211e-06 0.1115947726395539 1.429097076954706e-06 0.1108164664143028 1.429097147839057e-06 0.110204256460374 1.429097226692571e-06 0.109525796983828 \
1.429097289470346e-06 0.1089876103666232 1.429097349464702e-06 0.1084750215669379 1.429097460462474e-06 0.1075310013968523 1.42909754121676e-06 0.1068475792877216 \
1.429097653680086e-06 0.1059005796323111 1.429097704824629e-06 0.1054717782906781 1.429097787809798e-06 0.1047785948356612 1.429097845974503e-06 0.1042945647727652 \
1.429097960212503e-06 0.1033482075721767 1.42909801011597e-06 0.1029366076865433 1.429098095857569e-06 0.1022320954501846 1.429098144889019e-06 0.1018307629303728 \
1.429098227455441e-06 0.101157455862875 1.429098298387777e-06 0.1005815064560546 1.429098366538127e-06 0.1000302812267231 1.429098444148443e-06 0.0994053199805509 \
1.429098516491814e-06 0.09882546240595018 1.429098594067778e-06 0.09820656846618626 1.429098682738439e-06 0.09750287271560702 1.429098756553227e-06 0.09692010793638871 \
1.429098838144235e-06 0.09627924899616347 1.429098916282703e-06 0.09566870926115327 1.429099002032493e-06 0.09500229249765579 1.429099089729402e-06 0.09432453920671229 \
1.429099183638967e-06 0.09360304191323381 1.429099280098285e-06 0.09286661217778783 1.429099358728946e-06 0.09226977907248698 1.429099461452545e-06 0.09149473120661993 \
1.429099545280196e-06 0.09086620530027881 1.429099666032377e-06 0.08996702094116031 1.429099795302029e-06 0.08901247130467421 1.429099951190493e-06 0.08787237469953549 \
1.429100106290076e-06 0.08675000010972149 1.429100263305882e-06 0.08562614142917294 1.429100443326735e-06 0.08435280068725284 1.429100593847601e-06 0.08330035525696428 \
1.429100742221624e-06 0.08227363395463329 1.429100879838855e-06 0.08133079092382095 1.429101019758505e-06 0.08038162993974078 1.429101156365493e-06 0.07946425488810546 \
1.429101295092791e-06 0.07854214404995859 1.429101440403653e-06 0.07758663187171365 1.429101588151466e-06 0.07662571164688473 1.429101746748333e-06 0.07560598447141591 \
1.429101911000851e-06 0.07456266320243836 1.429102080017927e-06 0.07350246718885647 1.429102261906921e-06 0.07237646636762114 1.429102462529019e-06 0.07115268999588262 \
1.429102676406562e-06 0.0698691158856425 1.429102904040694e-06 0.0685263410462881 1.429103145626235e-06 0.06712722147996912 1.429103427215414e-06 0.06552977831071743 \
1.429103724369534e-06 0.06388229915275011 1.429104047802611e-06 0.06213267023812474 1.429104438962031e-06 0.0600758559534558 1.429104840456333e-06 0.05803293250078725 \
1.429105217397059e-06 0.05617754872181892 1.429105584510791e-06 0.05442503025024555 1.429105934627471e-06 0.05280240270907886 1.429106253933124e-06 0.05136309724710254 \
1.429106558257407e-06 0.05002640192327024 1.429106855163312e-06 0.04875503464657577 1.429107137163638e-06 0.04757867888787161 1.429107417596943e-06 0.04643900623749339 \
1.429107682320567e-06 0.04538777697325767 1.429107958218279e-06 0.04431704973151576 1.429108232683143e-06 0.04327654260273706 1.429108531102423e-06 0.04217254828989973 \
1.42910875761848e-06 0.04135316230013186 1.429109069531317e-06 0.04025053053625379 1.429109289786109e-06 0.03948972371590862 1.429109507050863e-06 0.03875470657060948 \
1.429109716773512e-06 0.03806113111453101 1.4291100269559e-06 0.03705828856757609 1.429110249553778e-06 0.03635538859683734 1.429110496919279e-06 0.03559019656168042 \
1.429110769325655e-06 0.03476651972027592 1.429110989958209e-06 0.03411384091885184 1.42911127423846e-06 0.03329124852897781 1.429111512151752e-06 0.0326183788879464 \
1.429111750241163e-06 0.03195887699386461 1.429111985496492e-06 0.03132132139405813 1.429112214275199e-06 0.03071728735992773 1.429112447005948e-06 0.03011490821398154 \
1.429112666308989e-06 0.02955843195412813 1.429112870252059e-06 0.02905055018162466 1.429113269161795e-06 0.02808303002558106 1.429113456316051e-06 0.02764052191221165 \
1.429113828521772e-06 0.0267814187683372 1.429114015473295e-06 0.02635997027055515 1.429114384827241e-06 0.02554620807076183 1.42911453848041e-06 0.02521471147941385 \
1.429114954694564e-06 0.02434161493068329 1.429115160182381e-06 0.02392065165079968 1.429115499190341e-06 0.02323955384462723 1.429115681885069e-06 0.02287916718068597 \
1.429116138978978e-06 0.02199597290476789 1.429116268719714e-06 0.02174967209293581 1.429116722140137e-06 0.02089828923199067 1.42911686451243e-06 0.0206336680476187 \
1.42911739407919e-06 0.01967289368906444 1.429117520286197e-06 0.01945139161001456 1.429118082520635e-06 0.01850749734048266 1.429118245259022e-06 0.01824627541187189 \
1.429118809439087e-06 0.01738327200207762 1.429118961183154e-06 0.01716165742474803 1.429119662862638e-06 0.01618760396393164 1.429119832951728e-06 0.01596324388168 \
1.429120488009604e-06 0.01513221026437959 1.429120654523916e-06 0.01492874613340729 1.429121387637676e-06 0.01406966818047924 1.429121520900854e-06 0.01391906482409888 \
1.429122372558029e-06 0.01299647369571925 1.429122510500477e-06 0.01285324185793544 1.429123450559967e-06 0.0119198170026788 1.429123614321604e-06 0.01176347583728811 \
1.429124601555038e-06 0.01085909507266535 1.429124736144114e-06 0.0107410715025141 1.429125877583544e-06 0.009819907073012045 1.429125985822443e-06 0.009738548299709823 \
1.429127309069827e-06 0.00880579379490502 1.429127441815525e-06 0.008718202093769473 1.42912896431665e-06 0.007760835273143199 1.429129076858719e-06 0.007690148685505111 \
1.429130769150306e-06 0.00669558715138598 1.429130909416891e-06 0.00662113250846694 1.429132982426194e-06 0.005629132576249021 1.42913317498771e-06 0.005545002188831318 \
1.429135385197559e-06 0.004656096148610405 1.429135791984232e-06 0.004507219767123045 1.429138613724209e-06 0.003590578528330178 1.429139135019959e-06 0.00344214578404881 \
1.429143347121009e-06 0.002447529662748036 1.429143899683877e-06 0.002340875287107731 1.429149782973417e-06 0.001359168649576994 1.429150032246415e-06 0.001311490127959886 \
1.429163182367465e-06 0.0003136950974005476 1.429163299150435e-06 0.0003112730584132499 1.458990000000011e-06 3.042397160644726e-06 1.502746667027013e-06 -0.0009024818035526668 \
1.502746739442629e-06 -0.001022682652537627 1.502747175467347e-06 -0.001858525046639076 1.50274726236173e-06 -0.002046124893065343 1.502747617065043e-06 -0.00288168582347465 \
1.502747716611644e-06 -0.003135075204051477 1.502747976881349e-06 -0.003828199033013717 1.50274811720375e-06 -0.004216406518003108 1.502748344689832e-06 -0.004856871791621592 \
1.502748481897271e-06 -0.005239031028659006 1.50274886679612e-06 -0.006187559915121 1.502748998893307e-06 -0.006423332025500122 1.502749687336335e-06 -0.005917035979538006 \
1.502749844265069e-06 -0.005202654566481615 1.502749971914231e-06 -0.004414133290428114 1.502750099456022e-06 -0.003433350487145549 1.502750217130233e-06 -0.002355902309038119 \
1.50275031626992e-06 -0.001320627313728655 1.50275042165263e-06 -9.507383675133965e-05 1.502750535559933e-06 0.001369964538583592 1.502750666615329e-06 0.003229572948258866 \
1.502750791978547e-06 0.005172303930030842 1.502750983820411e-06 0.008432154569684791 1.502751127490204e-06 0.01107975669588844 1.502751285472017e-06 0.01417105828876112 \
1.502751434071664e-06 0.01723098336859398 1.502751587122593e-06 0.02051714008521248 1.502751746187569e-06 0.02405720796424875 1.502751899257778e-06 0.02756764950178633 \
1.502752047604842e-06 0.03105219347129199 1.502752196711284e-06 0.03462388853332505 1.502752351275713e-06 0.03838854885099419 1.502752511961677e-06 0.04235886888523473 \
1.502752676640863e-06 0.04647718198980624 1.502752853163807e-06 0.05093664320808645 1.502753032175606e-06 0.05549818742091989 1.502753222948448e-06 0.0603932190016783 \
1.5027534277958e-06 0.06567927942044927 1.502753648293053e-06 0.07139554989571946 1.502753881211021e-06 0.07745499876455469 1.502754130458799e-06 0.08395499695136356 \
1.502754403380327e-06 0.09108394918256098 1.502754700173383e-06 0.09884095133633181 1.502755027609896e-06 0.1073964775374675 1.502755397423694e-06 0.1170487607486894 \
1.502755792369975e-06 0.1273407304921971 1.502756250458528e-06 0.1392499850125259 1.502756782558388e-06 0.1530377249371455 1.502757408110397e-06 0.169180864038255 \
1.502758094102463e-06 0.1867931863309214 1.502758896945878e-06 0.2072766958045763 1.50275979625821e-06 0.2300508264895909 1.502760696698323e-06 0.2526618731709107 \
1.502761498589855e-06 0.2726215666318766 1.502762194096996e-06 0.2897857674353052 1.502762826931282e-06 0.3052728323588638 1.502763422339773e-06 0.3197161646377594 \
1.502763969382815e-06 0.3328722959176427 1.502764503143162e-06 0.3455929446372428 1.502765022382586e-06 0.3578476146335662 1.502765529774049e-06 0.3697097539883151 \
1.502766033395218e-06 0.3813674725871593 1.502766545138114e-06 0.3930934709428262 1.502767052299123e-06 0.404595334768291 1.502767582595137e-06 0.4164962117964878 \
1.502768068708626e-06 0.4272847049163567 1.502768546816947e-06 0.437781779057129 1.502768986249071e-06 0.4473362978389137 1.502769109408535e-06 0.4500002106608159 \
1.502769355727463e-06 0.4553046876287923 1.502769698999458e-06 0.4626558934952216 1.502770010436459e-06 0.4692815017887791 1.502770261147724e-06 0.4745855323881177 \
1.502770531976868e-06 0.480281321066213 1.502770868458777e-06 0.4873122872019196 1.502771224467388e-06 0.4946959640027882 1.502771541737556e-06 0.5012322602315481 \
1.502771780618105e-06 0.506122906570856 1.502772021646287e-06 0.5110269393752048 1.502772273577991e-06 0.5161276795544476 1.502772513731835e-06 0.5209621749612534 \
1.502772736483296e-06 0.5254248476203834 1.502772925040943e-06 0.5291850880529715 1.502773139790987e-06 0.5334523706207774 1.502773354339378e-06 0.5376948565446859 \
1.50277361310367e-06 0.5427871977552768 1.502773863931242e-06 0.5477009885064807 1.502774119350104e-06 0.5526782776843104 1.502774470392629e-06 0.5594898819265107 \
1.502774735000954e-06 0.5645984056527484 1.50277500141751e-06 0.569709962982798 1.50277526193182e-06 0.5746801970751495 1.502775529021882e-06 0.5797469183389945 \
1.502775772159962e-06 0.5843213438768613 1.502776027852189e-06 0.5890994944692448 1.502776255671159e-06 0.5933243819692556 1.502776493215979e-06 0.5976999800355528 \
1.502776704606465e-06 0.6015679915939678 1.502776916747224e-06 0.6054277082074113 1.502777105936602e-06 0.6088479815213901 1.50277723709492e-06 0.6112112531841202 \
1.502777369391478e-06 0.6135871094428261 1.502777554614204e-06 0.6169015645304802 1.502777716636591e-06 0.6197943209800671 1.502777875055755e-06 0.6226100751126036 \
1.502778009167621e-06 0.6249846001944386 1.502778181488729e-06 0.6280247049765127 1.502778310427531e-06 0.6302937061188456 1.502778430805044e-06 0.6324061607157294 \
1.502778571333915e-06 0.634864734791624 1.502778764419407e-06 0.6382321981637986 1.502778914230185e-06 0.6408363654380513 1.50277908153778e-06 0.6437327988167145 \
1.502779262592003e-06 0.6468572757970242 1.502779465918433e-06 0.6503523798695617 1.502779648771588e-06 0.6534819287355287 1.502779819395834e-06 0.6563879501053153 \
1.502779996860074e-06 0.6594029650344411 1.502780162839025e-06 0.6622113135173925 1.502780320075814e-06 0.6648594636266301 1.502780460561866e-06 0.6672075432495704 \
1.502780604291994e-06 0.6695987751186935 1.502780737338985e-06 0.6718055529208897 1.502780879311128e-06 0.6741523780906628 1.502780999371661e-06 0.6761293215200647 \
1.502781144309748e-06 0.6785098354674278 1.502781260306798e-06 0.6804095298668216 1.502781379886685e-06 0.6823647593763783 1.50278147884666e-06 0.68397755359623 \
1.502781597355078e-06 0.6859039329668146 1.50278168439936e-06 0.6873150904607619 1.502781806410179e-06 0.6892866586554622 1.502781905332791e-06 0.6908817703737582 \
1.502781997228166e-06 0.6923536807698466 1.502782097196705e-06 0.6939486118486815 1.502782195442366e-06 0.6955126686751646 1.502782287156128e-06 0.6969676095571918 \
1.50278239128907e-06 0.698613189139943 1.502782527015812e-06 0.7007470979739818 1.502782681624274e-06 0.7031613517373301 1.502782816731986e-06 0.7052558942641604 \
1.502782963068532e-06 0.7075085519458914 1.502783091536073e-06 0.7094732734147607 1.502783215720207e-06 0.7113609898537658 1.502783325624507e-06 0.7130225953369277 \
1.502783442207576e-06 0.7147759898693785 1.502783542385407e-06 0.7162749667021007 1.502783679474215e-06 0.7183149847558421 1.502783799463242e-06 0.7200901405411056 \
1.50278391857669e-06 0.7218426783097279 1.502784045072077e-06 0.723693513465353 1.502784170939449e-06 0.7255245570057045 1.502784293560468e-06 0.7272980597885179 \
1.502784421177991e-06 0.7291334326655684 1.502784551426783e-06 0.7309957624152177 1.502784673019733e-06 0.73272442801297 1.502784811788425e-06 0.7346853525547948 \
1.502784912196869e-06 0.7360963845229137 1.502785015584257e-06 0.7375412410987998 1.5027851092447e-06 0.7388443755773992 1.502785220866297e-06 0.7403895158541485 \
1.502785307334899e-06 0.7415798421827293 1.50278540819801e-06 0.7429609798983192 1.502785540294732e-06 0.7447573558536402 1.502785649496034e-06 0.7462323422761349 \
1.502785754027664e-06 0.747635567415085 1.502785877674145e-06 0.7492836897664436 1.50278602637058e-06 0.7512497161812216 1.502786148251239e-06 0.7528480713857697 \
1.502786261855803e-06 0.7543274008692354 1.502786402375488e-06 0.7561429069656862 1.50278654356493e-06 0.7579511824827749 1.502786661311106e-06 0.7594470562859095 \
1.502786790000766e-06 0.7610693809796742 1.502786932555413e-06 0.7628512182523866 1.502787048411964e-06 0.7642872416835913 1.50278719417523e-06 0.7660789429779771 \
1.502787316007677e-06 0.7675637574673733 1.502787434476374e-06 0.7689965471136999 1.502787557264006e-06 0.7704700089613156 1.502787683416889e-06 0.7719718272910862 \
1.502787793785939e-06 0.7732757954107932 1.502787919217035e-06 0.7747465774777432 1.502788024698746e-06 0.775974259539018 1.502788157865176e-06 0.7775122819577122 \
1.502788280546631e-06 0.7789173428708996 1.502788415309674e-06 0.7804473432620218 1.502788525980962e-06 0.7816923373676121 1.502788635302591e-06 0.7829118427552927 \
1.502788770435025e-06 0.7844048889494442 1.50278892121405e-06 0.7860523747618094 1.502789061582958e-06 0.7875692293014268 1.502789181294483e-06 0.7888502570533434 \
1.502789319548824e-06 0.7903153082715967 1.502789442919159e-06 0.7916096503654788 1.502789588017784e-06 0.7931164937536124 1.502789727758043e-06 0.7945521172774316 \
1.502789854939467e-06 0.7958455533278409 1.50278997397922e-06 0.7970449251022731 1.502790086337411e-06 0.7981670522831598 1.502790190566191e-06 0.79919939674296 \
1.502790285905002e-06 0.8001364844871954 1.502790422193112e-06 0.8014634245741865 1.502790539085656e-06 0.8025894467082511 1.502790658725145e-06 0.8037305025474466 \
1.502790780606717e-06 0.8048811831579785 1.502790902985054e-06 0.8060245537852575 1.502791031013733e-06 0.8072081965553952 1.502791155658532e-06 0.8083483262222385 \
1.502791286157279e-06 0.8095291977395493 1.502791412617707e-06 0.8106611567088965 1.502791539743675e-06 0.8117869190804841 1.502791644861151e-06 0.8127087429624065 \
1.502791750111341e-06 0.8136235164943317 1.502791841251591e-06 0.8144090748259969 1.502791964669625e-06 0.8154632009865571 1.502792051748274e-06 0.8162003374872545 \
1.502792151070959e-06 0.8170344894488412 1.502792295992703e-06 0.8182390501293432 1.502792432261206e-06 0.8193582434421302 1.502792541723485e-06 0.8202477434185359 \
1.502792687843586e-06 0.8214214001843773 1.502792839202198e-06 0.8226208465286928 1.50279296500612e-06 0.8236052915965452 1.502793109416779e-06 0.824721541823094 \
1.50279323401773e-06 0.8256729463037898 1.502793384729791e-06 0.8268094083523665 1.50279352010105e-06 0.8278169867326588 1.502793645303979e-06 0.8287379047458127 \
1.502793762973362e-06 0.829593908450195 1.502793908801339e-06 0.8306418458276996 1.50279407529732e-06 0.8318207857986918 1.502794206154408e-06 0.8327345044534114 \
1.502794379603848e-06 0.833928356718921 1.502794547722322e-06 0.8350667646575466 1.502794717596124e-06 0.8361988603660855 1.502794898450754e-06 0.8373843006762304 \
1.502795041633135e-06 0.8383085120571983 1.502795155746479e-06 0.8390361588138326 1.50279528581247e-06 0.8398559950134801 1.502795387687706e-06 0.8404909448220066 \
1.502795504566998e-06 0.8412116130393378 1.502795641678929e-06 0.8420465258793415 1.502795839559572e-06 0.843231707656198 1.502796031345765e-06 0.8443585547012582 \
1.502796240708828e-06 0.8455646258450146 1.502796422822406e-06 0.846593677725298 1.502796619917178e-06 0.8476867969181797 1.502796793185875e-06 0.8486305714188691 \
1.502796976264561e-06 0.8496104335327738 1.502797147401587e-06 0.8505103231661706 1.502797322080438e-06 0.8514128411730317 1.502797497318728e-06 0.8523022053693007 \
1.502797673458367e-06 0.8531802340241421 1.502797863809624e-06 0.8541115036082744 1.50279805438677e-06 0.855025905954957 1.502798254818193e-06 0.8559685891497206 \
1.502798447410669e-06 0.8568563992305701 1.502798658273806e-06 0.8578086227668252 1.502798886187182e-06 0.8588150784816577 1.502799152217719e-06 0.8599606428795262 \
1.502799450738801e-06 0.8612090806949765 1.502799726692482e-06 0.8623286542354505 1.502800010954596e-06 0.8634483918036945 1.502800285103046e-06 0.8644969441068078 \
1.502800557392313e-06 0.8655088801415273 1.502800827558089e-06 0.8664846790737442 1.502801084736186e-06 0.8673881555543895 1.502801357299353e-06 0.868319368003445 \
1.502801633304697e-06 0.8692355072818493 1.502801903418629e-06 0.870106770567397 1.502802203245002e-06 0.8710447971670072 1.502802574222291e-06 0.8721640818024149 \
1.502802869154012e-06 0.8730224021943973 1.502803123432376e-06 0.873740732376842 1.502803421677207e-06 0.8745584461000401 1.502803695285219e-06 0.8752856917963749 \
1.502803931415444e-06 0.8758961959341748 1.502804171760979e-06 0.8765017794770257 1.502804394097168e-06 0.8770481951318053 1.50280458810245e-06 0.8775144010549708 \
1.502804917823794e-06 0.8782846129827527 1.50280507299682e-06 0.8786376896881318 1.502805390752408e-06 0.8793424631377607 1.502805569616983e-06 0.8797286397841958 \
1.502805912078462e-06 0.8804474051285093 1.502806096217817e-06 0.880822800830328 1.502806571118475e-06 0.881756283451624 1.502806738513154e-06 0.8820737784441692 \
1.5028072043462e-06 0.8829272622221894 1.502807385170493e-06 0.8832470363605239 1.502807879204793e-06 0.8840891816604841 1.502808020548669e-06 0.8843218944112644 \
1.502808626940586e-06 0.8852805359894154 1.502808779011766e-06 0.8855111592597558 1.502809425691436e-06 0.8864506941541785 1.502809553987642e-06 0.8866295550025313 \
1.502810202164815e-06 0.8874976172723908 1.502810331923675e-06 0.8876644392549727 1.502811100144497e-06 0.8886037370453904 1.502811229881009e-06 0.8887539063021698 \
1.502812083306654e-06 0.8896836309705964 1.502812226565088e-06 0.8898301468060963 1.502813212785821e-06 0.890764641901611 1.502813434267227e-06 0.8909571971396437 \
1.502814577308628e-06 0.8918770673440963 1.502814707298117e-06 0.8919774876506176 1.502816058923389e-06 0.8929731820841386 1.50281620928357e-06 0.89307657739048 \
1.502817689916169e-06 0.8939986636922405 1.502817928817934e-06 0.8941315911431026 1.502819693311633e-06 0.894999985510941 1.502820000994978e-06 0.8951330875684044 \
1.502822522266181e-06 0.8960612226716312 1.502822959317422e-06 0.8961978289811912 1.502826862729643e-06 0.8971619289239613 1.50282710951145e-06 0.8972094058147089 \
1.502834686001284e-06 0.8981998139535015 1.502834801913031e-06 0.8982099955090975 1.502853900445735e-06 0.8992062631372056 1.502854297888509e-06 0.8992194728667773 \
1.50300471332359e-06 0.9002121614362558 1.503004979381947e-06 0.9002436812458944 1.503010247532015e-06 0.8993470931706574 1.503010453902932e-06 0.899191170936528 \
1.503011932015742e-06 0.8982046351054961 1.503012112466399e-06 0.8981003355419954 1.503014334948061e-06 0.8971299612768925 1.503014541040576e-06 0.897079983173831 \
1.503024949306681e-06 0.8980580240048047 1.503025087164257e-06 0.8980839755683444 1.503031884513298e-06 0.8990685088718567 1.503032070084766e-06 0.8990874390200084 \
1.503528299258968e-06 0.9000706848616691 1.503528359054814e-06 0.9000975977971888 1.503529612605432e-06 0.9010828413531861 1.503529718298035e-06 0.9012097231395001 \
1.503530376428752e-06 0.9021613947651476 1.503530513611021e-06 0.9023918767045529 1.503531036637641e-06 0.9033649777562528 1.503531099501233e-06 0.9034908765919824 \
1.503531572096782e-06 0.904476514442582 1.503531623410596e-06 0.9045863669199017 1.503532089373931e-06 0.9055619780118375 1.503532121578392e-06 0.9056252631670594 \
1.503532838677129e-06 0.9066212416280413 1.503532923113402e-06 0.9066528951765993 1.503533523179781e-06 0.9059679814895146 1.503533643037393e-06 0.9055903401525059 \
1.503533774200172e-06 0.9050640446667092 1.503533909019925e-06 0.9043926011431642 1.503534057154984e-06 0.9034897747335404 1.503534194714335e-06 0.902493211317788 \
1.503534334926095e-06 0.9013135799985507 1.503534433588205e-06 0.9003872218501816 1.503534519272014e-06 0.8995148096066522 1.503534601836213e-06 0.8986166894493001 \
1.503534716618842e-06 0.8972773101170661 1.503534797717086e-06 0.8962642459447687 1.503534877134364e-06 0.8952218112132616 1.503534982588892e-06 0.8937633947192651 \
1.503535105230195e-06 0.8919606744930825 1.503535204954274e-06 0.890414036797163 1.503535375148685e-06 0.8876203405523397 1.503535521333777e-06 0.8850727273800474 \
1.503535689551925e-06 0.8819879035815887 1.503535861713021e-06 0.8786780617039783 1.503536046099114e-06 0.8749807502679057 1.503536230665458e-06 0.8711418063496947 \
1.503536414912944e-06 0.8671917613865908 1.503536600248607e-06 0.8631174608718694 1.503536774636335e-06 0.8592060069639053 1.503536957340272e-06 0.8550405244181323 \
1.503537132687366e-06 0.8509893565349284 1.503537315016877e-06 0.8467313026054767 1.503537505330306e-06 0.8422468264612591 1.503537675660435e-06 0.838204894125699 \
1.503537842184074e-06 0.8342320488410089 1.503538004754937e-06 0.830337741667393 1.50353815461616e-06 0.8267359097041467 1.503538305792179e-06 0.8230937075736249 \
1.503538494937653e-06 0.8185270080344306 1.503538640655707e-06 0.8150026134285653 1.503538815646674e-06 0.8107652770601156 1.503538964118217e-06 0.807166938184282 \
1.503539136005683e-06 0.8029987283123258 1.503539305073922e-06 0.7988973224349885 1.503539469252632e-06 0.7949140139776875 1.503539628580169e-06 0.7910485911592836 \
1.503539789029776e-06 0.7871568543472617 1.503539990849157e-06 0.7822630953020117 1.503540139296892e-06 0.7786646206504594 1.503540293464276e-06 0.77492821376164 \
1.503540430547636e-06 0.7716074476660475 1.503540539933082e-06 0.7689587163513494 1.503540645866538e-06 0.7663946531324515 1.503540772880885e-06 0.7633217481666642 \
1.503540887243854e-06 0.7605561828888391 1.503540990091676e-06 0.7580702160470256 1.503541111681993e-06 0.7551325442760125 1.503541222459267e-06 0.7524575925939972 \
1.503541339308092e-06 0.7496376180588871 1.503541450092818e-06 0.7469652567786068 1.503541568458919e-06 0.7441116745915923 1.503541693286014e-06 0.7411038668912771 \
1.50354184584781e-06 0.7374292753756717 1.503541979744798e-06 0.7342062928952946 1.503542100776237e-06 0.7312947572377408 1.503542264973752e-06 0.7273475399259534 \
1.503542442334699e-06 0.7230877912371642 1.503542624545107e-06 0.7187161681757385 1.503542805542373e-06 0.7143786395952922 1.503542986206316e-06 0.7100537072471783 \
1.503543176357883e-06 0.7055071781827296 1.503543364117777e-06 0.7010230964996226 1.503543564650881e-06 0.696237807975249 1.503543773336343e-06 0.6912646166759551 \
1.503543980979908e-06 0.6863227581165517 1.503544208547776e-06 0.6809140411171237 1.50354440082261e-06 0.6763521085712711 1.503544638087858e-06 0.6707310800019505 \
1.503544831366122e-06 0.6661595641347996 1.503545064098869e-06 0.6606646229758047 1.503545269656336e-06 0.6558174602470968 1.503545502009757e-06 0.6503484594495911 \
1.503545697011728e-06 0.6457674053103037 1.503545900240336e-06 0.6410004262200759 1.503546080092881e-06 0.6367906205544323 1.503546259199312e-06 0.6326052789263827 \
1.503546422576526e-06 0.628795088826817 1.50354659462593e-06 0.6247880828503264 1.503546758118769e-06 0.6209892715878097 1.503546933908587e-06 0.6169100951581823 \
1.503547115847573e-06 0.6126978430086294 1.503547304331305e-06 0.6083422542008314 1.503547510763727e-06 0.6035858951323969 1.50354769007839e-06 0.5994633272559844 \
1.503547887257256e-06 0.5949432360761027 1.503548096345397e-06 0.5901646611556908 1.50354830209466e-06 0.5854760387944159 1.503548542605348e-06 0.5800160304866983 \
1.50354871573345e-06 0.5760958285528379 1.503548880627452e-06 0.5723746772837877 1.503549061488027e-06 0.5683014035092815 1.503549218774123e-06 0.5647722902613652 \
1.503549387756918e-06 0.5609879409349005 1.503549567863379e-06 0.5569709657351898 1.503549720846506e-06 0.5535669615732179 1.503549852560951e-06 0.5506462283231492 \
1.503549999948651e-06 0.5473865746199473 1.503550087374242e-06 0.5454560063082221 1.503550172245482e-06 0.5435860258811447 1.503550270874694e-06 0.5414171943998213 \
1.503550342966855e-06 0.5398340751058975 1.503550440057874e-06 0.5377039800781129 1.503550525648258e-06 0.5358302678688993 1.503550590729134e-06 0.5344081412607664 \
1.503550714329502e-06 0.5317121235594142 1.503550808753772e-06 0.52965475734789 1.503550906276994e-06 0.5275349985745696 1.503551079137645e-06 0.5237893654184622 \
1.503551214133166e-06 0.5208709659121862 1.503551368316628e-06 0.5175498113398643 1.503551542781984e-06 0.5138002600288881 1.50355169458797e-06 0.510550000123414 \
1.503551840818953e-06 0.5074290310664136 1.503551984717826e-06 0.5043644611166801 1.503552127739669e-06 0.5013276181140283 1.503552223349517e-06 0.499301733014788 \
1.503552317793473e-06 0.4973032961550828 1.503552438849414e-06 0.4947494705229025 1.50355253372771e-06 0.4927525559781179 1.503552649558553e-06 0.4903172469328811 \
1.503552736822402e-06 0.4884854516151125 1.503552819252848e-06 0.4867593351188191 1.503552914660802e-06 0.484765406725184 1.503553015371081e-06 0.4826639978995959 \
1.503553112231473e-06 0.4806459052877932 1.503553250961225e-06 0.4777646955734051 1.503553386666086e-06 0.4749532752442271 1.503553587150809e-06 0.4708139964547478 \
1.503553802464962e-06 0.4663911383470885 1.503553984040267e-06 0.462674698484628 1.503554183012236e-06 0.4586189944293299 1.503554353577757e-06 0.455154096457448 \
1.503554527931445e-06 0.4516251957269069 1.503554696864699e-06 0.4482170126441485 1.50355486946186e-06 0.4447467276163349 1.50355505206819e-06 0.4410867902598327 \
1.503555240617055e-06 0.4373240875354826 1.503555434084593e-06 0.4334777823509549 1.503555642405232e-06 0.4293535036700135 1.503555856750462e-06 0.4251286740881063 \
1.503556082455792e-06 0.4207018662297695 1.50355630899916e-06 0.4162771402745992 1.503556571175911e-06 0.4111844468197049 1.503556820209735e-06 0.4063709766754009 \
1.503557121308433e-06 0.4005865607947761 1.50355741072925e-06 0.3950673729298416 1.503557718243529e-06 0.3892455819062323 1.503558040439924e-06 0.3831936848847286 \
1.503558368170407e-06 0.3770882112794804 1.503558700600163e-06 0.3709500980558715 1.50355903032917e-06 0.3649083177186754 1.503559351558758e-06 0.3590729273462687 \
1.503559682375082e-06 0.3531219177045733 1.503560024730645e-06 0.3470224718704957 1.503560324371677e-06 0.3417374346434491 1.503560654159242e-06 0.3359723367088904 \
1.503560981053185e-06 0.3303128110141857 1.503561319032532e-06 0.3245206193888226 1.503561628003696e-06 0.3192755432624759 1.503561952801669e-06 0.31382336954194 \
1.503562268431866e-06 0.3085864885517507 1.503562573419032e-06 0.3035810258414895 1.503562828757677e-06 0.2994330834535801 1.503563093620834e-06 0.295170851203172 \
1.503563380703519e-06 0.2905978071194348 1.503563603673297e-06 0.2870801635277143 1.503563803212566e-06 0.2839591363066187 1.50356401286858e-06 0.2807045410859125 \
1.503564193125121e-06 0.2779290029372279 1.503564355469842e-06 0.2754463208250681 1.503564505904816e-06 0.2731629026725527 1.503564656910124e-06 0.2708866524077067 \
1.503564853800715e-06 0.2679392949564011 1.503564984945479e-06 0.2659970646012914 1.503565109682017e-06 0.2641561221543183 1.50356526127406e-06 0.2619266655689588 \
1.503565357242231e-06 0.2605306204207966 1.5035654537936e-06 0.2591282589302421 1.503565578413389e-06 0.2573209601776467 1.503565720989923e-06 0.255257422470362 \
1.503565879923458e-06 0.25296979123958 1.503566012589525e-06 0.251062957019046 1.503566196158294e-06 0.2484301322588876 1.50356637739346e-06 0.2458327969660818 \
1.503566588907564e-06 0.2428051031600066 1.503566791497399e-06 0.2399069804317323 1.503566958053847e-06 0.2375282895552967 1.503567168273059e-06 0.2345337828133105 \
1.503567341690945e-06 0.2320692345528927 1.503567570533673e-06 0.2288260787734411 1.503567791168424e-06 0.2257162440502939 1.503567966830138e-06 0.2232503232699662 \
1.503568147290643e-06 0.2207258962977968 1.503568318047021e-06 0.2183528725291195 1.503568498243287e-06 0.2158619697278009 1.503568664973905e-06 0.2135675266585953 \
1.503568814095326e-06 0.2115251542210239 1.503568969905344e-06 0.2094125291275523 1.503569105085769e-06 0.2075875692769576 1.503569255167197e-06 0.2055694209972212 \
1.503569387612823e-06 0.2037957203154137 1.50356952815736e-06 0.2019220745191926 1.503569645226124e-06 0.2003748851744883 1.50356977493373e-06 0.1986681706274326 \
1.503569896991199e-06 0.1970700654731777 1.503570019534635e-06 0.1954731161836187 1.503570137553958e-06 0.1939418157697267 1.503570272576731e-06 0.1921981789937757 \
1.503570417201182e-06 0.1903420634523806 1.503570545551681e-06 0.1887049708672087 1.503570669186156e-06 0.1871351133418249 1.503570766736279e-06 0.1859021016257166 \
1.503570881809208e-06 0.1844539912642748 1.503570975507888e-06 0.1832809848801438 1.503571074292012e-06 0.1820493959460708 1.503571197226553e-06 0.1805230483556907 \
1.503571292980556e-06 0.1793400249325384 1.503571422068107e-06 0.177753298391591 1.503571524533477e-06 0.1764993061988986 1.503571622786974e-06 0.1753029542432101 \
1.503571742874187e-06 0.1738483570896001 1.503571845423405e-06 0.1726127298531683 1.503571955881064e-06 0.1712877101305652 1.503572084370928e-06 0.1697552709290656 \
1.503572175855769e-06 0.1686698090598139 1.503572280340358e-06 0.1674358120019214 1.503572355277094e-06 0.1665544493622226 1.503572444845591e-06 0.1655049734124585 \
1.5035724954106e-06 0.164914347906921 1.503572545388976e-06 0.1643318187475747 1.503572610358061e-06 0.163576534137217 1.503572645872029e-06 0.1631646263336159 \
1.503572718071202e-06 0.162329174921529 1.503572785200297e-06 0.1615546732967998 1.503572844430032e-06 0.160873195114598 1.50357288817563e-06 0.1603710314414745 \
1.503572935822458e-06 0.1598254649913795 1.503573006202993e-06 0.1590230739426561 1.503573088541159e-06 0.1580883269013631 1.503573166712759e-06 0.1572048664554128 \
1.503573248765709e-06 0.1562816770844126 1.503573341469331e-06 0.1552436243401225 1.503573464249495e-06 0.153877370231325 1.503573563395588e-06 0.1527810927807017 \
1.503573664895935e-06 0.1516651170047695 1.503573766171127e-06 0.1505582666538253 1.503573862662911e-06 0.1495093242781697 1.503573962080946e-06 0.1484346886615803 \
1.503574046381569e-06 0.1475281828465028 1.503574139320259e-06 0.1465342051547719 1.5035742219212e-06 0.1456551508734999 1.503574330687285e-06 0.1445034822456445 \
1.503574436330265e-06 0.1433917535370727 1.503574517989854e-06 0.1425365900703354 1.503574611735024e-06 0.1415598856352903 1.503574705302971e-06 0.1405903867550886 \
1.503574788187461e-06 0.139735765814107 1.503574876346636e-06 0.1388313836440244 1.503574956132722e-06 0.1380170907865772 1.503575049728122e-06 0.1370669869522621 \
1.503575139660646e-06 0.1361590166429519 1.503575210211042e-06 0.1354501541392388 1.503575279971219e-06 0.1347521119166949 1.503575394120126e-06 0.1336164586193709 \
1.50357547609874e-06 0.1328058651355588 1.503575563704042e-06 0.1319440719770354 1.503575663205238e-06 0.1309710196939938 1.503575772385241e-06 0.1299110174488692 \
1.503575874550573e-06 0.1289256009328031 1.503575982010779e-06 0.1278959836800649 1.503576102045057e-06 0.1267549558890445 1.503576196253091e-06 0.1258657925752028 \
1.503576327232195e-06 0.1246390638240933 1.503576426659896e-06 0.1237164070883829 1.503576535781582e-06 0.1227104370444639 1.50357664463475e-06 0.1217138859540913 \
1.503576736944154e-06 0.120874257454373 1.503576849784484e-06 0.1198547128626846 1.503576946796524e-06 0.118986084968971 1.503577051062872e-06 0.1180628196869088 \
1.503577160029802e-06 0.1171053395831002 1.503577259569368e-06 0.1162371554254778 1.503577376562078e-06 0.1152245300989246 1.503577463662868e-06 0.1144761644999183 \
1.50357757295452e-06 0.1135478691973115 1.503577654479583e-06 0.1128618460838699 1.503577754254576e-06 0.1120273350449922 1.503577871679726e-06 0.1110526766231405 \
1.503577973464844e-06 0.1102143708571793 1.503578061203792e-06 0.1094962336869811 1.5035781420033e-06 0.1088432886892514 1.503578228954319e-06 0.1081456845520918 \
1.503578309740945e-06 0.1075007757815706 1.503578399947511e-06 0.1067842832273628 1.503578490898266e-06 0.1060655611559195 1.50357857956879e-06 0.1053685613006139 \
1.503578678583611e-06 0.1045946508745568 1.503578772289787e-06 0.1038723470842792 1.503578866149063e-06 0.1031520741219857 1.503578966976511e-06 0.1023817709659086 \
1.503579071607409e-06 0.1015861061604995 1.503579195570165e-06 0.1006484085638475 1.503579292969478e-06 0.09991551135558702 1.503579413227425e-06 0.09901872452754552 \
1.5035795240953e-06 0.09819831936474602 1.503579628568336e-06 0.09742874659471555 1.503579745805045e-06 0.09656937225591002 1.503579847599366e-06 0.09582695326576983 \
1.503579945574917e-06 0.09511577589263259 1.503580086079406e-06 0.09410164141823299 1.503580191157202e-06 0.09334832721827611 1.503580289770019e-06 0.09264549593674179 \
1.503580382484827e-06 0.09198739948435641 1.503580468683212e-06 0.09137785861853052 1.503580562596188e-06 0.09071637432184691 1.503580659696934e-06 0.09003559055802626 \
1.503580769117988e-06 0.08927317549644689 1.503580870101537e-06 0.08857281843916648 1.503580963759483e-06 0.08792605868920525 1.503581037934155e-06 0.08741581771673042 \
1.503581175834007e-06 0.08647193599618339 1.503581248191011e-06 0.08597917321277694 1.503581383512214e-06 0.08506274029062395 1.503581469423819e-06 0.08448410751389913 \
1.503581614152054e-06 0.08351486081643937 1.503581710382619e-06 0.0828744112740944 1.503581798218398e-06 0.08229260392026354 1.503581914017306e-06 0.08152964121883956 \
1.503582029145757e-06 0.08077575264951149 1.50358214291219e-06 0.08003553900012179 1.503582283169683e-06 0.0791300282244784 1.503582424545716e-06 0.07822490276368012 \
1.503582574181758e-06 0.07727536491519127 1.503582718670613e-06 0.07636690312463701 1.503582869844724e-06 0.07542565384097814 1.503583019215543e-06 0.07450459906593411 \
1.503583168562251e-06 0.0735926433331697 1.503583328517767e-06 0.07262574717347114 1.503583484664678e-06 0.07169171823582712 1.503583659153112e-06 0.07065947636250877 \
1.503583828862219e-06 0.0696671357044583 1.503584014041303e-06 0.0685979885997255 1.50358421076238e-06 0.06747763456279594 1.5035844212802e-06 0.06629631776014881 \
1.503584643312255e-06 0.06507007089066431 1.503584873524276e-06 0.0638195278444372 1.503585116035382e-06 0.06252626147401 1.503585376689467e-06 0.06116236403900636 \
1.503585656588531e-06 0.05972739422233359 1.503585950172255e-06 0.05825544847408989 1.503586265108239e-06 0.05671370145268265 1.503586607914164e-06 0.05507846134953124 \
1.503586957380758e-06 0.0534565727116736 1.503587366284915e-06 0.05161746230842366 1.503587712949942e-06 0.05010669351290297 1.503588100364996e-06 0.04846839895323611 \
1.503588444582788e-06 0.04705645202362623 1.503588768009047e-06 0.04576625679949029 1.503589073054809e-06 0.04458093278443617 1.503589365916806e-06 0.04347099288378908 \
1.503589650057723e-06 0.04242242262004604 1.503589926078015e-06 0.04142902112907627 1.503590192930566e-06 0.04049015932812138 1.503590461822789e-06 0.03956531631184226 \
1.503590737883211e-06 0.03863769040165695 1.503591025478782e-06 0.03769451689421055 1.503591265044408e-06 0.03692662498323904 1.503591554211835e-06 0.03602084344675294 \
1.503591770003438e-06 0.03535960341037672 1.503591957720476e-06 0.03479599077274986 1.503592155849582e-06 0.03421285035004928 1.503592518724446e-06 0.03317032497347058 \
1.503592776866276e-06 0.03244834222605905 1.50359308657919e-06 0.0316030971185694 1.503593352049329e-06 0.03089664771451467 1.503593620168408e-06 0.03019941363307669 \
1.503593899042439e-06 0.02949128999862272 1.503594145228876e-06 0.02888043298519722 1.503594375860285e-06 0.02832033800396738 1.503594614150204e-06 0.02775711540944564 \
1.503594849157568e-06 0.02721270742060762 1.503595076940031e-06 0.02669509678424227 1.503595485552303e-06 0.02579039168486155 1.503595661854632e-06 0.02540904040268441 \
1.503596016332316e-06 0.02465798827491217 1.503596200203288e-06 0.02427641469830137 1.50359653515201e-06 0.02359448510613503 1.503596699060727e-06 0.02326678168937357 \
1.503597091331304e-06 0.02249905491676728 1.503597247322069e-06 0.02220010404946675 1.503597678925426e-06 0.02138321689778962 1.503597816314806e-06 0.0211255367654138 \
1.503598333123589e-06 0.02017559010600388 1.503598458659483e-06 0.01995091418019728 1.503598915901007e-06 0.01915998482559782 1.503599075046989e-06 0.01889493739859509 \
1.503599682285467e-06 0.01793263500095189 1.503599816822955e-06 0.01772934138481063 1.503600480086948e-06 0.01678091027541291 1.503600673410379e-06 0.01651856846389665 \
1.503601341067039e-06 0.01565087920017967 1.503601502655887e-06 0.01544858341705342 1.50360225789114e-06 0.01454101846553843 1.503602407452107e-06 0.01436800730673201 \
1.503603297789931e-06 0.01338293844200974 1.503603396447817e-06 0.01327873262558703 1.503604353121314e-06 0.01230993787860994 1.503604474231021e-06 0.01219243157195396 \
1.50360546572373e-06 0.01126376273051215 1.50360562925246e-06 0.01111855113153209 1.503606759174536e-06 0.01018247077230436 1.503606871621774e-06 0.01009565848301377 \
1.503608249445262e-06 0.009103273453806031 1.503608388390533e-06 0.009009747578659758 1.503609942788868e-06 0.008018073335410726 1.50361005485534e-06 0.00794673960805117 \
1.50361169983817e-06 0.006958154532207958 1.503611807090664e-06 0.006899512253112593 1.503613751584152e-06 0.005937533026687714 1.50361395848211e-06 0.005843834961138424 \
1.503616297369853e-06 0.00487227039639981 1.503616721356264e-06 0.004712306502041247 1.50361949358946e-06 0.003780857497341114 1.503619941898552e-06 0.003647790772321777 \
1.503623582397237e-06 0.00272553831825111 1.503624079053072e-06 0.002619503085887757 1.503629830173496e-06 0.001650572925599863 1.503630116955383e-06 0.001609446887446839 \
1.503635471944067e-06 0.0006353228983793809 1.503635677300692e-06 0.0005920420449145349 1.506282712074507e-06 -0.0002718533828215428 1.506282867950111e-06 -0.0004579010352009555 \
1.506283416265203e-06 -0.001326296959495401 1.506283529048879e-06 -0.001543805653187533 1.506283963541018e-06 -0.002491429791030493 1.506284039366175e-06 -0.002673591589873599 \
1.506284396016773e-06 -0.003590195133438418 1.506284523065853e-06 -0.003936807634339821 1.506284801566247e-06 -0.004716444651655622 1.50628490965073e-06 -0.005020876868076652 \
1.506285253249855e-06 -0.00592430224391268 1.50628536024372e-06 -0.006162325733041658 1.506286259614116e-06 -0.005653094509861465 1.506286438047545e-06 -0.004687598829536962 \
1.50628654377096e-06 -0.003940993102967527 1.506286668833738e-06 -0.002883597584075996 1.506286762417834e-06 -0.001971418478057775 1.506286840257396e-06 -0.001132968824455395 \
1.506286920329394e-06 -0.0001977429743171 1.506287042702205e-06 0.001370578777960296 1.506287160958077e-06 0.003041212838230153 1.506287279607187e-06 0.004860750887681821 \
1.506287393089626e-06 0.006730904986417607 1.506287496532764e-06 0.008536402178002854 1.506287611192018e-06 0.01064190690353853 1.506287801775811e-06 0.0143607330143792 \
1.506287935565949e-06 0.01711819191720031 1.506288085819515e-06 0.02033933849841947 1.506288240988763e-06 0.02378599874269359 1.506288396380811e-06 0.0273434151175349 \
1.506288544088043e-06 0.03080849965087477 1.506288693077668e-06 0.03437359286003162 1.506288848068751e-06 0.03814545786868043 1.506289007439365e-06 0.04208062121327779 \
1.506289172372776e-06 0.04620305710844342 1.506289347319105e-06 0.0506208066052034 1.506289526449176e-06 0.05518387280380205 1.506289716238432e-06 0.06005265756871143 \
1.5062899199354e-06 0.06530840376289772 1.506290139745932e-06 0.07100650943730057 1.506290371497376e-06 0.07703584544314998 1.506290619322674e-06 0.08349927754587044 \
1.506290890643603e-06 0.09058756662233436 1.506291185356381e-06 0.09829181712822582 1.506291510614029e-06 0.106792896697727 1.506291876859735e-06 0.1163551101154179 \
1.506292270156448e-06 0.1266079356677421 1.506292722809344e-06 0.1383809089651769 1.506293248524511e-06 0.1520098384503803 1.506293867738049e-06 0.1679979965193872 \
1.506294548482366e-06 0.1854865650013753 1.50629534215732e-06 0.2057488551561759 1.506296230922953e-06 0.2282732214494322 1.506297044312215e-06 0.2487218262351868 \
1.506297766061792e-06 0.2667261628598245 1.5062984017258e-06 0.282460740414376 1.506298973442562e-06 0.2965101025186013 1.506299508996846e-06 0.3095696210007924 \
1.506300012355259e-06 0.3217495654069301 1.506300488682702e-06 0.3331878525640654 1.506300962606306e-06 0.3444754071334732 1.506301420078024e-06 0.3552759747331513 \
1.506301886058294e-06 0.3661792384270033 1.506302335046104e-06 0.376592601923634 1.506302831152646e-06 0.3879857357798637 1.506303350914508e-06 0.3998002499051578 \
1.506303730319152e-06 0.4083447473225827 1.506304170327876e-06 0.4181679450526055 1.506304640096814e-06 0.4285466970600206 1.506305125617752e-06 0.4391589006481625 \
1.506305565065858e-06 0.4486701556983262 1.506305626818807e-06 0.4500002248264944 1.506305750324704e-06 0.4526540461147197 1.506305997336498e-06 0.4579447795386873 \
1.506306249931409e-06 0.463325462421476 1.506306447502524e-06 0.467511453725808 1.506306673074271e-06 0.4722681264242033 1.506306994642268e-06 0.4790073975813253 \
1.506307263421497e-06 0.4846013351959894 1.50630748207297e-06 0.4891262574467725 1.506307692176936e-06 0.4934547887280634 1.506307918582462e-06 0.4980921872304203 \
1.506308127687652e-06 0.5023516957637455 1.506308317089911e-06 0.5061927337048852 1.506308441251129e-06 0.5086969563931187 1.506308568006226e-06 0.5112441466129884 \
1.506308728004704e-06 0.5144514110933732 1.506308975647656e-06 0.5193914248715521 1.506309154234115e-06 0.5229351592435862 1.506309325187692e-06 0.5263079149198099 \
1.506309586537288e-06 0.5314455197962068 1.50630981260887e-06 0.5358634945234868 1.506310015740537e-06 0.5398188128751134 1.506310180971267e-06 0.5430252218652345 \
1.506310337758288e-06 0.5460612552756139 1.506310526914905e-06 0.5497137532216215 1.506310728782658e-06 0.5535976061995346 1.506310952933981e-06 0.5578986282275192 \
1.506311191316346e-06 0.5624617013850463 1.506311426077985e-06 0.566941985223824 1.50631165634869e-06 0.5713275351537204 1.506311862141324e-06 0.5752375533958141 \
1.506312067125538e-06 0.5791255875933676 1.50631230994078e-06 0.5837094709690289 1.506312564698362e-06 0.588493349632063 1.506312792926793e-06 0.5927514274590796 \
1.506313030765665e-06 0.5971656109489694 1.506313243043101e-06 0.6010807441713891 1.506313454836505e-06 0.6049674646600495 1.506313708720774e-06 0.6095919957414236 \
1.506313913314301e-06 0.6132953190650409 1.506314165037654e-06 0.6178178328453598 1.506314352827174e-06 0.6211736970442716 1.506314605700251e-06 0.6256587164710262 \
1.506314804109613e-06 0.6291560967673944 1.506314983842284e-06 0.6323071487074056 1.506315254113091e-06 0.6370161336915187 1.506315471396857e-06 0.6407803561788556 \
1.506315651923236e-06 0.6438916924996977 1.506315853084131e-06 0.6473460740030906 1.506316021667513e-06 0.650231451944099 1.50631622602572e-06 0.6537144072723954 \
1.506316371688778e-06 0.6561873372238678 1.506316536247377e-06 0.6589728476742622 1.506316705716593e-06 0.6618316558839334 1.506316859256675e-06 0.664412775690417 \
1.506317000490202e-06 0.6667750288922751 1.506317144066014e-06 0.6691685747430841 1.506317277296139e-06 0.6713840140331436 1.506317419196459e-06 0.6737368819239464 \
1.506317539430086e-06 0.6757233098298149 1.506317684081138e-06 0.6781085120392751 1.506317800299844e-06 0.6800197521569988 1.506317919382163e-06 0.6819757159594566 \
1.506318017960477e-06 0.6835903813535821 1.506318135558183e-06 0.6855122399681081 1.506318222994146e-06 0.6869376986921233 1.506318347740232e-06 0.6889650632873403 \
1.506318447547296e-06 0.6905825000046129 1.506318540037093e-06 0.6920753042469043 1.506318641321177e-06 0.6937043390836264 1.506318739114283e-06 0.695273833970533 \
1.506318830385075e-06 0.6967333967490603 1.506318932842905e-06 0.6983656370917724 1.506319065752136e-06 0.7004728611232253 1.506319220767541e-06 0.7029137789397926 \
1.506319355649227e-06 0.7050222373350452 1.506319501145018e-06 0.7072806469370021 1.506319628999685e-06 0.709252249158637 1.506319753457981e-06 0.7111597484283609 \
1.506319864783685e-06 0.7128563623504806 1.506319978813713e-06 0.7145852226468989 1.506320079324929e-06 0.7161013069709498 1.506320216526077e-06 0.7181590832501857 \
1.506320336471979e-06 0.7199473375636642 1.506320455641778e-06 0.7217141075019444 1.506320582586792e-06 0.7235855504531626 1.506320707354209e-06 0.7254141264975077 \
1.506320830849597e-06 0.7272133847865295 1.50632095763087e-06 0.7290498056238117 1.506321088220355e-06 0.730930225429108 1.506321210432258e-06 0.7326797786847141 \
1.506321347490271e-06 0.7346298644824388 1.506321448705626e-06 0.7360619656663578 1.506321553674562e-06 0.7375401619041119 1.506321645165995e-06 0.7388229997694907 \
1.506321758241356e-06 0.7404001534680551 1.50632184554224e-06 0.7416107338190071 1.506321950005571e-06 0.7430512000342341 1.506322080768703e-06 0.7448411286358657 \
1.5063221906822e-06 0.7463352048609909 1.506322295341958e-06 0.7477488743938407 1.50632241917362e-06 0.7494094725133206 1.506322567926971e-06 0.751387874302702 \
1.506322689842132e-06 0.7529958494242643 1.506322803696392e-06 0.7544867042370438 1.50632294419585e-06 0.7563117925204224 1.506323085519364e-06 0.7581313010100689 \
1.506323203298972e-06 0.7596352654099263 1.506323331697459e-06 0.7612620174900669 1.506323474021161e-06 0.7630496612437514 1.506323590410316e-06 0.7644991888858087 \
1.506323736133978e-06 0.7662987831554334 1.506323857913867e-06 0.7677897310961733 1.506323976478797e-06 0.7692300520321635 1.506324099092246e-06 0.7707078417740018 \
1.506324225543629e-06 0.77221964326554 1.506324335666584e-06 0.7735261258099556 1.506324461188726e-06 0.7750039859681491 1.506324566849672e-06 0.7762386743660952 \
1.506324702026829e-06 0.7778058706872942 1.506324825637346e-06 0.7792267957652825 1.506324955634725e-06 0.7807078764205345 1.506325068606223e-06 0.7819831642610904 \
1.506325176500111e-06 0.7831908181350914 1.506325313030793e-06 0.7847046126527283 1.506325463151702e-06 0.7863508260127218 1.506325605416006e-06 0.7878933964149381 \
1.506325724997519e-06 0.7891771019825847 1.506325861808649e-06 0.7906313890246753 1.506325984312413e-06 0.7919206245676671 1.506326128984341e-06 0.7934276941869095 \
1.506326269769414e-06 0.794878360380241 1.506326396585209e-06 0.796171745508174 1.506326515632602e-06 0.7973744708066829 1.506326627895563e-06 0.7984986270115709 \
1.506326732283333e-06 0.7995352562746869 1.506326827560395e-06 0.8004739840425704 1.506326963902891e-06 0.8018044219089175 1.50632708076796e-06 0.8029326473252685 \
1.506327200364489e-06 0.8040757482679398 1.506327322250299e-06 0.8052288531124292 1.506327444838559e-06 0.8063765489401953 1.506327572579618e-06 0.8075599074701925 \
1.506327697362526e-06 0.8087035441861687 1.506327827862901e-06 0.8098867241643505 1.506327954229597e-06 0.8110199871086299 1.506328081578389e-06 0.8121498004723215 \
1.506328186791179e-06 0.8130740322933268 1.506328291495184e-06 0.8139855427426806 1.50632838302539e-06 0.8147757515715357 1.50632850639836e-06 0.8158311616195392 \
1.506328593352408e-06 0.8165684017534872 1.506328692208245e-06 0.8173999442793862 1.506328836710884e-06 0.8186029267949408 1.506328973036573e-06 0.8197243345631372 \
1.506329082445008e-06 0.8206145128367788 1.506329228461948e-06 0.821788834531623 1.506329380203007e-06 0.8229927727264784 1.506329506119585e-06 0.8239792970156907 \
1.506329650568649e-06 0.8250971468990039 1.506329775264817e-06 0.8260503472050121 1.506329925878834e-06 0.8271873005969326 1.506330061249302e-06 0.8281959289694237 \
1.506330186472937e-06 0.8291179217777711 1.506330304128897e-06 0.8299746468143927 1.50633044991051e-06 0.8310230722388168 1.50633061639426e-06 0.8322027532553667 \
1.506330747215023e-06 0.8331167337813133 1.506330920675045e-06 0.834311196379941 1.506331088787841e-06 0.8354501125721271 1.506331258668969e-06 0.8365827385393307 \
1.506331439512628e-06 0.8377685497174457 1.506331582704692e-06 0.8386931238161603 1.506331696822189e-06 0.8394210074154138 1.5063318268738e-06 0.8402408682651782 \
1.506331928753516e-06 0.8408758513273116 1.506332045641139e-06 0.841596551294542 1.506332182786859e-06 0.8424315815669623 1.506332380696072e-06 0.8436167827761205 \
1.506332572515411e-06 0.8447436440637145 1.506332781866158e-06 0.8459494874145237 1.506332964017768e-06 0.8469786287449077 1.50633316110399e-06 0.8480715276019779 \
1.506333334356719e-06 0.8490148531186206 1.506333517450963e-06 0.8499943787178993 1.50633368858243e-06 0.8508936588199895 1.506333863270272e-06 0.8517955326875627 \
1.506334038504287e-06 0.8526841769874772 1.506334214641154e-06 0.8535614892404448 1.506334405008494e-06 0.8544920815553035 1.506334595580845e-06 0.8554057038167108 \
1.506334795976838e-06 0.8563474066245403 1.506334988566463e-06 0.8572344253714166 1.506335199466375e-06 0.858185963363946 1.506335427341862e-06 0.8591913103610016 \
1.506335693424718e-06 0.8603357477151101 1.506335991926854e-06 0.8615822374427254 1.506336267816323e-06 0.8627000332972231 1.506336552083493e-06 0.8638181192989086 \
1.506336826221443e-06 0.8648650323418529 1.506337098522366e-06 0.8658754039994767 1.506337368678562e-06 0.8668495780678541 1.506337625862699e-06 0.8677515347235455 \
1.506337898421613e-06 0.8686810999091764 1.506338174469332e-06 0.8695957110915412 1.506338444589598e-06 0.8704649939918846 1.506338744449489e-06 0.8714007440816277 \
1.506339115430114e-06 0.8725171209518352 1.506339410352536e-06 0.8733732402027278 1.506339664628271e-06 0.8740897163373675 1.506339962841735e-06 0.8749052413925265 \
1.506340236411346e-06 0.8756305047096297 1.506340472534749e-06 0.8762394088953867 1.506340712859886e-06 0.8768433401198644 1.506340935193821e-06 0.8773882060838187 \
1.506341129200254e-06 0.8778530214284207 1.506341458909681e-06 0.8786208714695904 1.50634161408109e-06 0.87897283049042 1.506341931723491e-06 0.8796750328643211 \
1.506342110604035e-06 0.8800599154915705 1.506342453064798e-06 0.8807759898408113 1.50634263726721e-06 0.8811501695110489 1.506343112296513e-06 0.8820806183873429 \
1.506343279683462e-06 0.8823969901232691 1.506343745459843e-06 0.8832471741583867 1.506343926299187e-06 0.8835657112976044 1.506344420308805e-06 0.8844044135654346 \
1.506344561623711e-06 0.8846360992458032 1.506345167867327e-06 0.8855901496945974 1.506345319942526e-06 0.8858196526512701 1.506345966662599e-06 0.8867549368993356 \
1.506346094949266e-06 0.8869330782847171 1.506346743158686e-06 0.8877977435561634 1.506346872882985e-06 0.8879638504720397 1.506347641302053e-06 0.8888993076310558 \
1.506347771073903e-06 0.8890488273083775 1.506348624736509e-06 0.8899738047157748 1.506348767761561e-06 0.8901192131187072 1.506349754067048e-06 0.8910487927319016 \
1.5063499755536e-06 0.8912403904783051 1.506351118378138e-06 0.8921548233216382 1.506351248258076e-06 0.8922544308366913 1.506352600758498e-06 0.8932425879319322 \
1.506352751041431e-06 0.8933452769452155 1.506354231575698e-06 0.8942627870546499 1.506354470485492e-06 0.8943950258099049 1.506356252518433e-06 0.8952625983306248 \
1.50635663826586e-06 0.895426813549116 1.506359040424079e-06 0.8963023915260389 1.506359515360049e-06 0.8964490046842035 1.506363433287165e-06 0.8974035634625627 \
1.506363903247409e-06 0.8974927205890085 1.506372272035387e-06 0.8984807567386782 1.506372492545714e-06 0.8984960697096243 1.506417072074293e-06 0.8994905034760702 \
1.506418273460192e-06 0.8995076493514624 1.506554083268694e-06 0.9004821828323031 1.506554262245419e-06 0.9005421539807538 1.506557707120337e-06 0.8996085030263692 \
1.506557879904192e-06 0.8994755022453073 1.5065592062239e-06 0.8985168769831137 1.506559392989208e-06 0.8983970610744239 1.506561177194233e-06 0.8974304740967198 \
1.506561389324515e-06 0.8973403978332656 1.506574730020299e-06 0.8983331062395279 1.506574843308144e-06 0.8983517458922662 1.506583546661241e-06 0.8993273409280406 \
1.50658409447182e-06 0.8993637478389299 1.507076621843715e-06 0.9003542216796759 1.507076717582566e-06 0.9004233209197793 1.507077660131942e-06 0.9014023545001312 \
1.507077822585254e-06 0.9016297223302431 1.5070783892915e-06 0.9025464066367429 1.507078496462212e-06 0.9027401250447874 1.507078889770564e-06 0.9035002370985188 \
1.507079022567928e-06 0.9037710185404622 1.507079402169034e-06 0.9045728679206633 1.50707953238378e-06 0.9048512534150681 1.507079993790073e-06 0.9057878278182891 \
1.507080113037131e-06 0.9060008176934132 1.507081542646166e-06 0.9050557440230738 1.507081626316292e-06 0.9046580283931719 1.507081751622122e-06 0.9039622140338933 \
1.50708185943629e-06 0.9032622438705011 1.507081978430637e-06 0.9023800387125585 1.507082093802854e-06 0.9014106868475621 1.507082183899751e-06 0.900578017289966 \
1.507082295347455e-06 0.8994526603282017 1.507082381426603e-06 0.8985125975436928 1.507082487392251e-06 0.8972736935213672 1.507082587160618e-06 0.8960214106762436 \
1.507082668156228e-06 0.8949470092681954 1.507082777804195e-06 0.8934133399212493 1.507082863391606e-06 0.8921520042367302 1.507082955514215e-06 0.8907345325087322 \
1.507083043733598e-06 0.8893220116766375 1.507083152508351e-06 0.8875100775672261 1.507083235401386e-06 0.8860780350921965 1.507083343975057e-06 0.8841400608632336 \
1.507083436201252e-06 0.8824412727986957 1.50708352082175e-06 0.8808423775446282 1.50708360666218e-06 0.8791839877465467 1.50708368587706e-06 0.8776224824828824 \
1.50708376196503e-06 0.8760960492665846 1.507083854301399e-06 0.874210837196514 1.507083914177735e-06 0.8729702140710593 1.507083971566019e-06 0.8717685933706794 \
1.507084033561192e-06 0.8704574090763495 1.507084096840043e-06 0.8691057216070059 1.507084146911381e-06 0.8680269866686803 1.507084196353534e-06 0.8669542389500936 \
1.50708426002324e-06 0.8655623656543436 1.507084335970659e-06 0.8638877358586781 1.507084384801671e-06 0.8628032002737418 1.507084433325624e-06 0.8617197496806845 \
1.507084509037347e-06 0.8600184098866027 1.507084576246125e-06 0.8584975010852487 1.507084618952631e-06 0.8575263577286506 1.507084662855204e-06 0.8565244243916033 \
1.507084750660351e-06 0.8545103166059256 1.507084813513519e-06 0.8530605771626394 1.507084872183177e-06 0.8517018597088126 1.507084908361778e-06 0.8508614974547222 \
1.507084943180258e-06 0.8500510151036469 1.507084978206243e-06 0.8492340038666518 1.507085048258213e-06 0.8475953578585981 1.507085096728698e-06 0.8464581214772323 \
1.507085140673499e-06 0.8454248116355969 1.507085186191255e-06 0.8443523575543517 1.507085250092166e-06 0.8428433081697474 1.50708531621854e-06 0.8412777165526386 \
1.507085421348608e-06 0.8387809254526315 1.507085509283283e-06 0.8366857089760468 1.507085588228565e-06 0.834800137446173 1.507085676393602e-06 0.8326899670047023 \
1.507085763209599e-06 0.8306078985741704 1.507085851101283e-06 0.8284959280419055 1.507085942350373e-06 0.8262996967350639 1.507086045112241e-06 0.8238226494465998 \
1.507086143615716e-06 0.8214450402687625 1.507086255948632e-06 0.8187302447322098 1.507086368922768e-06 0.8159967029774419 1.507086490210663e-06 0.8130591602364435 \
1.507086620717817e-06 0.8098958628758253 1.507086749763719e-06 0.8067658935936169 1.50708690323932e-06 0.8030416153605923 1.507087068523541e-06 0.799029304640783 \
1.507087236264745e-06 0.7949567682299736 1.507087432788334e-06 0.7901857478752816 1.507087637550659e-06 0.7852160332972318 1.507087850227715e-06 0.7800563994093253 \
1.507088050847662e-06 0.7751902022758907 1.507088251706389e-06 0.7703212856706637 1.507088401728407e-06 0.766686939713112 1.507088532263574e-06 0.7635264252913375 \
1.507088666681014e-06 0.7602735436595947 1.507088772876544e-06 0.7577048602246427 1.507088906182877e-06 0.754482067181252 1.507089013215803e-06 0.7518959494812111 \
1.507089156291704e-06 0.7484409822837247 1.507089320797846e-06 0.7444713482725677 1.507089441615093e-06 0.74155777711076 1.507089612721757e-06 0.7374334100931738 \
1.507089773612309e-06 0.733558046396253 1.50708999020493e-06 0.7283457217000903 1.507090183460631e-06 0.7236999380850822 1.507090362395765e-06 0.7194029726762079 \
1.507090529212387e-06 0.7154015770462002 1.507090715418352e-06 0.7109395231330657 1.507090903351594e-06 0.7064416825495208 1.507091069273699e-06 0.7024749886985119 \
1.507091261631787e-06 0.6978803202016938 1.507091402988682e-06 0.6945068232011449 1.507091559996444e-06 0.6907636199298515 1.507091755976089e-06 0.6860965106368763 \
1.507091918410194e-06 0.6822325558671515 1.507092079586376e-06 0.6784034260021697 1.507092271894574e-06 0.6738409413562468 1.507092489556454e-06 0.6686845685784016 \
1.507092737577756e-06 0.6628199086538362 1.507092915635219e-06 0.6586162961343578 1.507093164179028e-06 0.6527567611811057 1.507093366786271e-06 0.6479896840619462 \
1.507093536596938e-06 0.6440011601507294 1.507093695213124e-06 0.6402799599229552 1.507093833743559e-06 0.637035894415233 1.507093969951322e-06 0.6338503464729111 \
1.507094096262698e-06 0.6309003762865483 1.507094225721933e-06 0.6278810604265532 1.507094354053672e-06 0.6248911458464299 1.507094485383603e-06 0.6218374290191309 \
1.507094617410215e-06 0.6187713222160208 1.507094761570095e-06 0.6154276788919771 1.507094905778687e-06 0.6120888358645944 1.507095053433791e-06 0.6086753592300279 \
1.507095200490149e-06 0.6052842859263143 1.507095358304176e-06 0.6016504852589418 1.507095490909828e-06 0.5986039825107707 1.507095622374795e-06 0.5955897059985247 \
1.507095741804593e-06 0.5928552647156846 1.507095877873286e-06 0.5897484304797134 1.507095992801548e-06 0.5871283594046445 1.507096143912269e-06 0.5836892419704927 \
1.507096258561337e-06 0.5810871834776226 1.507096376499006e-06 0.5784138884735546 1.507096466280294e-06 0.576381560286313 1.507096556599689e-06 0.5743415774978985 \
1.507096623290559e-06 0.5728373329037385 1.507096688852372e-06 0.5713590910263378 1.507096739894496e-06 0.5702089751121119 1.507096801596215e-06 0.5688198806440578 \
1.507096864686071e-06 0.5674025889664359 1.507096929044424e-06 0.5659586381304559 1.507096982438224e-06 0.5647616504486359 1.507097075080806e-06 0.5626864159088959 \
1.507097151688078e-06 0.5609719030357503 1.50709720751314e-06 0.5597256439368602 1.507097276567267e-06 0.5581857825097393 1.507097383455393e-06 0.5558054549196561 \
1.507097461199018e-06 0.5540764009223496 1.507097562049117e-06 0.5518382286767042 1.507097687729972e-06 0.5490568313009737 1.507097787971657e-06 0.5468419758621708 \
1.50709789988934e-06 0.5443739014182352 1.507098003155247e-06 0.5421024366463116 1.507098122904589e-06 0.5394737463112931 1.507098224637469e-06 0.5372436950013484 \
1.507098340157213e-06 0.5347185748314579 1.507098455192299e-06 0.5322102907975605 1.507098581673211e-06 0.529456475824718 1.507098707047009e-06 0.5267350629320526 \
1.507098853862932e-06 0.5235577714138258 1.507098989426381e-06 0.5206304261698983 1.507099147124634e-06 0.5172373565578411 1.507099309443688e-06 0.5137528589513558 \
1.507099490267585e-06 0.5098871206809381 1.507099682715905e-06 0.5057874350093188 1.507099895621209e-06 0.5012700264709963 1.507100127802608e-06 0.4963634062180514 \
1.507100385093187e-06 0.4909555076455908 1.50710062471901e-06 0.4859407514401474 1.507100926434446e-06 0.479662588092526 1.5071012143538e-06 0.4737079198104491 \
1.507101527242619e-06 0.4672821326282255 1.507101846980824e-06 0.4607585360408045 1.507102186575985e-06 0.4538766993710576 1.507102513478483e-06 0.4472977926730654 \
1.507102849036864e-06 0.4405887635920606 1.507103166132787e-06 0.4342949501181722 1.507103500370541e-06 0.4277061431972559 1.507103851801663e-06 0.4208322784122511 \
1.507104166327817e-06 0.4147233751108969 1.507104489505308e-06 0.4084912998479469 1.507104930620066e-06 0.400057814108821 1.507105272736103e-06 0.3935812134363078 \
1.507105572680633e-06 0.3879522399691127 1.507105947811638e-06 0.3809760137481454 1.507106277555878e-06 0.3749002425561211 1.507106560798804e-06 0.3697269896098562 \
1.507106860945059e-06 0.3642865787664632 1.507107140547253e-06 0.3592589179584539 1.507107364323365e-06 0.3552676761685443 1.507107576103695e-06 0.3515151294490645 \
1.507107778537159e-06 0.3479514629380864 1.507107979628427e-06 0.3444362246481504 1.507108185342845e-06 0.3408632458568372 1.507108452965717e-06 0.3362478643926977 \
1.507108691897011e-06 0.3321601360780691 1.507108925403074e-06 0.3281974319442653 1.507109138868474e-06 0.3246000376975314 1.507109360246046e-06 0.3208952602338652 \
1.507109560209693e-06 0.3175728982722026 1.507109764482006e-06 0.3142073831356898 1.507109961828878e-06 0.3109812293225088 1.507110147201405e-06 0.3079732989686547 \
1.507110343307796e-06 0.3048147723336881 1.507110545584936e-06 0.3015820927993307 1.507110721243233e-06 0.2988007390096292 1.50711090711339e-06 0.295878328903569 \
1.507111114092783e-06 0.2926488196724605 1.507111299414374e-06 0.2897857719971084 1.507111494641182e-06 0.2867989994419413 1.507111650415531e-06 0.28443329608414 \
1.507111829172313e-06 0.2817356906084737 1.507112010203233e-06 0.2790344478478936 1.507112160100347e-06 0.2768142575519123 1.507112361143774e-06 0.273859574769726 \
1.507112510258904e-06 0.2716833853889438 1.507112648798334e-06 0.2696726034832688 1.507112800673409e-06 0.2674956304896134 1.507112915147538e-06 0.2658586287383957 \
1.507113046677468e-06 0.2639823142040156 1.507113172435956e-06 0.2622048582339201 1.507113276776362e-06 0.2607341604582348 1.507113389755722e-06 0.2591418073851619 \
1.507113506084246e-06 0.2575033437579446 1.507113649011667e-06 0.2554974228347739 1.507113762273172e-06 0.2539102348881249 1.507113896429905e-06 0.2520298733123076 \
1.50711400690271e-06 0.2504818583075984 1.507114162335285e-06 0.2483006006477398 1.507114303220383e-06 0.2463217957442577 1.507114454612954e-06 0.2441928603691365 \
1.507114609775035e-06 0.2420086586735095 1.507114739184283e-06 0.2401849910837116 1.507114873896376e-06 0.2382868210192302 1.507115011594202e-06 0.2363478190565156 \
1.507115129346217e-06 0.2346905900295477 1.50711528867041e-06 0.2324499447852502 1.507115425932636e-06 0.2305210708572645 1.507115566678993e-06 0.2285488733964877 \
1.507115672470167e-06 0.2270688194984586 1.507115802411564e-06 0.2252532503786337 1.507115902948028e-06 0.2238506847401111 1.507116005281736e-06 0.2224250970611539 \
1.507116079010317e-06 0.2214012665004395 1.50711615824426e-06 0.2203047212273054 1.507116229215507e-06 0.2193236206014474 1.507116280678535e-06 0.218612902325451 \
1.507116333626988e-06 0.2178825126218075 1.507116412781991e-06 0.2167921001391954 1.507116455054626e-06 0.2162104926182252 1.507116494899171e-06 0.2156628374086678 \
1.50711653812282e-06 0.2150692779925967 1.507116579029822e-06 0.2145080585354088 1.507116649152284e-06 0.2135474129702876 1.507116682837256e-06 0.2130867492099046 \
1.507116727666638e-06 0.212477723463 1.5071167865238e-06 0.2116792343136102 1.50711685130926e-06 0.2108017053965978 1.507116908790025e-06 0.2100241135398916 \
1.507116969219033e-06 0.209207737948094 1.507117066255463e-06 0.2078991976528634 1.507117150945123e-06 0.2067595417901527 1.507117259855885e-06 0.2052972881712416 \
1.507117356256692e-06 0.2040065614180294 1.507117451273329e-06 0.2027428333585779 1.507117554705127e-06 0.2013717100485363 1.507117649634473e-06 0.2001158751783069 \
1.507117752654899e-06 0.198757993281026 1.507117857737332e-06 0.1973779917312911 1.507117967046146e-06 0.1959482000350934 1.507118077489628e-06 0.1945091075764383 \
1.507118193779904e-06 0.1929996650696684 1.507118303709896e-06 0.1915811184357085 1.50711841337232e-06 0.1901717999899754 1.507118515088965e-06 0.1888694322720079 \
1.507118608043679e-06 0.1876837490531375 1.507118700772569e-06 0.1865049219968967 1.507118774458125e-06 0.1855719169757668 1.50711885729934e-06 0.1845269810791141 \
1.507118931885337e-06 0.1835895008849975 1.507119001608678e-06 0.1827150226754214 1.507119068327085e-06 0.1818808699270075 1.507119164170411e-06 0.1806871657728035 \
1.507119246877184e-06 0.1796611249561687 1.507119340441007e-06 0.1785035608809835 1.507119435337095e-06 0.1773351434884491 1.507119546707405e-06 0.1759704596301353 \
1.507119688349759e-06 0.1742450478777388 1.507119803596612e-06 0.1728486436789435 1.507119948144251e-06 0.1711076225712051 1.507120059739928e-06 0.1697708811114609 \
1.507120200958902e-06 0.1680898955975501 1.507120316696175e-06 0.1667201145354908 1.507120422656861e-06 0.1654722325850081 1.507120521416477e-06 0.164314417410061 \
1.50712061775965e-06 0.1631901152369615 1.507120706417402e-06 0.1621596955203892 1.507120831751673e-06 0.1607099933926625 1.507120926277088e-06 0.1596224416957933 \
1.50712102401604e-06 0.1585042187118262 1.507121132110917e-06 0.1572745454417887 1.507121226778605e-06 0.1562036643369483 1.507121334226451e-06 0.1549951394274829 \
1.507121425315495e-06 0.1539767092330788 1.507121532087207e-06 0.1527896463435911 1.507121635480473e-06 0.1516469620792683 1.507121746560958e-06 0.1504267727114754 \
1.507121835786939e-06 0.1494522115900035 1.507121921266868e-06 0.1485231035185812 1.507122005192055e-06 0.1476157397758405 1.507122074898619e-06 0.1468658175993407 \
1.507122153536697e-06 0.1460232248551682 1.507122231847954e-06 0.1451880611912267 1.507122302483827e-06 0.1444378248611795 1.507122387974695e-06 0.1435337156153706 \
1.507122475363672e-06 0.1426139614481139 1.507122556951186e-06 0.1417594571206545 1.507122654270137e-06 0.1407454482154784 1.50712273495966e-06 0.139910090776864 \
1.50712282574469e-06 0.1389752404035735 1.507122947088963e-06 0.1377336220260025 1.507123036138604e-06 0.13682812281983 1.507123134655454e-06 0.1358318692385875 \
1.507123221741723e-06 0.1349560640726983 1.507123332152611e-06 0.1338550874529322 1.507123420611433e-06 0.1329791517134813 1.507123521340027e-06 0.1319874611681985 \
1.50712362612958e-06 0.1309622419763913 1.507123720519813e-06 0.1300442429014473 1.507123817024605e-06 0.1291112112475518 1.507123916511258e-06 0.1281591654439075 \
1.507124002912429e-06 0.1273384721630967 1.50712409789256e-06 0.1264411177628728 1.507124202081388e-06 0.1254629331099751 1.507124311200139e-06 0.124445178694 \
1.507124405550594e-06 0.1235704029653004 1.507124517846343e-06 0.1225411084520107 1.507124613309697e-06 0.1216733466577494 1.507124717520587e-06 0.1207311846737792 \
1.507124806865944e-06 0.1199276649878674 1.507124877253217e-06 0.1192980345746366 1.507124952639251e-06 0.1186268760051257 1.507125028771421e-06 0.1179522201461119 \
1.507125097748918e-06 0.1173458504859956 1.507125180268091e-06 0.1166263596898966 1.507125252211578e-06 0.1160015972854393 1.507125334290304e-06 0.1152916772467617 \
1.50712541862478e-06 0.1145654108773922 1.507125496418619e-06 0.113898375935255 1.507125589183521e-06 0.1131065723182637 1.507125704787343e-06 0.1121254933399327 \
1.507125810692911e-06 0.1112341778178403 1.507125888349831e-06 0.1105854195321705 1.507125976646302e-06 0.1098504899494786 1.507126056703354e-06 0.1091866403929743 \
1.507126153629479e-06 0.1083861389179563 1.507126248864964e-06 0.1076031391441806 1.507126337436159e-06 0.1068780200140514 1.50712643874426e-06 0.1060523297458165 \
1.507126544289947e-06 0.1051963702337609 1.507126653484312e-06 0.1043160928234657 1.507126761601933e-06 0.1034503663302994 1.507126881519694e-06 0.1024949450012773 \
1.507126982881521e-06 0.1016914181115986 1.507127088891151e-06 0.100855068690839 1.50712721468278e-06 0.09986840123414902 1.507127344240086e-06 0.09885896724496235 \
1.50712747991544e-06 0.09780904711780367 1.507127655987304e-06 0.09645781830037269 1.507127819787824e-06 0.09521257997344186 1.507127982612565e-06 0.09398642071914091 \
1.5071280677512e-06 0.09334985726464029 1.507128137589223e-06 0.09282999162688726 1.507128207084828e-06 0.09231474740697931 1.507128281043488e-06 0.09176875214326782 \
1.507128377198375e-06 0.09106241641841166 1.507128451613741e-06 0.09051841344162129 1.50712852960331e-06 0.08995079828656057 1.507128606052139e-06 0.08939693755534793 \
1.507128693546224e-06 0.08876614459792892 1.507128795722934e-06 0.08803382885421264 1.507128884287322e-06 0.08740269463919083 1.50712899395281e-06 0.08662585268124241 \
1.507129110009217e-06 0.08580942306245626 1.507129251558034e-06 0.0848216759818637 1.507129384427017e-06 0.08390253510334872 1.507129525187328e-06 0.08293727564630923 \
1.507129674896948e-06 0.08192024575105315 1.507129810608835e-06 0.08100683753927941 1.507129952125717e-06 0.08006309454860433 1.507130087247591e-06 0.07917070961097784 \
1.507130228520028e-06 0.07824718349428782 1.50713037561292e-06 0.07729532867436953 1.507130527122786e-06 0.07632524417621221 1.5071306924985e-06 0.07527819040792309 \
1.50713085625969e-06 0.07425356708383206 1.507131032389632e-06 0.07316505371836476 1.50713122152861e-06 0.07201151367936541 1.507131432202234e-06 0.07074528708793332 \
1.507131651768855e-06 0.06944624562626683 1.507131886535262e-06 0.06808094281860989 1.5071321449277e-06 0.06660616301228137 1.50713243959236e-06 0.06496103773121734 \
1.507132743671683e-06 0.06330286177969326 1.507133104582163e-06 0.06138472526627536 1.507133440499035e-06 0.05964719353945821 1.507133880676406e-06 0.05743991201668189 \
1.507134259043809e-06 0.05560437501227136 1.507134701502772e-06 0.05352996728430704 1.507135055522916e-06 0.05192508193542229 1.507135442039672e-06 0.05022502935509546 \
1.507135786643729e-06 0.04875485597254389 1.507136108618665e-06 0.04741934964807833 1.507136412152492e-06 0.04619304551845941 1.507136707073488e-06 0.04503122626702559 \
1.507136989555767e-06 0.04394770877170886 1.507137266636177e-06 0.04291147062934708 1.507137532363668e-06 0.04194013461971725 1.507137803594355e-06 0.0409708748276704 \
1.507138079853372e-06 0.04000619535229137 1.507138369752594e-06 0.03901828782233653 1.507138598128987e-06 0.03825741181922668 1.507138903013054e-06 0.03726495139513845 \
1.50713911968491e-06 0.03657573971894532 1.507139311041637e-06 0.03597943984071691 1.507139509636156e-06 0.03537298232318693 1.507139839551497e-06 0.03438820140908775 \
1.50714008149717e-06 0.03368375433354889 1.507140396809222e-06 0.03278771666975258 1.507140666929207e-06 0.03203957074185158 1.507140923300881e-06 0.03134567005659093 \
1.507141203312881e-06 0.03060515313352298 1.507141448968657e-06 0.02997014710356035 1.507141681704302e-06 0.02938120249260199 1.507141924434299e-06 0.02878348292867495 \
1.507142161161563e-06 0.02821317433052753 1.507142389807974e-06 0.0276732289298247 1.507142807093635e-06 0.02671456010533928 1.507143002274328e-06 0.02627749693639509 \
1.507143383441411e-06 0.02544369227895442 1.507143560694233e-06 0.02506446942885681 1.507143903145688e-06 0.02434654114125227 1.50714405641412e-06 0.02403127656358269 \
1.507144431432584e-06 0.02327616399748992 1.507144569066725e-06 0.02300530455388665 1.507145053333359e-06 0.02207084195640928 1.50714517295276e-06 0.02184403312078184 \
1.507145589991563e-06 0.02106026682208277 1.507145733393791e-06 0.02079332360769017 1.507146254605172e-06 0.01984598817089831 1.507146382379043e-06 0.0196205814374062 \
1.507146966791417e-06 0.01863359713481367 1.507147139226823e-06 0.01835589372257288 1.507147743323573e-06 0.01743644241612937 1.507147904755214e-06 0.01720262545858322 \
1.507148544701434e-06 0.01631831686205014 1.5071487230176e-06 0.016083210242981 1.507149371001649e-06 0.01526127675881721 1.50714953625524e-06 0.01505930898173208 \
1.507150272557175e-06 0.01419381259610907 1.507150406833225e-06 0.01404154276213586 1.507151203932743e-06 0.01317592498067951 1.507151344530354e-06 0.01302934089458718 \
1.507152309873577e-06 0.0120661300044765 1.507152474212383e-06 0.01190857475316222 1.507153474943512e-06 0.01099048917119646 1.507153612213369e-06 0.01087009009405628 \
1.507154750907886e-06 0.009949273443646761 1.507154865085787e-06 0.009863136028526375 1.507156245730622e-06 0.008889755784408603 1.507156400087833e-06 0.00878832203975914 \
1.507157946582061e-06 0.00781340401000951 1.507158030943764e-06 0.007760176032106158 1.507159716371082e-06 0.006770348169342283 1.507159839899572e-06 0.00670487246831437 \
1.507161889714139e-06 0.005720970231232756 1.507162086114296e-06 0.005634691917282852 1.507164404793654e-06 0.004698942116576918 1.507164865407989e-06 0.004530544077955615 \
1.50716760550353e-06 0.003639937533647344 1.507168123648567e-06 0.00349159181499799 1.507172274289875e-06 0.002502201117031859 1.507172812139882e-06 0.002396807933581942 \
1.50717889437533e-06 0.001421603691354927 1.507179153355741e-06 0.001378272220758726 1.50718447611909e-06 0.0003814093765652445 1.507184589276134e-06 0.0003711807182531981 \
1.50983070639237e-06 -0.0004615907568095335 1.509830868831338e-06 -0.0006852153244161934 1.509831369832807e-06 -0.001554404032531494 1.50983145401537e-06 -0.001725199767551738 \
1.509831855538194e-06 -0.002626792336557519 1.509831944873161e-06 -0.002845673237760077 1.50983223146497e-06 -0.0035898660494722 1.509832359033499e-06 -0.003937855927128601 \
1.509832677745161e-06 -0.004830400105952924 1.509832791946313e-06 -0.00515011308870196 1.509833074346638e-06 -0.005887653497963378 1.509833204572857e-06 -0.006177415671381139 \
1.509834182925754e-06 -0.005220113099403402 1.509834370233287e-06 -0.004004368716724641 1.509834501677689e-06 -0.002901539130564616 1.509834607105242e-06 -0.001869327786897239 \
1.509834692822726e-06 -0.0009323217369615201 1.509834774749213e-06 4.151965372454519e-05 1.509834895786036e-06 0.001618129410352471 1.509834994714683e-06 0.003024565667809575 \
1.509835153111357e-06 0.005482561958548801 1.509835370558587e-06 0.00923691162542661 1.50983555178081e-06 0.0126653356758144 1.509835763874906e-06 0.01697021734206094 \
1.509835926898563e-06 0.02046388365739064 1.509836087520978e-06 0.02403759527126768 1.509836241061221e-06 0.02755862871109176 1.509836389117902e-06 0.031036270750196 \
1.509836538198811e-06 0.03460722192241437 1.509836692728722e-06 0.03837091703902212 1.509836853379538e-06 0.04234026030123839 1.509837018034219e-06 0.04645786783841532 \
1.509837194575117e-06 0.05091770581196236 1.509837373537969e-06 0.05547793877747508 1.509837564281134e-06 0.0603721650098247 1.509837769062163e-06 0.06565647483694508 \
1.509837989534449e-06 0.07137203566208646 1.509838222394174e-06 0.0774299331224613 1.50983847158165e-06 0.08392829098722057 1.509838744423778e-06 0.09105513637423955 \
1.509839041127578e-06 0.09880974921055499 1.509839368453968e-06 0.1073623706929605 1.509839738105355e-06 0.11701033799881 1.509840132977169e-06 0.1273002725707723 \
1.50984059081541e-06 0.1392030195235975 1.50984112262225e-06 0.1529832553757746 1.509841747860046e-06 0.1691182447448397 1.509842433607517e-06 0.1867241161332086 \
1.509843236003391e-06 0.2071957342970069 1.509844134802183e-06 0.2299563735557614 1.509844940415632e-06 0.2501946571168963 1.509845654166966e-06 0.2679877251922811 \
1.509846283728848e-06 0.2835633151515627 1.509846854092298e-06 0.2975737963344939 1.50984738504768e-06 0.3105173405876944 1.509847886835131e-06 0.3226580892822354 \
1.509848366129684e-06 0.3341673054699896 1.509848831685103e-06 0.3452566901045974 1.509849295481511e-06 0.3562094254686541 1.509849751229541e-06 0.3668794056881832 \
1.509850211449675e-06 0.3775613305945491 1.509850749733646e-06 0.3899285626759094 1.509851250584179e-06 0.4013172511919189 1.509851650806863e-06 0.4103337945930838 \
1.509852157667644e-06 0.421642452039157 1.509852643633856e-06 0.4323669409017459 1.509853043148568e-06 0.4410997362599856 1.509853453760627e-06 0.4500002277813482 \
1.50985388268706e-06 0.4592207708982954 1.509854284201442e-06 0.4677760623951868 1.509854591591889e-06 0.4742753916877908 1.509854941833647e-06 0.4816249679276425 \
1.509855295073851e-06 0.4889795533930016 1.50985554824443e-06 0.4942125642332652 1.50985578118832e-06 0.4989990073547648 1.509856022831611e-06 0.5039392821429431 \
1.509856247822229e-06 0.5085102868389438 1.509856439858337e-06 0.5123881070394828 1.509856624670034e-06 0.5161059569497825 1.50985684696035e-06 0.5205538992744256 \
1.509857013671757e-06 0.5238726938135662 1.509857230888352e-06 0.5281726418673847 1.509857433967244e-06 0.5321820613122353 1.509857611378699e-06 0.5356681922482178 \
1.509857799451086e-06 0.5393528234657015 1.509858035483266e-06 0.5439555888699217 1.509858301365289e-06 0.5491186112539347 1.509858523127178e-06 0.5534070305875756 \
1.509858803185033e-06 0.5588091140818973 1.509859046184818e-06 0.5634839438879177 1.509859321538161e-06 0.5687575845994758 1.509859566533502e-06 0.5734440561015828 \
1.50985980682772e-06 0.5780305526007354 1.509860047867023e-06 0.5826153106864888 1.509860305457841e-06 0.5874946531182738 1.509860540824618e-06 0.5919209497705462 \
1.509860772126727e-06 0.5962518282209535 1.509860994653448e-06 0.6003950532231523 1.509861203013056e-06 0.6042587207462122 1.509861440854871e-06 0.6086392006348278 \
1.509861651715085e-06 0.612499186772883 1.509861907322267e-06 0.617151767543529 1.509862106050033e-06 0.620751700070918 1.509862381682677e-06 0.6257066023742009 \
1.509862604438798e-06 0.6296824120643636 1.509862897809922e-06 0.6348814180513288 1.509863130579923e-06 0.6389753720667986 1.509863350781309e-06 0.6428252659334456 \
1.509863552051921e-06 0.6463216644290061 1.509863769340793e-06 0.6500784077528632 1.509863944056704e-06 0.6530842133917786 1.509864130321333e-06 0.6562672470877895 \
1.509864309060386e-06 0.6593113758161715 1.509864471764399e-06 0.6620700940033843 1.50986463703341e-06 0.6648583661366954 1.509864780301224e-06 0.6672607123132118 \
1.509864919531648e-06 0.669583864918244 1.509865059332215e-06 0.6719085596965743 1.509865194107422e-06 0.6741424479378803 1.509865321601663e-06 0.6762463034350935 \
1.509865454555775e-06 0.6784344250006583 1.509865576160125e-06 0.680430207161383 1.509865704573366e-06 0.6825336955632141 1.509865820340421e-06 0.6844241240890321 \
1.509865918381594e-06 0.686020684362688 1.5098660190777e-06 0.687656981754083 1.509866128831462e-06 0.689434454762776 1.509866245599418e-06 0.6913211166705923 \
1.509866336826191e-06 0.6927889453402305 1.509866446031605e-06 0.6945396927028351 1.509866547140326e-06 0.6961566646470493 1.509866642540618e-06 0.6976767415743361 \
1.509866752022642e-06 0.6994136821864276 1.509866886474277e-06 0.7015344809028976 1.509867035493214e-06 0.7038694457768003 1.509867164423232e-06 0.7058755144243859 \
1.509867311083691e-06 0.7081418729260142 1.509867437868072e-06 0.7100885084081828 1.509867562465961e-06 0.7119899232102255 1.509867674319728e-06 0.7136874821928206 \
1.509867787275692e-06 0.7153928249203609 1.509867887829089e-06 0.716903336497302 1.509868025110592e-06 0.7189542886859326 1.509868144979452e-06 0.7207346491296758 \
1.509868264162204e-06 0.7224952472954583 1.509868391164314e-06 0.7243608783177121 1.509868515712665e-06 0.726179956024653 1.509868639383676e-06 0.7279757435764195 \
1.509868765971953e-06 0.7298035010246171 1.509868896541188e-06 0.7316777339938921 1.509869019056222e-06 0.7334262671520465 1.509869155299713e-06 0.7353588786631546 \
1.509869256742486e-06 0.7367901064855561 1.509869362765969e-06 0.7382789144707947 1.509869453297152e-06 0.7395446819117977 1.509869567123378e-06 0.7411267287627761 \
1.50986965478496e-06 0.742338113895605 1.509869760680238e-06 0.7437932991468792 1.509869891033532e-06 0.7455718205320391 1.50987000160114e-06 0.7470699275523445 \
1.509870106271611e-06 0.7484790865773925 1.509870230233143e-06 0.7501360792234356 1.509870378790597e-06 0.752105598322839 1.509870500473193e-06 0.7537054667443914 \
1.509870614584882e-06 0.7551949470168074 1.509870755005484e-06 0.7570132059451244 1.509870896533544e-06 0.7588296197226846 1.509871014322813e-06 0.7603289862386273 \
1.509871142522635e-06 0.7619481626911874 1.509871284590468e-06 0.7637269294216019 1.509871401465576e-06 0.7651780119234867 1.509871547139362e-06 0.7669714049983392 \
1.50987166887781e-06 0.7684572223066155 1.509871787518301e-06 0.7698939375992205 1.509871909984594e-06 0.7713653733660819 1.509872036701685e-06 0.7728756341192486 \
1.509872146603679e-06 0.7741754302862822 1.509872272219022e-06 0.7756497674172792 1.509872378029431e-06 0.7768823528242577 1.509872514199553e-06 0.7784559787239111 \
1.509872638546601e-06 0.7798807766277074 1.509872765971877e-06 0.7813271999647126 1.509872880527956e-06 0.7826155184370988 1.509872987208226e-06 0.7838050786084815 \
1.509873125150823e-06 0.785328674235108 1.509873274600319e-06 0.7869612315653352 1.509873419452536e-06 0.7885256944569791 1.509873538888287e-06 0.7898026796320731 \
1.50987367431316e-06 0.7912364721526877 1.509873795807481e-06 0.7925100718437531 1.509873939166555e-06 0.7939977458315933 1.509874082600237e-06 0.7954699260458764 \
1.509874208411247e-06 0.7967479640295563 1.509874327457928e-06 0.7979459892863545 1.509874439471573e-06 0.7990632136113104 1.509874544263454e-06 0.8000996927221937 \
1.509874639456303e-06 0.8010335634530776 1.509874775866829e-06 0.8023587211299719 1.509874892679005e-06 0.8034813603122919 1.509875012140248e-06 0.8046180202255495 \
1.5098751341806e-06 0.8057672874017472 1.509875257080697e-06 0.8069126780167393 1.509875384200053e-06 0.8080849010520604 1.509875509341915e-06 0.8092265787736463 \
1.509875639893142e-06 0.8104047139317369 1.509875765969389e-06 0.811530109085512 1.509875893966049e-06 0.8126603425876329 1.509875999427297e-06 0.8135823118114501 \
1.509876102696598e-06 0.814477091043954 1.509876195349946e-06 0.8152732203909091 1.509876319044181e-06 0.8163262937528154 1.509876406664096e-06 0.8170655553659417 \
1.509876505330151e-06 0.8178914289762149 1.509876648877154e-06 0.819080619224994 1.509876784463306e-06 0.8201904093102529 1.509876893653288e-06 0.8210742465492874 \
1.509877041102747e-06 0.8222539401850584 1.509877191506449e-06 0.8234410273756358 1.509877316975412e-06 0.8244188977545531 1.509877461141395e-06 0.8255287290252299 \
1.50987758542996e-06 0.8264738611628292 1.509877735900256e-06 0.8276038147969816 1.509877871506614e-06 0.8286089145501508 1.509877996601616e-06 0.8295251220930787 \
1.509878114317453e-06 0.8303776282987162 1.509878260203052e-06 0.8314210189912619 1.509878426696148e-06 0.8325942517713072 1.509878557562851e-06 0.833503494447128 \
1.509878731007462e-06 0.8346911703335461 1.509878899140202e-06 0.8358239212093587 1.50987906899395e-06 0.8369500705213252 1.509879249886955e-06 0.838129582835239 \
1.509879393021216e-06 0.8390486258646698 1.509879507119162e-06 0.8397723391454259 1.509879637246322e-06 0.8405879656882547 1.509879739102179e-06 0.8412191375388212 \
1.509879855947599e-06 0.8419354178465567 1.509879992919396e-06 0.84276453896487 1.509880190759142e-06 0.843942473808897 1.50988038244463e-06 0.8450620046306492 \
1.509880591850993e-06 0.8462610422160779 1.509880773861877e-06 0.8472832413425977 1.509880970977333e-06 0.8483697584184032 1.509881144290447e-06 0.8493077402131245 \
1.509881327325656e-06 0.8502809338042043 1.509881498478783e-06 0.8511747489972419 1.509881673131736e-06 0.8520708361396651 1.509881848382891e-06 0.8529540285731302 \
1.509882024530391e-06 0.8538259128238825 1.509882214836779e-06 0.8547503816925358 1.509882405427748e-06 0.8556583881771193 1.509882605979791e-06 0.8565949481971697 \
1.509882798582588e-06 0.8574764650234362 1.509883009331288e-06 0.8584213553684483 1.509883237362186e-06 0.8594210644592908 1.509883503241952e-06 0.8605573106989262 \
1.509883801820094e-06 0.8617960322792503 1.509884077983729e-06 0.8629075153790151 1.509884362230229e-06 0.8640180616030438 1.509884636414231e-06 0.8650581816846495 \
1.50988490866944e-06 0.8660616517296992 1.509885178858914e-06 0.8670295451208139 1.509885436023238e-06 0.8679256252637404 1.509885708596972e-06 0.8688492356117473 \
1.509885984602435e-06 0.8697577927663542 1.509886254710518e-06 0.8706213441784563 1.509886554568938e-06 0.8715508809746347 1.509886925582816e-06 0.8726599440782473 \
1.509887220515529e-06 0.873510245983525 1.509887474800896e-06 0.8742218447789023 1.509887773044171e-06 0.8750318897722944 1.509888046640929e-06 0.8757523113099853 \
1.509888282767907e-06 0.8763571312809064 1.509888523107205e-06 0.876957042728428 1.509888745440861e-06 0.8774982514557473 1.509888939446794e-06 0.8779599514934209 \
1.509889269165228e-06 0.8787226653583874 1.509889424338019e-06 0.8790722725343518 1.50988974207141e-06 0.8797700114458387 1.50988992093906e-06 0.880152324917399 \
1.509890263400534e-06 0.8808637455080008 1.509890447552368e-06 0.8812353200296749 1.509890922478418e-06 0.8821594045029107 1.509891089871654e-06 0.8824737723885729 \
1.509891555692961e-06 0.8833186808430151 1.509891736520447e-06 0.883635209600208 1.509892230549786e-06 0.8844687288968743 1.509892371887773e-06 0.8846990198924604 \
1.509892978249103e-06 0.8856473543416146 1.509893130320955e-06 0.8858754372639542 1.509893777008948e-06 0.8868048391838264 1.509893905303109e-06 0.8869818633102416 \
1.509894553496582e-06 0.8878410756373726 1.509894683245133e-06 0.8880061989117775 1.509895451498601e-06 0.8889361126992519 1.509895581240625e-06 0.8890847997417872 \
1.509896434697557e-06 0.8900046759307325 1.509896577924673e-06 0.8901495209380393 1.509897564158077e-06 0.8910738355210844 1.509897785636141e-06 0.8912643084423501 \
1.509898928653688e-06 0.8921737958641509 1.509899058631989e-06 0.8922730011388891 1.509900410338988e-06 0.8932565980587214 1.509900560692342e-06 0.8933589605607284 \
1.509902041315768e-06 0.8942730372387374 1.50990228021907e-06 0.8944047337041336 1.509904061344228e-06 0.8952702388217941 1.509904447325594e-06 0.8954343910560414 \
1.509906848871634e-06 0.896309305076933 1.50990732380842e-06 0.8964562995603377 1.509911141970139e-06 0.8973944547681553 1.509911624459336e-06 0.897487269196476 \
1.509919510474849e-06 0.898471373493449 1.50992012663754e-06 0.8985180228791175 1.510015282612379e-06 0.899508178894561 1.510016773214557e-06 0.8995204306067698 \
1.510128061288741e-06 0.9005118233983579 1.510128237625743e-06 0.9005706457326812 1.510131860757067e-06 0.8996048713171836 1.510132041955094e-06 0.8994654179496379 \
1.51013335307657e-06 0.8985275682722235 1.510133534953976e-06 0.8984123497545736 1.51013535794417e-06 0.8974436520388238 1.510135517857424e-06 0.8973766233009967 \
1.510148668688723e-06 0.8983720910457982 1.510148779670276e-06 0.8983905835035384 1.510157601254383e-06 0.8993863063850064 1.510158148023847e-06 0.8994226481040219 \
1.510650719976681e-06 0.9003987622903815 1.510650789769166e-06 0.9004496773542636 1.510651622421929e-06 0.9012853800543292 1.510651748468094e-06 0.9014513953152168 \
1.510652328988957e-06 0.9023435091985418 1.510652469953212e-06 0.9025895326188698 1.510652869091291e-06 0.9033428289365844 1.510653019240832e-06 0.9036449200440446 \
1.510653462322153e-06 0.9045762589490434 1.510653619494256e-06 0.9049121924877023 1.510654065120987e-06 0.9058152254958243 1.510654163577326e-06 0.9059929146639856 \
1.51065558025872e-06 0.9052304871087643 1.510655711415865e-06 0.904616184869324 1.510655880423041e-06 0.9036290332250884 1.510656045714916e-06 0.9024406226812831 \
1.510656151980698e-06 0.9015554774641358 1.510656255417528e-06 0.9006052096506509 1.510656341184247e-06 0.8997486040545581 1.510656430678233e-06 0.8987887485205278 \
1.510656554922632e-06 0.8973492764100613 1.51065667300358e-06 0.8958624931586439 1.510656760219672e-06 0.8946938835082598 1.510656884526716e-06 0.8929289312882503 \
1.510656991510644e-06 0.8913158670103165 1.510657091342348e-06 0.8897378501708729 1.510657217633174e-06 0.8876466417139378 1.510657385821785e-06 0.884705368138502 \
1.510657541521538e-06 0.8818365157686672 1.510657738126367e-06 0.8780362649814708 1.510657921747617e-06 0.8743271923380105 1.51065813325501e-06 0.8698916163736473 \
1.51065831406481e-06 0.8659808238081558 1.510658498645858e-06 0.8618945354625286 1.510658671649854e-06 0.8579913311618118 1.510658857050504e-06 0.8537436868396935 \
1.510659036133651e-06 0.8495884889292737 1.510659219722713e-06 0.8452850234109005 1.510659386484418e-06 0.8413449312544377 1.510659554574996e-06 0.8373487193315756 \
1.510659717684167e-06 0.8334514816705533 1.510659872870403e-06 0.829729402178684 1.510660045969282e-06 0.8255639501984255 1.510660231959738e-06 0.8210763864673301 \
1.510660396580221e-06 0.8170961425007568 1.510660561450132e-06 0.8131038678717658 1.510660736782164e-06 0.8088537582860886 1.510660901208668e-06 0.8048648186953292 \
1.510661069844279e-06 0.8007719922541914 1.510661260647645e-06 0.7961398815555145 1.510661446171818e-06 0.7916360074082958 1.510661655100628e-06 0.7865651471012967 \
1.510661879917618e-06 0.7811107659751856 1.510662069732705e-06 0.77650678233121 1.510662271590188e-06 0.7716133355283564 1.510662415860827e-06 0.76811790639139 \
1.510662557504392e-06 0.7646880872338248 1.510662685202102e-06 0.7615975116975136 1.510662796247943e-06 0.7589113686396982 1.51066292481058e-06 0.7558028559024855 \
1.510663057376087e-06 0.7525995467138866 1.510663170697783e-06 0.7498629233610832 1.510663307032409e-06 0.7465723252212872 1.510663413431661e-06 0.7440058350410135 \
1.510663572650447e-06 0.7401674766516904 1.510663745028142e-06 0.7360137588823189 1.510663907275386e-06 0.7321074183421575 1.510664079624344e-06 0.7279612819449855 \
1.510664239010527e-06 0.7241302920521341 1.510664446815714e-06 0.7191408067115369 1.510664607355379e-06 0.7152908836069264 1.510664799844715e-06 0.7106793324906435 \
1.510664985361064e-06 0.7062404417184839 1.510665155237109e-06 0.7021802791355866 1.510665347106947e-06 0.6975984806629684 1.510665493330962e-06 0.6941099299715526 \
1.510665653617309e-06 0.6902897983225644 1.510665856006145e-06 0.6854719661536142 1.510666037294609e-06 0.681161582477689 1.510666206116036e-06 0.6771536053116509 \
1.510666391961911e-06 0.6727470762459599 1.510666597892751e-06 0.6678715161770782 1.510666765819558e-06 0.6639016226084196 1.510666926081261e-06 0.6601182542089066 \
1.510667164933735e-06 0.65448589698252 1.510667332694849e-06 0.6505369020837752 1.510667513768288e-06 0.6462813620835641 1.510667674923199e-06 0.642499550819208 \
1.51066782119046e-06 0.6390715923276049 1.510667959878569e-06 0.6358268652274862 1.510668089235615e-06 0.6328040340451749 1.51066821862017e-06 0.6297855584526113 \
1.51066834694149e-06 0.6267952385336898 1.510668477143629e-06 0.6237652412672913 1.510668606160074e-06 0.6207683673242944 1.510668744735633e-06 0.6175525629501428 \
1.51066889281122e-06 0.6141227553162802 1.510669079138505e-06 0.60981438109949 1.510669226822204e-06 0.6064079319686639 1.51066946198641e-06 0.600995965122186 \
1.510669654434141e-06 0.5965821560879089 1.510669895003955e-06 0.5910808370261941 1.510670064051326e-06 0.587228367631822 1.51067020171775e-06 0.5840969866928536 \
1.510670329822727e-06 0.581191110277254 1.510670443409422e-06 0.5786182870235701 1.510670534774226e-06 0.5765512826027382 1.510670624196113e-06 0.5745328691003393 \
1.510670691457846e-06 0.573016830490748 1.510670757478049e-06 0.5715297341779608 1.510670809531724e-06 0.5703577032508095 1.510670873770593e-06 0.5689124506700958 \
1.510670935307116e-06 0.5675311492520995 1.51067099958866e-06 0.5660899724818867 1.510671052779755e-06 0.5648985048860162 1.51067114512554e-06 0.5628316153148989 \
1.510671221701441e-06 0.5611191615154557 1.510671277545091e-06 0.5598732849310241 1.5106713468882e-06 0.5583285932816697 1.510671452739476e-06 0.5559733466166974 \
1.51067153043128e-06 0.5542469170533902 1.510671631029868e-06 0.5520159549745236 1.510671759063078e-06 0.5491849411292137 1.51067185856046e-06 0.5469885705929382 \
1.510671971125811e-06 0.544508366501287 1.510672074170131e-06 0.5422442603473754 1.510672194219017e-06 0.5396115972585003 1.510672295833426e-06 0.5373863339265779 \
1.510672411457693e-06 0.5348611538529422 1.510672526573874e-06 0.5323536236546169 1.510672653010918e-06 0.529604142030661 1.510672778525186e-06 0.5268822104345234 \
1.510672925204862e-06 0.5237112381511962 1.51067306087557e-06 0.5207845659358002 1.510673218641409e-06 0.5173942078023266 1.510673381063349e-06 0.5139116507621072 \
1.510673561971818e-06 0.5100482739823553 1.510673754563972e-06 0.5059503908118104 1.510673967555743e-06 0.5014368974673542 1.510674199988459e-06 0.4965308659362653 \
1.510674457509373e-06 0.49112491222925 1.510674697473551e-06 0.4861095397820235 1.510674998677906e-06 0.4798501326413723 1.510675286975534e-06 0.4738957353990632 \
1.510675600061861e-06 0.4674739717793394 1.510675919588141e-06 0.4609631488871989 1.510676259085406e-06 0.4540919149088484 1.510676585275518e-06 0.4475353831519197 \
1.51067692175678e-06 0.4408159131180407 1.510677238467587e-06 0.4345373385230166 1.51067757255266e-06 0.4279587671099637 1.510677924261529e-06 0.4210864038135054 \
1.510678238746378e-06 0.4149846225409808 1.510678562192836e-06 0.4087533091618546 1.510679003120948e-06 0.400331870031168 1.510679344916025e-06 0.3938679283557566 \
1.510679644350069e-06 0.3882534014213259 1.510680018872672e-06 0.3812944595528024 1.51068034825039e-06 0.375233915169682 1.510680631354694e-06 0.3700684563936956 \
1.510680931099705e-06 0.3646408765157301 1.510681210595549e-06 0.3596219010422631 1.510681434267487e-06 0.3556377385586224 1.510681645979194e-06 0.3518907610576284 \
1.510681848481927e-06 0.3483292724130969 1.510682049543475e-06 0.3448190020587957 1.510682255221384e-06 0.3412518188287665 1.51068247359686e-06 0.3374887625241871 \
1.510682717359257e-06 0.3333167726275162 1.510682944115829e-06 0.3294678078423895 1.510683164026801e-06 0.3257615367192951 1.510683382451408e-06 0.3221060038181086 \
1.510683586476418e-06 0.318715141566024 1.510683788334207e-06 0.3153870758963987 1.510683988657595e-06 0.3121102802474151 1.510684175271502e-06 0.309079115007194 \
1.510684372573108e-06 0.3058982938882217 1.510684581156335e-06 0.3025606704206737 1.510684786791057e-06 0.2992974534031506 1.510685011523137e-06 0.2957609785165763 \
1.510685228418979e-06 0.2923771984023277 1.510685436098331e-06 0.2891642611511841 1.510685667149178e-06 0.2856239464683982 1.510685841949429e-06 0.2829684481899911 \
1.510686021147604e-06 0.2802647299798244 1.51068619002212e-06 0.2777348429135014 1.510686418345393e-06 0.274348458173166 1.510686595082661e-06 0.2717528218126659 \
1.510686763365392e-06 0.2693020894036587 1.510686935832162e-06 0.2668230333489093 1.510687069934441e-06 0.264903804409765 1.510687215894446e-06 0.2628277003548514 \
1.510687354589946e-06 0.2608803500812688 1.510687476871551e-06 0.2591684246570544 1.510687610990381e-06 0.2572942758553639 1.510687740091486e-06 0.2554978336754472 \
1.51068785952522e-06 0.2538430842138498 1.51068798636042e-06 0.2520939183506197 1.510688106001441e-06 0.2504447954274527 1.510688255617635e-06 0.2483797066042054 \
1.510688390481146e-06 0.2465170278296022 1.51068852003856e-06 0.2447289494531232 1.510688677103379e-06 0.2425624627506451 1.510688801099014e-06 0.2408491463446025 \
1.510688941247149e-06 0.2389135279283614 1.51068907114005e-06 0.2371200701944942 1.51068919175767e-06 0.2354534357320198 1.510689354230601e-06 0.2332087289724075 \
1.510689500284699e-06 0.2311905595759856 1.510689638605484e-06 0.2292825126447264 1.510689746532702e-06 0.2277949627009887 1.510689877317609e-06 0.225993474229161 \
1.510689975823626e-06 0.22463752857886 1.510690079906972e-06 0.2232056532573264 1.510690152783836e-06 0.2222046546567725 1.510690234937313e-06 0.2210804129356655 \
1.510690302346398e-06 0.2201585377209549 1.51069034905066e-06 0.2195201149856669 1.51069039846802e-06 0.2188449488487562 1.510690489422163e-06 0.2176035744446363 \
1.510690555816576e-06 0.2166983392055156 1.510690602779869e-06 0.2160586379972232 1.510690653091075e-06 0.2153737902794619 1.510690712240425e-06 0.2145693142997165 \
1.510690755086328e-06 0.2139870779821451 1.510690798893629e-06 0.2133941263688522 1.510690868423894e-06 0.2124566309962414 1.510690955340708e-06 0.2112864027023158 \
1.510691036529563e-06 0.2101949018929156 1.510691122429026e-06 0.2090416531541652 1.510691216575207e-06 0.2077796428137634 1.510691308329081e-06 0.2065517647617813 \
1.510691403625517e-06 0.2052788208685862 1.510691500104208e-06 0.2039945431316728 1.51069160092949e-06 0.2026602783061639 1.510691696885502e-06 0.2013924147365721 \
1.510691799571213e-06 0.2000377255165624 1.510691902607566e-06 0.1986831378210229 1.510692012697906e-06 0.1972405340748948 1.510692121449794e-06 0.1958206085628783 \
1.510692241171749e-06 0.1942631948714586 1.510692351614651e-06 0.1928328887741874 1.510692459617459e-06 0.1914411844406488 1.510692584973803e-06 0.1898318066870429 \
1.510692677907979e-06 0.1886434908940876 1.510692756278755e-06 0.1876443873000938 1.510692832918829e-06 0.1866698667869858 1.510692915430143e-06 0.1856249297118943 \
1.510692984939759e-06 0.1847473639743596 1.510693050895387e-06 0.1839166514106665 1.510693115162722e-06 0.1831089953192083 1.510693227146207e-06 0.1817072258029639 \
1.510693321200174e-06 0.1805353135896268 1.510693428841935e-06 0.1791985758407087 1.510693535314993e-06 0.1778827552324552 1.51069365530692e-06 0.1764073736674057 \
1.510693793359546e-06 0.174720142305475 1.5106939095201e-06 0.1733081217455876 1.510694071616903e-06 0.1713503924599185 1.510694186705419e-06 0.1699688234017716 \
1.510694326691019e-06 0.1682987764548305 1.510694443897095e-06 0.1669083002780509 1.510694554816447e-06 0.1655990025649634 1.510694652444933e-06 0.1644521190704843 \
1.510694747295481e-06 0.1633427224865242 1.510694863349894e-06 0.161991523106341 1.510694954898444e-06 0.1609305136382055 1.51069505100742e-06 0.1598214181625073 \
1.510695145225553e-06 0.1587403933520305 1.510695238726156e-06 0.1576732160104884 1.510695332323478e-06 0.1566104070550305 1.510695428005016e-06 0.1555300824433628 \
1.510695518592921e-06 0.1545132165873678 1.510695609606078e-06 0.1534969984004868 1.510695705154556e-06 0.1524358767948732 1.510695795820268e-06 0.1514342506187442 \
1.510695898892631e-06 0.1503020548964867 1.51069597134408e-06 0.1495100717445464 1.510696050444873e-06 0.148649146151682 1.510696124993091e-06 0.1478424742503694 \
1.5106961960245e-06 0.1470770917224498 1.510696268788982e-06 0.1462962409077327 1.510696343406157e-06 0.1454990959398698 1.510696413389118e-06 0.1447543557055888 \
1.510696487550038e-06 0.143968261688537 1.510696541295377e-06 0.1434005634796054 1.510696594578932e-06 0.1428396203849428 1.51069665977469e-06 0.1421555039833398 \
1.510696731080731e-06 0.141411576573238 1.510696795450793e-06 0.1407432786314442 1.510696868802754e-06 0.1399847409254479 1.510696929420321e-06 0.1393607073002494 \
1.510697015453805e-06 0.1384787080092832 1.51069709140482e-06 0.1377037134581418 1.510697181372726e-06 0.1367902106004182 1.510697263099684e-06 0.1359645165492482 \
1.510697345789661e-06 0.1351360437760365 1.510697428345969e-06 0.1343145513298757 1.510697533908125e-06 0.1332698421778018 1.510697615775408e-06 0.1324642397250402 \
1.510697713142868e-06 0.1315110876582503 1.510697803143729e-06 0.130634908321232 1.510697891113988e-06 0.1297829978838479 1.510697974043842e-06 0.1289892226181523 \
1.510698048280934e-06 0.1282822873521282 1.510698147931993e-06 0.1273377645104763 1.510698243687052e-06 0.1264350619688987 1.510698330534456e-06 0.1256206895242312 \
1.510698420535994e-06 0.1247808744623497 1.510698500868674e-06 0.1240346855852102 1.510698587562703e-06 0.1232365419604467 1.510698686393032e-06 0.1223331159004786 \
1.51069877647517e-06 0.1215131568528167 1.510698886718427e-06 0.1205141992263624 1.510698973949866e-06 0.1197275966302077 1.510699042523e-06 0.1191120727131645 \
1.510699127185393e-06 0.1183553887582162 1.510699193692874e-06 0.1177634990399222 1.510699265148799e-06 0.1171309945267847 1.510699334822604e-06 0.1165184920865242 \
1.510699412159692e-06 0.1158409171037389 1.510699507902974e-06 0.1150054407698888 1.510699579157887e-06 0.1143861389207103 1.51069964652742e-06 0.1138025718558601 \
1.510699714964191e-06 0.113211685696446 1.510699790554542e-06 0.1125613765304429 1.510699881296389e-06 0.1117840233035959 1.510699964000116e-06 0.1110788257213999 \
1.510700077599187e-06 0.1101151050704521 1.510700187474899e-06 0.1091895325357105 1.510700279674213e-06 0.1084169374841771 1.510700403623544e-06 0.1073835127717347 \
1.510700491987867e-06 0.1066505015902263 1.510700631446837e-06 0.1055001025916527 1.510700730743538e-06 0.1046863788921388 1.51070082339359e-06 0.1039306459201802 \
1.510700933598102e-06 0.1030359883605075 1.510701018892542e-06 0.1023467905686673 1.510701103793345e-06 0.101663637589173 1.510701186744308e-06 0.1009989740617136 \
1.51070130925421e-06 0.1000225794851696 1.510701431196063e-06 0.09905761200121259 1.510701557818349e-06 0.09806258992746317 1.510701670630472e-06 0.09718220909187772 \
1.510701815205956e-06 0.09606278874246346 1.510701952919884e-06 0.09500564015228773 1.510702069610674e-06 0.09411672853020667 1.510702197354241e-06 0.0931507147971556 \
1.510702297018758e-06 0.09240236948627445 1.510702376452637e-06 0.09180921593916676 1.510702475187935e-06 0.09107599640376031 1.510702553063239e-06 0.09050081472416407 \
1.510702634529155e-06 0.08990210528957472 1.510702709246463e-06 0.0893557072655629 1.510702789776201e-06 0.08876971652456604 1.510702908608526e-06 0.08791061481419053 \
1.510702998269062e-06 0.08726673116015753 1.510703103183109e-06 0.08651800316437093 1.510703234657667e-06 0.08558693768262025 1.510703395765802e-06 0.08445695903909305 \
1.510703535947497e-06 0.08348350561263763 1.510703684450103e-06 0.08246223579158835 1.510703821170292e-06 0.08153124812726546 1.510703961182002e-06 0.08058696725890066 \
1.510704098179202e-06 0.07967195061625794 1.510704236789813e-06 0.07875532825288725 1.5107043812627e-06 0.07780967510081127 1.510704528808937e-06 0.07685421131041187 \
1.510704686312648e-06 0.07584560580436887 1.510704850707884e-06 0.07480523464991846 1.510705018799982e-06 0.07375451744755303 1.510705199799341e-06 0.07263751640721161 \
1.510705398512623e-06 0.07142823309373261 1.510705611921415e-06 0.07014922396308329 1.5107058380853e-06 0.06881630383186611 1.510706078645623e-06 0.06742468841361035 \
1.510706356206535e-06 0.06585179211508728 1.510706653410938e-06 0.06420523370201831 1.510706971711662e-06 0.06248365192299224 1.510707361695962e-06 0.06043183534616462 \
1.510707760522748e-06 0.05839861031494715 1.510708202994687e-06 0.05621846258761681 1.51070858797559e-06 0.05438828987170503 1.510709000022182e-06 0.05249218901100536 \
1.510709351759698e-06 0.05092353490091287 1.51070968726435e-06 0.04946969867921969 1.510709997763245e-06 0.04816021644386199 1.510710291700064e-06 0.04695194805701195 \
1.510710584430997e-06 0.04577883625507727 1.510710859274204e-06 0.04470700909733757 1.510711133117927e-06 0.04366353526031765 1.510711398807687e-06 0.04267398813878486 \
1.510711674116703e-06 0.04167180388267511 1.510711958673621e-06 0.04066026046469497 1.510712254971736e-06 0.03963283340811159 1.510712513847122e-06 0.03875659098599576 \
1.510712741803528e-06 0.03800131046948733 1.510712960528722e-06 0.03729095380188759 1.510713180383449e-06 0.03659437723507575 1.510713521249513e-06 0.03554043311314246 \
1.510713797290394e-06 0.03470953269536187 1.510714090721169e-06 0.03384790442147732 1.510714373289092e-06 0.03303898052111545 1.510714628198529e-06 0.03232625790162248 \
1.510714908882988e-06 0.03155947796597136 1.510715154716382e-06 0.03090318379665042 1.51071538687767e-06 0.03029616297556957 1.510715627215008e-06 0.02968398395812225 \
1.510715862851843e-06 0.02909722707395018 1.510716091063021e-06 0.0285403787496557 1.510716507835749e-06 0.02755138287878544 1.510716702361127e-06 0.02710176794309662 \
1.510717088601532e-06 0.02623051698020805 1.510717267770925e-06 0.0258356865503758 1.510717618998108e-06 0.02507792837274256 1.510717786904157e-06 0.0247229612172224 \
1.510718171166812e-06 0.02392944198669211 1.510718286448541e-06 0.02369675911063252 1.510718728496378e-06 0.02282172072611499 1.510718950311652e-06 0.02239223679446916 \
1.510719473931311e-06 0.02139838041889957 1.51071962929382e-06 0.02110714647916685 1.510720146999887e-06 0.02015295207761772 1.510720272033152e-06 0.01992792118872039 \
1.510720796234659e-06 0.01901759738223179 1.510720932454034e-06 0.01879045572456909 1.51072153873049e-06 0.01783210191617334 1.510721705739623e-06 0.01758082406519646 \
1.510722348947267e-06 0.01666064795441237 1.510722528091535e-06 0.0164167113061686 1.510723218250269e-06 0.01551958953683085 1.510723381870153e-06 0.01531511209162885 \
1.51072414235084e-06 0.01440332854054019 1.510724289392963e-06 0.01423371673427115 1.510725107264621e-06 0.01333087949608782 1.510725226813134e-06 0.01320411419549955 \
1.510726142674656e-06 0.01227329163592313 1.510726284027572e-06 0.01213544173166964 1.510727232503148e-06 0.01124488043697059 1.510727391142586e-06 0.01110230805801717 \
1.51072857354363e-06 0.01011356759191894 1.51072867164402e-06 0.01003725601038859 1.51072993325548e-06 0.009120360285939955 1.51073006766933e-06 0.009028655389366201 \
1.510731608240655e-06 0.008043892937307966 1.510731689273999e-06 0.007992925041580451 1.510733277867931e-06 0.007023242357651564 1.510733410759078e-06 0.006948518507451114 \
1.51073538746242e-06 0.005952856104192286 1.510735569200568e-06 0.005869662958407677 1.510737671554228e-06 0.004980929874643355 1.510738112345997e-06 0.004810448874467742 \
1.510740767560855e-06 0.003892108290451164 1.510741244140394e-06 0.003745909362026665 1.510744882222615e-06 0.00279447349697209 1.510745407746061e-06 0.002678838783887205 \
1.510751013810845e-06 0.001700248310874221 1.510751324898547e-06 0.001653333728976835 1.510756459226246e-06 0.0006858192122199529 1.510756653206019e-06 0.0006440832883579712 \
1.513404576914862e-06 -0.0002037173203380238 1.513404741115283e-06 -0.0003889174928863678 1.513405314458091e-06 -0.001270938904608877 1.513405389392278e-06 -0.001411855863724778 \
1.513405849976055e-06 -0.002393592696522268 1.513405961916807e-06 -0.002660411672198376 1.513406215188795e-06 -0.003300974950034667 1.5134063815721e-06 -0.003745951779090856 \
1.51340667656787e-06 -0.004566571567208835 1.513406788055442e-06 -0.00488071790655901 1.513407067428216e-06 -0.005641221413069743 1.513407188386555e-06 -0.005938820066262044 \
1.513408282339388e-06 -0.005180465225493313 1.513408406471631e-06 -0.004410796826645887 1.513408530879049e-06 -0.003456122327429311 1.513408650435429e-06 -0.002364170815481491 \
1.513408748579805e-06 -0.001341064316055312 1.513408855004127e-06 -0.0001052154991983786 1.513408967239972e-06 0.001336046702817826 1.513409102195821e-06 0.003249882807978809 \
1.513409224782331e-06 0.005149402351921401 1.513409413644246e-06 0.008353592055059769 1.513409554826578e-06 0.01094873860302964 1.513409708187922e-06 0.01393943619118621 \
1.513409851561427e-06 0.01687898420971235 1.513410005752867e-06 0.02017576688295359 1.513410161892825e-06 0.02363796584892512 1.513410317618878e-06 0.02719811802828209 \
1.513410465112557e-06 0.03065407560139007 1.513410613784323e-06 0.03420778369279751 1.513410769114407e-06 0.03798436241030867 1.513410927740287e-06 0.04189786275883118 \
1.513411092673448e-06 0.0460171220807938 1.513411267096336e-06 0.05041857973200652 1.513411446085736e-06 0.05497510627343041 1.513411635385597e-06 0.05982852266675163 \
1.513411838393603e-06 0.06506368941101938 1.513412057870669e-06 0.07075025585284363 1.513412288935331e-06 0.07675903373893865 1.513412535995649e-06 0.08319974270080552 \
1.513412806420637e-06 0.0902619122132732 1.513413099984324e-06 0.09793335781011638 1.513413424033306e-06 0.1064001814721126 1.513413788254856e-06 0.1159066558703892 \
1.513414180806326e-06 0.1261372395632307 1.513414630304251e-06 0.1378252442462487 1.513415153096484e-06 0.1513754922073403 1.513415766694219e-06 0.1672157090591849 \
1.513416444455093e-06 0.184625848284817 1.513417232720212e-06 0.2047487967247964 1.513418115553072e-06 0.22712469896725 1.513418933839029e-06 0.2476994923478653 \
1.513419661268608e-06 0.2658503723959502 1.513420301381636e-06 0.2817009601644404 1.51342087568535e-06 0.2958213763442377 1.513421413251317e-06 0.3089396094373287 \
1.513421917248776e-06 0.3211464104224903 1.51342239337143e-06 0.3325930942309646 1.513422871259445e-06 0.3439912352478621 1.513423324592551e-06 0.3547121966731367 \
1.513423795885259e-06 0.3657614311162562 1.513424238561085e-06 0.3760518588326446 1.513424757059872e-06 0.3879885572071845 1.513425284221992e-06 0.3999987293386327 \
1.513425663131623e-06 0.4085537955782026 1.513426193047166e-06 0.4204060347738258 1.513426622963746e-06 0.429919877745455 1.513427076664521e-06 0.4398653393542544 \
1.513427543378037e-06 0.4500002271552926 1.513427981059267e-06 0.4594210430579985 1.513428389021531e-06 0.468120704286539 1.513428708454565e-06 0.4748816926501604 \
1.513429080589836e-06 0.4826992142337162 1.513429315571978e-06 0.4876010339127531 1.513429549178225e-06 0.4924491904621348 1.513429797190648e-06 0.4975647713404599 \
1.513430095592078e-06 0.5036796627825791 1.51343035194848e-06 0.5088948470128004 1.51343056424179e-06 0.5131878547336713 1.513430758259862e-06 0.5170959594548015 \
1.513430905246394e-06 0.5200432695146362 1.513431059224405e-06 0.523118600542271 1.513431277106154e-06 0.5274469616807909 1.51343153021048e-06 0.5324525256580425 \
1.513431740049324e-06 0.5365797337241586 1.513431951502633e-06 0.5407247601751553 1.513432233709534e-06 0.5462280430697679 1.513432463254817e-06 0.5506821559930507 \
1.513432679151023e-06 0.5548604062613707 1.513432961372541e-06 0.560308769190463 1.513433212680268e-06 0.5651538146135803 1.51343351034116e-06 0.5708625224168123 \
1.513433760568061e-06 0.5756519166658941 1.513434016931556e-06 0.5805516059354519 1.51343425734157e-06 0.585116682128892 1.513434515521386e-06 0.5900038400537884 \
1.513434739113591e-06 0.5942175703762435 1.513434977623163e-06 0.5986919452581434 1.513435185207861e-06 0.6025689278491061 1.513435401730486e-06 0.6065904171332736 \
1.513435651033092e-06 0.6111939272561876 1.513435856106535e-06 0.6149609706257601 1.51343610737886e-06 0.6195555361399968 1.513436310600886e-06 0.6232455818254186 \
1.513436507472791e-06 0.6267987644955494 1.513436700764307e-06 0.630267737067843 1.513436955542762e-06 0.6348113783570861 1.513437185753374e-06 0.638887973644319 \
1.513437403107185e-06 0.6427143472883045 1.513437701512908e-06 0.6479268061885751 1.513437916915757e-06 0.6516657345437264 1.513438118139476e-06 0.6551344108237934 \
1.513438293060983e-06 0.6581323437428509 1.513438458126254e-06 0.6609495238976936 1.513438627594774e-06 0.6638251431769452 1.513438779731612e-06 0.666392827642013 \
1.513438917642298e-06 0.6687037209181631 1.513439066478412e-06 0.6711867545200138 1.513439194593014e-06 0.6733159837320549 1.513439337815827e-06 0.6756849429836936 \
1.513439459090078e-06 0.6776819274526149 1.513439596688762e-06 0.6799401191146522 1.513439716069216e-06 0.6818929034138137 1.513439863176962e-06 0.6842914131385206 \
1.513439980378628e-06 0.6861933934268433 1.513440073884205e-06 0.6877071857403232 1.513440164873897e-06 0.6891752279197846 1.513440267615961e-06 0.6908280855439021 \
1.513440369133525e-06 0.6924555900607121 1.513440487516631e-06 0.6943444167618776 1.513440599637217e-06 0.6961264383846065 1.513440717192718e-06 0.6979868779962457 \
1.513440902343005e-06 0.7008959348649784 1.513441033535213e-06 0.7029413755586562 1.513441169703753e-06 0.7050491462541959 1.513441291222456e-06 0.7069171228306749 \
1.513441431145468e-06 0.7090538254196674 1.513441535088117e-06 0.7106315721465845 1.513441646249101e-06 0.712309798010818 1.513441750508965e-06 0.7138759052437967 \
1.513441880147056e-06 0.7158124745844324 1.513441977077769e-06 0.7172526339884565 1.513442116000004e-06 0.7193052800722975 1.513442235549293e-06 0.7210612846995991 \
1.513442355121865e-06 0.7228080613301419 1.513442480897243e-06 0.7246353354365959 1.513442607615586e-06 0.7264656873164689 1.513442729655437e-06 0.728218443613998 \
1.51344285780388e-06 0.7300486655261287 1.513442987872205e-06 0.7318956587421809 1.513443108863227e-06 0.7336041830685722 1.513443249633811e-06 0.7355801168346318 \
1.51344335060338e-06 0.7369898206659778 1.513443452204237e-06 0.7384020079314992 1.513443548224548e-06 0.7397310783624924 1.513443659137403e-06 0.7412570822736337 \
1.51344374678503e-06 0.7424563811251772 1.513443846639401e-06 0.7438154404043728 1.513443981404538e-06 0.7456370856934184 1.513444097699018e-06 0.747198032089633 \
1.513444201190815e-06 0.7485782798032956 1.513444325446263e-06 0.7502239458264747 1.513444470359203e-06 0.7521280942578691 1.513444588339771e-06 0.753666143975803 \
1.513444707270879e-06 0.7552056331692281 1.513444846850418e-06 0.7569980918234445 1.513444991202808e-06 0.7588357421297242 1.513445109263616e-06 0.7603265096672839 \
1.513445234085335e-06 0.7618908200857619 1.513445373916531e-06 0.7636286950759973 1.513445498679428e-06 0.7651662633748356 1.513445642192899e-06 0.7669199865864609 \
1.513445762878377e-06 0.7683824344671055 1.513445883722124e-06 0.7698356273746885 1.513446003367048e-06 0.7712633747646481 1.513446133074687e-06 0.7727989859455529 \
1.51344624181849e-06 0.7740766298596218 1.513446364466226e-06 0.7755070372682662 1.513446474242911e-06 0.7767778749889983 1.513446603267025e-06 0.7782599816788072 \
1.513446735043344e-06 0.7797610257751375 1.51344684835592e-06 0.7810403609326458 1.513446969441862e-06 0.7823954393038701 1.513447073314495e-06 0.7835479431998941 \
1.513447215597517e-06 0.785111775748914 1.513447363800666e-06 0.7867227488076519 1.513447522694201e-06 0.7884297907063792 1.513447642887223e-06 0.7897074707829422 \
1.51344779245393e-06 0.7912811323018302 1.513447916569147e-06 0.7925734175081853 1.513448042273444e-06 0.7938699048627912 1.513448145219011e-06 0.7949224966762399 \
1.513448259590165e-06 0.7960823495211882 1.513448372064409e-06 0.7972131756542409 1.513448462336983e-06 0.7981137961420948 1.513448551677879e-06 0.7989989930139054 \
1.513448676903817e-06 0.800229513878344 1.51344878467518e-06 0.8012785338618679 1.513448914342978e-06 0.8025281307685926 1.513449035722257e-06 0.8036855380110038 \
1.513449152278057e-06 0.8047859282369955 1.513449273083453e-06 0.80591497746663 1.513449405708758e-06 0.8071413435168892 1.513449527502378e-06 0.8082555056211007 \
1.513449654106103e-06 0.8094015704683005 1.513449779719621e-06 0.8105266036187198 1.513449899211046e-06 0.8115857443778658 1.513450037409299e-06 0.8127973981963581 \
1.513450146908547e-06 0.8137473213416323 1.513450231056662e-06 0.8144713378799666 1.51345035186072e-06 0.8155017394983226 1.513450447369557e-06 0.8163089346032877 \
1.51345058366036e-06 0.8174496006492775 1.513450726424414e-06 0.8186303638797883 1.513450860857535e-06 0.8197292014569521 1.513450970729519e-06 0.8206175763825388 \
1.513451114629137e-06 0.8217677661037901 1.51345126795672e-06 0.8229768690765377 1.513451395805574e-06 0.8239722812379519 1.513451536202905e-06 0.8250521595273246 \
1.513451662107844e-06 0.8260088941474263 1.51345181672401e-06 0.8271688948348412 1.51345194907934e-06 0.8281489842609937 1.513452075346168e-06 0.8290730392392056 \
1.513452193006695e-06 0.8299245984162376 1.513452341409092e-06 0.8309852945996649 1.51345250860326e-06 0.8321626230293395 1.513452641380572e-06 0.8330844501529713 \
1.513452814281769e-06 0.8342675727345584 1.513452982699063e-06 0.8354015168591284 1.513453152193536e-06 0.8365246342267009 1.513453333630418e-06 0.8377070668209077 \
1.513453476186559e-06 0.8386219603417975 1.51345359009745e-06 0.8393441765511721 1.513453720973658e-06 0.8401643924869071 1.513453822596633e-06 0.8407940582489307 \
1.513453939036871e-06 0.8415078269750864 1.513454074330057e-06 0.8423269142909066 1.513454271595159e-06 0.8435017451489455 1.513454462114483e-06 0.844614933042255 \
1.513454672039296e-06 0.8458175693076773 1.513454852817827e-06 0.8468334846981137 1.513455050185846e-06 0.8479221976595614 1.51345522404434e-06 0.8488638701886076 \
1.513455406558583e-06 0.8498353939890455 1.513455577902693e-06 0.8507314120859523 1.513455752248258e-06 0.8516272398309612 1.513455927651258e-06 0.8525125793730954 \
1.513456103896448e-06 0.8533864315694911 1.513456293665326e-06 0.8543099749208749 1.513456484423344e-06 0.8552205033559714 1.51345668621255e-06 0.8561646193034282 \
1.513456878916116e-06 0.8570482883232282 1.513457088356793e-06 0.8579892478796384 1.513457318098559e-06 0.8589986827500428 1.513457583567511e-06 0.8601360945383778 \
1.513457882213856e-06 0.8613786760148464 1.513458160601222e-06 0.8625023989005415 1.513458444791177e-06 0.8636161469557806 1.513458719285784e-06 0.8646608622318305 \
1.513458991377281e-06 0.8656672252055042 1.513459261593727e-06 0.8666387059277968 1.513459518761915e-06 0.8675381145236246 1.513459791320979e-06 0.8684653318325959 \
1.51346006734232e-06 0.8693777905953765 1.513460337484171e-06 0.8702455402709716 1.513460637231955e-06 0.8711796653984102 1.513461008105812e-06 0.872294745819888 \
1.513461303028797e-06 0.8731503023941 1.513461557284845e-06 0.8738665406311316 1.513461855515577e-06 0.8746822274488602 1.513462129133901e-06 0.8754080260278182 \
1.513462365269549e-06 0.8760175227551726 1.513462605621406e-06 0.876622281264788 1.513462827963785e-06 0.8771680781109068 1.513463021968128e-06 0.8776338860468618 \
1.513463351691207e-06 0.8784037109613512 1.51346350686397e-06 0.8787567114621292 1.513463824616497e-06 0.879461652496718 1.513464003481858e-06 0.8798480920375044 \
1.513464345943324e-06 0.8805675499479563 1.513464530084847e-06 0.8809434933546246 1.513465004990284e-06 0.8818790560183651 1.513465172384703e-06 0.8821975058309585 \
1.513465638216128e-06 0.8830540251881659 1.513465819040967e-06 0.8833751042472839 1.513466313074347e-06 0.8842212008576973 1.513466454417056e-06 0.884455124402366 \
1.513467060806836e-06 0.8854193259359495 1.513467212878983e-06 0.8856514227360587 1.51346785955747e-06 0.8865980751852495 1.513467987853824e-06 0.8867785329419297 \
1.513468635979926e-06 0.8876550049536978 1.513468765772447e-06 0.8878236738033012 1.513469544034095e-06 0.8887860366092379 1.513469659025973e-06 0.8889208282599539 \
1.513470514758392e-06 0.8898661633196656 1.513470660021537e-06 0.8900169066926564 1.513471645777722e-06 0.8909664261264102 1.513471866882863e-06 0.8911622482549515 \
1.513473011997307e-06 0.8921020388386462 1.513473143207264e-06 0.8922053928944147 1.513474330865799e-06 0.8931033243919096 1.513474484486091e-06 0.8932130731307282 \
1.513475894522803e-06 0.8941348173026452 1.513476117329622e-06 0.8942660193790342 1.51347779802033e-06 0.8951452796684343 1.513478125641509e-06 0.8952966652167414 \
1.513480355582631e-06 0.8961896554712738 1.513480908496592e-06 0.8963788593752812 1.513484476711123e-06 0.8973573335043913 1.513484800223538e-06 0.8974284307984646 \
1.513491156631826e-06 0.8984120886469452 1.513491705534673e-06 0.8984686671268907 1.513544207609024e-06 0.8994658645395698 1.513544850637886e-06 0.8994692460188505 \
1.51373698930852e-06 0.9004073346715066 1.513737190722491e-06 0.9004708280105613 1.513741150500432e-06 0.8995366825576255 1.51374133452723e-06 0.8993953949813248 \
1.513742651124504e-06 0.8984641879157507 1.513742823168359e-06 0.8983566564859006 1.513744719544654e-06 0.8973720929359315 1.513744893250842e-06 0.897304621671452 \
1.513757467177875e-06 0.8982933655523699 1.513757552368112e-06 0.8983081509245614 1.513765819241151e-06 0.8993078551592517 1.513766293960572e-06 0.8993433667976791 \
1.514259794870012e-06 0.9002974142054325 1.514259914349736e-06 0.9003767372269074 1.514260807172786e-06 0.9012336455299185 1.514260953429423e-06 0.901423267690772 \
1.514261548322101e-06 0.9023325668564308 1.514261683292918e-06 0.9025673929107925 1.514262187968707e-06 0.9035294259428087 1.514262320579608e-06 0.9038000271808221 \
1.514262721206973e-06 0.9046475051114249 1.514262865572371e-06 0.9049556543240072 1.51426328869358e-06 0.9058123566484279 1.514263384150638e-06 0.9059850892484415 \
1.514264808709455e-06 0.9052205906349737 1.514264933747309e-06 0.9046352442223391 1.514265060157898e-06 0.9039223775493039 1.514265162806642e-06 0.9032486771507763 \
1.514265290021932e-06 0.9022944222362175 1.514265408867758e-06 0.9012801950564071 1.514265506520237e-06 0.9003603330664713 1.514265588522258e-06 0.8995243596151602 \
1.514265668185821e-06 0.8986589236008835 1.514265778963989e-06 0.8973708307079206 1.514265880140003e-06 0.8961049472956977 1.514265963084475e-06 0.8950067229086057 \
1.514266071529892e-06 0.8934921260891034 1.51426617999385e-06 0.8918872687155874 1.514266275049989e-06 0.8904106867557802 1.514266395922641e-06 0.8884444419111864 \
1.514266516699262e-06 0.8863849482818795 1.514266629744433e-06 0.8843763393508186 1.514266732915182e-06 0.8824794505619851 1.514266818515338e-06 0.8808620855018965 \
1.514266892989399e-06 0.8794251273161163 1.514266987312942e-06 0.8775673968166831 1.514267075773858e-06 0.8757888800524039 1.51426715484687e-06 0.8741711975775893 \
1.514267248834225e-06 0.872216793437976 1.514267330179529e-06 0.8704993514258973 1.514267425093555e-06 0.8684673705816817 1.514267518136275e-06 0.8664480751909672 \
1.514267614922069e-06 0.8643215060814092 1.514267738217441e-06 0.8615778533848952 1.514267851664452e-06 0.859022019682563 1.514267977516491e-06 0.8561558571929792 \
1.514268100844635e-06 0.8533196845306243 1.514268230022926e-06 0.850323637950593 1.514268370619783e-06 0.8470370034914 1.514268479399505e-06 0.8444782910716596 \
1.514268614459257e-06 0.8412850455921466 1.514268724119566e-06 0.8386804253780991 1.514268853299345e-06 0.8356002443501571 1.514268979483175e-06 0.8325812421138936 \
1.51426910657353e-06 0.8295317031556502 1.514269235595804e-06 0.826427745883674 1.514269344676045e-06 0.8237985689995477 1.514269484526701e-06 0.8204223029647078 \
1.514269623954893e-06 0.8170507778356514 1.514269756708524e-06 0.8138366863616762 1.514269886777199e-06 0.8106848159989707 1.514270010472646e-06 0.8076853837479523 \
1.514270147427036e-06 0.8043627031572629 1.514270261138882e-06 0.8016030849198694 1.514270388615923e-06 0.7985086235398901 1.514270499416994e-06 0.7958187897651571 \
1.514270618603452e-06 0.7929254985494992 1.514270731982509e-06 0.7901733724735396 1.514270866292901e-06 0.7869138859547327 1.514270973387169e-06 0.7843152933129034 \
1.514271089404312e-06 0.7815009627552112 1.514271218595275e-06 0.778367508739124 1.51427131620771e-06 0.7760002683782802 1.514271421787151e-06 0.773440790716327 \
1.51427153046932e-06 0.7708069008430674 1.514271632885583e-06 0.7683258101021144 1.514271726279241e-06 0.7660641808432364 1.514271845835017e-06 0.7631702213567544 \
1.514271938307379e-06 0.7609327305817616 1.514272030945494e-06 0.7586922094322426 1.51427212937031e-06 0.7563124992069843 1.514272237347962e-06 0.7537030947613649 \
1.514272333616474e-06 0.7513778334636231 1.514272419872877e-06 0.7492952979736797 1.514272522736666e-06 0.7468128004450286 1.514272601580994e-06 0.744910856519283 \
1.514272702387036e-06 0.7424801602439853 1.514272836915276e-06 0.7392377693660663 1.514272974140136e-06 0.7359316755186537 1.514273117619987e-06 0.7324773442723981 \
1.514273266044177e-06 0.7289066083419234 1.514273409305472e-06 0.7254625447335662 1.514273549382451e-06 0.7220977259655398 1.514273705808317e-06 0.7183435968963056 \
1.514273830210067e-06 0.715360858370426 1.514273951271848e-06 0.7124600029613375 1.51427410478411e-06 0.7087850045121084 1.514274239566055e-06 0.7055614325718365 \
1.514274365665088e-06 0.7025479112911024 1.514274508839371e-06 0.6991289103945657 1.514274628921163e-06 0.6962626602560111 1.514274758155491e-06 0.6931807499479741 \
1.514274864640539e-06 0.6906432840523983 1.514274976916361e-06 0.6879696524977363 1.514275073251648e-06 0.6856773754336868 1.51427517606134e-06 0.683232326200841 \
1.514275270865193e-06 0.6809792012818872 1.514275376187123e-06 0.6784784437814733 1.514275484625777e-06 0.6759058899658261 1.514275583635058e-06 0.673558569590366 \
1.51427570039165e-06 0.6707929011939652 1.514275808476928e-06 0.6682347329991606 1.514275918483137e-06 0.6656332609774134 1.514276004570979e-06 0.6635992664604092 \
1.514276134166118e-06 0.6605400273835189 1.514276226767366e-06 0.6583552307294462 1.514276322555092e-06 0.6560965362104854 1.514276407507078e-06 0.6540950852804182 \
1.514276526801602e-06 0.6512869789851043 1.51427661407154e-06 0.6492343850333612 1.514276704778561e-06 0.6471030993779646 1.514276805943536e-06 0.6447280068361273 \
1.514276885774359e-06 0.6428551652550211 1.514276974560194e-06 0.6407732405330839 1.51427705225042e-06 0.6389536101386547 1.514277114019368e-06 0.6375081226244841 \
1.514277177784013e-06 0.6360167668935747 1.514277241018233e-06 0.634538653569437 1.514277280258806e-06 0.6336218002627473 1.514277320897828e-06 0.6326726453797233 \
1.514277400982362e-06 0.6308039353694699 1.514277470886542e-06 0.6291742390428672 1.514277521523257e-06 0.6279942052995945 1.514277560272899e-06 0.6270914175114127 \
1.514277599267879e-06 0.6261832343283663 1.514277643882627e-06 0.6251445623164014 1.514277686739083e-06 0.6241478292286105 1.514277737053687e-06 0.6229782634938205 \
1.514277788990864e-06 0.6217719122409077 1.514277874058449e-06 0.6197972300178722 1.514277934038866e-06 0.6184052992407258 1.514278023826075e-06 0.61632338076978 \
1.514278100290156e-06 0.6145529519516876 1.514278179854447e-06 0.6127119801362371 1.514278260891059e-06 0.6108383709630588 1.514278350105382e-06 0.6087775861620425 \
1.514278440965394e-06 0.6066826282541496 1.514278528184102e-06 0.6046739453334793 1.514278621957293e-06 0.6025158549334848 1.514278723642756e-06 0.6001788642681311 \
1.514278823240849e-06 0.5978941858483342 1.514278935095889e-06 0.5953317151711254 1.514279051129026e-06 0.5926772450523136 1.514279172750132e-06 0.5899020947998995 \
1.514279277133946e-06 0.5875236635596754 1.514279421924166e-06 0.5842296531729801 1.514279534584127e-06 0.5816734289694181 1.514279643596094e-06 0.5792035939892568 \
1.514279736075537e-06 0.5771100174076607 1.514279829526176e-06 0.5749994714793375 1.51427992185204e-06 0.5729181236728181 1.514279994438741e-06 0.571283073141143 \
1.514280050392967e-06 0.5700232888304386 1.514280111461248e-06 0.5686498830286455 1.514280209950764e-06 0.5664400707212188 1.514280273162208e-06 0.5650238531380825 \
1.514280333588177e-06 0.5636708824310654 1.51428041053656e-06 0.5619492451093103 1.514280473695101e-06 0.5605380106414651 1.51428056200871e-06 0.558569506627369 \
1.514280633210033e-06 0.5569845302974165 1.514280719745787e-06 0.555060151797141 1.51428084109856e-06 0.5523665438352664 1.514280969027808e-06 0.5495364947125975 \
1.514281067158439e-06 0.5473694328713704 1.514281180282435e-06 0.5448752016832871 1.514281282350254e-06 0.5426314425864434 1.514281401299124e-06 0.5400217272291628 \
1.514281504386832e-06 0.5377630705755105 1.514281618593986e-06 0.5352670017334624 1.514281732009658e-06 0.532794946211756 1.514281859080713e-06 0.5300302694710822 \
1.514281982900802e-06 0.5273426867079006 1.514282127689607e-06 0.5242103332418484 1.51428226351311e-06 0.5212782585303676 1.514282418567968e-06 0.5179428401013338 \
1.514282579419853e-06 0.5144913885072363 1.514282758149301e-06 0.5106699876709851 1.51428294832834e-06 0.5066200804011861 1.514283158230362e-06 0.5021665212646098 \
1.514283386936347e-06 0.4973332357952056 1.514283640864285e-06 0.4919960258408594 1.514283881797751e-06 0.4869529241725989 1.514284177960236e-06 0.4807889695952298 \
1.514284467957623e-06 0.4747910561470179 1.514284774200956e-06 0.4684976697011882 1.514285094876887e-06 0.4619520863481486 1.514285422744054e-06 0.4553041925245184 \
1.514285762989109e-06 0.4484521981997251 1.514286088414654e-06 0.4419418052309769 1.514286410321802e-06 0.4355465312739703 1.514286740535907e-06 0.4290298934287748 \
1.514287096528499e-06 0.4220583188787752 1.514287415406928e-06 0.4158579595363656 1.514287752858691e-06 0.4093433989943853 1.514288180725407e-06 0.4011531841887147 \
1.514288529437356e-06 0.3945419525178304 1.514288837073319e-06 0.388759214407489 1.514289216899811e-06 0.3816861832573664 1.514289548089372e-06 0.3755780492082042 \
1.514289831697452e-06 0.370391509977049 1.514290142516397e-06 0.3647512908748707 1.514290421833005e-06 0.3597258263082204 1.514290648329153e-06 0.3556836811642302 \
1.514290864011538e-06 0.3518598964090484 1.514291061295543e-06 0.3483842179544538 1.514291266280002e-06 0.3447988491770444 1.514291478501966e-06 0.3411119200457455 \
1.514291733807154e-06 0.33670771290924 1.514291975329403e-06 0.3325734463267218 1.514292206706731e-06 0.3286464933807047 1.514292421559231e-06 0.3250253651850565 \
1.514292642118388e-06 0.3213332986541765 1.514292843544355e-06 0.3179852906236645 1.514293046612606e-06 0.3146379646143546 1.514293244508216e-06 0.3114011111455273 \
1.514293431469302e-06 0.3083651674074345 1.514293625269522e-06 0.3052406640298299 1.514293829186134e-06 0.3019773030815858 1.514294008255468e-06 0.2991336297844484 \
1.514294243846324e-06 0.2954229173226265 1.514294444650423e-06 0.2922868215109002 1.514294645829315e-06 0.2891696385850206 1.514294869639057e-06 0.2857334090862961 \
1.514295034201803e-06 0.2832271910241367 1.514295211129189e-06 0.2805503385691353 1.514295396922194e-06 0.2777610713150803 1.51429557873767e-06 0.2750538970423583 \
1.514295757762463e-06 0.2724132377985424 1.514295925107616e-06 0.2699606650006489 1.514296085536534e-06 0.2676371805838822 1.514296208110285e-06 0.2658719571410424 \
1.514296357874814e-06 0.2637236906090554 1.51429648557194e-06 0.2619099339733745 1.514296592880312e-06 0.2603957336038235 1.514296708880974e-06 0.2587625259947361 \
1.51429681918957e-06 0.2572125806747212 1.514296945068767e-06 0.2554509781935611 1.514297060550618e-06 0.2538402638894013 1.514297195131521e-06 0.2519757335310172 \
1.514297307194775e-06 0.2504255755821768 1.514297457534135e-06 0.2483447107137444 1.514297597159989e-06 0.2464124269747185 1.51429774305181e-06 0.2444035064209518 \
1.514297876012448e-06 0.2425734862730615 1.514297999574161e-06 0.2408709992523319 1.514298146783853e-06 0.2388417729476062 1.514298263370682e-06 0.2372355665500016 \
1.514298402825831e-06 0.23532008003217 1.514298537000301e-06 0.2334768281602104 1.514298662976757e-06 0.2317465561243653 1.51429878237616e-06 0.2301094434087779 \
1.514298877230585e-06 0.2288105340759602 1.514298990368184e-06 0.2272617792622066 1.514299070684642e-06 0.2261626001158484 1.514299158249699e-06 0.2249657246820506 \
1.514299283786835e-06 0.2232507767215072 1.514299389480543e-06 0.2218101326756785 1.514299479135054e-06 0.2205921574607158 1.514299549986253e-06 0.2196300825522397 \
1.514299593014783e-06 0.2190460135436258 1.514299635305326e-06 0.2184724035808872 1.514299677647042e-06 0.2178984240735344 1.514299749842462e-06 0.2169203674089526 \
1.514299792235817e-06 0.2163464205126744 1.514299827490656e-06 0.2158693585303403 1.514299871682239e-06 0.2152716287340076 1.514299941290466e-06 0.2143309212991285 \
1.514299975633796e-06 0.2138672544767182 1.514300020093325e-06 0.2132698436071631 1.514300087771806e-06 0.2123628126304402 1.514300174199065e-06 0.2112058698236149 \
1.514300248835667e-06 0.2102078598594563 1.514300330137675e-06 0.2091219706754807 1.514300427015059e-06 0.2078300362310651 1.514300552998548e-06 0.2061528795789772 \
1.514300655533384e-06 0.2047906894256944 1.514300757016901e-06 0.2034500128132261 1.514300858082597e-06 0.202119416354989 1.514300954696816e-06 0.2008491615811921 \
1.51430105666124e-06 0.1995112314821507 1.514301163383484e-06 0.1981153840927639 1.514301271788624e-06 0.1967018790395962 1.514301383782779e-06 0.1952465002768531 \
1.514301496249907e-06 0.1937897263683151 1.514301608323246e-06 0.1923454332378671 1.514301716215721e-06 0.1909603537828802 1.514301817598649e-06 0.1896629368444172 \
1.514301909236098e-06 0.1884941330679491 1.514302003211707e-06 0.1872990757663449 1.514302074478072e-06 0.1863957871745983 1.51430215115336e-06 0.1854271890400033 \
1.514302254812475e-06 0.184122202819407 1.514302328479595e-06 0.1831974022686171 1.514302401825496e-06 0.1822796569444652 1.514302515215845e-06 0.1808667181969195 \
1.514302603074485e-06 0.1797760932362061 1.514302686923162e-06 0.1787387947787487 1.51430281588559e-06 0.1771515524267008 1.514302917772084e-06 0.1759040172436072 \
1.514303023472791e-06 0.1746156056808686 1.514303125120866e-06 0.1733818993219825 1.514303255982584e-06 0.1718019019596718 1.514303363179221e-06 0.1705140034701537 \
1.514303492508118e-06 0.168969083715685 1.51430360420461e-06 0.167642098072289 1.514303704535189e-06 0.1664555496840579 1.514303800335743e-06 0.1653276075899142 \
1.514303911148015e-06 0.1640289617085985 1.514303998548296e-06 0.1630090521997956 1.514304109869413e-06 0.1617156184952586 1.514304202821272e-06 0.1606409001560029 \
1.51430429039415e-06 0.1596330843918451 1.514304392025023e-06 0.1584700928658864 1.514304476479078e-06 0.1575086241734052 1.514304551583457e-06 0.1566573095634876 \
1.5143046294057e-06 0.1557789554714152 1.514304709763569e-06 0.1548759612316424 1.514304810818399e-06 0.1537464547857493 1.514304893251963e-06 0.1528311848879565 \
1.514304985556514e-06 0.1518114053368895 1.514305062490987e-06 0.150965812476358 1.514305145413557e-06 0.1500585909391909 1.514305216944298e-06 0.1492793026301012 \
1.514305313327797e-06 0.1482344968214558 1.514305383556283e-06 0.1474766665551334 1.514305466536561e-06 0.1465853655470201 1.514305527978825e-06 0.1459298106834085 \
1.514305599661209e-06 0.1451677491870439 1.514305668289752e-06 0.1444408762699853 1.514305718558261e-06 0.1439102090153988 1.514305766138067e-06 0.143409423336876 \
1.514305820187418e-06 0.1428423132663369 1.514305879529516e-06 0.1422216078256897 1.514305947564923e-06 0.1415124633834424 1.514306023828345e-06 0.1407207186008814 \
1.514306092108145e-06 0.1400161356079559 1.514306186894323e-06 0.1390460813732662 1.514306276448135e-06 0.1381341561933974 1.514306348133609e-06 0.1374075731330657 \
1.514306432085018e-06 0.1365606113096345 1.514306497397473e-06 0.1359045398875483 1.514306558840598e-06 0.1352895588344758 1.514306633117097e-06 0.1345490408254265 \
1.514306695327357e-06 0.1339328028964004 1.514306763298366e-06 0.133265236037424 1.514306822505406e-06 0.1326856657519672 1.514306895177878e-06 0.1319767402814105 \
1.514306970197988e-06 0.1312477270463112 1.514307055651411e-06 0.1304208267333309 1.51430714175175e-06 0.1295914604616623 1.514307241877205e-06 0.1286317929389105 \
1.514307323166875e-06 0.127857435971709 1.514307424934223e-06 0.1268981149578782 1.514307509182182e-06 0.1261072369695883 1.514307607998911e-06 0.1251836587365037 \
1.514307680839456e-06 0.1245055382686853 1.514307760865543e-06 0.1237631876254407 1.514307831351338e-06 0.1231117958237987 1.51430790388176e-06 0.1224439308288319 \
1.514307981350756e-06 0.1217331219782777 1.514308088702104e-06 0.1207554316575004 1.51430818934012e-06 0.1198442997624752 1.514308261927674e-06 0.1191899427853172 \
1.514308330759514e-06 0.1185715582611356 1.514308396546334e-06 0.1179824683205609 1.514308466175132e-06 0.1173610347366148 1.514308536558877e-06 0.1167350538439435 \
1.514308611737249e-06 0.1160688810594495 1.514308715991484e-06 0.1151493019715505 1.514308791126139e-06 0.114489769343061 1.514308860041223e-06 0.1138870655592168 \
1.514308923246094e-06 0.1133369146236164 1.51430899278746e-06 0.1127339156958381 1.514309050088964e-06 0.1122385190692166 1.514309121730019e-06 0.1116210355509516 \
1.514309179565093e-06 0.1111240709857579 1.514309251686527e-06 0.1105063809580559 1.51430931410261e-06 0.1099736279351742 1.514309398424131e-06 0.1092565349771765 \
1.5143094660201e-06 0.1086842173446869 1.514309574816032e-06 0.1077671916889585 1.514309679126564e-06 0.1068924975608609 1.514309758614772e-06 0.1062289053282379 \
1.514309846183183e-06 0.1055008617114655 1.514309909639535e-06 0.1049752776433979 1.514309971350652e-06 0.10446579874651 1.514310075190416e-06 0.103612238268202 \
1.514310157871117e-06 0.1029362225408096 1.514310256339144e-06 0.1021348761715451 1.514310340785582e-06 0.101450818648051 1.514310457263062e-06 0.1005121841703865 \
1.514310591996508e-06 0.09943411943161744 1.514310728066044e-06 0.0983541971400249 1.514310842385451e-06 0.09745369041838402 1.514310927852596e-06 0.09678457778867394 \
1.514311038134269e-06 0.09592640631053104 1.514311118922622e-06 0.09530159220710262 1.514311218473493e-06 0.09453592511176086 1.514311308421543e-06 0.09384821103094763 \
1.514311380924943e-06 0.09329669945188329 1.514311462667009e-06 0.09267796846073476 1.514311590787244e-06 0.09171467366828615 1.514311672199308e-06 0.09110674702409056 \
1.514311746631215e-06 0.09055373306570065 1.514311821605099e-06 0.08999936228352182 1.514311901024075e-06 0.08941505746347288 1.514312009684932e-06 0.08862052380504259 \
1.514312104044903e-06 0.08793517800096999 1.514312193440026e-06 0.08728987318634121 1.514312300205743e-06 0.086524181682867 1.514312418708183e-06 0.08568073755029131 \
1.514312560233253e-06 0.08468224831562859 1.514312693371676e-06 0.08375174214918565 1.514312834217007e-06 0.08277682112810406 1.514312983268988e-06 0.08175525972387458 \
1.514313119066718e-06 0.08083369778093191 1.514313260523232e-06 0.0798830809748103 1.514313395783147e-06 0.07898330517332906 1.514313537164988e-06 0.07805242629322809 \
1.514313684232761e-06 0.07709434677344783 1.514313835960902e-06 0.07611680364043326 1.514314001309203e-06 0.07506403321855706 1.514314165176721e-06 0.07403332863189842 \
1.514314341490649e-06 0.07293832728335037 1.514314530925751e-06 0.07177777688466977 1.514314741692455e-06 0.07050569389938771 1.514314961464952e-06 0.06920150027616521 \
1.514315196433104e-06 0.06783224552442871 1.514315455333654e-06 0.06635227408830123 1.514315750264117e-06 0.06470266364809808 1.514316054610178e-06 0.06304001691994518 \
1.514316416556457e-06 0.06111393619706453 1.514316732684212e-06 0.05947639552636011 1.514317174006677e-06 0.0572596911373907 1.514317487572719e-06 0.05573556853365672 \
1.514317911072189e-06 0.0537382660685313 1.514318255024042e-06 0.05216649213267931 1.51431859526531e-06 0.05065508790922631 1.5143189061029e-06 0.04931137323461653 \
1.514319200574802e-06 0.04807062469528345 1.514319494274299e-06 0.04686392507224969 1.514319769145536e-06 0.04576537019482012 1.514320044685701e-06 0.04468949010490332 \
1.51432030977623e-06 0.04367785045825667 1.514320586533311e-06 0.04264571401740119 1.514320869801436e-06 0.04161414314527601 1.514321167794735e-06 0.04055545327485047 \
1.514321427280131e-06 0.03965542606183669 1.514321657303569e-06 0.03887446236327848 1.514321876995156e-06 0.03814321686473518 1.514322101935296e-06 0.0374128399305801 \
1.51432242218897e-06 0.0363978329183388 1.51432270998682e-06 0.03550963653148703 1.514322986382154e-06 0.03467738358988744 1.514323270201283e-06 0.03384352473043348 \
1.514323508310586e-06 0.03315996078327022 1.514323792621371e-06 0.03236211345273886 1.514324034533221e-06 0.03169864947531036 1.514324269673394e-06 0.03106710921041438 \
1.514324511380923e-06 0.03043352335444016 1.514324748333857e-06 0.02982731501219571 1.514324978676274e-06 0.02925002048968134 1.514325192426852e-06 0.02872465224286764 \
1.514325398273815e-06 0.02822791768061097 1.514325790610838e-06 0.02730524204782691 1.514325979002849e-06 0.02687312495148303 1.514326354614307e-06 0.02603163971789 \
1.514326529081082e-06 0.02564950258131362 1.514326953015541e-06 0.02474274850847508 1.514327073769958e-06 0.02449086781212801 1.514327544020721e-06 0.02353384026002922 \
1.514327693235786e-06 0.02323677291035493 1.514328086867998e-06 0.02246740853134286 1.514328257894342e-06 0.02213909006726131 1.514328745173274e-06 0.02121869533024997 \
1.514328887220983e-06 0.02095326544309953 1.514329420237252e-06 0.01997576278857772 1.514329542401289e-06 0.01975737097014436 1.514330064559034e-06 0.01885981776906158 \
1.514330235137336e-06 0.01857989792133653 1.514330722450399e-06 0.01781360777737795 1.514330893973323e-06 0.01755501440977742 1.51433151376008e-06 0.01666567753024489 \
1.514331684684406e-06 0.0164316648397145 1.514332390235396e-06 0.01551160061118263 1.514332552852409e-06 0.01530799450170666 1.514333309745899e-06 0.01439879525764199 \
1.514333450662544e-06 0.01423641007536438 1.514334350661384e-06 0.01324361033368418 1.514334438010635e-06 0.01315122959105692 1.514335342363989e-06 0.01223321097894121 \
1.514335479555938e-06 0.01209984223734439 1.514336450212214e-06 0.01118944790767422 1.514336578130092e-06 0.01107451071402888 1.514337728540039e-06 0.01011008206277823 \
1.514337822342075e-06 0.01003687265682024 1.514339078387887e-06 0.009120584045805383 1.514339215929201e-06 0.009026502753623255 1.514340774683602e-06 0.008029670037698805 \
1.514340858486287e-06 0.007977066150721189 1.514342463865106e-06 0.00699828665725172 1.51434257476345e-06 0.006935886594503895 1.514344507009824e-06 0.005959177461785255 \
1.51434468671476e-06 0.005876661013304485 1.514346798505876e-06 0.004981749118765498 1.514347141291012e-06 0.004848482978762325 1.514349654457045e-06 0.003966891390423618 \
1.514350124178715e-06 0.003819799497680527 1.51435376449499e-06 0.002847564273158896 1.514354280232175e-06 0.002731633924241866 1.514359622062014e-06 0.001773027297371861 \
1.514359907382299e-06 0.001729522787584184 1.514365136030129e-06 0.0007540451492352357 1.514365310176696e-06 0.0007162692714263865 1.517013698769002e-06 -0.0001123232525192561 \
1.51701387179429e-06 -0.0002901710972538241 1.517014491546044e-06 -0.001202022686018724 1.517014580115221e-06 -0.001365806793032466 1.517014941086355e-06 -0.002110727959526865 \
1.51701506578065e-06 -0.002395793696299351 1.517015429622531e-06 -0.003299857180474864 1.5170156008982e-06 -0.003758114451912169 1.517015894896038e-06 -0.004576312838821549 \
1.517016005104443e-06 -0.004886880824040592 1.517016283358441e-06 -0.005643955697619643 1.51701640463225e-06 -0.00594200199557267 1.517017498254348e-06 -0.00517389603226481 \
1.517017621358228e-06 -0.004409713243767066 1.517017744826303e-06 -0.003462788751204457 1.5170178649921e-06 -0.002366010162083454 1.517017962853768e-06 -0.001346276287748183 \
1.517018069556104e-06 -0.0001076498664581183 1.517018181397488e-06 0.001328007358939307 1.517018317371855e-06 0.003256083960376262 1.517018439401011e-06 0.00514709866632534 \
1.517018627817289e-06 0.008343062029134115 1.517018768805819e-06 0.01093380316938193 1.517018921577522e-06 0.01391176330477175 1.517019064280151e-06 0.01683596409946878 \
1.517019218632387e-06 0.02013443377634912 1.517019374426043e-06 0.02358734537610087 1.51701953048334e-06 0.02715365164079262 1.51701967788774e-06 0.03060642997674319 \
1.517019826504485e-06 0.03415780069914553 1.517019981925702e-06 0.03793559522944389 1.517020140311532e-06 0.04184227512730877 1.517020305251154e-06 0.04596085539464361 \
1.517020479500423e-06 0.05035714787605008 1.517020658443539e-06 0.05491177248689325 1.517020847583032e-06 0.0597604232635115 1.51702105036361e-06 0.06498910043066243 \
1.517021269735637e-06 0.07067233091134768 1.517021500572133e-06 0.07667464705993039 1.517021747383969e-06 0.0831083675499642 1.51702201751608e-06 0.09016243555275107 \
1.517022310704188e-06 0.0978236474935409 1.517022634359626e-06 0.1062798466079799 1.517022997926912e-06 0.1157689210849182 1.51702339022043e-06 0.1259925151671456 \
1.517023838699915e-06 0.1376538644086695 1.5170243603994e-06 0.1511757390224034 1.517024972772044e-06 0.1669844191341421 1.517025649417359e-06 0.1843663871188266 \
1.51702643632765e-06 0.2044554566749352 1.517027317548744e-06 0.2267919980918504 1.517028137292384e-06 0.2474048556006221 1.517028865745328e-06 0.2655829647002126 \
1.517029507221317e-06 0.2814688958417333 1.517030083144485e-06 0.2956305456066151 1.517030620401302e-06 0.3087428400511723 1.517031124292597e-06 0.3209487846516751 \
1.517031601896145e-06 0.3324328152479784 1.517032080019379e-06 0.343838772307344 1.517032532118228e-06 0.3545331600964184 1.517033003884519e-06 0.365596737404158 \
1.51703344758136e-06 0.3759140547845509 1.517033969549898e-06 0.3879344734281669 1.51703449708783e-06 0.399956933836353 1.517034876602574e-06 0.4085271910771138 \
1.517035405564175e-06 0.4203606102508351 1.517035874883255e-06 0.4307444005277802 1.517036310038791e-06 0.4402814026247405 1.517036757516117e-06 0.4500002273945978 \
1.517037197539592e-06 0.4594737646471725 1.517037600841335e-06 0.4680814138276727 1.517037919241101e-06 0.4748254127722248 1.517038289219015e-06 0.4826007100982719 \
1.517038525472097e-06 0.4875314737878706 1.517038760543493e-06 0.4924129045770672 1.517039011882831e-06 0.4975994385012801 1.517039318269865e-06 0.5038799449729535 \
1.517039575228319e-06 0.5091120301871851 1.517039783702615e-06 0.5133309170973237 1.517039984084905e-06 0.5173683849445317 1.517040126478606e-06 0.5202244049244739 \
1.517040275403072e-06 0.5231993726577677 1.517040486949329e-06 0.5274019882470222 1.517040713006952e-06 0.5318780389403845 1.517040907549333e-06 0.5357103559602913 \
1.517041096681229e-06 0.539423417888626 1.517041326128277e-06 0.5439012399750046 1.517041508634083e-06 0.5474563135343053 1.517041745996952e-06 0.5520623276458133 \
1.51704201499126e-06 0.5572695987004129 1.51704226390171e-06 0.5620706638085723 1.517042507918531e-06 0.5667633705755619 1.517042780273744e-06 0.5719926523718327 \
1.517043041669873e-06 0.5769928369418796 1.517043299301279e-06 0.5819084237686675 1.517043546144628e-06 0.586601202059797 1.517043791890354e-06 0.5912552023551558 \
1.517044018467874e-06 0.5955288021520931 1.517044249620064e-06 0.5998646534936181 1.517044455900444e-06 0.6037202012184053 1.517044684021204e-06 0.6079592993751251 \
1.517044906401185e-06 0.6120725203834017 1.517045133377667e-06 0.6162454422471376 1.517045348430617e-06 0.6201823359462864 1.51704557780019e-06 0.6243500782103125 \
1.517045846823065e-06 0.6292041961704016 1.517046069836712e-06 0.6331993632081415 1.517046282091289e-06 0.6369772451758789 1.517046493488879e-06 0.6407176358819484 \
1.517046693558109e-06 0.644236566349866 1.517046923151958e-06 0.6482486956559365 1.517047163988886e-06 0.6524328529570182 1.517047345738273e-06 0.6555667906748446 \
1.5170475342865e-06 0.6588018260593631 1.517047687366139e-06 0.6614154033769962 1.517047859374421e-06 0.6643352515471471 1.51704800954724e-06 0.6668697017322168 \
1.517048146064529e-06 0.6691578850264722 1.517048295693716e-06 0.6716547631652277 1.517048423434085e-06 0.673777752640997 1.517048563020223e-06 0.6760856948620949 \
1.51704868725891e-06 0.6781310478824312 1.51704881840875e-06 0.6802827752320969 1.517048942850093e-06 0.6823179209931315 1.517049080080916e-06 0.6845542421253382 \
1.517049200329086e-06 0.6865048414796368 1.517049341660529e-06 0.6887891282595083 1.517049441991641e-06 0.6904033553735033 1.517049563109343e-06 0.6923460943304175 \
1.517049653886878e-06 0.6937948943079848 1.517049751145343e-06 0.6953408241330762 1.517049847353224e-06 0.6968660703265798 1.517049935967068e-06 0.6982647859968389 \
1.517050033255091e-06 0.6997938110311075 1.517050165723729e-06 0.7018622871835729 1.517050320913928e-06 0.7042674555997347 1.517050458791879e-06 0.7063866855441746 \
1.517050603646153e-06 0.7085960165693863 1.51705073070791e-06 0.7105202221428537 1.51705085539347e-06 0.7123960184768648 1.517050968098846e-06 0.7140814553427599 \
1.517051079889191e-06 0.7157437310299281 1.51705118066784e-06 0.7172341607972841 1.517051317946295e-06 0.7192525454101454 1.517051437630367e-06 0.7210013704967912 \
1.517051557059838e-06 0.7227365757678518 1.51705168394306e-06 0.7245692610776365 1.517051808360712e-06 0.7263556789600311 1.517051932093537e-06 0.728121726658988 \
1.517052058689063e-06 0.7299181396522603 1.517052189074464e-06 0.7317573312219798 1.517052311884284e-06 0.7334798522758219 1.517052447320059e-06 0.7353678990088863 \
1.517052548609838e-06 0.7367723836293941 1.517052656232334e-06 0.7382576460517265 1.517052745760416e-06 0.7394878879617913 1.517052860308785e-06 0.7410528648863303 \
1.517052948337041e-06 0.7422487366778059 1.517053055415107e-06 0.7436953530868765 1.5170531854801e-06 0.7454403311053276 1.517053296759795e-06 0.7469230742113165 \
1.517053401378355e-06 0.7483084058091373 1.51705352546134e-06 0.7499400420429273 1.517053673762169e-06 0.7518749696944975 1.517053795162033e-06 0.7534462209622173 \
1.51705390960278e-06 0.7549170836379747 1.517054049940098e-06 0.7567069362027918 1.517054191702981e-06 0.7584995177563068 1.517054309503919e-06 0.759977341175643 \
1.517054437480785e-06 0.761570846386187 1.517054579183209e-06 0.7633205808366864 1.517054696694523e-06 0.7647599110190483 1.517054842299792e-06 0.7665289162262866 \
1.517054963994099e-06 0.7679951561698679 1.517055082724709e-06 0.7694149786178283 1.517055205011304e-06 0.7708662727382939 1.51705533205582e-06 0.77236234268503 \
1.517055441699792e-06 0.7736439866494906 1.517055567386705e-06 0.7751025186690397 1.517055673401805e-06 0.776323977486031 1.517055808987772e-06 0.7778743028704433 \
1.517055933950769e-06 0.7792913979962601 1.517056059856921e-06 0.7807070123991936 1.517056175124167e-06 0.7819915514687489 1.51705628142864e-06 0.7831664991275713 \
1.517056419833432e-06 0.7846822315516878 1.517056569129882e-06 0.7862997378875561 1.517056714637327e-06 0.7878588534534761 1.517056834041839e-06 0.7891257303126159 \
1.517056969134663e-06 0.7905455128963393 1.517057090387826e-06 0.7918076974797237 1.517057233381105e-06 0.7932816011184505 1.51705737758541e-06 0.7947523458802197 \
1.517057503122239e-06 0.7960199014141693 1.517057622168612e-06 0.7972110037065316 1.517057734104495e-06 0.7983213107123885 1.517057838976047e-06 0.7993531099923881 \
1.517057934226459e-06 0.8002831901653534 1.517058070569705e-06 0.8016020813281191 1.517058187393835e-06 0.8027203407102198 1.517058306798445e-06 0.803852171037294 \
1.517058428905249e-06 0.8049980820693966 1.51705855186025e-06 0.8061401395390313 1.517058678828951e-06 0.8073073595000361 1.51705880406856e-06 0.8084467645495962 \
1.517058934640955e-06 0.8096220968518901 1.517059060631473e-06 0.8107441738369082 1.517059188817386e-06 0.8118738099374113 1.517059294347114e-06 0.8127947795787664 \
1.517059397218887e-06 0.8136847278655364 1.517059490214057e-06 0.8144826950388273 1.51705961401066e-06 0.8155354283166244 1.517059701978917e-06 0.8162769513478326 \
1.517059800709988e-06 0.8171027376706747 1.517059943975142e-06 0.8182889948057973 1.517060079253827e-06 0.8193962136425846 1.517060188368449e-06 0.8202800249700468 \
1.517060336451758e-06 0.8214657808291811 1.517060486222685e-06 0.8226492530953341 1.517060611457285e-06 0.8236267526687548 1.517060755448703e-06 0.8247372275730155 \
1.517060879504774e-06 0.8256825756473101 1.517061029968032e-06 0.8268152483647575 1.517061165678884e-06 0.8278240064655301 1.517061290697392e-06 0.828742521381556 \
1.517061408452322e-06 0.8295983347934622 1.517061554429135e-06 0.8306466023667578 1.517061720938452e-06 0.8318251482734692 1.517061851861028e-06 0.8327390940956469 \
1.517062025288466e-06 0.8339327615268647 1.517062193435348e-06 0.8350717495747054 1.517062363270277e-06 0.8362042975620877 1.517062544195048e-06 0.8373912937861997 \
1.517062687293307e-06 0.8383160748488641 1.517062801379198e-06 0.8390446117604563 1.517062931553184e-06 0.8398665237782376 1.517063033394266e-06 0.8405024977857931 \
1.517063150213615e-06 0.8412243379523001 1.517063287078045e-06 0.8420597162999857 1.517063484876668e-06 0.8432475311273343 1.51706367648074e-06 0.8443767279905872 \
1.517063885921222e-06 0.8455874169714939 1.517064067846852e-06 0.8466193100105236 1.517064264979957e-06 0.8477171434207121 1.517064438329848e-06 0.8486653666163242 \
1.517064621329232e-06 0.8496493024239481 1.517064792495495e-06 0.8505537352954988 1.517064967127282e-06 0.8514606693963016 1.517065142389669e-06 0.8523550102558151 \
1.517065318541785e-06 0.8532381479010797 1.517065508812824e-06 0.8541746551565574 1.517065699414774e-06 0.85509499218684 1.517065900062401e-06 0.8560449689899254 \
1.517066092672966e-06 0.8569390259424264 1.517066303330652e-06 0.8578972157030333 1.517066531456051e-06 0.8589122247267402 1.517066797213368e-06 0.8600655879592763 \
1.517067095837813e-06 0.8613244245924475 1.517067372169332e-06 0.862454900702886 1.51706765640239e-06 0.8635842083919951 1.517067930614306e-06 0.8646423892283146 \
1.517068202842372e-06 0.8656634505877856 1.517068473051191e-06 0.8666487272755322 1.517068730204067e-06 0.8675609437488442 1.517069002786335e-06 0.868501515423508 \
1.517069278771335e-06 0.8694269133137555 1.517069548872911e-06 0.8703069289141475 1.517069848734863e-06 0.8712546000783432 1.517070219768993e-06 0.8723856543073821 \
1.517070514706754e-06 0.8732530157608677 1.517070768997536e-06 0.8739790309043101 1.517071067254951e-06 0.8748056771600844 1.517071340863485e-06 0.8755409825400007 \
1.51707157699155e-06 0.8761583495732972 1.51707181733693e-06 0.876770807053994 1.517072039670212e-06 0.8773233906735478 1.51707223367596e-06 0.8777948466981503 \
1.517072563398506e-06 0.8785737911727464 1.517072718571944e-06 0.8789308835864816 1.517073036347473e-06 0.8796437246174529 1.51707321520917e-06 0.8800342982281311 \
1.517073557671047e-06 0.8807611334253193 1.517073741799519e-06 0.8811407335605206 1.517074216677856e-06 0.8820849466541889 1.517074384074053e-06 0.8824061830950772 \
1.517074849915456e-06 0.8832696475595492 1.517075030737665e-06 0.8835931319180218 1.517075524775914e-06 0.8844450822729043 1.517075666124327e-06 0.8846804878101884 \
1.517076272457385e-06 0.8856498028150036 1.517076424526725e-06 0.8858829444029697 1.5170770712152e-06 0.8868329272509302 1.517077199509723e-06 0.8870138524519416 \
1.517077847626928e-06 0.8878919388991984 1.517077977425791e-06 0.8880607713689423 1.517078755627481e-06 0.8890227771434612 1.517078870684414e-06 0.8891574578072456 \
1.517079726342848e-06 0.8901003239091128 1.517079871707616e-06 0.8902505899439886 1.51708085746403e-06 0.8911948786459364 1.51708107856904e-06 0.8913892999646706 \
1.517082223696019e-06 0.8923206810037944 1.517082354912618e-06 0.892422953350996 1.517083696124267e-06 0.8934189515818408 1.517083847523211e-06 0.8935240845833778 \
1.517085328961459e-06 0.8944568913393511 1.517085567840892e-06 0.8945912088657246 1.517087337161074e-06 0.8954685138428928 1.51708772631084e-06 0.895637400736999 \
1.517090119976628e-06 0.896526474291006 1.51709059568945e-06 0.8966764365754722 1.517094011699057e-06 0.8975478548673914 1.517094658849072e-06 0.8976786076740833 \
1.517102137013678e-06 0.8986646932675814 1.517102809590796e-06 0.8987192862546014 1.517195253995367e-06 0.8997188196574962 1.517195917228051e-06 0.8997241906476866 \
1.517385126389945e-06 0.900686595210158 1.517385288462789e-06 0.9007292695325627 1.517387933983676e-06 0.8998161167154269 1.517388102533154e-06 0.8996881690130656 \
1.517389379285545e-06 0.8987393243250013 1.517389581451881e-06 0.8986030018074492 1.517391189561267e-06 0.8976721249252815 1.517391381667192e-06 0.8975774045828077 \
1.517406495049839e-06 0.8985726115129884 1.517406683108756e-06 0.8986004060702872 1.517417988037768e-06 0.8995874924221801 1.517418361423516e-06 0.8996034751727418 \
1.517907373786698e-06 0.9005892719715856 1.517907484554898e-06 0.9006868984798269 1.517908237227259e-06 0.9015617873136611 1.517908339021946e-06 0.9017086238768567 \
1.51790887442049e-06 0.9025814930725723 1.517908976929663e-06 0.9027670217776843 1.517909369148482e-06 0.9035254014384071 1.517909509991429e-06 0.9038129158713877 \
1.517909951028881e-06 0.9047472953155866 1.517910136514484e-06 0.9051402477015744 1.517910652827601e-06 0.9061269394579334 1.517910737502694e-06 0.9062564181617988 \
1.517911972174744e-06 0.9053011091537977 1.517912129388156e-06 0.9045688862145235 1.517912321204817e-06 0.9034162411061901 1.517912488045348e-06 0.9021712267446264 \
1.517912635003746e-06 0.9008824031243315 1.517912749119942e-06 0.8997575350477262 1.517912878992032e-06 0.8983446880789033 1.51791299010955e-06 0.8970273815442567 \
1.517913082914029e-06 0.8958483937359277 1.517913171236719e-06 0.8946639786015808 1.517913274417478e-06 0.8932058048613533 1.517913366625413e-06 0.8918333298588224 \
1.51791345419561e-06 0.8904732289418564 1.517913568189077e-06 0.8886245408236838 1.5179137299935e-06 0.8858564722885236 1.517913914992118e-06 0.8825005184224666 \
1.517914107151785e-06 0.8788219124347386 1.517914308599139e-06 0.874780227084481 1.517914515009728e-06 0.8704697801294994 1.517914700181681e-06 0.8664790122147591 \
1.517914884689405e-06 0.862405115500708 1.517915057841296e-06 0.8585071391690239 1.517915242887321e-06 0.8542751393552932 1.517915420261525e-06 0.8501657390392787 \
1.517915597007955e-06 0.8460284987362284 1.517915763166606e-06 0.8421077870518131 1.517915925211044e-06 0.8382599993991456 1.517916091783925e-06 0.8342839555277276 \
1.517916250437662e-06 0.8304816347052207 1.517916441313687e-06 0.8258903812682129 1.517916616297259e-06 0.8216694867670907 1.517916786243393e-06 0.8175615830390965 \
1.517916951419567e-06 0.8135626411663678 1.517917124611674e-06 0.8093650119631921 1.517917295673877e-06 0.8052155696745213 1.517917463774914e-06 0.801136095357175 \
1.517917654109863e-06 0.7965156511928794 1.517917837691806e-06 0.7920591698039 1.517918045682732e-06 0.7870113041480956 1.517918268259242e-06 0.7816114142545842 \
1.517918457674258e-06 0.7770174196885687 1.517918650984654e-06 0.7723312127316435 1.517918794430241e-06 0.7688556734481145 1.517918943853591e-06 0.7652374066097742 \
1.517919063006063e-06 0.7623536300085233 1.517919175722544e-06 0.7596269484184472 1.517919284997451e-06 0.7569846861296079 1.517919421027209e-06 0.753697254849378 \
1.517919533823024e-06 0.750972995067179 1.51791965602098e-06 0.7480232093637929 1.517919767605753e-06 0.7453311011793381 1.517919892312216e-06 0.7423241425761796 \
1.517920046694167e-06 0.7386034578119585 1.517920213478233e-06 0.7345862494782525 1.517920430642921e-06 0.7293605768817599 1.51792062520351e-06 0.7246835946359503 \
1.517920785534395e-06 0.7208333202545074 1.517920960959998e-06 0.7166251500492028 1.517921150723573e-06 0.7120779400724765 1.517921339451897e-06 0.7075610435995559 \
1.517921521273264e-06 0.7032145396962334 1.517921705870676e-06 0.6988062725207448 1.517921842953811e-06 0.6955348514212173 1.517921996242049e-06 0.6918805091472418 \
1.517922191613795e-06 0.6872279990818534 1.517922347770547e-06 0.6835136309588888 1.517922505722766e-06 0.6797605476340507 1.51792270397403e-06 0.6750570282453686 \
1.517922897319928e-06 0.6704763548785364 1.517923133825274e-06 0.6648822204491218 1.517923320030378e-06 0.6604858901039825 1.517923557652698e-06 0.6548824851665868 \
1.517923744451452e-06 0.6504854738275335 1.517923925009211e-06 0.6462424706993735 1.517924088085156e-06 0.6424159959781919 1.517924232696721e-06 0.6390271817202816 \
1.517924373299071e-06 0.6357379642635244 1.517924500108657e-06 0.632774906490579 1.517924632245193e-06 0.6296924762754078 1.517924758489145e-06 0.6267508340255646 \
1.517924889752774e-06 0.6236963630311418 1.517925018850514e-06 0.6206978048938425 1.517925158276179e-06 0.6174624210713571 1.517925306646171e-06 0.6140261568477932 \
1.51792550120306e-06 0.6095278574984737 1.517925644648937e-06 0.6062198040692683 1.517925879109183e-06 0.6008245134060309 1.517926051007495e-06 0.5968818013610552 \
1.517926263928033e-06 0.5920102583789468 1.517926436394651e-06 0.5880775912131976 1.517926566719198e-06 0.5851108450968721 1.517926698275517e-06 0.5821241897920357 \
1.517926808505599e-06 0.5796262478458715 1.517926904159847e-06 0.5774603558442819 1.517927003393806e-06 0.5752182923213994 1.517927086311907e-06 0.5733484809858778 \
1.517927165227534e-06 0.5715706040143225 1.517927228156309e-06 0.5701535626562365 1.517927293664786e-06 0.5686800671140783 1.517927374150839e-06 0.5668736364148982 \
1.517927424016846e-06 0.5657560592102344 1.517927473205615e-06 0.5646541775062763 1.517927534675401e-06 0.5632780399140616 1.517927582596929e-06 0.5622058085646952 \
1.517927633441648e-06 0.5610687758404553 1.517927692541903e-06 0.5597501790023616 1.51792775115623e-06 0.5584442118409422 1.517927826782323e-06 0.5567607189607793 \
1.517927897341035e-06 0.5551915720267918 1.517927986471042e-06 0.5532116467156011 1.51792807569462e-06 0.5512351177508077 1.51792816099823e-06 0.5493490637975145 \
1.517928248625197e-06 0.5474138635528197 1.51792834562712e-06 0.545274424894262 1.517928449972891e-06 0.5429792414815097 1.517928566264315e-06 0.5404269323775457 \
1.517928672601932e-06 0.5380963700835184 1.517928784310815e-06 0.5356536306660374 1.517928896605295e-06 0.5332047801427824 1.517929023802854e-06 0.5304364255197962 \
1.517929146572528e-06 0.5277698476303582 1.517929288796924e-06 0.5246912237717902 1.517929425160057e-06 0.5217463069543907 1.517929577381123e-06 0.5184691491721333 \
1.517929737017329e-06 0.5150420887864461 1.517929912992521e-06 0.5112761258030903 1.517930101501109e-06 0.5072591542828934 1.51793030856769e-06 0.5028616940969075 \
1.517930533509662e-06 0.4981043078903621 1.517930784905619e-06 0.4928144328841237 1.517931021331185e-06 0.4878598554762091 1.517931318494919e-06 0.4816683149127979 \
1.517931609172211e-06 0.4756487143466775 1.517931917027196e-06 0.469313240945046 1.517932230852953e-06 0.4628991126846517 1.517932559994313e-06 0.4562163541974347 \
1.51793289337242e-06 0.4494927613461197 1.517933224999028e-06 0.4428490490857003 1.517933546548425e-06 0.4364504708187015 1.517933874224238e-06 0.4299742838549845 \
1.51793422184386e-06 0.4231546934710667 1.517934555065174e-06 0.4166645133789623 1.517934900974402e-06 0.4099771621835854 1.517935346388221e-06 0.4014400148089548 \
1.517935704178092e-06 0.3946500490499754 1.517936018334912e-06 0.3887397205534429 1.517936402745392e-06 0.3815756289527631 1.517936732720036e-06 0.3754830843203271 \
1.517937017930125e-06 0.3702633801070484 1.517937326220382e-06 0.3646649204592909 1.517937606017443e-06 0.3596257204303125 1.517937832011793e-06 0.3555880084110294 \
1.517938046849748e-06 0.3517755993421203 1.51793824528482e-06 0.3482769933469286 1.517938449224337e-06 0.3447071465415313 1.517938659760396e-06 0.3410461989361561 \
1.517938916734521e-06 0.3366091000429626 1.517939157995129e-06 0.3324763702393667 1.517939389568845e-06 0.3285420159269506 1.517939604222291e-06 0.3249208057821749 \
1.517939825046275e-06 0.3212218866489027 1.517940026292867e-06 0.3178749657716667 1.51794022938212e-06 0.3145250552959265 1.517940427226991e-06 0.3112865758726304 \
1.517940614079937e-06 0.3082497660855442 1.517940808016663e-06 0.3051208532403978 1.517941011761317e-06 0.30185834615803 1.517941190488583e-06 0.2990186060348319 \
1.517941428134378e-06 0.2952727068736475 1.517941627896611e-06 0.2921508861588616 1.517941829525427e-06 0.2890253490052915 1.517942054991886e-06 0.285561995332 \
1.517942221086285e-06 0.2830312764183137 1.517942399705387e-06 0.2803277612349699 1.517942581409588e-06 0.2775983111934518 1.517942770043305e-06 0.2747882307029562 \
1.517942947466508e-06 0.2721695222189568 1.517943124659646e-06 0.2695724116247911 1.517943284731561e-06 0.2672552081803913 1.517943405132238e-06 0.2655193337608355 \
1.517943552958303e-06 0.2633957862580221 1.517943681588075e-06 0.2615692882062232 1.517943783793658e-06 0.2601227034409412 1.517943902028939e-06 0.2584516051170885 \
1.5179440224823e-06 0.2567534139348401 1.517944146190618e-06 0.2550183706610066 1.517944264442643e-06 0.2533694204037282 1.517944392295773e-06 0.2515887492000971 \
1.517944512581604e-06 0.249915736161692 1.51794466526121e-06 0.2477917697339537 1.517944800173988e-06 0.2459264316518071 1.51794492881341e-06 0.2441493177932957 \
1.517945086528788e-06 0.2419705448111171 1.517945213210091e-06 0.2402201997919771 1.517945348536158e-06 0.2383592392624043 1.517945487448727e-06 0.2364550510890953 \
1.517945605221031e-06 0.2348405558720491 1.517945764491849e-06 0.2326580599570062 1.517945901013704e-06 0.2307878375452989 1.51794604224565e-06 0.2288626996658652 \
1.517946148058693e-06 0.2274220928889542 1.51794627840164e-06 0.2256484734765637 1.517946378112453e-06 0.2242944442559471 1.517946480933888e-06 0.2228991027388591 \
1.517946554349542e-06 0.2219046249368765 1.517946634181104e-06 0.2208265149641777 1.517946704228335e-06 0.2198809561195558 1.517946754631426e-06 0.2192009305305119 \
1.517946806883225e-06 0.2184966408607167 1.517946886120743e-06 0.2174292050927151 1.517946927964696e-06 0.2168658036437602 1.517946967304648e-06 0.216336351877609 \
1.517947010340057e-06 0.2157575332679269 1.517947054507484e-06 0.2151638767852215 1.517947128273224e-06 0.2141731338947761 1.517947163785221e-06 0.2136967174286463 \
1.517947211500021e-06 0.2130606706933813 1.517947272229561e-06 0.2122518321687151 1.517947340486787e-06 0.2113438957752176 1.517947413008566e-06 0.2103801801047663 \
1.517947485683193e-06 0.2094152724966429 1.517947593999181e-06 0.2079788886429202 1.517947691670323e-06 0.20668564243436 1.517947803221819e-06 0.2052110974836689 \
1.517947901757253e-06 0.2039136008387587 1.517948005250393e-06 0.2025572972554956 1.517948101152128e-06 0.2013021587886929 1.517948203780057e-06 0.1999606878451601 \
1.51794830660317e-06 0.1986207062101238 1.517948416722797e-06 0.1971897063011611 1.517948525418353e-06 0.1957815523781236 1.517948645095582e-06 0.1942360962608612 \
1.517948755373261e-06 0.192818053470401 1.517948863436481e-06 0.1914343471929882 1.517948988535148e-06 0.1898375077741012 1.517949078504982e-06 0.1886931806549971 \
1.517949157191935e-06 0.1876950225942949 1.517949234476806e-06 0.1867173468865102 1.517949320985383e-06 0.1856271834369256 1.517949419934593e-06 0.1843848109964498 \
1.517949490443458e-06 0.1835017733581451 1.517949561894511e-06 0.1826096997732476 1.517949667039846e-06 0.1813018727451555 1.517949746279475e-06 0.1803200401832796 \
1.517949827363369e-06 0.1793174195483187 1.51794992085531e-06 0.1781663090788374 1.517950021631285e-06 0.1769308188703378 1.517950171343388e-06 0.175105380089017 \
1.517950287132704e-06 0.1737009932372819 1.51795043813808e-06 0.1718807311127691 1.5179505492465e-06 0.1705485445502526 1.517950691372958e-06 0.168854666407182 \
1.517950809031379e-06 0.167460358327668 1.517950913935975e-06 0.1662230887079887 1.517951008998573e-06 0.1651069099307241 1.517951102429828e-06 0.1640147999883682 \
1.51795120347649e-06 0.1628388413495604 1.517951299823398e-06 0.1617223204899406 1.517951396975644e-06 0.1606011553546776 1.517951480024216e-06 0.1596469772300165 \
1.51795159006187e-06 0.1583897228513109 1.517951672364432e-06 0.1574542248873526 1.517951777364141e-06 0.156267858580057 1.51795185506021e-06 0.1553950893374849 \
1.517951937879689e-06 0.1544690878994293 1.517952019541594e-06 0.1535604570452941 1.517952108890884e-06 0.152571060794856 1.51795218460332e-06 0.1517364980793458 \
1.517952267165934e-06 0.1508307726525361 1.517952343747367e-06 0.1499942554682341 1.517952412035253e-06 0.1492531084507001 1.517952505402265e-06 0.1482449401818621 \
1.517952574555677e-06 0.1475015570698688 1.517952650180008e-06 0.1466917482325688 1.517952711729128e-06 0.1460354497178591 1.517952778977892e-06 0.1453208357145237 \
1.517952850039892e-06 0.1445684785944268 1.51795292553732e-06 0.143772322008306 1.51795298444886e-06 0.1431546944759192 1.51795306112247e-06 0.1423563022825049 \
1.517953141443212e-06 0.1415233898163201 1.51795321459452e-06 0.1407682091691316 1.517953308750941e-06 0.139800669784813 1.517953380355125e-06 0.1390684367429364 \
1.5179534538159e-06 0.1383201464810226 1.517953537327651e-06 0.1374732033664194 1.517953626806795e-06 0.1365744208092838 1.5179536918717e-06 0.1359252211013016 \
1.517953803997723e-06 0.1348115665849295 1.517953869183863e-06 0.1341670699454539 1.517953939222108e-06 0.1334770515823289 1.517953999527163e-06 0.1328849371768329 \
1.517954054537987e-06 0.1323464455745446 1.517954142654965e-06 0.1314871014507438 1.51795418344126e-06 0.131090685705856 1.51795428714401e-06 0.1300923774523848 \
1.51795433045658e-06 0.1296773144713907 1.517954391675178e-06 0.1290920262082728 1.517954436511897e-06 0.1286643765206081 1.517954524107923e-06 0.127831527987147 \
1.517954565661879e-06 0.1274377589706847 1.517954625523389e-06 0.1268718307679372 1.517954697367115e-06 0.1261946708524367 1.517954753579841e-06 0.1256664967939027 \
1.51795481606734e-06 0.125081039250218 1.517954890295323e-06 0.1243877959456236 1.517954964976328e-06 0.1236954937854857 1.517955052159541e-06 0.1228905551604285 \
1.517955120558092e-06 0.1222610287411191 1.517955201128775e-06 0.1215216597888775 1.517955282424256e-06 0.120778012781285 1.517955349340781e-06 0.1201677797529914 \
1.517955432157726e-06 0.1194156054679852 1.517955491346448e-06 0.1188799972037829 1.517955557267448e-06 0.1182853617472536 1.517955637141492e-06 0.1175675408705869 \
1.51795571363729e-06 0.1168828806096336 1.517955795099401e-06 0.1161574242846086 1.517955893570281e-06 0.1152852106851665 1.51795596868063e-06 0.114622623867465 \
1.51795607166842e-06 0.1137180076826871 1.517956145852372e-06 0.1130691786503039 1.517956243471825e-06 0.1122190343868764 1.51795633928278e-06 0.1113890351962442 \
1.517956435131205e-06 0.110562946039519 1.517956516069412e-06 0.1098685209805978 1.517956604452683e-06 0.1091134439098378 1.517956703052662e-06 0.108274944429282 \
1.517956775836866e-06 0.1076586405352824 1.517956865109775e-06 0.1069058608836731 1.517956927091788e-06 0.1063852406583179 1.517956989684956e-06 0.1058613310701875 \
1.517957074907104e-06 0.105150777260444 1.517957180369478e-06 0.1042758147594986 1.51795726019996e-06 0.1036167065755082 1.517957340914214e-06 0.1029530974056021 \
1.517957423527949e-06 0.1022768941101355 1.517957493972562e-06 0.1017026162492672 1.517957597231928e-06 0.1008648142128753 1.517957670072053e-06 0.1002767039768694 \
1.517957755712335e-06 0.09958839426015198 1.517957874514073e-06 0.09863954321822334 1.517957942151898e-06 0.09810250133474645 1.51795801190202e-06 0.09755100310752296 \
1.517958089237e-06 0.09694230106952094 1.517958181657254e-06 0.09621870517595056 1.517958253354782e-06 0.09566033062548993 1.517958339171942e-06 0.09499542738017568 \
1.517958441597192e-06 0.09420660575030523 1.517958534892083e-06 0.09349264652734962 1.517958631208557e-06 0.09276005482712441 1.517958708110818e-06 0.09217843893134048 \
1.517958801590805e-06 0.09147541043939374 1.517958880833232e-06 0.09088281005358793 1.517958995455426e-06 0.0900310686188453 1.517959125063686e-06 0.08907580221142102 \
1.517959258320877e-06 0.08810234090122065 1.517959402350766e-06 0.08705990691030199 1.51795955951891e-06 0.08593388720602639 1.517959709295387e-06 0.08487214151476249 \
1.517959871762979e-06 0.08373303262435308 1.517960014942984e-06 0.08273971668837025 1.517960167622107e-06 0.0816913199659166 1.517960301891878e-06 0.08077856892457436 \
1.517960443644156e-06 0.07982444400446118 1.517960578643816e-06 0.07892500874648442 1.517960720601214e-06 0.07798882638923543 1.517960867448644e-06 0.07703088995320664 \
1.517961019894053e-06 0.07604750978240994 1.517961185112776e-06 0.07499422991502351 1.517961349250621e-06 0.07396067809208305 1.517961526112024e-06 0.07286119333145537 \
1.51796171645358e-06 0.07169407515132428 1.517961927410093e-06 0.07042030845332216 1.517962147819232e-06 0.0691121699798517 1.517962383344393e-06 0.06773900533435212 \
1.517962643793767e-06 0.0662496528900723 1.517962939459177e-06 0.06459579389282195 1.517963244581463e-06 0.06292902455725519 1.517963609576024e-06 0.06098725515092194 \
1.517964004456839e-06 0.05894944116461652 1.517964410847493e-06 0.05692211719668253 1.517964826573035e-06 0.05491854459141238 1.517965189379358e-06 0.0532251207245777 \
1.517965533980648e-06 0.05166301626031383 1.51796584916051e-06 0.05027284652491828 1.517966144689875e-06 0.04900240867073854 1.517966442670382e-06 0.04775344010203557 \
1.517966718469172e-06 0.04662857640242725 1.517966997243768e-06 0.04551884372531381 1.517967261178638e-06 0.04449205559535935 1.517967537201377e-06 0.04344260531795661 \
1.51796781615763e-06 0.04240676967887352 1.517968129850963e-06 0.04127097799875453 1.51796836585125e-06 0.04043636567030678 1.517968621645987e-06 0.03955075129286261 \
1.517968881769487e-06 0.03867033103466553 1.517969151904759e-06 0.03778142289416799 1.517969431124747e-06 0.03688501536902895 1.517969712963396e-06 0.03600226561751176 \
1.517969989839066e-06 0.03515600409566183 1.517970268932665e-06 0.03432349610146775 1.517970501810273e-06 0.03364444121149882 1.517970785646989e-06 0.03283527291840588 \
1.517971025751924e-06 0.03216626441466421 1.517971265550746e-06 0.0315119836023277 1.51797150482792e-06 0.03087436846876356 1.517971740084942e-06 0.03026290129608995 \
1.517971971011964e-06 0.02967475842909434 1.517972186001007e-06 0.02913788335257221 1.51797258815546e-06 0.02816043724496065 1.517972786878278e-06 0.02768988489927659 \
1.517973160561295e-06 0.0268265706552881 1.517973347359617e-06 0.02640514011949098 1.517973694919304e-06 0.02563810810034544 1.517973816848767e-06 0.0253740445387235 \
1.517974199320207e-06 0.02456430406701914 1.517974370028237e-06 0.02421180751242828 1.517974827125621e-06 0.02328894863848502 1.517975012758007e-06 0.0229225623309489 \
1.51797537621526e-06 0.02221803970155307 1.517975596582612e-06 0.02179832126591805 1.51797605430897e-06 0.02093867417890744 1.517976189728599e-06 0.02068687731869814 \
1.517976719624047e-06 0.01972418011126781 1.517976838945017e-06 0.01951377505543128 1.517977404730696e-06 0.01856069823426573 1.517977569110437e-06 0.0182962226476828 \
1.517978187655734e-06 0.01735107502432094 1.517978357709933e-06 0.01710418363667701 1.517978889842166e-06 0.01636278834442301 1.517979086926142e-06 0.01610013864443424 \
1.517979810045215e-06 0.01517806887136661 1.517979974675381e-06 0.01497647803580381 1.517980723800768e-06 0.01409711804523418 1.51798085710012e-06 0.01394643716836554 \
1.517981717353759e-06 0.01301449210748497 1.517981852457379e-06 0.01287422877142914 1.51798279503482e-06 0.01193816285908547 1.517982958630574e-06 0.01178202925388569 \
1.517983959987201e-06 0.0108653384673985 1.517984097529988e-06 0.01074500730514941 1.517985319636371e-06 0.009765086624518643 1.517985426589084e-06 0.00968516078425012 \
1.517986830780577e-06 0.008707372520026449 1.517986935611284e-06 0.008639312158696611 1.517988470448246e-06 0.00767719340797631 1.517988565731547e-06 0.007617466071856052 \
1.517990174528868e-06 0.006680264535635283 1.517990308605608e-06 0.006609506832171614 1.517992405618559e-06 0.005610918814474722 1.517992636163191e-06 0.005510783990371394 \
1.517994959158435e-06 0.004586584533412417 1.517995440488638e-06 0.004413562233393853 1.517998278050269e-06 0.003511943147855551 1.517998822969955e-06 0.003360532104877318 \
1.518002947178352e-06 0.002408309874554541 1.518003490902011e-06 0.002305347543005144 1.518009362191237e-06 0.001333291345955189 1.518009605056421e-06 0.001286469439319215 \
1.518023932948772e-06 0.0002880570268237783 1.518024077507414e-06 0.0002853642807229123 1.520661356428513e-06 -0.0006859155495331031 1.52066149598365e-06 -0.000901903561740745 \
1.520662005077583e-06 -0.001859438188174024 1.520662094565085e-06 -0.002052812934985279 1.520662457959945e-06 -0.00291126965001638 1.520662548982015e-06 -0.003143482006111167 \
1.520662914420052e-06 -0.004127275145644371 1.520663024680619e-06 -0.004436819103926468 1.520663336727774e-06 -0.005309594399865315 1.520663439442621e-06 -0.005584800160857357 \
1.520663803290477e-06 -0.006384516484886619 1.520663968081208e-06 -0.006586298968823262 1.520664547677408e-06 -0.005791490933239759 1.520664722787551e-06 -0.004914057272375438 \
1.520664839479485e-06 -0.004132845175365214 1.520664966064091e-06 -0.003100877896798674 1.520665067873012e-06 -0.002132773363901063 1.520665188361723e-06 -0.0008283127610571584 \
1.520665278808799e-06 0.0002599396317828252 1.52066537669893e-06 0.001541559978017447 1.520665475763239e-06 0.002943971508909197 1.520665646570516e-06 0.005594911825788154 \
1.520665868338539e-06 0.00944046646559993 1.520666064242384e-06 0.01317281463966807 1.520666223123766e-06 0.01639870563256729 1.520666387552263e-06 0.01989779506365397 \
1.520666541918294e-06 0.02331070396473752 1.520666700690818e-06 0.02693200463312963 1.520666847428777e-06 0.03036422445567413 1.520666996052748e-06 0.0339113704936035 \
1.520667151667245e-06 0.03768995713197771 1.520667308909259e-06 0.04156499463828727 1.520667473802058e-06 0.04567927910670353 1.520667647221578e-06 0.05005184210758699 \
1.520667825915293e-06 0.05459761989277153 1.520668014531131e-06 0.05943075613080645 1.520668215431274e-06 0.06460909294799391 1.520668434888064e-06 0.0702927970720964 \
1.520668664434351e-06 0.07626037976612585 1.520668910133291e-06 0.08266408948881369 1.52066917869823e-06 0.08967663153997742 1.520669470040144e-06 0.09728936802005522 \
1.520669791708172e-06 0.1056939239977524 1.520670152022263e-06 0.1150987971742611 1.520670543001701e-06 0.1252892839303718 1.520670986416517e-06 0.1368209045172546 \
1.520671502729605e-06 0.1502062239570841 1.520672108934821e-06 0.16586000516691 1.520672780191848e-06 0.1831102247110778 1.520673559691505e-06 0.20301830483439 \
1.520674432001389e-06 0.2251413938832897 1.520675262336714e-06 0.2460320778586349 1.520675993667063e-06 0.264292249712138 1.520676641612843e-06 0.280346965484095 \
1.520677224923317e-06 0.29469740877147 1.520677760655584e-06 0.3077798509628869 1.520678263914169e-06 0.3199778888071559 1.52067874911767e-06 0.3316516836183861 \
1.520679228040375e-06 0.3430829066939081 1.520679674471008e-06 0.3536501814456421 1.520680148800718e-06 0.3647819492304352 1.520680597991712e-06 0.3752331958288908 \
1.52068108846397e-06 0.3865396207984229 1.520681617036723e-06 0.3985997842463301 1.520681988181062e-06 0.4069920784971888 1.520682515935418e-06 0.4188173133762567 \
1.520682978292178e-06 0.4290642331729484 1.520683450624318e-06 0.4394285229343968 1.520683932409041e-06 0.4498981261869666 1.520683965448159e-06 0.4506126593745911 \
1.520684003207152e-06 0.45142837879914 1.520684078725137e-06 0.4530572051633331 1.520684229761107e-06 0.4563088938659436 1.520684437280372e-06 0.460764549126051 \
1.520684625319184e-06 0.4647825567212808 1.520684844328398e-06 0.469441659996985 1.520685087159409e-06 0.4745824626509371 1.520685386935037e-06 0.4808894567257585 \
1.520685624728187e-06 0.4858624696070272 1.520685887949588e-06 0.4913374535260851 1.520686148847133e-06 0.4967277906005185 1.52068637840122e-06 0.5014431429135263 \
1.520686601461413e-06 0.506003872007333 1.520686803037404e-06 0.5100983586086808 1.520686951867463e-06 0.51310967141356 1.520687196178516e-06 0.5180317772556589 \
1.520687328783749e-06 0.5206893064287169 1.520687468140331e-06 0.5234717264876519 1.520687679105724e-06 0.5276623644271943 1.520687853979606e-06 0.5311266030493931 \
1.520688122027852e-06 0.5364094032095129 1.52068831705351e-06 0.5402319029111832 1.520688496615017e-06 0.5437361368949839 1.520688747571146e-06 0.5486228351952749 \
1.520689024979257e-06 0.5540035987981641 1.520689308928559e-06 0.5594901708581531 1.52068956456585e-06 0.5644152233389156 1.52068985554807e-06 0.570006772487656 \
1.520690115853754e-06 0.5749917787111524 1.520690384297874e-06 0.5801232573974072 1.520690627063004e-06 0.5847450403362237 1.520690883594205e-06 0.5896146675871002 \
1.520691109757648e-06 0.59388771440121 1.520691347099143e-06 0.5983512154742827 1.52069155648786e-06 0.6022720321566808 1.520691770260628e-06 0.6062574570422776 \
1.520692023713469e-06 0.6109557890491497 1.520692226567816e-06 0.6146943332140289 1.520692419372338e-06 0.6182333111593361 1.520692609677365e-06 0.6217090173923294 \
1.520692800335854e-06 0.6251694921350958 1.52069300291378e-06 0.6288260100903066 1.520693265662542e-06 0.6335359534764116 1.520693494630232e-06 0.6376100987349322 \
1.520693714577867e-06 0.6414991146358265 1.52069394026254e-06 0.6454625140719233 1.520694149149966e-06 0.6491091855837361 1.520694370803585e-06 0.652957810138281 \
1.520694555693011e-06 0.6561429680377227 1.520694745707565e-06 0.6594017273991298 1.520694895862686e-06 0.6619630641908443 1.520695070740593e-06 0.6649292185271485 \
1.52069521646131e-06 0.6673855496832628 1.520695352493842e-06 0.6696641287411549 1.520695500856121e-06 0.672138295335571 1.520695630303834e-06 0.6742883907026684 \
1.520695764169531e-06 0.6764996355878535 1.52069589251393e-06 0.6786115243545502 1.520696017902058e-06 0.6806677490053815 1.520696147367755e-06 0.6827843190971332 \
1.52069627834897e-06 0.6849171426143115 1.520696426722072e-06 0.6873221141612875 1.520696534784827e-06 0.6890667486235877 1.5206966633165e-06 0.6911333958680312 \
1.520696798756283e-06 0.6933004139195943 1.520696923690607e-06 0.6952876996714908 1.520697049447875e-06 0.6972799977491608 1.520697155963766e-06 0.6989584331773744 \
1.520697273081655e-06 0.7007929859467624 1.520697391621401e-06 0.7026383448210159 1.520697514924798e-06 0.704545102273978 1.520697618097696e-06 0.7061304255463237 \
1.520697769068859e-06 0.7084341141567283 1.520697885323065e-06 0.7101955266062138 1.520698015883454e-06 0.7121605601685687 1.520698134445982e-06 0.7139335830373704 \
1.520698240519852e-06 0.7155108922888329 1.520698340544791e-06 0.716990346352101 1.520698477870007e-06 0.719009255813789 1.520698596531362e-06 0.7207429633399333 \
1.520698718230586e-06 0.7225107522614664 1.520698843413151e-06 0.7243181860083944 1.520698965432965e-06 0.7260693242762759 1.520699093464719e-06 0.7278954552757622 \
1.520699217946458e-06 0.7296603419865877 1.520699346245781e-06 0.7314685590147565 1.520699473339584e-06 0.7332489547570846 1.520699599364423e-06 0.7350034830462163 \
1.52069970210311e-06 0.7364262918236342 1.520699816775856e-06 0.7380063527755659 1.520699898181918e-06 0.7391232259175492 1.520700017381438e-06 0.7407496908814458 \
1.520700110023778e-06 0.7420059782745783 1.520700248182835e-06 0.7438668850244906 1.520700379238334e-06 0.7456179978167152 1.520700509370502e-06 0.7473439783685625 \
1.520700614344577e-06 0.7487266533969134 1.520700753484419e-06 0.7505456565005918 1.520700907428719e-06 0.7525407731682957 1.520701029372999e-06 0.7541080835708853 \
1.520701176919359e-06 0.7559892974429111 1.520701298924537e-06 0.7575320275232224 1.520701447624467e-06 0.7593968175435225 1.520701581671092e-06 0.7610632318338031 \
1.520701703924347e-06 0.7625711443351471 1.520701816790257e-06 0.763953046884334 1.520701959641225e-06 0.7656882893306027 1.520702086364119e-06 0.7672149413549471 \
1.520702202168994e-06 0.7685995877768005 1.520702331910823e-06 0.7701390587657672 1.520702447649211e-06 0.7715019052061673 1.520702570601637e-06 0.7729391548276606 \
1.520702688317297e-06 0.7743051053122872 1.520702794287273e-06 0.7755262985206828 1.520702910698467e-06 0.7768586864857919 1.5207030173164e-06 0.7780703956921795 \
1.52070312951512e-06 0.7793369495935717 1.52070321618369e-06 0.7803089322889447 1.520703319569181e-06 0.7814603789665585 1.520703432733433e-06 0.7827108149434853 \
1.520703538380716e-06 0.783868819044773 1.520703647720273e-06 0.7850578567336689 1.520703754897288e-06 0.786214126597127 1.520703884303365e-06 0.7875981444497275 \
1.52070399672075e-06 0.7887899291890393 1.52070412010849e-06 0.7900869036018625 1.520704237558825e-06 0.7913106402786101 1.520704381085744e-06 0.7927918312347375 \
1.520704496005322e-06 0.7939667362870242 1.520704634727735e-06 0.7953719780830618 1.520704772759875e-06 0.7967562205547866 1.52070488225303e-06 0.7978444364842524 \
1.520704983271459e-06 0.7988406866985471 1.52070508435942e-06 0.7998302780396641 1.520705216746616e-06 0.8011146558616069 1.520705335472037e-06 0.8022550163876687 \
1.520705457256542e-06 0.8034134048507504 1.520705576346336e-06 0.8045351524060473 1.520705697550853e-06 0.8056657048884367 1.520705829194664e-06 0.8068811249615274 \
1.520705952212703e-06 0.8080052413861453 1.520706079823023e-06 0.8091594649786741 1.520706210891683e-06 0.8103325925767672 1.520706334212046e-06 0.8114249716726942 \
1.52070644213631e-06 0.8123719892944993 1.520706549931703e-06 0.8133095350680949 1.520706631652631e-06 0.8140147772069938 1.520706748520247e-06 0.815015186305849 \
1.520706839581256e-06 0.8157880755829442 1.520706973749887e-06 0.8169164295805346 1.52070711832076e-06 0.8181184617099191 1.520707251823127e-06 0.8192158725965917 \
1.520707361789037e-06 0.8201107352847025 1.520707505654698e-06 0.8212684563313245 1.520707658960262e-06 0.8224861772268215 1.520707786698555e-06 0.8234883060891934 \
1.520707927340891e-06 0.8245786478120171 1.520708053124456e-06 0.8255423809867173 1.520708207742427e-06 0.8267124309768116 1.520708340154194e-06 0.8277017767197102 \
1.520708466433798e-06 0.8286345641820314 1.520708584064113e-06 0.8294941055817234 1.520708732230976e-06 0.8305638349826423 1.520708899375221e-06 0.8317531470681401 \
1.520709031993881e-06 0.832683775428688 1.520709204938569e-06 0.8338803479528284 1.520709373325224e-06 0.8350269493631071 1.520709542859754e-06 0.8361634673386688 \
1.520709724228909e-06 0.8373596561587384 1.520709866861491e-06 0.8382862741713709 1.52070998079734e-06 0.8390176620397163 1.520710111571134e-06 0.8398476357987267 \
1.520710213225074e-06 0.8404856735008092 1.520710329718803e-06 0.8412091703399448 1.520710465236349e-06 0.8420405885319162 1.520710662580143e-06 0.8432318270427018 \
1.520710853245141e-06 0.8443612543037786 1.52071106310198e-06 0.8455804035625291 1.520711244039104e-06 0.8466117334714958 1.520711441374591e-06 0.8477160230260256 \
1.520711615161427e-06 0.8486711109012058 1.520711797742881e-06 0.8496572451898022 1.520711969062461e-06 0.850566499179887 1.520712143447507e-06 0.8514760798656241 \
1.520712318831052e-06 0.8523748177975867 1.520712495063209e-06 0.8532619682996843 1.520712684901452e-06 0.8542000584728613 1.520712875637665e-06 0.8551245802328369 \
1.520713077434399e-06 0.856083442102113 1.520713270127775e-06 0.8569809170305027 1.520713479756076e-06 0.857937542729613 1.52071370919384e-06 0.8589615588718806 \
1.52071397499048e-06 0.8601183337444025 1.520714273565708e-06 0.8613802063570262 1.520714551467221e-06 0.8625196921548358 1.520714835677695e-06 0.8636511027355716 \
1.520715110089482e-06 0.8647118800460076 1.520715382252364e-06 0.8657341977214618 1.520715652421456e-06 0.8667205537246333 1.520715909616139e-06 0.8676338760342862 \
1.52071618215581e-06 0.868575115807136 1.520716458190291e-06 0.8695013130444248 1.520716728342986e-06 0.8703818891200001 1.520717028049788e-06 0.8713292845176382 \
1.520717398867258e-06 0.8724597217497643 1.520717693785921e-06 0.8733269024855727 1.520717948030199e-06 0.8740525764960509 1.520718246254198e-06 0.8748787854419284 \
1.520718519878969e-06 0.8756137195941651 1.520718756017959e-06 0.8762307200963571 1.520718996373686e-06 0.8768427579093606 1.520719218719338e-06 0.8773949085683344 \
1.520719412723072e-06 0.877865919014753 1.520719742447196e-06 0.878644045115768 1.520719897619855e-06 0.8790007149587372 1.520720215373248e-06 0.879712598742095 \
1.520720394238605e-06 0.8801026384247937 1.520720736700093e-06 0.8808283583858193 1.520720920841293e-06 0.8812073588304842 1.520721395746114e-06 0.8821499412898334 \
1.520721563140601e-06 0.8824705695712217 1.520722028971889e-06 0.8833323038036038 1.520722209796771e-06 0.8836551183393088 1.520722703830028e-06 0.8845051821644966 \
1.520722845172603e-06 0.8847400410050358 1.520723451563118e-06 0.8857071861637142 1.520723603635685e-06 0.8859397703602404 1.520724250313758e-06 0.8868873789663725 \
1.520724378610247e-06 0.8870678433440622 1.520725026723245e-06 0.8879435266410994 1.520725156528523e-06 0.8881118897635528 1.520725934785608e-06 0.8890711781604964 \
1.520726049780423e-06 0.8892053868933587 1.520726905511062e-06 0.8901454611437621 1.520727050777629e-06 0.8902951528450479 1.520728036533732e-06 0.8912364417375994 \
1.520728257640946e-06 0.8914302300078862 1.520729402752027e-06 0.892358484239638 1.520729533960174e-06 0.8924604119362172 1.520730875263369e-06 0.8934531785430913 \
1.52073102665103e-06 0.8935579568409697 1.520732508109867e-06 0.8944876667405802 1.520732746990229e-06 0.894621531696939 1.520734516461986e-06 0.8954958910368339 \
1.520734905568823e-06 0.8956641700186337 1.520737299334232e-06 0.8965498195158238 1.520737774894223e-06 0.8966991754584082 1.520741837950387e-06 0.8976977719002629 \
1.520742329424408e-06 0.8977905759376156 1.520750645951487e-06 0.8987839664765119 1.520751565805377e-06 0.8988472044554419 1.520877770945903e-06 0.8998441026240215 \
1.520878784754255e-06 0.8998514601858095 1.521070497347411e-06 0.8990059056521554 1.521070727348974e-06 0.8988405173838494 1.521072342221535e-06 0.8978439928078279 \
1.521072519935389e-06 0.8977495532019018 1.521089285710428e-06 0.8987316330193963 1.521089421698825e-06 0.8987497732072308 1.521104884427938e-06 0.8997471920221268 \
1.52110515229253e-06 0.8997526389354535 1.521588977619798e-06 0.9006560548284696 1.521589098408999e-06 0.9007687033315858 1.521589886180037e-06 0.9017381658104292 \
1.521590020318756e-06 0.901943163319478 1.52159051393353e-06 0.9027850367016239 1.521590658833145e-06 0.9030569221572713 1.52159105464053e-06 0.9038490360455199 \
1.521591174436184e-06 0.9041001886668685 1.521591558609717e-06 0.9049189780371781 1.521591670731365e-06 0.9051556495331843 1.521592178052336e-06 0.9061253139956988 \
1.521592272051192e-06 0.90626859229291 1.521593430700898e-06 0.9055667778886739 1.521593533663832e-06 0.9051589876696525 1.521593617506701e-06 0.9047707260375384 \
1.521593751246752e-06 0.9040404158978201 1.521593851964133e-06 0.9033957423200318 1.521593959579919e-06 0.9026166239542108 1.521594077153173e-06 0.9016533104038295 \
1.521594165418223e-06 0.90085556431878 1.521594285051691e-06 0.8996698288011099 1.521594382373389e-06 0.8986166602050341 1.521594493390828e-06 0.8973222354192386 \
1.521594595500415e-06 0.8960407982554908 1.521594678931815e-06 0.8949326975987755 1.521594783112883e-06 0.8934749428758865 1.521594874199646e-06 0.8921321265381427 \
1.521594966740432e-06 0.8907058396397178 1.52159506189443e-06 0.8891776325191247 1.521595176449407e-06 0.88725933118288 1.521595265292509e-06 0.8857137884271823 \
1.521595363531691e-06 0.8839502506198179 1.521595448901865e-06 0.8823735982707064 1.521595529802107e-06 0.8808434949738935 1.5215956027634e-06 0.8794355441897157 \
1.521595669782045e-06 0.8781198554636557 1.521595738393124e-06 0.8767515715160701 1.521595821888036e-06 0.8750591081124355 1.521595884015366e-06 0.8737811510706814 \
1.521595946997964e-06 0.8724704924326797 1.521596042153715e-06 0.8704632161180945 1.521596142764353e-06 0.8683077530860182 1.521596222643545e-06 0.8665738309361769 \
1.521596306905814e-06 0.8647250601592834 1.521596386016074e-06 0.8629723295901451 1.521596448831519e-06 0.8615696597604833 1.521596536288554e-06 0.8596016864744445 \
1.521596602182084e-06 0.8581079708060287 1.521596670243627e-06 0.856556281928966 1.521596719556134e-06 0.8554267461646872 1.521596774792924e-06 0.85415654045335 \
1.521596815532529e-06 0.8532164928603474 1.521596861834283e-06 0.8521450198670055 1.521596892048343e-06 0.8514441160591502 1.521596921089625e-06 0.8507691938976955 \
1.52159695172822e-06 0.8500558939662993 1.52159701300541e-06 0.8486254874746039 1.521597066077972e-06 0.8473828229799116 1.521597119733165e-06 0.8461232012188223 \
1.521597182390447e-06 0.8446482873934593 1.521597245673395e-06 0.8431545995644786 1.521597336171269e-06 0.8410121009440262 1.521597433169049e-06 0.8387078554355326 \
1.52159751614655e-06 0.8367307351423475 1.521597598150905e-06 0.8347721678896715 1.521597687219307e-06 0.8326403548070889 1.521597771732643e-06 0.8306135893189693 \
1.521597862591523e-06 0.8284303722590877 1.521597954526378e-06 0.8262176456275642 1.521598056957308e-06 0.8237486178045141 1.52159815707534e-06 0.8213320995840899 \
1.521598271896223e-06 0.8185572053828121 1.52159838410276e-06 0.8158423448209959 1.521598509096305e-06 0.8128151787794674 1.521598640356713e-06 0.8096337870015397 \
1.521598785627755e-06 0.8061104108175116 1.521598940135368e-06 0.8023613213197434 1.521599111575989e-06 0.7981999722344618 1.521599275625781e-06 0.794217661721315 \
1.521599460041203e-06 0.7897413884478564 1.521599666533577e-06 0.7847307375046715 1.52159985602742e-06 0.7801344622909899 1.521600049421183e-06 0.775444374634302 \
1.521600249988037e-06 0.7705834242206392 1.521600397552439e-06 0.7670092004965298 1.52160052756389e-06 0.7638619034739171 1.521600662428303e-06 0.7605987503374771 \
1.521600768918754e-06 0.7580234999254772 1.521600900608547e-06 0.7548403390839162 1.521601007032976e-06 0.7522693550468039 1.521601150211605e-06 0.7488125398635642 \
1.521601311338716e-06 0.7449250928176189 1.521601429565533e-06 0.7420746008290786 1.521601599798354e-06 0.7379721584775248 1.521601765724623e-06 0.7339761998059781 \
1.521601985266954e-06 0.7286940862104242 1.521602178454078e-06 0.724050920820232 1.521602353368041e-06 0.719851304223293 1.521602520315139e-06 0.7158476177432674 \
1.5216027078061e-06 0.711355754450834 1.521602895234537e-06 0.7068709122373377 1.521603063571096e-06 0.7028473835914892 1.52160325640163e-06 0.6982428782038785 \
1.521603396451378e-06 0.694901318858167 1.521603552708666e-06 0.6911769338170629 1.521603746878113e-06 0.6865540563080536 1.521603905984602e-06 0.6827702245679255 \
1.521604064344632e-06 0.679008548037742 1.52160425966174e-06 0.6743756772263459 1.521604470090519e-06 0.6693917663527935 1.521604722792665e-06 0.6634173774538097 \
1.521604902460615e-06 0.6591769455535931 1.521605154037489e-06 0.6532475027332399 1.521605354410306e-06 0.6485340174553987 1.521605526064158e-06 0.6445032789616798 \
1.521605684756275e-06 0.6407814961122935 1.521605823964202e-06 0.637522316374186 1.521605960288252e-06 0.6343349641335875 1.521606087501276e-06 0.6313646237382058 \
1.521606216993834e-06 0.6283457899522861 1.521606344985121e-06 0.6253646753452949 1.52160647605963e-06 0.6223174651643489 1.521606606771705e-06 0.6192830747181834 \
1.521606749379757e-06 0.6159760732208495 1.521606892103236e-06 0.612672916206165 1.521607044651037e-06 0.6091471600588 1.521607189155024e-06 0.6058158037532523 \
1.521607353173272e-06 0.6020406322262999 1.521607490637933e-06 0.5988837056407329 1.521607625454949e-06 0.5957940466067043 1.521607746953592e-06 0.5930134750293682 \
1.521607885803897e-06 0.5898448108574432 1.521607999450713e-06 0.5872554148224447 1.521608150860885e-06 0.5838116422847746 1.52160826457956e-06 0.5812320812748947 \
1.521608383992651e-06 0.5785269636915771 1.521608472673178e-06 0.5765205397309219 1.521608563818269e-06 0.5744630259469776 1.521608629157145e-06 0.5729901393713442 \
1.521608693626847e-06 0.5715377831648228 1.521608744447459e-06 0.5703933076453638 1.521608803422398e-06 0.569066051987989 1.521608870867106e-06 0.5675516747474645 \
1.521608937959298e-06 0.5660472084764079 1.521608990879742e-06 0.5648615894615425 1.521609086527225e-06 0.5627204246953637 1.521609143708362e-06 0.5614413394337 \
1.521609197510977e-06 0.5602399192081799 1.521609259253082e-06 0.5588634520375642 1.521609345086214e-06 0.5569525037715509 1.521609427781862e-06 0.5551133137453282 \
1.521609553910589e-06 0.552313430559463 1.521609689009665e-06 0.5493247407981657 1.521609787329828e-06 0.5471534914294828 1.52160989990789e-06 0.5446716589975775 \
1.521610002452305e-06 0.5424173856211837 1.521610122561131e-06 0.5397821662853191 1.521610224248782e-06 0.5375541863492928 1.521610339752746e-06 0.5350300289250629 \
1.521610454643861e-06 0.5325260225312031 1.521610581121134e-06 0.5297740207092871 1.52161070633833e-06 0.5270565158317848 1.521610853184312e-06 0.5238798967507053 \
1.521610988642446e-06 0.5209557060405445 1.521611146203055e-06 0.5175672114705414 1.521611308357229e-06 0.5140875588169389 1.521611489068307e-06 0.5102248342695275 \
1.52161168131606e-06 0.5061308236654174 1.521611894038323e-06 0.5016182665703952 1.521612125943484e-06 0.4967183500883584 1.521612383137188e-06 0.4913135654247419 \
1.521612622690498e-06 0.4863004534671564 1.521612924620373e-06 0.4800178499336004 1.521613212386814e-06 0.4740665530855001 1.521613525189057e-06 0.4676409412178996 \
1.521613845020806e-06 0.4611139840073785 1.521614184657409e-06 0.4542292677834274 1.521614511873228e-06 0.4476411633207955 1.521614847034797e-06 0.4409363684817221 \
1.521615164291458e-06 0.4346351592989786 1.521615498111436e-06 0.4280489847791872 1.52161584979678e-06 0.4211625252737479 1.521616163864498e-06 0.4150547397555842 \
1.521616486893702e-06 0.4088175946446666 1.521616927873099e-06 0.4003732788922496 1.521617270275942e-06 0.3938810608698495 1.52161757072383e-06 0.3882325136127223 \
1.521617946053401e-06 0.3812375944419973 1.52161827612863e-06 0.3751439175705365 1.521618559406411e-06 0.3699597784791666 1.521618859913772e-06 0.3645020109013299 \
1.521619139561233e-06 0.3594637112692664 1.521619363423524e-06 0.3554634414471464 1.521619575274513e-06 0.35170280677964 1.521619777623113e-06 0.3481338771034005 \
1.521619978758139e-06 0.3446120049995081 1.521620184535657e-06 0.3410324794262659 1.521620445514371e-06 0.3365252478245505 1.521620685004553e-06 0.3324209773202946 \
1.521620917679624e-06 0.3284665339262754 1.521621131761216e-06 0.3248537323113044 1.521621352906983e-06 0.3211475567840967 1.521621553789873e-06 0.3178053707831449 \
1.521621757181075e-06 0.3144500223650613 1.521621954849487e-06 0.3112139453100684 1.521622141093175e-06 0.3081862077816076 1.521622336074257e-06 0.3050391973134606 \
1.521622539536502e-06 0.3017803754370622 1.521622717477408e-06 0.2989521325826759 1.521622953201112e-06 0.2952356640875101 1.521623151333966e-06 0.2921385263640672 \
1.521623352678033e-06 0.2890160050544278 1.52162357696723e-06 0.2855690750291008 1.521623741897129e-06 0.2830551950838826 1.521623919525814e-06 0.2803657404651576 \
1.521624103924961e-06 0.2775946687427531 1.521624287746306e-06 0.2748547260732712 1.521624466202979e-06 0.2722194282383935 1.521624638103246e-06 0.2696976713509589 \
1.521624798643653e-06 0.2673699088296289 1.521624920125711e-06 0.265617282026588 1.521625073047239e-06 0.2634201198254058 1.521625200480934e-06 0.2616085083773952 \
1.521625304654605e-06 0.2601317890528609 1.521625421559082e-06 0.2584775571399547 1.521625536570573e-06 0.2568557450124987 1.521625660932803e-06 0.2551103168403305 \
1.521625776507087e-06 0.2534925198640895 1.521625910614607e-06 0.2516172680784447 1.521626025601848e-06 0.2500177396912131 1.521626179351445e-06 0.2478798443778067 \
1.521626316154646e-06 0.2459790966208961 1.521626450740453e-06 0.2441094379339017 1.521626606604589e-06 0.2419575875351012 1.521626731253411e-06 0.2402378086535915 \
1.521626870468935e-06 0.2383186229544463 1.52162700069296e-06 0.236525770455347 1.521627121045801e-06 0.2348769158236033 1.521627256439084e-06 0.233027137746051 \
1.521627407644063e-06 0.2309620730808924 1.521627542400533e-06 0.2291249940296414 1.52162764708672e-06 0.2277003186426776 1.521627769622861e-06 0.2260366668203369 \
1.52162790456742e-06 0.2242086518061946 1.521627999683167e-06 0.2229209267876512 1.521628114943222e-06 0.2213657311907907 1.521628197476202e-06 0.2202562617028589 \
1.521628268681533e-06 0.2192992955643472 1.521628317389017e-06 0.2186449771734718 1.521628364583973e-06 0.2180112263680214 1.521628411132791e-06 0.2173864029843717 \
1.521628464521355e-06 0.2166701476649976 1.521628501898025e-06 0.2161690444847812 1.521628539283138e-06 0.2156680710113931 1.521628579604508e-06 0.2151283464800275 \
1.521628650854647e-06 0.2141753141901174 1.521628685068904e-06 0.2137180869447317 1.521628731463535e-06 0.2131018213873352 1.521628791907201e-06 0.2122998083652294 \
1.52162886091012e-06 0.2113853596849882 1.521628926205072e-06 0.210520730631805 1.521628994183195e-06 0.2096212333552783 1.521629110629525e-06 0.2080823984153433 \
1.521629200551714e-06 0.2068957989735914 1.52162930821762e-06 0.2054771097790837 1.521629404278935e-06 0.2042146625011118 1.521629507657509e-06 0.2028641889872041 \
1.521629604342544e-06 0.2016026287683381 1.521629707152397e-06 0.2002625524503448 1.521629807912368e-06 0.1989526210414513 1.521629919058035e-06 0.1975116692735505 \
1.521630026097528e-06 0.1961279675313261 1.521630144004064e-06 0.1946083430154048 1.521630252114387e-06 0.1932197128021231 1.521630361412988e-06 0.1918224631760269 \
1.521630482044739e-06 0.1902849927564414 1.521630576945331e-06 0.1890796997295432 1.52163070550625e-06 0.18745262875399 1.521630798541038e-06 0.1862801166370808 \
1.521630900937595e-06 0.1849947785893032 1.521630988904886e-06 0.1838942174288659 1.521631087175557e-06 0.182668828510528 1.521631183776179e-06 0.1814691026470878 \
1.521631270414692e-06 0.1803971466393716 1.521631356823704e-06 0.1793305247657973 1.521631452660814e-06 0.1781527189679156 1.521631557387688e-06 0.1768710765218302 \
1.521631703199975e-06 0.1750963017969037 1.521631819167907e-06 0.1736923427161618 1.521631975631711e-06 0.1718092975148396 1.52163208681163e-06 0.1704786474822015 \
1.521632227061631e-06 0.1688098560703619 1.521632350073035e-06 0.1673544160765056 1.521632456564033e-06 0.1661007559767333 1.521632552889492e-06 0.1649724583647661 \
1.521632650322958e-06 0.1638357962207703 1.521632754176237e-06 0.1626293386330815 1.52163284597681e-06 0.1615673458739011 1.521632944364525e-06 0.1604337426303964 \
1.52163302728317e-06 0.1594828374885931 1.521633122651503e-06 0.1583950132920943 1.521633205213852e-06 0.1574587876231885 1.521633307798537e-06 0.1563016192679324 \
1.521633384076854e-06 0.1554454316211293 1.521633472662479e-06 0.1544557264474612 1.521633544831984e-06 0.1536532700165102 1.521633626541473e-06 0.1527486200895024 \
1.521633700220281e-06 0.1519363404455653 1.521633780440409e-06 0.1510573496788611 1.521633852168484e-06 0.1502755532525617 1.521633920425463e-06 0.149534520573691 \
1.521634018141422e-06 0.1484788062294206 1.521634087591606e-06 0.147731872792437 1.521634170343085e-06 0.1468455801890639 1.521634230379995e-06 0.1462052652532956 \
1.521634300618659e-06 0.1454587420502366 1.521634372046193e-06 0.1447037411390827 1.521634452559695e-06 0.1438588888651768 1.521634515822599e-06 0.1431977449412327 \
1.521634593496578e-06 0.1423892845091393 1.521634682806343e-06 0.141463758692191 1.521634752169929e-06 0.1407479403162204 1.521634850118149e-06 0.1397418416088305 \
1.521634940462669e-06 0.1388188591118084 1.521635026242994e-06 0.1379520826379384 1.521635093896779e-06 0.1372719511642241 1.521635160204629e-06 0.1366075914250998 \
1.521635238824321e-06 0.1358227655030745 1.52163531951923e-06 0.135020537018139 1.521635377921894e-06 0.1344419857224206 1.521635438674417e-06 0.1338420332148588 \
1.521635532580729e-06 0.1329184183639811 1.521635574978232e-06 0.1325029080242558 1.521635654222426e-06 0.1317336600863391 1.521635694592585e-06 0.1313430593815061 \
1.521635784293463e-06 0.130477658168832 1.52163582324155e-06 0.1301029732927899 1.521635918857236e-06 0.1291862249441596 1.521635957741065e-06 0.1288146335111444 \
1.521636050975841e-06 0.1279263274670414 1.52163611931843e-06 0.1272775968534341 1.521636171639285e-06 0.1267823325594629 1.521636253739999e-06 0.1260075984242486 \
1.521636324903378e-06 0.1253406747583812 1.521636402856366e-06 0.1246136378429537 1.521636481976102e-06 0.1238779526756392 1.521636560619333e-06 0.1231489004754178 \
1.521636640654242e-06 0.122409328367501 1.521636702388658e-06 0.1218405706457005 1.52163677598364e-06 0.1211645344030958 1.521636859363458e-06 0.120401093559758 \
1.521636923460189e-06 0.1198161795466899 1.521636992898777e-06 0.119184869057559 1.521637065921715e-06 0.1185234239195788 1.521637150796627e-06 0.1177582144838446 \
1.521637230159478e-06 0.117046673033812 1.521637314893136e-06 0.1162898833629492 1.521637405604425e-06 0.1154830714735263 1.521637481187504e-06 0.1148135241260771 \
1.521637546915428e-06 0.1142333070693714 1.521637606975201e-06 0.1137047561823949 1.521637676580917e-06 0.1130943456353956 1.521637742999968e-06 0.1125141752866663 \
1.521637822411231e-06 0.1118230150855203 1.521637912674161e-06 0.1110406875128299 1.521637981718461e-06 0.1104447270551955 1.52163805627358e-06 0.1098035355921305 \
1.521638144757501e-06 0.1090456469739195 1.521638223865648e-06 0.1083709350695736 1.521638293734029e-06 0.1077773127978274 1.521638374743399e-06 0.1070920034756896 \
1.521638430948213e-06 0.106618206733547 1.521638493607492e-06 0.1060916009495399 1.521638558754098e-06 0.105545887371837 1.521638630089726e-06 0.1049504956797945 \
1.521638750386101e-06 0.1039516085561449 1.521638801939674e-06 0.103525508500865 1.521638857088742e-06 0.1030709598036589 1.521638947785926e-06 0.1023262935955709 \
1.521639030175778e-06 0.1016530765296615 1.521639125755585e-06 0.1008759670630478 1.521639232965152e-06 0.1000092507657299 1.521639336624558e-06 0.09917656019160864 \
1.521639422832161e-06 0.09848810438956324 1.521639509074386e-06 0.09780303991321163 1.52163958861546e-06 0.09717448010577609 1.521639668628333e-06 0.09654538840876434 \
1.521639759916661e-06 0.09583163072761708 1.521639841662079e-06 0.09519620281310773 1.521639930588917e-06 0.09450872319168514 1.521640020366224e-06 0.09381864801001834 \
1.521640097328872e-06 0.09323024625953365 1.521640187653689e-06 0.0925435244861572 1.521640251462415e-06 0.09206084550525626 1.521640323925983e-06 0.09151514907748673 \
1.521640388054635e-06 0.09103438864950099 1.521640466302011e-06 0.09045054736970405 1.521640566003292e-06 0.08971110930136832 1.521640640056444e-06 0.08916512281998501 \
1.521640726664979e-06 0.08852997392441805 1.521640872964685e-06 0.08746544055362569 1.521640983676948e-06 0.08666684197409438 1.521641093986626e-06 0.08587717033461532 \
1.521641236182269e-06 0.08486839672072237 1.52164137623472e-06 0.08388450488753585 1.521641518880534e-06 0.08289222299161547 1.521641667651249e-06 0.08186778387581196 \
1.521641804363935e-06 0.08093569403044946 1.521641946484565e-06 0.07997640434545976 1.521642081061545e-06 0.07907728405019222 1.521642221281423e-06 0.07814997945867638 \
1.521642369028229e-06 0.07718353387841098 1.521642518982415e-06 0.07621348085094087 1.521642683698247e-06 0.07516037195605636 1.521642847284363e-06 0.07412732798506308 \
1.521643021932716e-06 0.07303837372665309 1.521643208986408e-06 0.07188781219077654 1.521643418972926e-06 0.0706159374129187 1.521643637046174e-06 0.06931715807027321 \
1.521643870366327e-06 0.06795188046253516 1.521644124845882e-06 0.0664909822812602 1.52164441780254e-06 0.06484528303377844 1.521644719953089e-06 0.06318745987130532 \
1.521645057674792e-06 0.06138078634948794 1.521645452783393e-06 0.05932807220464856 1.521645820234636e-06 0.05747953410674719 1.521646237842402e-06 0.05544691527644593 \
1.521646582838376e-06 0.0538196438399016 1.521646933380665e-06 0.05221302159193914 1.521647248341029e-06 0.0508087490907442 1.521647547582395e-06 0.049508488261462 \
1.521647846948248e-06 0.04824029756235761 1.521648122190958e-06 0.04710512226277328 1.521648405654524e-06 0.04596497870754415 1.521648667254946e-06 0.04493681260994405 \
1.521648944707071e-06 0.04387103439794762 1.521649220766506e-06 0.04283531238677037 1.521649529036243e-06 0.04170718945545093 1.521649751468863e-06 0.0409114719535993 \
1.521650039009947e-06 0.03990505631995635 1.52165027524288e-06 0.0390969788355163 1.521650593704555e-06 0.03803800466874574 1.521650844115589e-06 0.03722710566490722 \
1.521651167100391e-06 0.03620720400565681 1.521651425436406e-06 0.03541203096995557 1.521651715410285e-06 0.03454066075983582 1.521651945205103e-06 0.0338658635512188 \
1.521652230100444e-06 0.03304787219836024 1.521652469846563e-06 0.03237513696606491 1.521652710481132e-06 0.03171392889024889 1.521652949599619e-06 0.03107212555077287 \
1.52165318553853e-06 0.03045460689686571 1.521653416367391e-06 0.02986254663395104 1.521653631393919e-06 0.02932175456294728 1.52165403355976e-06 0.0283374222946415 \
1.52165423211788e-06 0.02786401170979088 1.521654605819066e-06 0.02699470773596776 1.521654792632261e-06 0.02657042318767052 1.521655138633508e-06 0.02580176906824739 \
1.521655260576946e-06 0.02553595448027303 1.521655643429963e-06 0.02472011952872977 1.521655803864149e-06 0.02438657631284594 1.521656246865303e-06 0.02348572425118655 \
1.521656417479345e-06 0.02314627247835563 1.521656738055941e-06 0.02251902970747987 1.521656938340868e-06 0.0221336684630111 1.521657385278801e-06 0.02128811173678137 \
1.521657513222917e-06 0.02104854104185888 1.521658001100276e-06 0.02014826272243131 1.521658136077553e-06 0.01990454278080647 1.521658618329071e-06 0.0190640092473091 \
1.521658780655186e-06 0.01879235028057063 1.521659267049527e-06 0.01801148170254873 1.521659430077186e-06 0.01776103207540622 1.521660110298877e-06 0.01676849304257711 \
1.521660249382614e-06 0.01657541006259178 1.521660981877148e-06 0.01560782569993242 1.52166114077078e-06 0.01540693214221847 1.521661923851867e-06 0.01445869962397344 \
1.521662069644422e-06 0.01428952172302696 1.521662920425781e-06 0.01334248985256295 1.521663031529053e-06 0.01322388191882306 1.521663964823417e-06 0.0122699293983148 \
1.521664098661466e-06 0.01213902814618388 1.521665057199482e-06 0.01123495036716388 1.521665178316551e-06 0.01112486091825863 1.521666300400349e-06 0.01017270671243764 \
1.521666405901602e-06 0.01008921053061839 1.521667734976014e-06 0.009112307258623473 1.521667855180288e-06 0.009029744095492466 1.521669403542048e-06 0.008036808760534916 \
1.521669484329818e-06 0.007986285493236449 1.521671055209352e-06 0.007024564730313319 1.521671122625551e-06 0.006986095570813155 1.52167304339223e-06 0.006001386377072119 \
1.521673230194113e-06 0.005914747648762168 1.52167554560806e-06 0.0049318160947762 1.521675945134907e-06 0.004777795182599986 1.521678508944408e-06 0.003889929704329555 \
1.521679007815328e-06 0.003736330440833864 1.521682637539317e-06 0.002784984367379526 1.521683188233292e-06 0.002663729254427667 1.521688586673671e-06 0.001711392372544448 \
1.521688899941243e-06 0.001662511220227468 1.521693892233791e-06 0.0006970413096974805 1.521694076252826e-06 0.0006571176749162138 1.52434255539561e-06 -0.0002691198397987355 \
1.524342711454572e-06 -0.0004551674219448388 1.524343259438427e-06 -0.001322174727784445 1.52434337237642e-06 -0.001539785040943742 1.52434380163135e-06 -0.002474302920374066 \
1.524343907888515e-06 -0.002730173903076456 1.524344190690667e-06 -0.003454402452283872 1.52434430428521e-06 -0.003760966378165151 1.524344642839789e-06 -0.004705104513819927 \
1.52434475526375e-06 -0.005021586953003071 1.524345083541651e-06 -0.005887841248467669 1.524345191080172e-06 -0.006130875888161453 1.524346071006203e-06 -0.005789627805322099 \
1.52434624621225e-06 -0.004910736584223327 1.524346363043013e-06 -0.004127745010746014 1.524346489910137e-06 -0.00309221842859156 1.524346591442863e-06 -0.002125750314016509 \
1.524346712864133e-06 -0.0008095618968406578 1.524346803029046e-06 0.0002767910803854594 1.524346900212696e-06 0.001550247908954045 1.52434699828696e-06 0.002938803805678211 \
1.524347165508045e-06 0.005530627736217106 1.524347387813323e-06 0.009378371294171852 1.524347573551714e-06 0.01290572951649239 1.524347797633049e-06 0.01747895571448658 \
1.524347957277782e-06 0.02091945933227325 1.524348121767111e-06 0.02459614091902196 1.524348271591569e-06 0.0280452875125503 1.524348420991461e-06 0.03156498790849799 \
1.524348570522767e-06 0.03515592969144176 1.524348724602661e-06 0.03891669635189081 1.524348886786809e-06 0.0429309674228065 1.524349053210035e-06 0.0470989728378523 \
1.524349229143508e-06 0.05154884981278444 1.524349410271779e-06 0.05616867911875007 1.524349602402705e-06 0.06110225049351239 1.524349810098117e-06 0.0664648391313285 \
1.524350032018198e-06 0.07222051812179281 1.52435026721968e-06 0.07834079218654426 1.524350519405989e-06 0.08491829088081257 1.524350795545224e-06 0.09213111703448683 \
1.524351096666701e-06 0.1000001933597138 1.524351428586562e-06 0.1086702418150647 1.52435180590533e-06 0.1185147411083515 1.524352204195387e-06 0.1288888856248832 \
1.524352673503706e-06 0.1410822143415975 1.524353219529231e-06 0.1552200475789812 1.524353854489538e-06 0.1715918832733369 1.524354553890129e-06 0.1895291194622146 \
1.524355372129055e-06 0.2103807608661494 1.524356277823022e-06 0.2332840710921665 1.524357067334088e-06 0.253091928008631 1.524357771092906e-06 0.2706124241987875 \
1.524358388943719e-06 0.2858796548825839 1.524358954567131e-06 0.2997575097153312 1.524359476302405e-06 0.3124620269501652 1.524359974086121e-06 0.3244932238414255 \
1.524360457724081e-06 0.3360954048923613 1.524360914598215e-06 0.3469667650518959 1.524361387439109e-06 0.3581213589834248 1.524361827052466e-06 0.3684065070151987 \
1.524362314929562e-06 0.379719432411247 1.524362845729985e-06 0.3919028193132517 1.524363343625359e-06 0.4032143644097119 1.524363775002613e-06 0.41292177789323 \
1.524364261889801e-06 0.4237731225600331 1.524364761989243e-06 0.4348012155672935 1.524365106609934e-06 0.4423321287141763 1.524365460003778e-06 0.4500000647748709 \
1.524365887773617e-06 0.4592134948422093 1.524366279634688e-06 0.4675816212925634 1.524366579929045e-06 0.4739471552041949 1.524366921860125e-06 0.4811428413521782 \
1.52436726519457e-06 0.4883132334011818 1.524367525955058e-06 0.4937215836208605 1.524367768011588e-06 0.4987106167174703 1.524368034010056e-06 0.5041617362307154 \
1.524368293498239e-06 0.5094435946950286 1.52436848341454e-06 0.5132872703533161 1.524368698649141e-06 0.5176241792560061 1.5243688371999e-06 0.5204025546691405 \
1.524368982080679e-06 0.5232962183003332 1.524369195494746e-06 0.5275364624051522 1.52436939751936e-06 0.5315382148201082 1.524369590248024e-06 0.5353370730264509 \
1.524369775503404e-06 0.5389735557287745 1.524369952500928e-06 0.5424323215059959 1.524370261764263e-06 0.5484573594957171 1.524370522912311e-06 0.5535233414883098 \
1.524370824731481e-06 0.5593562770234363 1.524371080160122e-06 0.5642781701956761 1.524371372515619e-06 0.5698968483756405 1.524371631969813e-06 0.5748654731717864 \
1.52437190208979e-06 0.5800301911327002 1.524372144100348e-06 0.5846380733684551 1.524372401610146e-06 0.5895273573494454 1.524372628054483e-06 0.5938057549890672 \
1.524372864942966e-06 0.5982619499065401 1.524373074987873e-06 0.6021962733001386 1.524373287918585e-06 0.6061670177072124 1.524373541397282e-06 0.6108668889270118 \
1.524373744692931e-06 0.6146150465592417 1.524373936381114e-06 0.6181346807088086 1.524374125007478e-06 0.6215812235468744 1.524374312325416e-06 0.6249823889551316 \
1.524374517937406e-06 0.6286953279350977 1.524374767760625e-06 0.6331759959753138 1.524374971572403e-06 0.6368063379741715 1.524375179211121e-06 0.6404826298163093 \
1.524375371862737e-06 0.6438748386876914 1.52437561647481e-06 0.6481531432733096 1.524375864373314e-06 0.6524620620600715 1.524376044208219e-06 0.6555644139995785 \
1.524376234982255e-06 0.6588391718544121 1.524376388158437e-06 0.6614554104590837 1.524376559827147e-06 0.6643705886591137 1.524376710293968e-06 0.6669108747194671 \
1.524376846897971e-06 0.6692010654183506 1.524376996338372e-06 0.6716954191563786 1.524377124072523e-06 0.6738189269502312 1.52437726394477e-06 0.6761323074508511 \
1.524377388021905e-06 0.6781756764962316 1.52437751938327e-06 0.6803315871556701 1.524377643554731e-06 0.6823627547057004 1.524377781331592e-06 0.6846081866267727 \
1.524377901575812e-06 0.6865586181592046 1.524378043628417e-06 0.6888545186016138 1.524378143856122e-06 0.6904668682779994 1.524378265160113e-06 0.6924123325129877 \
1.524378356135388e-06 0.6938641504265992 1.524378453518671e-06 0.695411869780077 1.524378550601538e-06 0.6969507228893711 1.524378639884158e-06 0.6983595753378042 \
1.524378737855943e-06 0.699898781449533 1.52437886813103e-06 0.7019319515314388 1.524379021543255e-06 0.7043083163565919 1.524379157109067e-06 0.7063909659299702 \
1.524379301449562e-06 0.708591461371511 1.524379427320445e-06 0.710496752775434 1.524379552347831e-06 0.712376488910674 1.524379666630191e-06 0.7140841686551523 \
1.524379777613335e-06 0.7157331888171029 1.524379877308405e-06 0.7172065512867005 1.524380014352622e-06 0.7192196995505324 1.524380133379835e-06 0.7209572005600779 \
1.524380253677943e-06 0.7227029412191364 1.524380380176863e-06 0.7245276185835638 1.524380504108467e-06 0.7263044524160376 1.5243806283948e-06 0.7280754330070212 \
1.524380754759953e-06 0.7298652243312684 1.524380884571695e-06 0.7316925631262517 1.524381008410214e-06 0.7334254795816325 1.524381141191101e-06 0.735272086289578 \
1.524381242042306e-06 0.7366670415914529 1.524381355233975e-06 0.738224777043618 1.524381442019956e-06 0.7394137384482823 1.524381558645253e-06 0.7410021813026957 \
1.52438164793451e-06 0.7422110784210975 1.524381759111394e-06 0.7437075443329063 1.524381888370158e-06 0.7454347509364776 1.524382002229194e-06 0.7469455276109591 \
1.524382106633406e-06 0.74832188588007 1.524382231000437e-06 0.7499498655229884 1.524382378240616e-06 0.7518616907275563 1.524382498520907e-06 0.753411006437983 \
1.524382614425446e-06 0.7548933175676444 1.52438275450129e-06 0.7566706674475765 1.52438289711296e-06 0.7584645678799224 1.524383015067203e-06 0.7599365027959469 \
1.524383141883712e-06 0.7615071445339606 1.524383282766856e-06 0.7632375905494565 1.524383402560354e-06 0.7646969139886852 1.524383547519211e-06 0.7664484133613445 \
1.524383669077996e-06 0.7679052725436226 1.52438378811749e-06 0.7693214142140735 1.524383909748853e-06 0.7707575700077021 1.524384037717832e-06 0.772256936813787 \
1.524384146933014e-06 0.7735272422640712 1.524384271823892e-06 0.774969549136603 1.524384378939953e-06 0.7761978171588899 1.524384512193147e-06 0.7777146071439789 \
1.524384639296593e-06 0.7791497354387434 1.524384761047568e-06 0.7805132846941326 1.524384877632151e-06 0.7818078758210534 1.524384983459753e-06 0.7829735233300771 \
1.524385122825895e-06 0.7844949153190801 1.524385271897694e-06 0.786105286864636 1.524385419626362e-06 0.7876841235632186 1.52438553893224e-06 0.7889471147195867 \
1.524385672939052e-06 0.7903527806482344 1.524385793365227e-06 0.791604423795974 1.524385934910404e-06 0.7930616786923709 1.524386082336417e-06 0.7945638089648995 \
1.524386206810925e-06 0.7958198087139573 1.524386325854918e-06 0.7970105506108808 1.524386437445202e-06 0.7981174590942314 1.52438654267449e-06 0.7991530841216606 \
1.524386638185594e-06 0.8000862307887144 1.524386774247548e-06 0.8014036057482816 1.524386891123682e-06 0.8025237700417888 1.524387010277354e-06 0.8036549841722296 \
1.524387132589548e-06 0.8048050501807249 1.524387255861622e-06 0.8059526272620129 1.524387382358398e-06 0.8071184350969989 1.524387507861062e-06 0.8082633544790385 \
1.524387638586967e-06 0.8094437311890262 1.524387764154939e-06 0.8105658358439867 1.524387893209803e-06 0.8117072367686948 1.524387999065961e-06 0.8126345588578442 \
1.524388100234836e-06 0.8135133322873783 1.524388194854657e-06 0.8143286754242188 1.52438831913574e-06 0.8153900871385379 1.524388408847426e-06 0.816149614585347 \
1.52438850788495e-06 0.8169816577628611 1.524388645662827e-06 0.8181280288377792 1.524388780198677e-06 0.81923501721715 1.524388888604944e-06 0.8201180631035904 \
1.524389038518447e-06 0.8213254631869725 1.524389189097025e-06 0.8225223201378843 1.52438931459218e-06 0.8235077122548546 1.524389458438707e-06 0.8246238332260477 \
1.524389583021971e-06 0.8255790649890803 1.524389731875191e-06 0.8267066458678887 1.524389868023775e-06 0.827725029289517 1.524389993047602e-06 0.8286494160599757 \
1.524390110754582e-06 0.8295103773055483 1.52439025639358e-06 0.8305630309532103 1.524390422774875e-06 0.8317484146982921 1.524390553358565e-06 0.8326660250626342 \
1.524390726880675e-06 0.8338683097812621 1.524390895002578e-06 0.8350147136930499 1.52439106486518e-06 0.8361549927788252 1.524391245766883e-06 0.8373497079260466 \
1.524391388876165e-06 0.8382806519784776 1.524391502965127e-06 0.839013953006387 1.524391633127604e-06 0.8398410866028793 1.524391734972734e-06 0.8404811280669765 \
1.52439185179894e-06 0.8412075886390841 1.52439198869038e-06 0.8420483852080155 1.524392186497604e-06 0.843243620449199 1.524392378122751e-06 0.8443797466267589 \
1.524392587554618e-06 0.8455974227529048 1.5243927695013e-06 0.8466352798309468 1.524392966630154e-06 0.8477391449715804 1.524393139971014e-06 0.8486924050423899 \
1.524393322979321e-06 0.8496814535024207 1.524393494142356e-06 0.8505903669473519 1.524393668779451e-06 0.851501688465695 1.524393844039281e-06 0.8524001683007644 \
1.52439402018973e-06 0.8532872510191711 1.52439421047003e-06 0.8542278331088334 1.52439440106916e-06 0.8551519386507073 1.524394601692395e-06 0.8561055033533737 \
1.52439479430095e-06 0.8570028516027762 1.524395004981641e-06 0.8579644845832216 1.524395233083109e-06 0.8589827023971403 1.524395498871092e-06 0.860139640227508 \
1.524395797483852e-06 0.8614018215255795 1.524396073772491e-06 0.8625348754565382 1.52439635800901e-06 0.8636666213345715 1.52439663221378e-06 0.8647267940813509 \
1.524396904448638e-06 0.8657495569722869 1.52439717465278e-06 0.8667361702337206 1.524397431808391e-06 0.867649441901348 1.524397704388604e-06 0.8685908808535525 \
1.52439798037489e-06 0.8695169452638583 1.524398250477721e-06 0.870397355937691 1.524398550334798e-06 0.8713451925332844 1.524398921362456e-06 0.8724761722512941 \
1.524399216299767e-06 0.8733433185969293 1.524399470589206e-06 0.8740690226522811 1.52439976884599e-06 0.874895168896023 1.524400042455427e-06 0.8756299040683481 \
1.524400278583914e-06 0.8762466977562872 1.524400518929827e-06 0.8768585021646264 1.524400741263492e-06 0.8774104263690854 1.524400935269169e-06 0.8778812671168952 \
1.524401264991885e-06 0.8786590883967833 1.524401420165319e-06 0.8790156160651978 1.524401737941389e-06 0.8797272612331356 1.524401916803032e-06 0.8801171459162566 \
1.524402259264861e-06 0.8808425821290963 1.524402443393021e-06 0.881221400612852 1.524402918270754e-06 0.8821634994206867 1.524403085666965e-06 0.8824839765989225 \
1.524403551508905e-06 0.8833452998114757 1.524403732330958e-06 0.8836679564577563 1.524404226369383e-06 0.8845176198113115 1.524404367718007e-06 0.8847523712107549 \
1.524404974052072e-06 0.8857188576377059 1.524405126121396e-06 0.8859512996759633 1.524405772809558e-06 0.8868983431897121 1.52440590110417e-06 0.8870786909355212 \
1.524406549221232e-06 0.8879538337624689 1.524406679020295e-06 0.8881220828502663 1.524407457223772e-06 0.8890807033877333 1.524407572278734e-06 0.8892148977954012 \
1.524408427940207e-06 0.8901543051721961 1.524408573301076e-06 0.8903040038307473 1.524409559057127e-06 0.8912446482480114 1.524409780162496e-06 0.8914382978987679 \
1.524410925289423e-06 0.8923659558950503 1.524411056506439e-06 0.8924678262926897 1.524412397715013e-06 0.8934599079028542 1.524412549114272e-06 0.8935646301988298 \
1.524414030551995e-06 0.8944937559627255 1.524414269431373e-06 0.8946275407274444 1.524416038746979e-06 0.8955013787854181 1.524416427898191e-06 0.8956696032899972 \
1.524418821561142e-06 0.8965547188539188 1.52441929727014e-06 0.8967039926079825 1.52442336043021e-06 0.8977020505850396 1.524423851854269e-06 0.8977948037134476 \
1.524432168453822e-06 0.898787348739254 1.52443308835295e-06 0.8988506593152591 1.52457657358348e-06 0.8998476076348748 1.524577692016456e-06 0.8998537475785264 \
1.524782783635956e-06 0.898985773748599 1.524783010725457e-06 0.8988224379910277 1.524784620332255e-06 0.8978282360369357 1.524784797740799e-06 0.8977338482811539 \
1.5248017048891e-06 0.8987315468430059 1.524801814328198e-06 0.8987460089186867 1.524817595049444e-06 0.8997418097871094 1.524817891375339e-06 0.8997476966799167 \
1.525301325027745e-06 0.9007060148833608 1.525301454078085e-06 0.9008313386292994 1.52530210422793e-06 0.9016292186224167 1.525302293723661e-06 0.9019133038041363 \
1.52530279694564e-06 0.9027675859898705 1.525302932418299e-06 0.9030208676018907 1.525303332877016e-06 0.9038195223753869 1.525303464814953e-06 0.9040958310886574 \
1.525303866030017e-06 0.9049509627747726 1.525303964290194e-06 0.9051582028152527 1.525304430164004e-06 0.9060587574877488 1.525304591662727e-06 0.9063060456044927 \
1.52530573567525e-06 0.9055153668657776 1.525305880654596e-06 0.9049059606760256 1.525306059207353e-06 0.9039396653125833 1.525306239402631e-06 0.9027054491383806 \
1.525306382093561e-06 0.9015369228101149 1.525306499253165e-06 0.9004524619440171 1.525306588234525e-06 0.8995505656965809 1.525306679878178e-06 0.8985529714258781 \
1.52530681299011e-06 0.8969831049011855 1.525306906711193e-06 0.8957895978311226 1.525306997850002e-06 0.8945634483845346 1.525307111142313e-06 0.8929516940777753 \
1.525307214251226e-06 0.8913998138690341 1.525307310518406e-06 0.8898830246517148 1.525307429655523e-06 0.8879200664089764 1.525307598240772e-06 0.8849885378698126 \
1.525307760012273e-06 0.8820195265790133 1.525307953231332e-06 0.8782956415026882 1.525308138794443e-06 0.8745571577041361 1.525308349060748e-06 0.8701566079887386 \
1.525308531309788e-06 0.8662213066841463 1.525308716173183e-06 0.8621339172744639 1.52530888885833e-06 0.8582419637438897 1.525309074966403e-06 0.8539816046497358 \
1.525309252782491e-06 0.849858603441091 1.525309433499072e-06 0.8456251963850057 1.525309598637331e-06 0.8417258760277182 1.525309763911433e-06 0.837798995916667 \
1.525309927159096e-06 0.8339004324287677 1.52531008574937e-06 0.8300982805770993 1.525310262673771e-06 0.8258418712800655 1.525310459187584e-06 0.8211009660847696 \
1.525310626744125e-06 0.8170498602679914 1.525310793484544e-06 0.8130123908857781 1.525310967908062e-06 0.8087844286215062 1.525311137277684e-06 0.8046757316210446 \
1.525311305476779e-06 0.8005936994537799 1.525311494325046e-06 0.7960093488074458 1.525311685140882e-06 0.7913773844868103 1.525311893523092e-06 0.7863203192056716 \
1.525312119942597e-06 0.7808277108969495 1.525312309142794e-06 0.7762391340290878 1.525312519289483e-06 0.7711455503222944 1.525312668057987e-06 0.7675418410361046 \
1.525312799050976e-06 0.7643705172588006 1.525312936616212e-06 0.7610417440783073 1.525313042367441e-06 0.7584842184275663 1.525313177141075e-06 0.7552262509102785 \
1.5253132889738e-06 0.7525244432456109 1.525313418408964e-06 0.7493992292091655 1.525313573597688e-06 0.7456545577979357 1.525313685233441e-06 0.7429626190147979 \
1.525313844808055e-06 0.7391166470929011 1.525314020129688e-06 0.7348935218456193 1.525314232505151e-06 0.7297828120356423 1.525314425387679e-06 0.7251458607116523 \
1.525314582088971e-06 0.7213823872711312 1.525314768763662e-06 0.716903961299824 1.525314957650011e-06 0.7123775767926828 1.525315148534203e-06 0.70780884692282 \
1.525315335282138e-06 0.7033444557767304 1.525315518366954e-06 0.698972331957095 1.525315655685935e-06 0.6956951921588121 1.525315808928893e-06 0.6920418367118417 \
1.525316004057543e-06 0.6873949992893974 1.525316161351872e-06 0.6836535194673684 1.525316320746467e-06 0.6798660670227984 1.52531651649026e-06 0.6752219404489795 \
1.525316708689394e-06 0.6706682621108646 1.525316943641022e-06 0.6651105611269369 1.52531713111727e-06 0.6606839627962382 1.525317368354404e-06 0.6550894036851447 \
1.525317557534366e-06 0.6506361170423679 1.525317738150179e-06 0.6463915264929231 1.525317901844741e-06 0.6425504277539856 1.52531804639615e-06 0.6391628119244788 \
1.52531818686792e-06 0.6358764726647652 1.525318313968707e-06 0.6329064225879303 1.525318446276184e-06 0.6298198307262635 1.52531857286323e-06 0.626870110582017 \
1.525318703443498e-06 0.62383130535404 1.525318832712897e-06 0.6208285625908692 1.525318971819793e-06 0.6176004736356133 1.525319120330103e-06 0.6141606483517721 \
1.525319309878658e-06 0.6097777958748198 1.525319455581914e-06 0.6064170107178907 1.525319690632478e-06 0.601007464699683 1.525319873631749e-06 0.5968099615921 \
1.525320097973423e-06 0.5916778694808832 1.525320269146672e-06 0.5877753019413697 1.525320401480491e-06 0.5847634284691802 1.52532053327703e-06 0.5817721407249107 \
1.525320639820933e-06 0.5793579518205488 1.525320735711292e-06 0.5771868999037388 1.525320828211542e-06 0.5750974572268882 1.525320920638905e-06 0.5730134868920421 \
1.525320993067211e-06 0.5713818265150021 1.525321048796317e-06 0.5701269325864891 1.525321109905405e-06 0.5687522410723198 1.52532120667008e-06 0.5665806864277688 \
1.525321268161595e-06 0.5652027770813386 1.525321327214216e-06 0.5638802801505602 1.525321402840882e-06 0.5621878686488651 1.52532146986366e-06 0.5606896577364279 \
1.52532154346077e-06 0.5590483558003441 1.525321611066772e-06 0.5575429304381756 1.525321727135829e-06 0.5549610936632026 1.525321827342234e-06 0.5527359403974305 \
1.525321939349424e-06 0.5502565947066531 1.525322033841475e-06 0.5481686943853854 1.525322154996173e-06 0.5454955387196141 1.525322255183939e-06 0.5432910220514219 \
1.525322371174451e-06 0.5407443765731218 1.525322478878289e-06 0.5383833065966291 1.525322588456977e-06 0.5359861028148916 1.525322700578421e-06 0.5335400310751951 \
1.525322827515605e-06 0.5307765704644959 1.525322949665123e-06 0.5281221248815906 1.525323089426038e-06 0.525095489155881 1.525323226564154e-06 0.522132778766487 \
1.525323376529244e-06 0.5189020692106626 1.525323535302247e-06 0.5154923220538846 1.525323709327904e-06 0.511765695450105 1.525323896158028e-06 0.5077823379664483 \
1.525324101125994e-06 0.5034264211640872 1.525324323834942e-06 0.4987133299464507 1.525324576739139e-06 0.4933874474923696 1.525324811693046e-06 0.4884604410272814 \
1.525325107961308e-06 0.4822828691822955 1.525325397751266e-06 0.4762763831984252 1.525325704087085e-06 0.4699660956099861 1.525326016405612e-06 0.4635767846525711 \
1.525326354971068e-06 0.4566963260653934 1.525326678082485e-06 0.4501741115777416 1.525327016477788e-06 0.4433881855507311 1.525327340309053e-06 0.4369378830387565 \
1.525327664703474e-06 0.4305204627449936 1.52532800763776e-06 0.4237851826852676 1.525328346918578e-06 0.4171698123421442 1.525328686393212e-06 0.4105997181257849 \
1.525329129505058e-06 0.4020958655332711 1.525329491573227e-06 0.3952155038183801 1.525329812124964e-06 0.3891775711374149 1.525330199059535e-06 0.3819561902961204 \
1.525330526929795e-06 0.3758957719299574 1.525330812088852e-06 0.3706704968427373 1.525331130457646e-06 0.3648820026298218 1.525331413288573e-06 0.3597820188690578 \
1.525331641977337e-06 0.3556924369094372 1.525331859870142e-06 0.3518226517641353 1.525332055119486e-06 0.3483769517668343 1.525332262027586e-06 0.344751588202948 \
1.525332476824342e-06 0.3410137651016431 1.525332729050892e-06 0.3366564674340092 1.525332971046205e-06 0.3325077909124976 1.525333201898484e-06 0.3285822460490526 \
1.525333416746675e-06 0.3249550452085373 1.525333637103364e-06 0.3212604562488142 1.525333838674264e-06 0.3179050685021769 1.52533404175821e-06 0.3145531374773136 \
1.525334239655597e-06 0.3113121771742085 1.525334426754836e-06 0.3082694484595072 1.525334620655179e-06 0.3051385396431291 1.525334825703514e-06 0.3018527636900292 \
1.525335005938266e-06 0.2989872106339772 1.525335241836277e-06 0.2952669081535775 1.525335443123827e-06 0.2921198200609627 1.525335644514631e-06 0.2889965001417216 \
1.525335869163794e-06 0.2855437159941698 1.525336034543768e-06 0.2830223598911593 1.525336212348106e-06 0.280330186126118 1.525336396004319e-06 0.277570343839212 \
1.525336581246076e-06 0.2748090658167894 1.525336759391454e-06 0.2721781298892599 1.525336932983517e-06 0.2696316866093095 1.52533709334837e-06 0.267306655456324 \
1.525337214459553e-06 0.2655585721882695 1.525337367654341e-06 0.2633570345323199 1.525337494985789e-06 0.2615475749425888 1.525337598313628e-06 0.2600830587034867 \
1.525337715638424e-06 0.2584225376281647 1.525337833445381e-06 0.2567591557214636 1.525337957409147e-06 0.2550199666844239 1.525338074393314e-06 0.2533821414201824 \
1.525338205189442e-06 0.2515535495016885 1.525338322399552e-06 0.2499173892700276 1.525338475652677e-06 0.2477853623028658 1.525338611183197e-06 0.2459029165157107 \
1.525338742864406e-06 0.244074199323236 1.525338899457317e-06 0.2419017673596028 1.525339024653874e-06 0.2401755227310949 1.525339160371501e-06 0.2383060149301216 \
1.525339292798663e-06 0.2364844144139329 1.525339412772324e-06 0.2348355337769661 1.525339575820161e-06 0.232606585912384 1.525339714627252e-06 0.230713852557009 \
1.525339853100972e-06 0.2288300961780371 1.525339958645721e-06 0.2273962817971701 1.525340087007401e-06 0.2256537837490921 1.525340191135024e-06 0.2242444877898851 \
1.525340291651026e-06 0.222886569499566 1.525340366695402e-06 0.2218745444235658 1.525340444028458e-06 0.2208349692306942 1.525340518791637e-06 0.2198305887827458 \
1.525340596755314e-06 0.218785487158918 1.525340651621824e-06 0.2180503923904892 1.5253407081186e-06 0.2172938400168352 1.525340751572119e-06 0.2167123195211523 \
1.525340791613165e-06 0.2161767335077376 1.525340830852113e-06 0.2156521099473339 1.52534087172635e-06 0.2151058606261434 1.52534092587884e-06 0.2143825797409383 \
1.525340964295971e-06 0.2138698309421548 1.525341003584678e-06 0.2133480458229882 1.525341065121386e-06 0.2125332203444249 1.525341127098915e-06 0.2117131287842428 \
1.525341183575664e-06 0.2109664019951111 1.525341248207255e-06 0.2101124842966758 1.525341343715876e-06 0.2088522205996687 1.525341431031608e-06 0.207701294711168 \
1.525341527641208e-06 0.2064291756790013 1.525341624870762e-06 0.2051510266126755 1.525341725717823e-06 0.2038307158897115 1.525341826317594e-06 0.2025192706911573 \
1.525341922808891e-06 0.2012627769767186 1.525342024991065e-06 0.1999338657614989 1.525342128630721e-06 0.1985898465970496 1.525342238404734e-06 0.1971698847140261 \
1.52534234757976e-06 0.1957617939809042 1.525342467677852e-06 0.1942174441246506 1.525342577697376e-06 0.1928086337505992 1.525342685809285e-06 0.1914295694688549 \
1.525342808837984e-06 0.1898652723262108 1.525342898948554e-06 0.1887234630454603 1.525343006314044e-06 0.1873671680421656 1.525343083125353e-06 0.1864004060894758 \
1.525343166570621e-06 0.1853535952511875 1.525343256102432e-06 0.1842338297700716 1.525343340667899e-06 0.1831790839553313 1.525343420384039e-06 0.1821880912968773 \
1.525343521709242e-06 0.1809331989518758 1.525343630056471e-06 0.1795959386230563 1.525343726532169e-06 0.1784102562612937 1.525343851909986e-06 0.1768766438339704 \
1.525343984693456e-06 0.1752616821119887 1.525344102464279e-06 0.1738362801839788 1.525344248115856e-06 0.1720835746408261 1.525344358713008e-06 0.1707596463148658 \
1.525344500843447e-06 0.1690680578777541 1.52534461655307e-06 0.1676985735146403 1.525344722027083e-06 0.166456424915798 1.525344816543742e-06 0.1653485352650968 \
1.525344912181115e-06 0.1642320043563913 1.525345009252958e-06 0.1631032360400927 1.525345108304212e-06 0.161956192050434 1.525345202227769e-06 0.1608730077890209 \
1.525345287503444e-06 0.1598934595213354 1.525345387883236e-06 0.1587475631033795 1.525345472186073e-06 0.1577906478848196 1.525345574585582e-06 0.1566342854655733 \
1.525345651979844e-06 0.1557646215197878 1.525345744324758e-06 0.154731814591042 1.52534581457623e-06 0.1539498814072817 1.525345910750659e-06 0.1528844393027091 \
1.525345987575322e-06 0.152038051282755 1.525346066345474e-06 0.1511758489440315 1.525346140238395e-06 0.150370438825067 1.525346207936138e-06 0.1496353997608715 \
1.525346304000026e-06 0.1485973848112393 1.525346373572453e-06 0.1478489919002561 1.525346457461625e-06 0.1469503328160803 1.525346518593461e-06 0.146298213254472 \
1.525346590861543e-06 0.1455309799806117 1.525346663300106e-06 0.1447677488542132 1.525346744281147e-06 0.1439178685120187 1.525346810355616e-06 0.1432275520600639 \
1.525346887756114e-06 0.1424219220725307 1.525346977131571e-06 0.1414956876531561 1.525347047992216e-06 0.1407644282175171 1.525347146879283e-06 0.1397487730030469 \
1.525347224198192e-06 0.1389620820751095 1.525347306243419e-06 0.1381330876879582 1.52534739435453e-06 0.1372467208126059 1.525347461981677e-06 0.1365690714953818 \
1.525347542278859e-06 0.1357674830239305 1.525347617062888e-06 0.1350239185327315 1.525347685064065e-06 0.1343502586094245 1.525347731746974e-06 0.1338891847862563 \
1.525347820998567e-06 0.1330118383700247 1.525347859221617e-06 0.1326395291833771 1.525347928213527e-06 0.1319690872918072 1.525347980961596e-06 0.1314578750898332 \
1.525348063954378e-06 0.1306559489775353 1.525348104132829e-06 0.1302688434457458 1.525348196650203e-06 0.1293805059784019 1.52534823536857e-06 0.1290098403727171 \
1.525348309129285e-06 0.1283055160094505 1.525348370757287e-06 0.1277188748199021 1.525348442784976e-06 0.1270353589407805 1.525348510952008e-06 0.1263909833196726 \
1.525348585574169e-06 0.1256908956540175 1.525348667426635e-06 0.1249253613889138 1.525348750880797e-06 0.124147338931438 1.525348823832511e-06 0.1234692772477456 \
1.525348896559441e-06 0.122795332839617 1.525348956549435e-06 0.1222410931008323 1.525349042917447e-06 0.121445549533078 1.525349103886165e-06 0.1208856452315438 \
1.525349162271955e-06 0.1203507897957366 1.52534922790662e-06 0.119751336354628 1.525349287260861e-06 0.1192111367930785 1.525349355292642e-06 0.1185941868697126 \
1.525349452587012e-06 0.11771710490035 1.525349531078992e-06 0.1170124163111649 1.525349621315123e-06 0.1162055395685231 1.525349717161808e-06 0.1153523005684616 \
1.525349792119505e-06 0.1146878351828532 1.525349896478921e-06 0.1137670532163148 1.525349983267518e-06 0.1130053589403202 1.525350092924934e-06 0.1120476726212376 \
1.525350174478997e-06 0.1113387926087848 1.525350270092629e-06 0.1105114393564785 1.525350346804822e-06 0.10985058581598 1.525350441723287e-06 0.1090364400125625 \
1.525350517546392e-06 0.1083889268999046 1.525350595246049e-06 0.1077282965354292 1.5253506775775e-06 0.1070311517075373 1.525350737142764e-06 0.1065286079538068 \
1.525350800900501e-06 0.1059924133642201 1.525350861995109e-06 0.1054803128126646 1.525350957858847e-06 0.1046801683739134 1.525351002721942e-06 0.1043071445723913 \
1.525351085962687e-06 0.1036173314376927 1.525351135082509e-06 0.1032117000904133 1.525351244131271e-06 0.1023149933518279 1.525351288967353e-06 0.1019479364619093 \
1.525351379228585e-06 0.1012117400678687 1.525351420105203e-06 0.1008795969612472 1.525351490563617e-06 0.1003088525914566 1.525351576851038e-06 0.09961307626065434 \
1.525351668628597e-06 0.09887705578174606 1.52535173815669e-06 0.09832225024344161 1.525351816683849e-06 0.09769854072774181 1.525351907412525e-06 0.09698178745350861 \
1.525351983228664e-06 0.09638605854785212 1.525352065241407e-06 0.09574500473888557 1.525352146994443e-06 0.09510943278387665 1.525352237502267e-06 0.09440967388330095 \
1.525352327061564e-06 0.09372126988887708 1.525352412671398e-06 0.09306698857649189 1.525352505450896e-06 0.09236212353634379 1.525352586338857e-06 0.0917510971760913 \
1.525352687467827e-06 0.09099177263830999 1.525352767961352e-06 0.09039108594384238 1.525352852204218e-06 0.08976589684797046 1.525352926049265e-06 0.08922077348043934 \
1.525353002898743e-06 0.08865632925481931 1.525353091039112e-06 0.08801255002475737 1.525353171103481e-06 0.08743108261130086 1.525353264139672e-06 0.08675939571108145 \
1.525353382140385e-06 0.08591369538214398 1.525353524513612e-06 0.08490278100234279 1.525353668761962e-06 0.08388867104764453 1.525353811089671e-06 0.08289807427203813 \
1.525353960667415e-06 0.08186746790234835 1.525354096981161e-06 0.08093761126893445 1.525354239101592e-06 0.0799778356000513 1.52535437365502e-06 0.07907840240745091 \
1.52535451400773e-06 0.07814980287393705 1.525354661689802e-06 0.0771833418413561 1.525354811805299e-06 0.07621180464723754 1.525354976525776e-06 0.07515824360926991 \
1.525355140155128e-06 0.07412455432658185 1.525355314933688e-06 0.07303438636984133 1.525355502186304e-06 0.07188220095900363 1.525355712231308e-06 0.07060976590783831 \
1.525355930441531e-06 0.06930979572898451 1.52535616389862e-06 0.06794333957253913 1.525356418744638e-06 0.06648001693367038 1.525356711839195e-06 0.06483321328442151 \
1.525357014178957e-06 0.06317411115207273 1.525357328765833e-06 0.06148945259513613 1.525357725026527e-06 0.05942677493938087 1.525358058743672e-06 0.05774249301432461 \
1.525358466054501e-06 0.05574994498853819 1.52535879393926e-06 0.05419380357502902 1.525359150629899e-06 0.05254809000207299 1.52535946386806e-06 0.05114243792209583 \
1.525359766835193e-06 0.04981740498512215 1.525360064375718e-06 0.04854875663330436 1.525360343155274e-06 0.04739109061078805 1.525360626155169e-06 0.04624570307560639 \
1.525360887895477e-06 0.04521055793698023 1.52536116713437e-06 0.04413130357485813 1.52536143924029e-06 0.0431040186124033 1.525361746607047e-06 0.04197194005652995 \
1.525361968409948e-06 0.04117329707315532 1.525362274870428e-06 0.04009446155587663 1.525362501059881e-06 0.03931650950691581 1.525362739977207e-06 0.03851359500741255 \
1.525362964401039e-06 0.03777663690506906 1.52536316666332e-06 0.03712468825868943 1.525363367705949e-06 0.03648814235703791 1.525363719479983e-06 0.03540095449820539 \
1.525363969725821e-06 0.03464776841732944 1.525364216044101e-06 0.03392252499723709 1.525364497376965e-06 0.03311308780599518 1.52536474046795e-06 0.03242954897046491 \
1.525364975941701e-06 0.03178112583711486 1.525365217601206e-06 0.03113119522156456 1.525365454483484e-06 0.03050988948014832 1.525365685016041e-06 0.02991733361391674 \
1.525365898984569e-06 0.02937801894285819 1.525366104927116e-06 0.02886851641492237 1.525366497651603e-06 0.02792196059063811 1.525366685729283e-06 0.02747992420741849 \
1.525367061168249e-06 0.02661861215736662 1.525367236042477e-06 0.02622659266649364 1.525367659365491e-06 0.02530049759795254 1.525367780614875e-06 0.02504150687334681 \
1.525368221176528e-06 0.02412433837770948 1.525368363674648e-06 0.02383402682615681 1.525368695728157e-06 0.02316883068419595 1.525368878693682e-06 0.02280879143785283 \
1.525369267997886e-06 0.02205689891561978 1.525369436343594e-06 0.02173705378531499 1.525369908457993e-06 0.02085107653961301 1.525370048202727e-06 0.0205916297664938 \
1.525370543782805e-06 0.01969297428531048 1.525370671008237e-06 0.01946923320191776 1.525371238917342e-06 0.01851512288677271 1.52537140317129e-06 0.0182513999453204 \
1.525372013043028e-06 0.0173209960017622 1.525372172728257e-06 0.01708922829277545 1.525372699639798e-06 0.01635462467776483 1.525372904157091e-06 0.01608193551804103 \
1.525373627634478e-06 0.01515939662837778 1.52537379307661e-06 0.01495683325581705 1.525374539636356e-06 0.01408081084911163 1.525374672939569e-06 0.01393008075245666 \
1.525375533124155e-06 0.01299799962960837 1.52537566920557e-06 0.01285670227674402 1.525376609799459e-06 0.01192267652923807 1.525376773572533e-06 0.01176632439256516 \
1.525377774751465e-06 0.01084959205883911 1.525377912229187e-06 0.01072929995296418 1.525379082926798e-06 0.009787962024485789 1.525379175323166e-06 0.009718668544398181 \
1.525380593399014e-06 0.008725931027897449 1.525380680375162e-06 0.00866912727384293 1.525382221370793e-06 0.00770199130002063 1.525382330686807e-06 0.007633428668288294 \
1.525383973934629e-06 0.006673746291950173 1.525384106791908e-06 0.006603544020797993 1.525386201172206e-06 0.005605323336654431 1.525386409576941e-06 0.00551468736035817 \
1.525388763913366e-06 0.004577307911602986 1.525389237472123e-06 0.004407121484391641 1.525392122908979e-06 0.003492041675788492 1.525392652573326e-06 0.00334538389506189 \
1.525396860800552e-06 0.00237996320858989 1.525397374234803e-06 0.002283557532494709 1.525403133485495e-06 0.001325291758975802 1.525403368066713e-06 0.001279502680325907 \
1.525418035894088e-06 0.0002809017338477542 1.52541814896418e-06 0.0002788534805396912 1.52805516904393e-06 -0.0006849217749926401 1.528055335205606e-06 -0.0009443270389602415 \
1.528055814074993e-06 -0.001850320037528519 1.52805590679462e-06 -0.002050462221988249 1.528056272019697e-06 -0.002913187630468476 1.528056363676814e-06 -0.00314709230904735 \
1.528056729783165e-06 -0.004133001189868674 1.528056839930291e-06 -0.004442309109773816 1.528057150668543e-06 -0.005311341427314526 1.528057252407188e-06 -0.005583925258601597 \
1.528057616111313e-06 -0.00638370916272213 1.528057780957636e-06 -0.006585924750287024 1.528058360754957e-06 -0.005792290386912202 1.528058535589415e-06 -0.004916934050781314 \
1.528058652279015e-06 -0.00413641027497409 1.528058778708708e-06 -0.00310656561120747 1.528058880730911e-06 -0.002137079422087956 1.528059000577393e-06 -0.0008406209844352954 \
1.528059091214629e-06 0.0002489246187367611 1.528059189634679e-06 0.001536790859923857 1.528059289358324e-06 0.002948496343048522 1.528059456842332e-06 0.005545701385567424 \
1.528059675420934e-06 0.009327395936412004 1.528059861491256e-06 0.0128572688386996 1.528060082873864e-06 0.01737012273305725 1.528060243533997e-06 0.02082840415615294 \
1.528060406999647e-06 0.02447866954313523 1.528060557635164e-06 0.02794359528291388 1.528060706690917e-06 0.03145289236167962 1.528060856153671e-06 0.03504014479003619 \
1.528061010184684e-06 0.03879791952579481 1.528061172300943e-06 0.04280891157365373 1.528061338330408e-06 0.04696567134311741 1.528061514283228e-06 0.05141478668696391 \
1.528061694953866e-06 0.05602187592747932 1.528061886774812e-06 0.06094655248807559 1.528062093880316e-06 0.06629309753158302 1.528062315452046e-06 0.07203901748582854 \
1.528062550186215e-06 0.07814662931008168 1.528062801725783e-06 0.08470684589377442 1.528063077167849e-06 0.09190125212984442 1.528063377363668e-06 0.09974607960254324 \
1.528063708295878e-06 0.108390578238945 1.528064083962612e-06 0.1181923833971668 1.52806448154548e-06 0.1285487285136021 1.528064948370082e-06 0.1406786766767902 \
1.528065491362617e-06 0.1547396794802719 1.52806612478764e-06 0.1710742296429572 1.528066820727691e-06 0.1889259607126788 1.5280676362848e-06 0.2097135943149445 \
1.528068546312904e-06 0.2327316641523666 1.528069339569124e-06 0.2526372689279454 1.5280700450442e-06 0.2702038474981599 1.528070663988468e-06 0.2855008995781749 \
1.528071231094408e-06 0.2994177966724069 1.528071754174414e-06 0.3121574438576628 1.528072253153207e-06 0.3242197130846058 1.528072737193214e-06 0.3358335658028451 \
1.528073192420047e-06 0.3466679577370423 1.528073666932009e-06 0.3578644504627745 1.528074106840717e-06 0.368158604789619 1.528074592685345e-06 0.3794271463718566 \
1.528075124288118e-06 0.3916316501999784 1.528075626951417e-06 0.4030538969706937 1.52807605602367e-06 0.4127111343288326 1.528076547040338e-06 0.4236561147984291 \
1.528077048470419e-06 0.434714731975362 1.528077395015009e-06 0.442288187401736 1.528077750424386e-06 0.4500000616404133 1.528078177652114e-06 0.4592019891792938 \
1.528078569851637e-06 0.4675774400278049 1.528078870233395e-06 0.4739448723400065 1.528079212045155e-06 0.4811381049525967 1.528079555484969e-06 0.4883107756756314 \
1.528079816220095e-06 0.4937186470393492 1.528080058250048e-06 0.4987071765458648 1.528080324195292e-06 0.5041573145298286 1.528080581464587e-06 0.509394255416739 \
1.52808077158369e-06 0.5132422368582924 1.528080985109851e-06 0.5175451019736222 1.528081124800157e-06 0.5203466115392713 1.528081271000449e-06 0.5232668091041763 \
1.52808148498835e-06 0.5275186200231483 1.52808169300461e-06 0.5316389396023125 1.528081885465879e-06 0.5354321131715788 1.52808207058211e-06 0.5390651926504321 \
1.528082244955557e-06 0.5424725330931349 1.528082549497633e-06 0.5484058192982523 1.528082810056515e-06 0.5534602958276967 1.528083111487545e-06 0.5592859190791987 \
1.528083365805138e-06 0.5641865993769294 1.528083658661328e-06 0.5698153316805189 1.52808391787448e-06 0.5747800306938655 1.528084188950812e-06 0.579963273174682 \
1.528084430794571e-06 0.5845680738798381 1.528084688299729e-06 0.5894577538325241 1.528084915043605e-06 0.5937419314630586 1.528085152044424e-06 0.5982006324572362 \
1.528085362230986e-06 0.6021379329905048 1.52808557499152e-06 0.6061060319396779 1.528085827870286e-06 0.6107954169450593 1.528086031533554e-06 0.6145509252949414 \
1.528086222250936e-06 0.6180531102377972 1.528086409587374e-06 0.6214768531423983 1.528086598465652e-06 0.6249070011644339 1.528086806665447e-06 0.6286671070650327 \
1.528087050997562e-06 0.6330499453121026 1.528087250564095e-06 0.6366057789565548 1.528087454709836e-06 0.6402215701419991 1.52808763934909e-06 0.643474671963314 \
1.528087908884781e-06 0.6481901084955864 1.528088136591637e-06 0.652149230294136 1.528088324263375e-06 0.6553888277830079 1.52808850516352e-06 0.6584949378977958 \
1.528088664704602e-06 0.661221510907812 1.528088835167002e-06 0.6641177016088209 1.528088986918443e-06 0.6666817235716488 1.528089124561455e-06 0.6689905419339194 \
1.528089273556319e-06 0.6714784915997724 1.528089401298182e-06 0.6736028790357499 1.528089544284695e-06 0.675968899142866 1.528089666067751e-06 0.6779749688503388 \
1.528089802351161e-06 0.6802121872853304 1.528089922180063e-06 0.682172759947357 1.528090068775623e-06 0.6845626218370968 1.528090187248565e-06 0.6864845934661837 \
1.528090283181927e-06 0.6880368302455475 1.528090375701511e-06 0.6895284278106264 1.528090480762022e-06 0.6912169000724893 1.528090578843908e-06 0.6927871490736753 \
1.528090715959225e-06 0.6949707622226827 1.528090835157868e-06 0.6968607547931925 1.528090945097838e-06 0.6985951241089645 1.528091082597081e-06 0.7007503743809057 \
