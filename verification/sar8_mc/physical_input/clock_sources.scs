7.035471158475732e-07 0.6126978430086294 7.035473043313055e-07 0.6083422542008314 7.035475107637274e-07 0.6035858951323969 7.035476900783896e-07 0.5994633272559844 \
7.035478872572566e-07 0.5949432360761027 7.035480963453974e-07 0.5901646611556908 7.035483020946604e-07 0.5854760387944159 7.035485426053479e-07 0.5800160304866983 \
7.035487157334496e-07 0.5760958285528379 7.035488806274519e-07 0.5723746772837877 7.035490614880266e-07 0.5683014035092815 7.035492187741233e-07 0.5647722902613652 \
7.035493877569178e-07 0.5609879409349005 7.03549567863379e-07 0.5569709657351898 7.035497208465059e-07 0.5535669615732179 7.035498525609507e-07 0.5506462283231492 \
7.035499999486508e-07 0.5473865746199473 7.03550087374242e-07 0.5454560063082221 7.035501722454816e-07 0.5435860258811447 7.03550270874694e-07 0.5414171943998213 \
7.035503429668553e-07 0.5398340751058975 7.035504400578744e-07 0.5377039800781129 7.035505256482576e-07 0.5358302678688993 7.035505907291341e-07 0.5344081412607664 \
7.03550714329502e-07 0.5317121235594142 7.035508087537724e-07 0.52965475734789 7.035509062769941e-07 0.5275349985745696 7.035510791376451e-07 0.5237893654184622 \
7.035512141331662e-07 0.5208709659121862 7.035513683166277e-07 0.5175498113398643 7.03551542781984e-07 0.5138002600288881 7.035516945879704e-07 0.510550000123414 \
7.03551840818953e-07 0.5074290310664136 7.03551984717826e-07 0.5043644611166801 7.035521277396694e-07 0.5013276181140283 7.035522233495175e-07 0.499301733014788 \
7.035523177934733e-07 0.4973032961550828 7.03552438849414e-07 0.4947494705229025 7.035525337277098e-07 0.4927525559781179 7.035526495585532e-07 0.4903172469328811 \
7.035527368224019e-07 0.4884854516151125 7.035528192528481e-07 0.4867593351188191 7.035529146608015e-07 0.484765406725184 7.035530153710815e-07 0.4826639978995959 \
7.03553112231473e-07 0.4806459052877932 7.035532509612246e-07 0.4777646955734051 7.035533866660861e-07 0.4749532752442271 7.035535871508094e-07 0.4708139964547478 \
7.035538024649621e-07 0.4663911383470885 7.03553984040267e-07 0.462674698484628 7.035541830122363e-07 0.4586189944293299 7.035543535777573e-07 0.455154096457448 \
7.035545279314447e-07 0.4516251957269069 7.035546968646987e-07 0.4482170126441485 7.035548694618603e-07 0.4447467276163349 7.035550520681902e-07 0.4410867902598327 \
7.035552406170554e-07 0.4373240875354826 7.035554340845929e-07 0.4334777823509549 7.035556424052317e-07 0.4293535036700135 7.035558567504624e-07 0.4251286740881063 \
7.035560824557922e-07 0.4207018662297695 7.035563089991605e-07 0.4162771402745992 7.035565711759108e-07 0.4111844468197049 7.035568202097347e-07 0.4063709766754009 \
7.035571213084326e-07 0.4005865607947761 7.035574107292502e-07 0.3950673729298416 7.03557718243529e-07 0.3892455819062323 7.035580404399245e-07 0.3831936848847286 \
7.035583681704071e-07 0.3770882112794804 7.035587006001628e-07 0.3709500980558715 7.035590303291706e-07 0.3649083177186754 7.035593515587582e-07 0.3590729273462687 \
7.03559682375082e-07 0.3531219177045733 7.035600247306453e-07 0.3470224718704957 7.035603243716774e-07 0.3417374346434491 7.035606541592421e-07 0.3359723367088904 \
7.035609810531851e-07 0.3303128110141857 7.03561319032532e-07 0.3245206193888226 7.035616280036957e-07 0.3192755432624759 7.035619528016686e-07 0.31382336954194 \
7.035622684318663e-07 0.3085864885517507 7.035625734190322e-07 0.3035810258414895 7.035628287576776e-07 0.2994330834535801 7.035630936208339e-07 0.295170851203172 \
7.035633807035186e-07 0.2905978071194348 7.035636036732975e-07 0.2870801635277143 7.035638032125665e-07 0.2839591363066187 7.035640128685797e-07 0.2807045410859125 \
7.035641931251209e-07 0.2779290029372279 7.035643554698416e-07 0.2754463208250681 7.035645059048155e-07 0.2731629026725527 7.035646569101241e-07 0.2708866524077067 \
7.035648538007149e-07 0.2679392949564011 7.035649849454786e-07 0.2659970646012914 7.035651096820175e-07 0.2641561221543183 7.035652612740598e-07 0.2619266655689588 \
7.03565357242231e-07 0.2605306204207966 7.035654537935995e-07 0.2591282589302421 7.035655784133887e-07 0.2573209601776467 7.035657209899234e-07 0.255257422470362 \
7.035658799234579e-07 0.25296979123958 7.035660125895253e-07 0.251062957019046 7.03566196158294e-07 0.2484301322588876 7.035663773934596e-07 0.2458327969660818 \
7.035665889075645e-07 0.2428051031600066 7.035667914973991e-07 0.2399069804317323 7.035669580538466e-07 0.2375282895552967 7.03567168273059e-07 0.2345337828133105 \
7.03567341690945e-07 0.2320692345528927 7.035675705336728e-07 0.2288260787734411 7.035677911684243e-07 0.2257162440502939 7.035679668301377e-07 0.2232503232699662 \
7.035681472906433e-07 0.2207258962977968 7.035683180470208e-07 0.2183528725291195 7.035684982432871e-07 0.2158619697278009 7.035686649739047e-07 0.2135675266585953 \
7.03568814095326e-07 0.2115251542210239 7.035689699053442e-07 0.2094125291275523 7.035691050857695e-07 0.2075875692769576 7.035692551671966e-07 0.2055694209972212 \
7.035693876128229e-07 0.2037957203154137 7.035695281573595e-07 0.2019220745191926 7.035696452261238e-07 0.2003748851744883 7.035697749337301e-07 0.1986681706274326 \
7.035698969911991e-07 0.1970700654731777 7.035700195346348e-07 0.1954731161836187 7.035701375539584e-07 0.1939418157697267 7.035702725767313e-07 0.1921981789937757 \
7.035704172011819e-07 0.1903420634523806 7.035705455516813e-07 0.1887049708672087 7.03570669186156e-07 0.1871351133418249 7.035707667362788e-07 0.1859021016257166 \
7.035708818092081e-07 0.1844539912642748 7.035709755078879e-07 0.1832809848801438 7.035710742920116e-07 0.1820493959460708 7.035711972265529e-07 0.1805230483556907 \
7.035712929805559e-07 0.1793400249325384 7.035714220681073e-07 0.177753298391591 7.035715245334772e-07 0.1764993061988986 7.035716227869744e-07 0.1753029542432101 \
7.035717428741866e-07 0.1738483570896001 7.035718454234049e-07 0.1726127298531683 7.035719558810641e-07 0.1712877101305652 7.035720843709282e-07 0.1697552709290656 \
7.035721758557693e-07 0.1686698090598139 7.035722803403581e-07 0.1674358120019214 7.035723552770941e-07 0.1665544493622226 7.03572444845591e-07 0.1655049734124585 \
7.035724954106002e-07 0.164914347906921 7.035725453889763e-07 0.1643318187475747 7.035726103580609e-07 0.163576534137217 7.035726458720287e-07 0.1631646263336159 \
7.035727180712023e-07 0.162329174921529 7.035727852002974e-07 0.1615546732967998 7.035728444300317e-07 0.160873195114598 7.035728881756304e-07 0.1603710314414745 \
7.035729358224586e-07 0.1598254649913795 7.03573006202993e-07 0.1590230739426561 7.03573088541159e-07 0.1580883269013631 7.035731667127594e-07 0.1572048664554128 \
7.035732487657084e-07 0.1562816770844126 7.035733414693307e-07 0.1552436243401225 7.035734642494946e-07 0.153877370231325 7.035735633955882e-07 0.1527810927807017 \
7.035736648959354e-07 0.1516651170047695 7.035737661711264e-07 0.1505582666538253 7.035738626629106e-07 0.1495093242781697 7.035739620809455e-07 0.1484346886615803 \
7.03574046381569e-07 0.1475281828465028 7.035741393202594e-07 0.1465342051547719 7.035742219212e-07 0.1456551508734999 7.035743306872851e-07 0.1445034822456445 \
7.035744363302651e-07 0.1433917535370727 7.035745179898545e-07 0.1425365900703354 7.03574611735024e-07 0.1415598856352903 7.035747053029709e-07 0.1405903867550886 \
7.035747881874616e-07 0.139735765814107 7.035748763466362e-07 0.1388313836440244 7.035749561327221e-07 0.1380170907865772 7.035750497281216e-07 0.1370669869522621 \
7.035751396606458e-07 0.1361590166429519 7.035752102110423e-07 0.1354501541392388 7.035752799712188e-07 0.1347521119166949 7.035753941201258e-07 0.1336164586193709 \
7.035754760987401e-07 0.1328058651355588 7.035755637040425e-07 0.1319440719770354 7.035756632052385e-07 0.1309710196939938 7.035757723852409e-07 0.1299110174488692 \
7.03575874550573e-07 0.1289256009328031 7.035759820107789e-07 0.1278959836800649 7.035761020450569e-07 0.1267549558890445 7.035761962530915e-07 0.1258657925752028 \
7.035763272321949e-07 0.1246390638240933 7.035764266598964e-07 0.1237164070883829 7.035765357815822e-07 0.1227104370444639 7.035766446347502e-07 0.1217138859540913 \
7.035767369441536e-07 0.120874257454373 7.035768497844843e-07 0.1198547128626846 7.035769467965243e-07 0.118986084968971 7.035770510628723e-07 0.1180628196869088 \
7.035771600298026e-07 0.1171053395831002 7.035772595693683e-07 0.1162371554254778 7.035773765620782e-07 0.1152245300989246 7.035774636628685e-07 0.1144761644999183 \
7.0357757295452e-07 0.1135478691973115 7.035776544795827e-07 0.1128618460838699 7.035777542545759e-07 0.1120273350449922 7.03577871679726e-07 0.1110526766231405 \
7.035779734648438e-07 0.1102143708571793 7.035780612037922e-07 0.1094962336869811 7.035781420032999e-07 0.1088432886892514 7.035782289543191e-07 0.1081456845520918 \
7.035783097409447e-07 0.1075007757815706 7.035783999475114e-07 0.1067842832273628 7.03578490898266e-07 0.1060655611559195 7.035785795687901e-07 0.1053685613006139 \
7.035786785836107e-07 0.1045946508745568 7.035787722897869e-07 0.1038723470842792 7.035788661490627e-07 0.1031520741219857 7.035789669765109e-07 0.1023817709659086 \
7.035790716074087e-07 0.1015861061604995 7.03579195570165e-07 0.1006484085638475 7.035792929694782e-07 0.09991551135558702 7.035794132274253e-07 0.09901872452754552 \
7.035795240953005e-07 0.09819831936474602 7.035796285683363e-07 0.09742874659471555 7.035797458050451e-07 0.09656937225591002 7.035798475993662e-07 0.09582695326576983 \
7.035799455749167e-07 0.09511577589263259 7.035800860794065e-07 0.09410164141823299 7.035801911572026e-07 0.09334832721827611 7.035802897700187e-07 0.09264549593674179 \
7.035803824848273e-07 0.09198739948435641 7.035804686832123e-07 0.09137785861853052 7.035805625961876e-07 0.09071637432184691 7.035806596969337e-07 0.09003559055802626 \
7.03580769117988e-07 0.08927317549644689 7.035808701015371e-07 0.08857281843916648 7.035809637594832e-07 0.08792605868920525 7.035810379341552e-07 0.08741581771673042 \
7.03581175834007e-07 0.08647193599618339 7.035812481910108e-07 0.08597917321277694 7.035813835122141e-07 0.08506274029062395 7.035814694238194e-07 0.08448410751389913 \
7.03581614152054e-07 0.08351486081643937 7.035817103826188e-07 0.0828744112740944 7.035817982183981e-07 0.08229260392026354 7.035819140173063e-07 0.08152964121883956 \
7.035820291457576e-07 0.08077575264951149 7.035821429121899e-07 0.08003553900012179 7.035822831696827e-07 0.0791300282244784 7.035824245457161e-07 0.07822490276368012 \
7.035825741817576e-07 0.07727536491519127 7.035827186706132e-07 0.07636690312463701 7.035828698447241e-07 0.07542565384097814 7.035830192155436e-07 0.07450459906593411 \
7.03583168562251e-07 0.0735926433331697 7.035833285177668e-07 0.07262574717347114 7.035834846646777e-07 0.07169171823582712 7.035836591531124e-07 0.07065947636250877 \
7.035838288622191e-07 0.0696671357044583 7.035840140413029e-07 0.0685979885997255 7.035842107623799e-07 0.06747763456279594 7.035844212801998e-07 0.06629631776014881 \
7.03584643312255e-07 0.06507007089066431 7.035848735242763e-07 0.0638195278444372 7.035851160353819e-07 0.06252626147401 7.035853766894672e-07 0.06116236403900636 \
7.035856565885314e-07 0.05972739422233359 7.035859501722554e-07 0.05825544847408989 7.035862651082392e-07 0.05671370145268265 7.035866079141644e-07 0.05507846134953124 \
7.035869573807585e-07 0.0534565727116736 7.035873662849151e-07 0.05161746230842366 7.035877129499425e-07 0.05010669351290297 7.035881003649954e-07 0.04846839895323611 \
7.035884445827877e-07 0.04705645202362623 7.035887680090468e-07 0.04576625679949029 7.035890730548091e-07 0.04458093278443617 7.035893659168059e-07 0.04347099288378908 \
7.035896500577228e-07 0.04242242262004604 7.035899260780149e-07 0.04142902112907627 7.03590192930566e-07 0.04049015932812138 7.035904618227892e-07 0.03956531631184226 \
7.035907378832112e-07 0.03863769040165695 7.035910254787821e-07 0.03769451689421055 7.035912650444082e-07 0.03692662498323904 7.03591554211835e-07 0.03602084344675294 \
7.03591770003438e-07 0.03535960341037672 7.035919577204763e-07 0.03479599077274986 7.035921558495825e-07 0.03421285035004928 7.03592518724446e-07 0.03317032497347058 \
7.03592776866276e-07 0.03244834222605905 7.035930865791899e-07 0.0316030971185694 7.035933520493286e-07 0.03089664771451467 7.035936201684082e-07 0.03019941363307669 \
7.03593899042439e-07 0.02949128999862272 7.035941452288756e-07 0.02888043298519722 7.035943758602853e-07 0.02832033800396738 7.035946141502041e-07 0.02775711540944564 \
7.035948491575684e-07 0.02721270742060762 7.03595076940031e-07 0.02669509678424227 7.035954855523029e-07 0.02579039168486155 7.03595661854632e-07 0.02540904040268441 \
7.03596016332316e-07 0.02465798827491217 7.035962002032882e-07 0.02427641469830137 7.035965351520103e-07 0.02359448510613503 7.035966990607275e-07 0.02326678168937357 \
7.035970913313036e-07 0.02249905491676728 7.035972473220689e-07 0.02220010404946675 7.035976789254263e-07 0.02138321689778962 7.035978163148065e-07 0.0211255367654138 \
7.03598333123589e-07 0.02017559010600388 7.035984586594829e-07 0.01995091418019728 7.035989159010076e-07 0.01915998482559782 7.035990750469891e-07 0.01889493739859509 \
7.035996822854669e-07 0.01793263500095189 7.03599816822955e-07 0.01772934138481063 7.036004800869477e-07 0.01678091027541291 7.036006734103789e-07 0.01651856846389665 \
7.036013410670396e-07 0.01565087920017967 7.03601502655887e-07 0.01544858341705342 7.0360225789114e-07 0.01454101846553843 7.036024074521069e-07 0.01436800730673201 \
7.036032977899311e-07 0.01338293844200974 7.036033964478169e-07 0.01327873262558703 7.03604353121314e-07 0.01230993787860994 7.036044742310215e-07 0.01219243157195396 \
7.036054657237297e-07 0.01126376273051215 7.036056292524602e-07 0.01111855113153209 7.036067591745355e-07 0.01018247077230436 7.036068716217738e-07 0.01009565848301377 \
7.036082494452622e-07 0.009103273453806031 7.036083883905334e-07 0.009009747578659758 7.036099427888683e-07 0.008018073335410726 7.0361005485534e-07 0.00794673960805117 \
7.036116998381698e-07 0.006958154532207958 7.036118070906645e-07 0.006899512253112593 7.036137515841525e-07 0.005937533026687714 7.036139584821097e-07 0.005843834961138424 \
7.036162973698526e-07 0.00487227039639981 7.036167213562637e-07 0.004712306502041247 7.036194935894604e-07 0.003780857497341114 7.036199418985521e-07 0.003647790772321777 \
7.03623582397237e-07 0.00272553831825111 7.036240790530716e-07 0.002619503085887757 7.036298301734959e-07 0.001650572925599863 7.036301169553824e-07 0.001609446887446839 \
7.036354719440668e-07 0.0006353228983793809 7.036356773006917e-07 0.0005920420449145349 7.062827120745073e-07 -0.0002718533828215428 7.062828679501106e-07 -0.0004579010352009555 \
7.062834162652027e-07 -0.001326296959495401 7.062835290488787e-07 -0.001543805653187533 7.062839635410184e-07 -0.002491429791030493 7.062840393661748e-07 -0.002673591589873599 \
7.062843960167732e-07 -0.003590195133438418 7.062845230658532e-07 -0.003936807634339821 7.062848015662471e-07 -0.004716444651655622 7.062849096507304e-07 -0.005020876868076652 \
7.06285253249855e-07 -0.00592430224391268 7.062853602437201e-07 -0.006162325733041658 7.062862596141159e-07 -0.005653094509861465 7.062864380475456e-07 -0.004687598829536962 \
7.062865437709605e-07 -0.003940993102967527 7.062866688337377e-07 -0.002883597584075996 7.062867624178337e-07 -0.001971418478057775 7.062868402573964e-07 -0.001132968824455395 \
7.062869203293945e-07 -0.0001977429743171 7.062870427022046e-07 0.001370578777960296 7.062871609580771e-07 0.003041212838230153 7.062872796071872e-07 0.004860750887681821 \
7.06287393089626e-07 0.006730904986417607 7.062874965327644e-07 0.008536402178002854 7.062876111920181e-07 0.01064190690353853 7.062878017758113e-07 0.0143607330143792 \
7.062879355659492e-07 0.01711819191720031 7.062880858195149e-07 0.02033933849841947 7.062882409887624e-07 0.02378599874269359 7.062883963808114e-07 0.0273434151175349 \
7.062885440880426e-07 0.03080849965087477 7.062886930776679e-07 0.03437359286003162 7.06288848068751e-07 0.03814545786868043 7.062890074393647e-07 0.04208062121327779 \
7.062891723727756e-07 0.04620305710844342 7.062893473191045e-07 0.0506208066052034 7.062895264491763e-07 0.05518387280380205 7.062897162384316e-07 0.06005265756871143 \
7.062899199354002e-07 0.06530840376289772 7.062901397459318e-07 0.07100650943730057 7.062903714973765e-07 0.07703584544314998 7.062906193226736e-07 0.08349927754587044 \
7.062908906436034e-07 0.09058756662233436 7.062911853563813e-07 0.09829181712822582 7.062915106140292e-07 0.106792896697727 7.062918768597349e-07 0.1163551101154179 \
7.062922701564477e-07 0.1266079356677421 7.062927228093435e-07 0.1383809089651769 7.062932485245107e-07 0.1520098384503803 7.06293867738049e-07 0.1679979965193872 \
7.062945484823656e-07 0.1854865650013753 7.062953421573203e-07 0.2057488551561759 7.062962309229534e-07 0.2282732214494322 7.062970443122153e-07 0.2487218262351868 \
7.062977660617924e-07 0.2667261628598245 7.062984017258004e-07 0.282460740414376 7.062989734425617e-07 0.2965101025186013 7.062995089968458e-07 0.3095696210007924 \
7.063000123552588e-07 0.3217495654069301 7.063004886827014e-07 0.3331878525640654 7.063009626063057e-07 0.3444754071334732 7.063014200780244e-07 0.3552759747331513 \
7.063018860582939e-07 0.3661792384270033 7.063023350461038e-07 0.376592601923634 7.063028311526456e-07 0.3879857357798637 7.063033509145082e-07 0.3998002499051578 \
7.063037303191525e-07 0.4083447473225827 7.063041703278757e-07 0.4181679450526055 7.063046400968136e-07 0.4285466970600206 7.063051256177521e-07 0.4391589006481625 \
7.063055650658585e-07 0.4486701556983262 7.063056268188068e-07 0.4500002248264944 7.063057503247037e-07 0.4526540461147197 7.063059973364976e-07 0.4579447795386873 \
7.063062499314088e-07 0.463325462421476 7.063064475025244e-07 0.467511453725808 7.063066730742714e-07 0.4722681264242033 7.06306994642268e-07 0.4790073975813253 \
7.063072634214966e-07 0.4846013351959894 7.0630748207297e-07 0.4891262574467725 7.063076921769364e-07 0.4934547887280634 7.063079185824616e-07 0.4980921872304203 \
7.063081276876521e-07 0.5023516957637455 7.063083170899107e-07 0.5061927337048852 7.06308441251129e-07 0.5086969563931187 7.063085680062259e-07 0.5112441466129884 \
7.06308728004704e-07 0.5144514110933732 7.063089756476561e-07 0.5193914248715521 7.063091542341148e-07 0.5229351592435862 7.063093251876918e-07 0.5263079149198099 \
7.063095865372878e-07 0.5314455197962068 7.063098126088702e-07 0.5358634945234868 7.063100157405373e-07 0.5398188128751134 7.063101809712675e-07 0.5430252218652345 \
7.063103377582878e-07 0.5460612552756139 7.063105269149053e-07 0.5497137532216215 7.063107287826585e-07 0.5535976061995346 7.06310952933981e-07 0.5578986282275192 \
7.063111913163462e-07 0.5624617013850463 7.06311426077985e-07 0.566941985223824 7.063116563486904e-07 0.5713275351537204 7.063118621413239e-07 0.5752375533958141 \
7.063120671255381e-07 0.5791255875933676 7.063123099407797e-07 0.5837094709690289 7.063125646983618e-07 0.588493349632063 7.063127929267933e-07 0.5927514274590796 \
7.063130307656652e-07 0.5971656109489694 7.063132430431007e-07 0.6010807441713891 7.063134548365055e-07 0.6049674646600495 7.06313708720774e-07 0.6095919957414236 \
7.063139133143013e-07 0.6132953190650409 7.063141650376543e-07 0.6178178328453598 7.063143528271744e-07 0.6211736970442716 7.063146057002513e-07 0.6256587164710262 \
7.063148041096133e-07 0.6291560967673944 7.06314983842284e-07 0.6323071487074056 7.063152541130913e-07 0.6370161336915187 7.063154713968567e-07 0.6407803561788556 \
7.063156519232363e-07 0.6438916924996977 7.063158530841307e-07 0.6473460740030906 7.063160216675126e-07 0.650231451944099 7.063162260257197e-07 0.6537144072723954 \
7.063163716887783e-07 0.6561873372238678 7.063165362473771e-07 0.6589728476742622 7.063167057165935e-07 0.6618316558839334 7.063168592566751e-07 0.664412775690417 \
7.06317000490202e-07 0.6667750288922751 7.063171440660136e-07 0.6691685747430841 7.063172772961389e-07 0.6713840140331436 7.063174191964593e-07 0.6737368819239464 \
7.063175394300862e-07 0.6757233098298149 7.063176840811383e-07 0.6781085120392751 7.063178002998436e-07 0.6800197521569988 7.063179193821632e-07 0.6819757159594566 \
7.063180179604766e-07 0.6835903813535821 7.063181355581832e-07 0.6855122399681081 7.063182229941461e-07 0.6869376986921233 7.063183477402321e-07 0.6889650632873403 \
7.063184475472963e-07 0.6905825000046129 7.063185400370926e-07 0.6920753042469043 7.063186413211772e-07 0.6937043390836264 7.063187391142832e-07 0.695273833970533 \
7.063188303850746e-07 0.6967333967490603 7.063189328429049e-07 0.6983656370917724 7.063190657521355e-07 0.7004728611232253 7.063192207675414e-07 0.7029137789397926 \
7.063193556492269e-07 0.7050222373350452 7.063195011450183e-07 0.7072806469370021 7.063196289996853e-07 0.709252249158637 7.063197534579805e-07 0.7111597484283609 \
7.063198647836849e-07 0.7128563623504806 7.063199788137126e-07 0.7145852226468989 7.063200793249296e-07 0.7161013069709498 7.063202165260769e-07 0.7181590832501857 \
7.063203364719788e-07 0.7199473375636642 7.06320455641778e-07 0.7217141075019444 7.063205825867916e-07 0.7235855504531626 7.063207073542093e-07 0.7254141264975077 \
7.063208308495972e-07 0.7272133847865295 7.063209576308702e-07 0.7290498056238117 7.063210882203554e-07 0.730930225429108 7.063212104322583e-07 0.7326797786847141 \
7.063213474902715e-07 0.7346298644824388 7.063214487056265e-07 0.7360619656663578 7.063215536745619e-07 0.7375401619041119 7.06321645165995e-07 0.7388229997694907 \
7.06321758241356e-07 0.7404001534680551 7.063218455422403e-07 0.7416107338190071 7.063219500055705e-07 0.7430512000342341 7.063220807687029e-07 0.7448411286358657 \
7.063221906822003e-07 0.7463352048609909 7.063222953419584e-07 0.7477488743938407 7.0632241917362e-07 0.7494094725133206 7.063225679269713e-07 0.751387874302702 \
7.06322689842132e-07 0.7529958494242643 7.063228036963925e-07 0.7544867042370438 7.0632294419585e-07 0.7563117925204224 7.063230855193645e-07 0.7581313010100689 \
7.063232032989716e-07 0.7596352654099263 7.063233316974594e-07 0.7612620174900669 7.063234740211609e-07 0.7630496612437514 7.063235904103157e-07 0.7644991888858087 \
7.063237361339775e-07 0.7662987831554334 7.063238579138671e-07 0.7677897310961733 7.06323976478797e-07 0.7692300520321635 7.063240990922458e-07 0.7707078417740018 \
7.063242255436291e-07 0.77221964326554 7.06324335666584e-07 0.7735261258099556 7.063244611887263e-07 0.7750039859681491 7.06324566849672e-07 0.7762386743660952 \
7.063247020268293e-07 0.7778058706872942 7.063248256373457e-07 0.7792267957652825 7.06324955634725e-07 0.7807078764205345 7.06325068606223e-07 0.7819831642610904 \
7.063251765001111e-07 0.7831908181350914 7.063253130307933e-07 0.7847046126527283 7.063254631517019e-07 0.7863508260127218 7.063256054160057e-07 0.7878933964149381 \
7.063257249975189e-07 0.7891771019825847 7.063258618086489e-07 0.7906313890246753 7.063259843124129e-07 0.7919206245676671 7.06326128984341e-07 0.7934276941869095 \
7.063262697694143e-07 0.794878360380241 7.063263965852094e-07 0.796171745508174 7.063265156326017e-07 0.7973744708066829 7.063266278955628e-07 0.7984986270115709 \
7.063267322833333e-07 0.7995352562746869 7.063268275603949e-07 0.8004739840425704 7.063269639028913e-07 0.8018044219089175 7.063270807679598e-07 0.8029326473252685 \
7.063272003644895e-07 0.8040757482679398 7.063273222502994e-07 0.8052288531124292 7.063274448385593e-07 0.8063765489401953 7.06327572579618e-07 0.8075599074701925 \
7.06327697362526e-07 0.8087035441861687 7.063278278629006e-07 0.8098867241643505 7.063279542295968e-07 0.8110199871086299 7.06328081578389e-07 0.8121498004723215 \
7.063281867911793e-07 0.8130740322933268 7.063282914951838e-07 0.8139855427426806 7.063283830253901e-07 0.8147757515715357 7.063285063983601e-07 0.8158311616195392 \
7.063285933524084e-07 0.8165684017534872 7.063286922082447e-07 0.8173999442793862 7.063288367108844e-07 0.8186029267949408 7.063289730365725e-07 0.8197243345631372 \
7.063290824450085e-07 0.8206145128367788 7.06329228461948e-07 0.821788834531623 7.063293802030074e-07 0.8229927727264784 7.063295061195854e-07 0.8239792970156907 \
7.063296505686489e-07 0.8250971468990039 7.063297752648172e-07 0.8260503472050121 7.063299258788342e-07 0.8271873005969326 7.063300612493022e-07 0.8281959289694237 \
7.063301864729373e-07 0.8291179217777711 7.063303041288969e-07 0.8299746468143927 7.063304499105104e-07 0.8310230722388168 7.063306163942599e-07 0.8322027532553667 \
7.063307472150236e-07 0.8331167337813133 7.063309206750455e-07 0.834311196379941 7.063310887878414e-07 0.8354501125721271 7.063312586689692e-07 0.8365827385393307 \
7.063314395126275e-07 0.8377685497174457 7.06331582704692e-07 0.8386931238161603 7.063316968221893e-07 0.8394210074154138 7.063318268737995e-07 0.8402408682651782 \
7.063319287535162e-07 0.8408758513273116 7.063320456411388e-07 0.841596551294542 7.063321827868591e-07 0.8424315815669623 7.063323806960721e-07 0.8436167827761205 \
7.063325725154114e-07 0.8447436440637145 7.063327818661576e-07 0.8459494874145237 7.063329640177679e-07 0.8469786287449077 7.063331611039906e-07 0.8480715276019779 \
7.063333343567188e-07 0.8490148531186206 7.063335174509634e-07 0.8499943787178993 7.063336885824298e-07 0.8508936588199895 7.063338632702718e-07 0.8517955326875627 \
7.063340385042872e-07 0.8526841769874772 7.063342146411542e-07 0.8535614892404448 7.063344050084937e-07 0.8544920815553035 7.063345955808446e-07 0.8554057038167108 \
7.063347959768378e-07 0.8563474066245403 7.063349885664634e-07 0.8572344253714166 7.06335199466375e-07 0.858185963363946 7.063354273418617e-07 0.8591913103610016 \
7.063356934247181e-07 0.8603357477151101 7.063359919268544e-07 0.8615822374427254 7.063362678163234e-07 0.8627000332972231 7.063365520834926e-07 0.8638181192989086 \
7.063368262214432e-07 0.8648650323418529 7.06337098522366e-07 0.8658754039994767 7.063373686785625e-07 0.8668495780678541 7.063376258626988e-07 0.8677515347235455 \
7.063378984216134e-07 0.8686810999091764 7.063381744693315e-07 0.8695957110915412 7.063384445895985e-07 0.8704649939918846 7.063387444494889e-07 0.8714007440816277 \
7.063391154301144e-07 0.8725171209518352 7.063394103525362e-07 0.8733732402027278 7.063396646282708e-07 0.8740897163373675 7.06339962841735e-07 0.8749052413925265 \
7.063402364113466e-07 0.8756305047096297 7.063404725347486e-07 0.8762394088953867 7.063407128598864e-07 0.8768433401198644 7.063409351938211e-07 0.8773882060838187 \
7.063411292002539e-07 0.8778530214284207 7.063414589096812e-07 0.8786208714695904 7.063416140810901e-07 0.87897283049042 7.063419317234907e-07 0.8796750328643211 \
7.063421106040349e-07 0.8800599154915705 7.063424530647979e-07 0.8807759898408113 7.063426372672098e-07 0.8811501695110489 7.063431122965131e-07 0.8820806183873429 \
7.06343279683462e-07 0.8823969901232691 7.063437454598435e-07 0.8832471741583867 7.063439262991872e-07 0.8835657112976044 7.063444203088052e-07 0.8844044135654346 \
7.063445616237109e-07 0.8846360992458032 7.063451678673265e-07 0.8855901496945974 7.063453199425257e-07 0.8858196526512701 7.063459666625989e-07 0.8867549368993356 \
7.063460949492666e-07 0.8869330782847171 7.063467431586864e-07 0.8877977435561634 7.063468728829849e-07 0.8879638504720397 7.063476413020526e-07 0.8888993076310558 \
7.063477710739033e-07 0.8890488273083775 7.063486247365088e-07 0.8899738047157748 7.063487677615613e-07 0.8901192131187072 7.063497540670479e-07 0.8910487927319016 \
7.063499755535999e-07 0.8912403904783051 7.063511183781384e-07 0.8921548233216382 7.063512482580762e-07 0.8922544308366913 7.06352600758498e-07 0.8932425879319322 \
7.063527510414313e-07 0.8933452769452155 7.063542315756977e-07 0.8942627870546499 7.063544704854918e-07 0.8943950258099049 7.063562525184327e-07 0.8952625983306248 \
7.063566382658602e-07 0.895426813549116 7.063590404240788e-07 0.8963023915260389 7.063595153600486e-07 0.8964490046842035 7.063634332871646e-07 0.8974035634625627 \
7.063639032474093e-07 0.8974927205890085 7.063722720353867e-07 0.8984807567386782 7.063724925457144e-07 0.8984960697096243 7.064170720742926e-07 0.8994905034760702 \
7.064182734601915e-07 0.8995076493514624 7.065540832686942e-07 0.9004821828323031 7.065542622454192e-07 0.9005421539807538 7.065577071203374e-07 0.8996085030263692 \
7.065578799041917e-07 0.8994755022453073 7.065592062238996e-07 0.8985168769831137 7.06559392989208e-07 0.8983970610744239 7.065611771942332e-07 0.8974304740967198 \
7.065613893245152e-07 0.8973403978332656 7.065747300202991e-07 0.8983331062395279 7.065748433081446e-07 0.8983517458922662 7.065835466612413e-07 0.8993273409280406 \
7.065840944718199e-07 0.8993637478389299 7.070766218437148e-07 0.9003542216796759 7.070767175825666e-07 0.9004233209197793 7.070776601319424e-07 0.9014023545001312 \
7.070778225852538e-07 0.9016297223302431 7.070783892915005e-07 0.9025464066367429 7.070784964622122e-07 0.9027401250447874 7.07078889770564e-07 0.9035002370985188 \
7.07079022567928e-07 0.9037710185404622 7.070794021690343e-07 0.9045728679206633 7.070795323837805e-07 0.9048512534150681 7.070799937900729e-07 0.9057878278182891 \
7.070801130371311e-07 0.9060008176934132 7.070815426461655e-07 0.9050557440230738 7.070816263162926e-07 0.9046580283931719 7.07081751622122e-07 0.9039622140338933 \
7.070818594362906e-07 0.9032622438705011 7.070819784306371e-07 0.9023800387125585 7.070820938028541e-07 0.9014106868475621 7.070821838997508e-07 0.900578017289966 \
7.070822953474548e-07 0.8994526603282017 7.070823814266029e-07 0.8985125975436928 7.070824873922515e-07 0.8972736935213672 7.070825871606176e-07 0.8960214106762436 \
7.070826681562277e-07 0.8949470092681954 7.070827778041954e-07 0.8934133399212493 7.070828633916056e-07 0.8921520042367302 7.070829555142148e-07 0.8907345325087322 \
7.07083043733598e-07 0.8893220116766375 7.070831525083507e-07 0.8875100775672261 7.070832354013856e-07 0.8860780350921965 7.070833439750573e-07 0.8841400608632336 \
7.070834362012525e-07 0.8824412727986957 7.070835208217502e-07 0.8808423775446282 7.0708360666218e-07 0.8791839877465467 7.0708368587706e-07 0.8776224824828824 \
7.070837619650304e-07 0.8760960492665846 7.070838543013987e-07 0.874210837196514 7.070839141777347e-07 0.8729702140710593 7.070839715660191e-07 0.8717685933706794 \
7.070840335611921e-07 0.8704574090763495 7.070840968400434e-07 0.8691057216070059 7.07084146911381e-07 0.8680269866686803 7.070841963535335e-07 0.8669542389500936 \
7.070842600232402e-07 0.8655623656543436 7.070843359706592e-07 0.8638877358586781 7.070843848016709e-07 0.8628032002737418 7.070844333256242e-07 0.8617197496806845 \
7.07084509037347e-07 0.8600184098866027 7.070845762461248e-07 0.8584975010852487 7.070846189526311e-07 0.8575263577286506 7.070846628552044e-07 0.8565244243916033 \
7.070847506603508e-07 0.8545103166059256 7.070848135135196e-07 0.8530605771626394 7.070848721831767e-07 0.8517018597088126 7.070849083617784e-07 0.8508614974547222 \
7.07084943180258e-07 0.8500510151036469 7.070849782062432e-07 0.8492340038666518 7.070850482582133e-07 0.8475953578585981 7.07085096728698e-07 0.8464581214772323 \
7.070851406734992e-07 0.8454248116355969 7.070851861912554e-07 0.8443523575543517 7.070852500921663e-07 0.8428433081697474 7.070853162185395e-07 0.8412777165526386 \
7.07085421348608e-07 0.8387809254526315 7.070855092832832e-07 0.8366857089760468 7.070855882285648e-07 0.834800137446173 7.070856763936022e-07 0.8326899670047023 \
7.070857632095988e-07 0.8306078985741704 7.070858511012833e-07 0.8284959280419055 7.070859423503732e-07 0.8262996967350639 7.070860451122408e-07 0.8238226494465998 \
7.070861436157165e-07 0.8214450402687625 7.070862559486315e-07 0.8187302447322098 7.070863689227677e-07 0.8159967029774419 7.070864902106627e-07 0.8130591602364435 \
7.070866207178167e-07 0.8098958628758253 7.070867497637196e-07 0.8067658935936169 7.070869032393198e-07 0.8030416153605923 7.070870685235404e-07 0.799029304640783 \
7.070872362647446e-07 0.7949567682299736 7.070874327883338e-07 0.7901857478752816 7.07087637550659e-07 0.7852160332972318 7.070878502277153e-07 0.7800563994093253 \
7.070880508476619e-07 0.7751902022758907 7.070882517063895e-07 0.7703212856706637 7.070884017284074e-07 0.766686939713112 7.070885322635739e-07 0.7635264252913375 \
7.070886666810141e-07 0.7602735436595947 7.070887728765445e-07 0.7577048602246427 7.070889061828773e-07 0.754482067181252 7.070890132158029e-07 0.7518959494812111 \
7.070891562917044e-07 0.7484409822837247 7.070893207978459e-07 0.7444713482725677 7.070894416150925e-07 0.74155777711076 7.070896127217564e-07 0.7374334100931738 \
7.070897736123089e-07 0.733558046396253 7.070899902049296e-07 0.7283457217000903 7.070901834606309e-07 0.7236999380850822 7.07090362395765e-07 0.7194029726762079 \
7.070905292123874e-07 0.7154015770462002 7.070907154183522e-07 0.7109395231330657 7.070909033515934e-07 0.7064416825495208 7.070910692736986e-07 0.7024749886985119 \
7.07091261631787e-07 0.6978803202016938 7.07091402988682e-07 0.6945068232011449 7.070915599964439e-07 0.6907636199298515 7.07091755976089e-07 0.6860965106368763 \
7.070919184101942e-07 0.6822325558671515 7.070920795863762e-07 0.6784034260021697 7.070922718945738e-07 0.6738409413562468 7.070924895564538e-07 0.6686845685784016 \
7.070927375777557e-07 0.6628199086538362 7.07092915635219e-07 0.6586162961343578 7.070931641790282e-07 0.6527567611811057 7.070933667862709e-07 0.6479896840619462 \
7.07093536596938e-07 0.6440011601507294 7.070936952131239e-07 0.6402799599229552 7.070938337435587e-07 0.637035894415233 7.070939699513215e-07 0.6338503464729111 \
7.070940962626978e-07 0.6309003762865483 7.070942257219331e-07 0.6278810604265532 7.070943540536725e-07 0.6248911458464299 7.070944853836027e-07 0.6218374290191309 \
7.070946174102147e-07 0.6187713222160208 7.070947615700951e-07 0.6154276788919771 7.07094905778687e-07 0.6120888358645944 7.070950534337911e-07 0.6086753592300279 \
7.070952004901491e-07 0.6052842859263143 7.070953583041756e-07 0.6016504852589418 7.070954909098278e-07 0.5986039825107707 7.070956223747947e-07 0.5955897059985247 \
7.070957418045935e-07 0.5928552647156846 7.070958778732863e-07 0.5897484304797134 7.070959928015483e-07 0.5871283594046445 7.070961439122688e-07 0.5836892419704927 \
7.070962585613367e-07 0.5810871834776226 7.070963764990063e-07 0.5784138884735546 7.070964662802944e-07 0.576381560286313 7.070965565996887e-07 0.5743415774978985 \
7.070966232905592e-07 0.5728373329037385 7.070966888523724e-07 0.5713590910263378 7.070967398944957e-07 0.5702089751121119 7.070968015962151e-07 0.5688198806440578 \
7.070968646860707e-07 0.5674025889664359 7.070969290444246e-07 0.5659586381304559 7.070969824382235e-07 0.5647616504486359 7.070970750808062e-07 0.5626864159088959 \
7.070971516880784e-07 0.5609719030357503 7.070972075131406e-07 0.5597256439368602 7.070972765672667e-07 0.5581857825097393 7.070973834553926e-07 0.5558054549196561 \
7.070974611990176e-07 0.5540764009223496 7.070975620491173e-07 0.5518382286767042 7.070976877299716e-07 0.5490568313009737 7.070977879716568e-07 0.5468419758621708 \
7.070978998893402e-07 0.5443739014182352 7.070980031552469e-07 0.5421024366463116 7.070981229045887e-07 0.5394737463112931 7.070982246374689e-07 0.5372436950013484 \
7.070983401572132e-07 0.5347185748314579 7.070984551922987e-07 0.5322102907975605 7.07098581673211e-07 0.529456475824718 7.070987070470086e-07 0.5267350629320526 \
7.070988538629319e-07 0.5235577714138258 7.070989894263807e-07 0.5206304261698983 7.070991471246342e-07 0.5172373565578411 7.070993094436886e-07 0.5137528589513558 \
7.070994902675847e-07 0.5098871206809381 7.070996827159053e-07 0.5057874350093188 7.070998956212086e-07 0.5012700264709963 7.071001278026081e-07 0.4963634062180514 \
7.071003850931866e-07 0.4909555076455908 7.071006247190101e-07 0.4859407514401474 7.071009264344461e-07 0.479662588092526 7.071012143537997e-07 0.4737079198104491 \
7.071015272426188e-07 0.4672821326282255 7.071018469808238e-07 0.4607585360408045 7.071021865759847e-07 0.4538766993710576 7.071025134784829e-07 0.4472977926730654 \
7.071028490368641e-07 0.4405887635920606 7.071031661327867e-07 0.4342949501181722 7.071035003705415e-07 0.4277061431972559 7.071038518016635e-07 0.4208322784122511 \
7.071041663278176e-07 0.4147233751108969 7.071044895053079e-07 0.4084912998479469 7.071049306200656e-07 0.400057814108821 7.071052727361034e-07 0.3935812134363078 \
7.071055726806328e-07 0.3879522399691127 7.071059478116385e-07 0.3809760137481454 7.071062775558776e-07 0.3749002425561211 7.071065607988036e-07 0.3697269896098562 \
7.071068609450588e-07 0.3642865787664632 7.071071405472531e-07 0.3592589179584539 7.071073643233647e-07 0.3552676761685443 7.071075761036954e-07 0.3515151294490645 \
7.071077785371594e-07 0.3479514629380864 7.071079796284271e-07 0.3444362246481504 7.071081853428453e-07 0.3408632458568372 7.071084529657171e-07 0.3362478643926977 \
7.071086918970113e-07 0.3321601360780691 7.07108925403074e-07 0.3281974319442653 7.071091388684736e-07 0.3246000376975314 7.071093602460465e-07 0.3208952602338652 \
7.071095602096931e-07 0.3175728982722026 7.07109764482006e-07 0.3142073831356898 7.071099618288777e-07 0.3109812293225088 7.071101472014048e-07 0.3079732989686547 \
7.071103433077958e-07 0.3048147723336881 7.071105455849362e-07 0.3015820927993307 7.071107212432327e-07 0.2988007390096292 7.0711090711339e-07 0.295878328903569 \
7.071111140927825e-07 0.2926488196724605 7.071112994143739e-07 0.2897857719971084 7.071114946411816e-07 0.2867989994419413 7.07111650415531e-07 0.28443329608414 \
7.071118291723129e-07 0.2817356906084737 7.071120102032329e-07 0.2790344478478936 7.071121601003467e-07 0.2768142575519123 7.071123611437743e-07 0.273859574769726 \
7.071125102589039e-07 0.2716833853889438 7.071126487983334e-07 0.2696726034832688 7.071128006734089e-07 0.2674956304896134 7.071129151475376e-07 0.2658586287383957 \
7.071130466774682e-07 0.2639823142040156 7.071131724359563e-07 0.2622048582339201 7.071132767763623e-07 0.2607341604582348 7.071133897557217e-07 0.2591418073851619 \
7.071135060842464e-07 0.2575033437579446 7.071136490116675e-07 0.2554974228347739 7.071137622731725e-07 0.2539102348881249 7.071138964299053e-07 0.2520298733123076 \
7.071140069027097e-07 0.2504818583075984 7.071141623352846e-07 0.2483006006477398 7.071143032203834e-07 0.2463217957442577 7.071144546129539e-07 0.2441928603691365 \
7.071146097750345e-07 0.2420086586735095 7.071147391842834e-07 0.2401849910837116 7.071148738963765e-07 0.2382868210192302 7.071150115942015e-07 0.2363478190565156 \
7.071151293462172e-07 0.2346905900295477 7.071152886704099e-07 0.2324499447852502 7.071154259326363e-07 0.2305210708572645 7.071155666789934e-07 0.2285488733964877 \
7.071156724701667e-07 0.2270688194984586 7.071158024115645e-07 0.2252532503786337 7.071159029480281e-07 0.2238506847401111 7.071160052817357e-07 0.2224250970611539 \
7.071160790103171e-07 0.2214012665004395 7.071161582442603e-07 0.2203047212273054 7.071162292155075e-07 0.2193236206014474 7.071162806785351e-07 0.218612902325451 \
7.071163336269882e-07 0.2178825126218075 7.071164127819908e-07 0.2167921001391954 7.071164550546258e-07 0.2162104926182252 7.071164948991708e-07 0.2156628374086678 \
7.071165381228203e-07 0.2150692779925967 7.071165790298224e-07 0.2145080585354088 7.071166491522843e-07 0.2135474129702876 7.071166828372557e-07 0.2130867492099046 \
7.071167276666377e-07 0.212477723463 7.071167865237998e-07 0.2116792343136102 7.071168513092604e-07 0.2108017053965978 7.071169087900245e-07 0.2100241135398916 \
7.071169692190328e-07 0.209207737948094 7.071170662554631e-07 0.2078991976528634 7.07117150945123e-07 0.2067595417901527 7.071172598558851e-07 0.2052972881712416 \
7.071173562566921e-07 0.2040065614180294 7.071174512733293e-07 0.2027428333585779 7.071175547051275e-07 0.2013717100485363 7.071176496344727e-07 0.2001158751783069 \
7.071177526548994e-07 0.198757993281026 7.071178577373321e-07 0.1973779917312911 7.071179670461462e-07 0.1959482000350934 7.07118077489628e-07 0.1945091075764383 \
7.071181937799036e-07 0.1929996650696684 7.071183037098964e-07 0.1915811184357085 7.071184133723204e-07 0.1901717999899754 7.071185150889654e-07 0.1888694322720079 \
7.071186080436791e-07 0.1876837490531375 7.071187007725689e-07 0.1865049219968967 7.07118774458125e-07 0.1855719169757668 7.071188572993398e-07 0.1845269810791141 \
7.071189318853364e-07 0.1835895008849975 7.071190016086783e-07 0.1827150226754214 7.071190683270854e-07 0.1818808699270075 7.071191641704113e-07 0.1806871657728035 \
7.071192468771838e-07 0.1796611249561687 7.071193404410075e-07 0.1785035608809835 7.071194353370949e-07 0.1773351434884491 7.071195467074052e-07 0.1759704596301353 \
7.071196883497589e-07 0.1742450478777388 7.071198035966122e-07 0.1728486436789435 7.071199481442513e-07 0.1711076225712051 7.071200597399285e-07 0.1697708811114609 \
7.071202009589021e-07 0.1680898955975501 7.071203166961755e-07 0.1667201145354908 7.071204226568608e-07 0.1654722325850081 7.071205214164775e-07 0.164314417410061 \
7.071206177596498e-07 0.1631901152369615 7.071207064174022e-07 0.1621596955203892 7.071208317516728e-07 0.1607099933926625 7.071209262770884e-07 0.1596224416957933 \
7.071210240160401e-07 0.1585042187118262 7.071211321109171e-07 0.1572745454417887 7.071212267786046e-07 0.1562036643369483 7.071213342264514e-07 0.1549951394274829 \
7.071214253154951e-07 0.1539767092330788 7.071215320872067e-07 0.1527896463435911 7.071216354804728e-07 0.1516469620792683 7.071217465609577e-07 0.1504267727114754 \
7.071218357869394e-07 0.1494522115900035 7.071219212668682e-07 0.1485231035185812 7.071220051920548e-07 0.1476157397758405 7.071220748986192e-07 0.1468658175993407 \
7.071221535366968e-07 0.1460232248551682 7.071222318479541e-07 0.1451880611912267 7.071223024838273e-07 0.1444378248611795 7.071223879746948e-07 0.1435337156153706 \
7.071224753636722e-07 0.1426139614481139 7.071225569511858e-07 0.1417594571206545 7.071226542701372e-07 0.1407454482154784 7.071227349596596e-07 0.139910090776864 \
7.071228257446906e-07 0.1389752404035735 7.07122947088963e-07 0.1377336220260025 7.071230361386038e-07 0.13682812281983 7.071231346554539e-07 0.1358318692385875 \
7.071232217417229e-07 0.1349560640726983 7.071233321526109e-07 0.1338550874529322 7.071234206114333e-07 0.1329791517134813 7.071235213400266e-07 0.1319874611681985 \
7.071236261295802e-07 0.1309622419763913 7.07123720519813e-07 0.1300442429014473 7.07123817024605e-07 0.1291112112475518 7.071239165112583e-07 0.1281591654439075 \
7.071240029124292e-07 0.1273384721630967 7.071240978925598e-07 0.1264411177628728 7.071242020813879e-07 0.1254629331099751 7.071243112001386e-07 0.124445178694 \
7.071244055505945e-07 0.1235704029653004 7.07124517846343e-07 0.1225411084520107 7.071246133096966e-07 0.1216733466577494 7.071247175205872e-07 0.1207311846737792 \
7.071248068659445e-07 0.1199276649878674 7.071248772532174e-07 0.1192980345746366 7.071249526392512e-07 0.1186268760051257 7.071250287714207e-07 0.1179522201461119 \
7.071250977489184e-07 0.1173458504859956 7.071251802680908e-07 0.1166263596898966 7.071252522115779e-07 0.1160015972854393 7.071253342903043e-07 0.1152916772467617 \
7.0712541862478e-07 0.1145654108773922 7.07125496418619e-07 0.113898375935255 7.071255891835211e-07 0.1131065723182637 7.071257047873425e-07 0.1121254933399327 \
7.071258106929114e-07 0.1112341778178403 7.071258883498311e-07 0.1105854195321705 7.071259766463023e-07 0.1098504899494786 7.071260567033545e-07 0.1091866403929743 \
7.071261536294793e-07 0.1083861389179563 7.07126248864964e-07 0.1076031391441806 7.071263374361587e-07 0.1068780200140514 7.071264387442598e-07 0.1060523297458165 \
7.071265442899472e-07 0.1051963702337609 7.071266534843118e-07 0.1043160928234657 7.071267616019328e-07 0.1034503663302994 7.071268815196938e-07 0.1024949450012773 \
7.071269828815214e-07 0.1016914181115986 7.071270888911508e-07 0.100855068690839 7.071272146827802e-07 0.09986840123414902 7.071273442400856e-07 0.09885896724496235 \
7.071274799154405e-07 0.09780904711780367 7.071276559873036e-07 0.09645781830037269 7.071278197878237e-07 0.09521257997344186 7.071279826125652e-07 0.09398642071914091 \
7.071280677512003e-07 0.09334985726464029 7.07128137589223e-07 0.09282999162688726 7.071282070848284e-07 0.09231474740697931 7.071282810434879e-07 0.09176875214326782 \
7.071283771983754e-07 0.09106241641841166 7.071284516137407e-07 0.09051841344162129 7.071285296033096e-07 0.08995079828656057 7.071286060521395e-07 0.08939693755534793 \
7.071286935462239e-07 0.08876614459792892 7.071287957229341e-07 0.08803382885421264 7.071288842873223e-07 0.08740269463919083 7.071289939528099e-07 0.08662585268124241 \
7.071291100092175e-07 0.08580942306245626 7.07129251558034e-07 0.0848216759818637 7.071293844270175e-07 0.08390253510334872 7.071295251873281e-07 0.08293727564630923 \
7.071296748969478e-07 0.08192024575105315 7.071298106088348e-07 0.08100683753927941 7.07129952125717e-07 0.08006309454860433 7.071300872475906e-07 0.07917070961097784 \
7.071302285200282e-07 0.07824718349428782 7.071303756129204e-07 0.07729532867436953 7.07130527122786e-07 0.07632524417621221 7.071306924984999e-07 0.07527819040792309 \
7.071308562596902e-07 0.07425356708383206 7.071310323896319e-07 0.07316505371836476 7.071312215286099e-07 0.07201151367936541 7.071314322022336e-07 0.07074528708793332 \
7.071316517688555e-07 0.06944624562626683 7.071318865352622e-07 0.06808094281860989 7.071321449277002e-07 0.06660616301228137 7.071324395923604e-07 0.06496103773121734 \
7.071327436716829e-07 0.06330286177969326 7.071331045821629e-07 0.06138472526627536 7.071334404990351e-07 0.05964719353945821 7.07133880676406e-07 0.05743991201668189 \
7.071342590438092e-07 0.05560437501227136 7.071347015027716e-07 0.05352996728430704 7.071350555229165e-07 0.05192508193542229 7.071354420396717e-07 0.05022502935509546 \
7.071357866437289e-07 0.04875485597254389 7.071361086186649e-07 0.04741934964807833 7.07136412152492e-07 0.04619304551845941 7.071367070734883e-07 0.04503122626702559 \
7.071369895557667e-07 0.04394770877170886 7.071372666361775e-07 0.04291147062934708 7.071375323636684e-07 0.04194013461971725 7.071378035943552e-07 0.0409708748276704 \
7.071380798533722e-07 0.04000619535229137 7.071383697525942e-07 0.03901828782233653 7.071385981289875e-07 0.03825741181922668 7.071389030130544e-07 0.03726495139513845 \
7.071391196849105e-07 0.03657573971894532 7.071393110416373e-07 0.03597943984071691 7.071395096361558e-07 0.03537298232318693 7.071398395514967e-07 0.03438820140908775 \
7.071400814971701e-07 0.03368375433354889 7.071403968092222e-07 0.03278771666975258 7.071406669292072e-07 0.03203957074185158 7.071409233008807e-07 0.03134567005659093 \
7.071412033128806e-07 0.03060515313352298 7.071414489686567e-07 0.02997014710356035 7.071416817043017e-07 0.02938120249260199 7.07141924434299e-07 0.02878348292867495 \
7.071421611615635e-07 0.02821317433052753 7.071423898079744e-07 0.0276732289298247 7.071428070936344e-07 0.02671456010533928 7.071430022743284e-07 0.02627749693639509 \
7.071433834414109e-07 0.02544369227895442 7.071435606942329e-07 0.02506446942885681 7.071439031456877e-07 0.02434654114125227 7.0714405641412e-07 0.02403127656358269 \
7.071444314325841e-07 0.02327616399748992 7.071445690667252e-07 0.02300530455388665 7.071450533333593e-07 0.02207084195640928 7.071451729527604e-07 0.02184403312078184 \
7.071455899915635e-07 0.02106026682208277 7.07145733393791e-07 0.02079332360769017 7.071462546051726e-07 0.01984598817089831 7.071463823790427e-07 0.0196205814374062 \
7.071469667914166e-07 0.01863359713481367 7.071471392268229e-07 0.01835589372257288 7.071477433235728e-07 0.01743644241612937 7.071479047552141e-07 0.01720262545858322 \
7.071485447014338e-07 0.01631831686205014 7.071487230176005e-07 0.016083210242981 7.071493710016487e-07 0.01526127675881721 7.071495362552397e-07 0.01505930898173208 \
7.071502725571753e-07 0.01419381259610907 7.071504068332254e-07 0.01404154276213586 7.071512039327433e-07 0.01317592498067951 7.071513445303545e-07 0.01302934089458718 \
7.07152309873577e-07 0.0120661300044765 7.071524742123827e-07 0.01190857475316222 7.071534749435119e-07 0.01099048917119646 7.071536122133689e-07 0.01087009009405628 \
7.071547509078863e-07 0.009949273443646761 7.071548650857871e-07 0.009863136028526375 7.071562457306217e-07 0.008889755784408603 7.071564000878327e-07 0.00878832203975914 \
7.071579465820611e-07 0.00781340401000951 7.071580309437644e-07 0.007760176032106158 7.07159716371082e-07 0.006770348169342283 7.071598398995725e-07 0.00670487246831437 \
7.071618897141387e-07 0.005720970231232756 7.071620861142965e-07 0.005634691917282852 7.071644047936537e-07 0.004698942116576918 7.071648654079885e-07 0.004530544077955615 \
7.071676055035305e-07 0.003639937533647344 7.071681236485673e-07 0.00349159181499799 7.071722742898753e-07 0.002502201117031859 7.071728121398824e-07 0.002396807933581942 \
7.0717889437533e-07 0.001421603691354927 7.071791533557405e-07 0.001378272220758726 7.071844761190904e-07 0.0003814093765652445 7.071845892761344e-07 0.0003711807182531981 \
7.098307063923701e-07 -0.0004615907568095335 7.098308688313385e-07 -0.0006852153244161934 7.098313698328069e-07 -0.001554404032531494 7.098314540153697e-07 -0.001725199767551738 \
7.098318555381937e-07 -0.002626792336557519 7.098319448731606e-07 -0.002845673237760077 7.098322314649697e-07 -0.0035898660494722 7.098323590334992e-07 -0.003937855927128601 \
7.098326777451613e-07 -0.004830400105952924 7.098327919463135e-07 -0.00515011308870196 7.098330743466382e-07 -0.005887653497963378 7.098332045728569e-07 -0.006177415671381139 \
7.09834182925754e-07 -0.005220113099403402 7.098343702332871e-07 -0.004004368716724641 7.098345016776888e-07 -0.002901539130564616 7.098346071052425e-07 -0.001869327786897239 \
7.098346928227261e-07 -0.0009323217369615201 7.098347747492128e-07 4.151965372454519e-05 7.098348957860361e-07 0.001618129410352471 7.098349947146828e-07 0.003024565667809575 \
7.098351531113568e-07 0.005482561958548801 7.098353705585866e-07 0.00923691162542661 7.098355517808095e-07 0.0126653356758144 7.09835763874906e-07 0.01697021734206094 \
7.098359268985627e-07 0.02046388365739064 7.098360875209785e-07 0.02403759527126768 7.09836241061221e-07 0.02755862871109176 7.098363891179022e-07 0.031036270750196 \
7.098365381988111e-07 0.03460722192241437 7.098366927287224e-07 0.03837091703902212 7.098368533795379e-07 0.04234026030123839 7.098370180342185e-07 0.04645786783841532 \
7.098371945751168e-07 0.05091770581196236 7.098373735379687e-07 0.05547793877747508 7.098375642811338e-07 0.0603721650098247 7.09837769062163e-07 0.06565647483694508 \
7.098379895344492e-07 0.07137203566208646 7.098382223941741e-07 0.0774299331224613 7.098384715816505e-07 0.08392829098722057 7.098387444237776e-07 0.09105513637423955 \
7.098390411275777e-07 0.09880974921055499 7.098393684539683e-07 0.1073623706929605 7.098397381053549e-07 0.11701033799881 7.098401329771689e-07 0.1273002725707723 \
7.098405908154096e-07 0.1392030195235975 7.098411226222497e-07 0.1529832553757746 7.09841747860046e-07 0.1691182447448397 7.098424336075175e-07 0.1867241161332086 \
7.098432360033912e-07 0.2071957342970069 7.098441348021829e-07 0.2299563735557614 7.098449404156324e-07 0.2501946571168963 7.098456541669657e-07 0.2679877251922811 \
7.098462837288477e-07 0.2835633151515627 7.098468540922982e-07 0.2975737963344939 7.098473850476803e-07 0.3105173405876944 7.098478868351306e-07 0.3226580892822354 \
7.098483661296844e-07 0.3341673054699896 7.098488316851033e-07 0.3452566901045974 7.098492954815109e-07 0.3562094254686541 7.098497512295407e-07 0.3668794056881832 \
7.098502114496752e-07 0.3775613305945491 7.098507497336462e-07 0.3899285626759094 7.098512505841795e-07 0.4013172511919189 7.098516508068632e-07 0.4103337945930838 \
7.09852157667644e-07 0.421642452039157 7.098526436338564e-07 0.4323669409017459 7.098530431485677e-07 0.4410997362599856 7.098534537606271e-07 0.4500002277813482 \
7.098538826870602e-07 0.4592207708982954 7.098542842014423e-07 0.4677760623951868 7.098545915918887e-07 0.4742753916877908 7.098549418336473e-07 0.4816249679276425 \
7.098552950738506e-07 0.4889795533930016 7.0985554824443e-07 0.4942125642332652 7.098557811883199e-07 0.4989990073547648 7.098560228316108e-07 0.5039392821429431 \
7.098562478222295e-07 0.5085102868389438 7.098564398583375e-07 0.5123881070394828 7.098566246700343e-07 0.5161059569497825 7.098568469603498e-07 0.5205538992744256 \
7.098570136717574e-07 0.5238726938135662 7.098572308883525e-07 0.5281726418673847 7.098574339672442e-07 0.5321820613122353 7.098576113786994e-07 0.5356681922482178 \
7.098577994510862e-07 0.5393528234657015 7.098580354832655e-07 0.5439555888699217 7.098583013652895e-07 0.5491186112539347 7.098585231271783e-07 0.5534070305875756 \
7.098588031850331e-07 0.5588091140818973 7.098590461848179e-07 0.5634839438879177 7.09859321538161e-07 0.5687575845994758 7.098595665335016e-07 0.5734440561015828 \
7.098598068277205e-07 0.5780305526007354 7.098600478670233e-07 0.5826153106864888 7.09860305457841e-07 0.5874946531182738 7.098605408246178e-07 0.5919209497705462 \
7.09860772126727e-07 0.5962518282209535 7.098609946534482e-07 0.6003950532231523 7.098612030130559e-07 0.6042587207462122 7.098614408548706e-07 0.6086392006348278 \
7.098616517150854e-07 0.612499186772883 7.09861907322267e-07 0.617151767543529 7.098621060500327e-07 0.620751700070918 7.098623816826772e-07 0.6257066023742009 \
7.098626044387981e-07 0.6296824120643636 7.098628978099215e-07 0.6348814180513288 7.098631305799232e-07 0.6389753720667986 7.098633507813091e-07 0.6428252659334456 \
7.098635520519211e-07 0.6463216644290061 7.098637693407936e-07 0.6500784077528632 7.098639440567036e-07 0.6530842133917786 7.098641303213334e-07 0.6562672470877895 \
7.098643090603858e-07 0.6593113758161715 7.098644717643993e-07 0.6620700940033843 7.098646370334099e-07 0.6648583661366954 7.098647803012238e-07 0.6672607123132118 \
7.098649195316479e-07 0.669583864918244 7.098650593322145e-07 0.6719085596965743 7.098651941074222e-07 0.6741424479378803 7.098653216016632e-07 0.6762463034350935 \
7.098654545557746e-07 0.6784344250006583 7.098655761601248e-07 0.680430207161383 7.098657045733663e-07 0.6825336955632141 7.098658203404209e-07 0.6844241240890321 \
7.098659183815936e-07 0.686020684362688 7.098660190776997e-07 0.687656981754083 7.098661288314626e-07 0.689434454762776 7.098662455994179e-07 0.6913211166705923 \
7.098663368261915e-07 0.6927889453402305 7.098664460316049e-07 0.6945396927028351 7.098665471403262e-07 0.6961566646470493 7.098666425406181e-07 0.6976767415743361 \
7.098667520226425e-07 0.6994136821864276 7.098668864742773e-07 0.7015344809028976 7.098670354932137e-07 0.7038694457768003 7.098671644232324e-07 0.7058755144243859 \
7.09867311083691e-07 0.7081418729260142 7.098674378680718e-07 0.7100885084081828 7.098675624659611e-07 0.7119899232102255 7.098676743197281e-07 0.7136874821928206 \
7.098677872756922e-07 0.7153928249203609 7.098678878290892e-07 0.716903336497302 7.098680251105924e-07 0.7189542886859326 7.098681449794518e-07 0.7207346491296758 \
7.09868264162204e-07 0.7224952472954583 7.098683911643136e-07 0.7243608783177121 7.098685157126647e-07 0.726179956024653 7.098686393836757e-07 0.7279757435764195 \
7.09868765971953e-07 0.7298035010246171 7.098688965411881e-07 0.7316777339938921 7.098690190562223e-07 0.7334262671520465 7.098691552997129e-07 0.7353588786631546 \
7.09869256742486e-07 0.7367901064855561 7.098693627659689e-07 0.7382789144707947 7.098694532971524e-07 0.7395446819117977 7.098695671233782e-07 0.7411267287627761 \
7.098696547849604e-07 0.742338113895605 7.098697606802377e-07 0.7437932991468792 7.098698910335325e-07 0.7455718205320391 7.098700016011402e-07 0.7470699275523445 \
7.098701062716114e-07 0.7484790865773925 7.098702302331429e-07 0.7501360792234356 7.098703787905969e-07 0.752105598322839 7.098705004731933e-07 0.7537054667443914 \
7.098706145848825e-07 0.7551949470168074 7.098707550054835e-07 0.7570132059451244 7.098708965335436e-07 0.7588296197226846 7.098710143228134e-07 0.7603289862386273 \
7.098711425226351e-07 0.7619481626911874 7.098712845904682e-07 0.7637269294216019 7.098714014655762e-07 0.7651780119234867 7.098715471393621e-07 0.7669714049983392 \
7.098716688778096e-07 0.7684572223066155 7.098717875183015e-07 0.7698939375992205 7.098719099845945e-07 0.7713653733660819 7.098720367016846e-07 0.7728756341192486 \
7.098721466036787e-07 0.7741754302862822 7.098722722190223e-07 0.7756497674172792 7.098723780294307e-07 0.7768823528242577 7.098725141995533e-07 0.7784559787239111 \
7.098726385466015e-07 0.7798807766277074 7.098727659718769e-07 0.7813271999647126 7.098728805279563e-07 0.7826155184370988 7.098729872082258e-07 0.7838050786084815 \
7.098731251508229e-07 0.785328674235108 7.098732746003193e-07 0.7869612315653352 7.098734194525364e-07 0.7885256944569791 7.098735388882871e-07 0.7898026796320731 \
7.098736743131599e-07 0.7912364721526877 7.098737958074809e-07 0.7925100718437531 7.098739391665555e-07 0.7939977458315933 7.09874082600237e-07 0.7954699260458764 \
7.098742084112467e-07 0.7967479640295563 7.098743274579285e-07 0.7979459892863545 7.098744394715731e-07 0.7990632136113104 7.098745442634543e-07 0.8000996927221937 \
7.098746394563032e-07 0.8010335634530776 7.098747758668286e-07 0.8023587211299719 7.098748926790049e-07 0.8034813603122919 7.098750121402484e-07 0.8046180202255495 \
7.098751341806002e-07 0.8057672874017472 7.098752570806968e-07 0.8069126780167393 7.098753842000532e-07 0.8080849010520604 7.098755093419151e-07 0.8092265787736463 \
7.098756398931421e-07 0.8104047139317369 7.09875765969389e-07 0.811530109085512 7.098758939660489e-07 0.8126603425876329 7.09875999427297e-07 0.8135823118114501 \
7.098761026965977e-07 0.814477091043954 7.098761953499457e-07 0.8152732203909091 7.098763190441811e-07 0.8163262937528154 7.098764066640956e-07 0.8170655553659417 \
7.098765053301514e-07 0.8178914289762149 7.098766488771538e-07 0.819080619224994 7.098767844633065e-07 0.8201904093102529 7.09876893653288e-07 0.8210742465492874 \
7.09877041102747e-07 0.8222539401850584 7.09877191506449e-07 0.8234410273756358 7.098773169754118e-07 0.8244188977545531 7.098774611413952e-07 0.8255287290252299 \
7.098775854299598e-07 0.8264738611628292 7.098777359002563e-07 0.8276038147969816 7.098778715066145e-07 0.8286089145501508 7.098779966016159e-07 0.8295251220930787 \
7.098781143174533e-07 0.8303776282987162 7.098782602030521e-07 0.8314210189912619 7.098784266961482e-07 0.8325942517713072 7.098785575628508e-07 0.833503494447128 \
7.098787310074617e-07 0.8346911703335461 7.098788991402021e-07 0.8358239212093587 7.098790689939496e-07 0.8369500705213252 7.098792498869552e-07 0.838129582835239 \
7.098793930212162e-07 0.8390486258646698 7.098795071191619e-07 0.8397723391454259 7.098796372463217e-07 0.8405879656882547 7.098797391021787e-07 0.8412191375388212 \
7.098798559475988e-07 0.8419354178465567 7.098799929193963e-07 0.84276453896487 7.098801907591422e-07 0.843942473808897 7.098803824446297e-07 0.8450620046306492 \
7.09880591850993e-07 0.8462610422160779 7.098807738618767e-07 0.8472832413425977 7.098809709773334e-07 0.8483697584184032 7.098811442904469e-07 0.8493077402131245 \
7.098813273256562e-07 0.8502809338042043 7.098814984787831e-07 0.8511747489972419 7.098816731317363e-07 0.8520708361396651 7.098818483828913e-07 0.8529540285731302 \
7.098820245303913e-07 0.8538259128238825 7.098822148367787e-07 0.8547503816925358 7.098824054277478e-07 0.8556583881771193 7.098826059797908e-07 0.8565949481971697 \
7.098827985825885e-07 0.8574764650234362 7.098830093312883e-07 0.8584213553684483 7.098832373621856e-07 0.8594210644592908 7.098835032419522e-07 0.8605573106989262 \
7.098838018200941e-07 0.8617960322792503 7.098840779837292e-07 0.8629075153790151 7.098843622302292e-07 0.8640180616030438 7.098846364142308e-07 0.8650581816846495 \
7.098849086694401e-07 0.8660616517296992 7.098851788589146e-07 0.8670295451208139 7.098854360232381e-07 0.8679256252637404 7.098857085969722e-07 0.8688492356117473 \
7.098859846024351e-07 0.8697577927663542 7.09886254710518e-07 0.8706213441784563 7.098865545689378e-07 0.8715508809746347 7.098869255828163e-07 0.8726599440782473 \
7.09887220515529e-07 0.873510245983525 7.098874748008954e-07 0.8742218447789023 7.098877730441707e-07 0.8750318897722944 7.098880466409288e-07 0.8757523113099853 \
7.098882827679075e-07 0.8763571312809064 7.098885231072055e-07 0.876957042728428 7.098887454408612e-07 0.8774982514557473 7.098889394467937e-07 0.8779599514934209 \
7.098892691652286e-07 0.8787226653583874 7.09889424338019e-07 0.8790722725343518 7.098897420714095e-07 0.8797700114458387 7.098899209390604e-07 0.880152324917399 \
7.098902634005339e-07 0.8808637455080008 7.098904475523682e-07 0.8812353200296749 7.098909224784184e-07 0.8821594045029107 7.098910898716537e-07 0.8824737723885729 \
7.098915556929604e-07 0.8833186808430151 7.098917365204472e-07 0.883635209600208 7.098922305497856e-07 0.8844687288968743 7.098923718877728e-07 0.8846990198924604 \
7.098929782491027e-07 0.8856473543416146 7.098931303209552e-07 0.8858754372639542 7.098937770089477e-07 0.8868048391838264 7.09893905303109e-07 0.8869818633102416 \
7.098945534965822e-07 0.8878410756373726 7.098946832451334e-07 0.8880061989117775 7.09895451498601e-07 0.8889361126992519 7.098955812406254e-07 0.8890847997417872 \
7.098964346975574e-07 0.8900046759307325 7.098965779246734e-07 0.8901495209380393 7.098975641580769e-07 0.8910738355210844 7.09897785636141e-07 0.8912643084423501 \
7.098989286536885e-07 0.8921737958641509 7.098990586319893e-07 0.8922730011388891 7.099004103389882e-07 0.8932565980587214 7.099005606923423e-07 0.8933589605607284 \
7.09902041315768e-07 0.8942730372387374 7.0990228021907e-07 0.8944047337041336 7.099040613442277e-07 0.8952702388217941 7.099044473255946e-07 0.8954343910560414 \
7.099068488716344e-07 0.896309305076933 7.099073238084202e-07 0.8964562995603377 7.099111419701395e-07 0.8973944547681553 7.099116244593364e-07 0.897487269196476 \
7.099195104748493e-07 0.898471373493449 7.099201266375397e-07 0.8985180228791175 7.100152826123789e-07 0.899508178894561 7.100167732145567e-07 0.8995204306067698 \
7.101280612887406e-07 0.9005118233983579 7.101282376257435e-07 0.9005706457326812 7.10131860757067e-07 0.8996048713171836 7.101320419550936e-07 0.8994654179496379 \
7.101333530765704e-07 0.8985275682722235 7.101335349539762e-07 0.8984123497545736 7.101353579441702e-07 0.8974436520388238 7.101355178574243e-07 0.8973766233009967 \
7.10148668688723e-07 0.8983720910457982 7.101487796702764e-07 0.8983905835035384 7.101576012543832e-07 0.8993863063850064 7.101581480238466e-07 0.8994226481040219 \
7.106507199766804e-07 0.9003987622903815 7.106507897691656e-07 0.9004496773542636 7.106516224219291e-07 0.9012853800543292 7.10651748468094e-07 0.9014513953152168 \
7.106523289889574e-07 0.9023435091985418 7.106524699532118e-07 0.9025895326188698 7.106528690912907e-07 0.9033428289365844 7.106530192408316e-07 0.9036449200440446 \
7.106534623221535e-07 0.9045762589490434 7.106536194942561e-07 0.9049121924877023 7.106540651209874e-07 0.9058152254958243 7.106541635773263e-07 0.9059929146639856 \
7.106555802587203e-07 0.9052304871087643 7.10655711415865e-07 0.904616184869324 7.10655880423041e-07 0.9036290332250884 7.106560457149166e-07 0.9024406226812831 \
7.106561519806978e-07 0.9015554774641358 7.106562554175281e-07 0.9006052096506509 7.106563411842469e-07 0.8997486040545581 7.106564306782332e-07 0.8987887485205278 \
7.106565549226324e-07 0.8973492764100613 7.106566730035805e-07 0.8958624931586439 7.106567602196721e-07 0.8946938835082598 7.106568845267161e-07 0.8929289312882503 \
7.106569915106438e-07 0.8913158670103165 7.106570913423478e-07 0.8897378501708729 7.106572176331742e-07 0.8876466417139378 7.106573858217853e-07 0.884705368138502 \
7.106575415215381e-07 0.8818365157686672 7.106577381263672e-07 0.8780362649814708 7.106579217476167e-07 0.8743271923380105 7.106581332550105e-07 0.8698916163736473 \
7.106583140648105e-07 0.8659808238081558 7.106584986458582e-07 0.8618945354625286 7.106586716498537e-07 0.8579913311618118 7.106588570505038e-07 0.8537436868396935 \
7.106590361336512e-07 0.8495884889292737 7.106592197227131e-07 0.8452850234109005 7.106593864844182e-07 0.8413449312544377 7.10659554574996e-07 0.8373487193315756 \
7.10659717684167e-07 0.8334514816705533 7.106598728704026e-07 0.829729402178684 7.10660045969282e-07 0.8255639501984255 7.106602319597376e-07 0.8210763864673301 \
7.106603965802215e-07 0.8170961425007568 7.106605614501323e-07 0.8131038678717658 7.106607367821645e-07 0.8088537582860886 7.10660901208668e-07 0.8048648186953292 \
7.106610698442787e-07 0.8007719922541914 7.106612606476452e-07 0.7961398815555145 7.106614461718183e-07 0.7916360074082958 7.106616551006281e-07 0.7865651471012967 \
7.10661879917618e-07 0.7811107659751856 7.106620697327054e-07 0.77650678233121 7.106622715901883e-07 0.7716133355283564 7.106624158608268e-07 0.76811790639139 \
7.106625575043926e-07 0.7646880872338248 7.106626852021022e-07 0.7615975116975136 7.106627962479434e-07 0.7589113686396982 7.106629248105796e-07 0.7558028559024855 \
7.106630573760869e-07 0.7525995467138866 7.106631706977831e-07 0.7498629233610832 7.106633070324095e-07 0.7465723252212872 7.106634134316607e-07 0.7440058350410135 \
7.106635726504468e-07 0.7401674766516904 7.106637450281421e-07 0.7360137588823189 7.106639072753859e-07 0.7321074183421575 7.106640796243437e-07 0.7279612819449855 \
7.10664239010527e-07 0.7241302920521341 7.106644468157139e-07 0.7191408067115369 7.106646073553789e-07 0.7152908836069264 7.106647998447152e-07 0.7106793324906435 \
7.10664985361064e-07 0.7062404417184839 7.106651552371092e-07 0.7021802791355866 7.106653471069472e-07 0.6975984806629684 7.106654933309622e-07 0.6941099299715526 \
7.106656536173094e-07 0.6902897983225644 7.10665856006145e-07 0.6854719661536142 7.106660372946089e-07 0.681161582477689 7.106662061160357e-07 0.6771536053116509 \
7.106663919619109e-07 0.6727470762459599 7.106665978927512e-07 0.6678715161770782 7.10666765819558e-07 0.6639016226084196 7.106669260812615e-07 0.6601182542089066 \
7.106671649337354e-07 0.65448589698252 7.106673326948486e-07 0.6505369020837752 7.10667513768288e-07 0.6462813620835641 7.106676749231988e-07 0.642499550819208 \
7.106678211904597e-07 0.6390715923276049 7.106679598785689e-07 0.6358268652274862 7.106680892356149e-07 0.6328040340451749 7.106682186201701e-07 0.6297855584526113 \
7.106683469414899e-07 0.6267952385336898 7.106684771436295e-07 0.6237652412672913 7.106686061600736e-07 0.6207683673242944 7.10668744735633e-07 0.6175525629501428 \
7.1066889281122e-07 0.6141227553162802 7.106690791385051e-07 0.60981438109949 7.106692268222044e-07 0.6064079319686639 7.106694619864099e-07 0.600995965122186 \
7.106696544341406e-07 0.5965821560879089 7.106698950039548e-07 0.5910808370261941 7.106700640513256e-07 0.587228367631822 7.1067020171775e-07 0.5840969866928536 \
7.106703298227265e-07 0.581191110277254 7.106704434094219e-07 0.5786182870235701 7.106705347742257e-07 0.5765512826027382 7.106706241961132e-07 0.5745328691003393 \
7.106706914578463e-07 0.573016830490748 7.106707574780488e-07 0.5715297341779608 7.106708095317241e-07 0.5703577032508095 7.106708737705931e-07 0.5689124506700958 \
7.106709353071159e-07 0.5675311492520995 7.106709995886598e-07 0.5660899724818867 7.106710527797555e-07 0.5648985048860162 7.106711451255398e-07 0.5628316153148989 \
7.106712217014408e-07 0.5611191615154557 7.10671277545091e-07 0.5598732849310241 7.106713468881998e-07 0.5583285932816697 7.106714527394756e-07 0.5559733466166974 \
7.106715304312799e-07 0.5542469170533902 7.106716310298676e-07 0.5520159549745236 7.106717590630782e-07 0.5491849411292137 7.106718585604598e-07 0.5469885705929382 \
7.106719711258113e-07 0.544508366501287 7.106720741701315e-07 0.5422442603473754 7.106721942190172e-07 0.5396115972585003 7.106722958334261e-07 0.5373863339265779 \
7.10672411457693e-07 0.5348611538529422 7.106725265738741e-07 0.5323536236546169 7.106726530109181e-07 0.529604142030661 7.106727785251858e-07 0.5268822104345234 \
7.106729252048618e-07 0.5237112381511962 7.106730608755697e-07 0.5207845659358002 7.106732186414087e-07 0.5173942078023266 7.106733810633495e-07 0.5139116507621072 \
7.106735619718178e-07 0.5100482739823553 7.106737545639722e-07 0.5059503908118104 7.106739675557428e-07 0.5014368974673542 7.106741999884594e-07 0.4965308659362653 \
7.106744575093731e-07 0.49112491222925 7.106746974735513e-07 0.4861095397820235 7.106749986779056e-07 0.4798501326413723 7.106752869755342e-07 0.4738957353990632 \
7.106756000618611e-07 0.4674739717793394 7.106759195881406e-07 0.4609631488871989 7.106762590854062e-07 0.4540919149088484 7.106765852755183e-07 0.4475353831519197 \
7.106769217567802e-07 0.4408159131180407 7.106772384675872e-07 0.4345373385230166 7.106775725526604e-07 0.4279587671099637 7.106779242615286e-07 0.4210864038135054 \
7.106782387463783e-07 0.4149846225409808 7.106785621928357e-07 0.4087533091618546 7.106790031209485e-07 0.400331870031168 7.106793449160247e-07 0.3938679283557566 \
7.106796443500685e-07 0.3882534014213259 7.10680018872672e-07 0.3812944595528024 7.106803482503896e-07 0.375233915169682 7.10680631354694e-07 0.3700684563936956 \
7.106809310997049e-07 0.3646408765157301 7.106812105955488e-07 0.3596219010422631 7.10681434267487e-07 0.3556377385586224 7.106816459791946e-07 0.3518907610576284 \
7.106818484819267e-07 0.3483292724130969 7.10682049543475e-07 0.3448190020587957 7.106822552213836e-07 0.3412518188287665 7.106824735968597e-07 0.3374887625241871 \
7.106827173592565e-07 0.3333167726275162 7.106829441158294e-07 0.3294678078423895 7.106831640268007e-07 0.3257615367192951 7.106833824514083e-07 0.3221060038181086 \
7.106835864764178e-07 0.318715141566024 7.106837883342075e-07 0.3153870758963987 7.106839886575955e-07 0.3121102802474151 7.106841752715021e-07 0.309079115007194 \
7.106843725731086e-07 0.3058982938882217 7.10684581156335e-07 0.3025606704206737 7.106847867910569e-07 0.2992974534031506 7.106850115231367e-07 0.2957609785165763 \
7.106852284189794e-07 0.2923771984023277 7.106854360983307e-07 0.2891642611511841 7.106856671491776e-07 0.2856239464683982 7.10685841949429e-07 0.2829684481899911 \
7.10686021147604e-07 0.2802647299798244 7.106861900221201e-07 0.2777348429135014 7.106864183453934e-07 0.274348458173166 7.106865950826614e-07 0.2717528218126659 \
7.106867633653918e-07 0.2693020894036587 7.106869358321621e-07 0.2668230333489093 7.106870699344411e-07 0.264903804409765 7.10687215894446e-07 0.2628277003548514 \
7.106873545899465e-07 0.2608803500812688 7.106874768715512e-07 0.2591684246570544 7.106876109903814e-07 0.2572942758553639 7.106877400914858e-07 0.2554978336754472 \
7.106878595252204e-07 0.2538430842138498 7.106879863604196e-07 0.2520939183506197 7.106881060014414e-07 0.2504447954274527 7.106882556176352e-07 0.2483797066042054 \
7.106883904811462e-07 0.2465170278296022 7.106885200385602e-07 0.2447289494531232 7.106886771033789e-07 0.2425624627506451 7.106888010990138e-07 0.2408491463446025 \
7.106889412471492e-07 0.2389135279283614 7.106890711400503e-07 0.2371200701944942 7.106891917576704e-07 0.2354534357320198 7.106893542306008e-07 0.2332087289724075 \
7.106895002846996e-07 0.2311905595759856 7.106896386054839e-07 0.2292825126447264 7.106897465327019e-07 0.2277949627009887 7.106898773176092e-07 0.225993474229161 \
7.106899758236256e-07 0.22463752857886 7.106900799069717e-07 0.2232056532573264 7.106901527838363e-07 0.2222046546567725 7.10690234937313e-07 0.2210804129356655 \
7.106903023463979e-07 0.2201585377209549 7.106903490506606e-07 0.2195201149856669 7.106903984680203e-07 0.2188449488487562 7.10690489422163e-07 0.2176035744446363 \
7.10690555816576e-07 0.2166983392055156 7.106906027798693e-07 0.2160586379972232 7.106906530910749e-07 0.2153737902794619 7.106907122404248e-07 0.2145693142997165 \
7.106907550863284e-07 0.2139870779821451 7.10690798893629e-07 0.2133941263688522 7.106908684238941e-07 0.2124566309962414 7.106909553407081e-07 0.2112864027023158 \
7.106910365295632e-07 0.2101949018929156 7.106911224290263e-07 0.2090416531541652 7.106912165752074e-07 0.2077796428137634 7.10691308329081e-07 0.2065517647617813 \
7.106914036255171e-07 0.2052788208685862 7.106915001042082e-07 0.2039945431316728 7.106916009294901e-07 0.2026602783061639 7.106916968855022e-07 0.2013924147365721 \
7.10691799571213e-07 0.2000377255165624 7.106919026075664e-07 0.1986831378210229 7.10692012697906e-07 0.1972405340748948 7.106921214497938e-07 0.1958206085628783 \
7.106922411717489e-07 0.1942631948714586 7.106923516146512e-07 0.1928328887741874 7.106924596174587e-07 0.1914411844406488 7.10692584973803e-07 0.1898318066870429 \
7.106926779079788e-07 0.1886434908940876 7.106927562787551e-07 0.1876443873000938 7.10692832918829e-07 0.1866698667869858 7.106929154301432e-07 0.1856249297118943 \
7.106929849397591e-07 0.1847473639743596 7.106930508953873e-07 0.1839166514106665 7.106931151627221e-07 0.1831089953192083 7.106932271462069e-07 0.1817072258029639 \
7.106933212001736e-07 0.1805353135896268 7.106934288419354e-07 0.1791985758407087 7.106935353149933e-07 0.1778827552324552 7.106936553069198e-07 0.1764073736674057 \
7.106937933595455e-07 0.174720142305475 7.106939095201005e-07 0.1733081217455876 7.106940716169029e-07 0.1713503924599185 7.106941867054195e-07 0.1699688234017716 \
7.106943266910192e-07 0.1682987764548305 7.106944438970947e-07 0.1669083002780509 7.106945548164474e-07 0.1655990025649634 7.106946524449328e-07 0.1644521190704843 \
7.106947472954812e-07 0.1633427224865242 7.106948633498935e-07 0.161991523106341 7.106949548984438e-07 0.1609305136382055 7.106950510074198e-07 0.1598214181625073 \
7.106951452255533e-07 0.1587403933520305 7.106952387261563e-07 0.1576732160104884 7.106953323234783e-07 0.1566104070550305 7.106954280050165e-07 0.1555300824433628 \
7.106955185929211e-07 0.1545132165873678 7.106956096060781e-07 0.1534969984004868 7.106957051545556e-07 0.1524358767948732 7.106957958202681e-07 0.1514342506187442 \
7.106958988926308e-07 0.1503020548964867 7.106959713440796e-07 0.1495100717445464 7.106960504448726e-07 0.148649146151682 7.106961249930914e-07 0.1478424742503694 \
7.106961960245004e-07 0.1470770917224498 7.106962687889816e-07 0.1462962409077327 7.106963434061566e-07 0.1454990959398698 7.106964133891184e-07 0.1447543557055888 \
7.106964875500381e-07 0.143968261688537 7.106965412953772e-07 0.1434005634796054 7.106965945789318e-07 0.1428396203849428 7.106966597746903e-07 0.1421555039833398 \
7.106967310807313e-07 0.141411576573238 7.106967954507931e-07 0.1407432786314442 7.106968688027537e-07 0.1399847409254479 7.106969294203206e-07 0.1393607073002494 \
7.106970154538046e-07 0.1384787080092832 7.106970914048206e-07 0.1377037134581418 7.106971813727261e-07 0.1367902106004182 7.106972630996836e-07 0.1359645165492482 \
7.106973457896614e-07 0.1351360437760365 7.106974283459692e-07 0.1343145513298757 7.106975339081246e-07 0.1332698421778018 7.106976157754082e-07 0.1324642397250402 \
7.106977131428679e-07 0.1315110876582503 7.106978031437286e-07 0.130634908321232 7.106978911139876e-07 0.1297829978838479 7.106979740438425e-07 0.1289892226181523 \
7.106980482809344e-07 0.1282822873521282 7.106981479319927e-07 0.1273377645104763 7.106982436870517e-07 0.1264350619688987 7.106983305344565e-07 0.1256206895242312 \
7.106984205359939e-07 0.1247808744623497 7.106985008686745e-07 0.1240346855852102 7.10698587562703e-07 0.1232365419604467 7.106986863930319e-07 0.1223331159004786 \
7.106987764751697e-07 0.1215131568528167 7.106988867184272e-07 0.1205141992263624 7.106989739498661e-07 0.1197275966302077 7.106990425230002e-07 0.1191120727131645 \
7.106991271853926e-07 0.1183553887582162 7.106991936928737e-07 0.1177634990399222 7.106992651487992e-07 0.1171309945267847 7.10699334822604e-07 0.1165184920865242 \
7.106994121596921e-07 0.1158409171037389 7.106995079029744e-07 0.1150054407698888 7.106995791578869e-07 0.1143861389207103 7.106996465274203e-07 0.1138025718558601 \
7.106997149641909e-07 0.113211685696446 7.106997905545423e-07 0.1125613765304429 7.106998812963886e-07 0.1117840233035959 7.106999640001163e-07 0.1110788257213999 \
7.107000775991873e-07 0.1101151050704521 7.107001874748992e-07 0.1091895325357105 7.107002796742131e-07 0.1084169374841771 7.107004036235445e-07 0.1073835127717347 \
7.107004919878672e-07 0.1066505015902263 7.107006314468373e-07 0.1055001025916527 7.107007307435382e-07 0.1046863788921388 7.107008233935897e-07 0.1039306459201802 \
7.10700933598102e-07 0.1030359883605075 7.107010188925421e-07 0.1023467905686673 7.107011037933451e-07 0.101663637589173 7.107011867443086e-07 0.1009989740617136 \
7.107013092542103e-07 0.1000225794851696 7.107014311960625e-07 0.09905761200121259 7.10701557818349e-07 0.09806258992746317 7.107016706304718e-07 0.09718220909187772 \
7.107018152059564e-07 0.09606278874246346 7.107019529198845e-07 0.09500564015228773 7.107020696106742e-07 0.09411672853020667 7.107021973542415e-07 0.0931507147971556 \
7.107022970187578e-07 0.09240236948627445 7.107023764526374e-07 0.09180921593916676 7.107024751879353e-07 0.09107599640376031 7.107025530632389e-07 0.09050081472416407 \
7.107026345291548e-07 0.08990210528957472 7.107027092464628e-07 0.0893557072655629 7.107027897762005e-07 0.08876971652456604 7.107029086085258e-07 0.08791061481419053 \
7.107029982690621e-07 0.08726673116015753 7.107031031831091e-07 0.08651800316437093 7.107032346576667e-07 0.08558693768262025 7.107033957658019e-07 0.08445695903909305 \
7.107035359474972e-07 0.08348350561263763 7.107036844501031e-07 0.08246223579158835 7.10703821170292e-07 0.08153124812726546 7.107039611820024e-07 0.08058696725890066 \
7.10704098179202e-07 0.07967195061625794 7.107042367898133e-07 0.07875532825288725 7.107043812626999e-07 0.07780967510081127 7.107045288089374e-07 0.07685421131041187 \
7.107046863126477e-07 0.07584560580436887 7.107048507078841e-07 0.07480523464991846 7.107050187999819e-07 0.07375451744755303 7.10705199799341e-07 0.07263751640721161 \
7.107053985126234e-07 0.07142823309373261 7.10705611921415e-07 0.07014922396308329 7.107058380853001e-07 0.06881630383186611 7.107060786456225e-07 0.06742468841361035 \
7.107063562065354e-07 0.06585179211508728 7.107066534109385e-07 0.06420523370201831 7.107069717116617e-07 0.06248365192299224 7.10707361695962e-07 0.06043183534616462 \
7.107077605227481e-07 0.05839861031494715 7.10708202994687e-07 0.05621846258761681 7.107085879755897e-07 0.05438828987170503 7.107090000221824e-07 0.05249218901100536 \
7.10709351759698e-07 0.05092353490091287 7.107096872643497e-07 0.04946969867921969 7.107099977632445e-07 0.04816021644386199 7.107102917000642e-07 0.04695194805701195 \
7.107105844309969e-07 0.04577883625507727 7.107108592742044e-07 0.04470700909733757 7.107111331179271e-07 0.04366353526031765 7.107113988076876e-07 0.04267398813878486 \
7.107116741167033e-07 0.04167180388267511 7.107119586736206e-07 0.04066026046469497 7.107122549717361e-07 0.03963283340811159 7.107125138471216e-07 0.03875659098599576 \
7.107127418035276e-07 0.03800131046948733 7.107129605287219e-07 0.03729095380188759 7.107131803834488e-07 0.03659437723507575 7.107135212495135e-07 0.03554043311314246 \
7.107137972903942e-07 0.03470953269536187 7.107140907211691e-07 0.03384790442147732 7.107143732890922e-07 0.03303898052111545 7.107146281985287e-07 0.03232625790162248 \
7.107149088829883e-07 0.03155947796597136 7.107151547163818e-07 0.03090318379665042 7.107153868776701e-07 0.03029616297556957 7.10715627215008e-07 0.02968398395812225 \
7.107158628518432e-07 0.02909722707395018 7.107160910630208e-07 0.0285403787496557 7.107165078357495e-07 0.02755138287878544 7.107167023611269e-07 0.02710176794309662 \
7.107170886015322e-07 0.02623051698020805 7.10717267770925e-07 0.0258356865503758 7.107176189981086e-07 0.02507792837274256 7.107177869041566e-07 0.0247229612172224 \
7.107181711668123e-07 0.02392944198669211 7.107182864485406e-07 0.02369675911063252 7.107187284963782e-07 0.02282172072611499 7.107189503116516e-07 0.02239223679446916 \
7.107194739313108e-07 0.02139838041889957 7.107196292938196e-07 0.02110714647916685 7.107201469998876e-07 0.02015295207761772 7.10720272033152e-07 0.01992792118872039 \
7.107207962346589e-07 0.01901759738223179 7.107209324540342e-07 0.01879045572456909 7.107215387304897e-07 0.01783210191617334 7.107217057396231e-07 0.01758082406519646 \
7.107223489472666e-07 0.01666064795441237 7.107225280915353e-07 0.0164167113061686 7.107232182502689e-07 0.01551958953683085 7.107233818701531e-07 0.01531511209162885 \
7.107241423508397e-07 0.01440332854054019 7.107242893929629e-07 0.01423371673427115 7.107251072646214e-07 0.01333087949608782 7.107252268131343e-07 0.01320411419549955 \
7.107261426746556e-07 0.01227329163592313 7.107262840275722e-07 0.01213544173166964 7.107272325031483e-07 0.01124488043697059 7.107273911425863e-07 0.01110230805801717 \
7.1072857354363e-07 0.01011356759191894 7.107286716440201e-07 0.01003725601038859 7.107299332554799e-07 0.009120360285939955 7.107300676693303e-07 0.009028655389366201 \
7.107316082406548e-07 0.008043892937307966 7.107316892739986e-07 0.007992925041580451 7.107332778679313e-07 0.007023242357651564 7.10733410759078e-07 0.006948518507451114 \
7.107353874624202e-07 0.005952856104192286 7.107355692005682e-07 0.005869662958407677 7.107376715542283e-07 0.004980929874643355 7.107381123459968e-07 0.004810448874467742 \
7.107407675608551e-07 0.003892108290451164 7.107412441403943e-07 0.003745909362026665 7.107448822226149e-07 0.00279447349697209 7.107454077460605e-07 0.002678838783887205 \
7.107510138108453e-07 0.001700248310874221 7.107513248985468e-07 0.001653333728976835 7.107564592262457e-07 0.0006858192122199529 7.107566532060193e-07 0.0006440832883579712 \
7.134045769148618e-07 -0.0002037173203380238 7.134047411152831e-07 -0.0003889174928863678 7.134053144580911e-07 -0.001270938904608877 7.134053893922784e-07 -0.001411855863724778 \
7.134058499760551e-07 -0.002393592696522268 7.134059619168068e-07 -0.002660411672198376 7.134062151887948e-07 -0.003300974950034667 7.134063815720996e-07 -0.003745951779090856 \
7.134066765678696e-07 -0.004566571567208835 7.134067880554425e-07 -0.00488071790655901 7.134070674282164e-07 -0.005641221413069743 7.134071883865554e-07 -0.005938820066262044 \
7.134082823393885e-07 -0.005180465225493313 7.134084064716309e-07 -0.004410796826645887 7.134085308790491e-07 -0.003456122327429311 7.134086504354286e-07 -0.002364170815481491 \
7.134087485798049e-07 -0.001341064316055312 7.13408855004127e-07 -0.0001052154991983786 7.134089672399721e-07 0.001336046702817826 7.134091021958209e-07 0.003249882807978809 \
7.134092247823306e-07 0.005149402351921401 7.134094136442457e-07 0.008353592055059769 7.134095548265784e-07 0.01094873860302964 7.134097081879224e-07 0.01393943619118621 \
7.134098515614266e-07 0.01687898420971235 7.13410005752867e-07 0.02017576688295359 7.134101618928252e-07 0.02363796584892512 7.134103176188778e-07 0.02719811802828209 \
7.134104651125568e-07 0.03065407560139007 7.134106137843234e-07 0.03420778369279751 7.134107691144076e-07 0.03798436241030867 7.134109277402875e-07 0.04189786275883118 \
7.134110926734479e-07 0.0460171220807938 7.134112670963364e-07 0.05041857973200652 7.134114460857363e-07 0.05497510627343041 7.134116353855968e-07 0.05982852266675163 \
7.134118383936027e-07 0.06506368941101938 7.134120578706689e-07 0.07075025585284363 7.134122889353304e-07 0.07675903373893865 7.134125359956494e-07 0.08319974270080552 \
7.134128064206373e-07 0.0902619122132732 7.134130999843244e-07 0.09793335781011638 7.13413424033306e-07 0.1064001814721126 7.134137882548562e-07 0.1159066558703892 \
7.134141808063258e-07 0.1261372395632307 7.134146303042508e-07 0.1378252442462487 7.134151530964837e-07 0.1513754922073403 7.134157666942191e-07 0.1672157090591849 \
7.134164444550933e-07 0.184625848284817 7.134172327202124e-07 0.2047487967247964 7.134181155530716e-07 0.22712469896725 7.134189338390288e-07 0.2476994923478653 \
7.13419661268608e-07 0.2658503723959502 7.134203013816357e-07 0.2817009601644404 7.134208756853502e-07 0.2958213763442377 7.134214132513172e-07 0.3089396094373287 \
7.134219172487761e-07 0.3211464104224903 7.134223933714299e-07 0.3325930942309646 7.134228712594449e-07 0.3439912352478621 7.134233245925507e-07 0.3547121966731367 \
7.134237958852586e-07 0.3657614311162562 7.134242385610846e-07 0.3760518588326446 7.134247570598719e-07 0.3879885572071845 7.134252842219919e-07 0.3999987293386327 \
7.134256631316234e-07 0.4085537955782026 7.134261930471662e-07 0.4204060347738258 7.13426622963746e-07 0.429919877745455 7.134270766645208e-07 0.4398653393542544 \
7.134275433780368e-07 0.4500002271552926 7.134279810592672e-07 0.4594210430579985 7.134283890215308e-07 0.468120704286539 7.134287084545645e-07 0.4748816926501604 \
7.134290805898365e-07 0.4826992142337162 7.134293155719776e-07 0.4876010339127531 7.13429549178225e-07 0.4924491904621348 7.134297971906479e-07 0.4975647713404599 \
7.134300955920778e-07 0.5036796627825791 7.134303519484798e-07 0.5088948470128004 7.134305642417897e-07 0.5131878547336713 7.134307582598616e-07 0.5170959594548015 \
7.134309052463942e-07 0.5200432695146362 7.134310592244046e-07 0.523118600542271 7.134312771061537e-07 0.5274469616807909 7.134315302104803e-07 0.5324525256580425 \
7.134317400493245e-07 0.5365797337241586 7.134319515026335e-07 0.5407247601751553 7.134322337095338e-07 0.5462280430697679 7.134324632548168e-07 0.5506821559930507 \
7.134326791510235e-07 0.5548604062613707 7.134329613725408e-07 0.560308769190463 7.134332126802682e-07 0.5651538146135803 7.134335103411598e-07 0.5708625224168123 \
7.134337605680606e-07 0.5756519166658941 7.134340169315557e-07 0.5805516059354519 7.134342573415698e-07 0.585116682128892 7.134345155213862e-07 0.5900038400537884 \
7.134347391135916e-07 0.5942175703762435 7.134349776231627e-07 0.5986919452581434 7.134351852078614e-07 0.6025689278491061 7.134354017304865e-07 0.6065904171332736 \
7.134356510330918e-07 0.6111939272561876 7.134358561065347e-07 0.6149609706257601 7.134361073788606e-07 0.6195555361399968 7.134363106008859e-07 0.6232455818254186 \
7.134365074727913e-07 0.6267987644955494 7.134367007643072e-07 0.630267737067843 7.134369555427622e-07 0.6348113783570861 7.13437185753374e-07 0.638887973644319 \
7.134374031071848e-07 0.6427143472883045 7.134377015129076e-07 0.6479268061885751 7.134379169157571e-07 0.6516657345437264 7.134381181394756e-07 0.6551344108237934 \
7.134382930609835e-07 0.6581323437428509 7.134384581262539e-07 0.6609495238976936 7.134386275947745e-07 0.6638251431769452 7.134387797316125e-07 0.666392827642013 \
7.134389176422984e-07 0.6687037209181631 7.134390664784122e-07 0.6711867545200138 7.134391945930142e-07 0.6733159837320549 7.134393378158276e-07 0.6756849429836936 \
7.134394590900776e-07 0.6776819274526149 7.134395966887616e-07 0.6799401191146522 7.13439716069216e-07 0.6818929034138137 7.134398631769623e-07 0.6842914131385206 \
7.134399803786277e-07 0.6861933934268433 7.13440073884205e-07 0.6877071857403232 7.134401648738969e-07 0.6891752279197846 7.134402676159613e-07 0.6908280855439021 \
7.134403691335248e-07 0.6924555900607121 7.134404875166308e-07 0.6943444167618776 7.134405996372169e-07 0.6961264383846065 7.13440717192718e-07 0.6979868779962457 \
7.134409023430049e-07 0.7008959348649784 7.134410335352131e-07 0.7029413755586562 7.134411697037527e-07 0.7050491462541959 7.13441291222456e-07 0.7069171228306749 \
7.134414311454678e-07 0.7090538254196674 7.134415350881169e-07 0.7106315721465845 7.134416462491006e-07 0.712309798010818 7.134417505089649e-07 0.7138759052437967 \
7.134418801470564e-07 0.7158124745844324 7.134419770777692e-07 0.7172526339884565 7.134421160000041e-07 0.7193052800722975 7.134422355492926e-07 0.7210612846995991 \
7.134423551218654e-07 0.7228080613301419 7.134424808972429e-07 0.7246353354365959 7.134426076155856e-07 0.7264656873164689 7.134427296554369e-07 0.728218443613998 \
7.134428578038805e-07 0.7300486655261287 7.13442987872205e-07 0.7318956587421809 7.134431088632273e-07 0.7336041830685722 7.134432496338107e-07 0.7355801168346318 \
7.134433506033799e-07 0.7369898206659778 7.134434522042367e-07 0.7384020079314992 7.13443548224548e-07 0.7397310783624924 7.134436591374028e-07 0.7412570822736337 \
7.134437467850298e-07 0.7424563811251772 7.134438466394007e-07 0.7438154404043728 7.134439814045385e-07 0.7456370856934184 7.13444097699018e-07 0.747198032089633 \
7.13444201190815e-07 0.7485782798032956 7.134443254462628e-07 0.7502239458264747 7.134444703592029e-07 0.7521280942578691 7.134445883397714e-07 0.753666143975803 \
7.134447072708787e-07 0.7552056331692281 7.134448468504184e-07 0.7569980918234445 7.134449912028081e-07 0.7588357421297242 7.134451092636163e-07 0.7603265096672839 \
7.134452340853355e-07 0.7618908200857619 7.134453739165311e-07 0.7636286950759973 7.134454986794279e-07 0.7651662633748356 7.134456421928986e-07 0.7669199865864609 \
7.134457628783765e-07 0.7683824344671055 7.13445883722124e-07 0.7698356273746885 7.134460033670484e-07 0.7712633747646481 7.134461330746873e-07 0.7727989859455529 \
7.134462418184901e-07 0.7740766298596218 7.134463644662266e-07 0.7755070372682662 7.134464742429112e-07 0.7767778749889983 7.13446603267025e-07 0.7782599816788072 \
7.134467350433437e-07 0.7797610257751375 7.134468483559198e-07 0.7810403609326458 7.134469694418617e-07 0.7823954393038701 7.134470733144949e-07 0.7835479431998941 \
7.134472155975174e-07 0.785111775748914 7.134473638006659e-07 0.7867227488076519 7.134475226942011e-07 0.7884297907063792 7.134476428872233e-07 0.7897074707829422 \
7.134477924539297e-07 0.7912811323018302 7.134479165691468e-07 0.7925734175081853 7.134480422734439e-07 0.7938699048627912 7.134481452190108e-07 0.7949224966762399 \
7.134482595901654e-07 0.7960823495211882 7.134483720644089e-07 0.7972131756542409 7.134484623369832e-07 0.7981137961420948 7.134485516778793e-07 0.7989989930139054 \
7.134486769038166e-07 0.800229513878344 7.134487846751798e-07 0.8012785338618679 7.134489143429785e-07 0.8025281307685926 7.134490357222573e-07 0.8036855380110038 \
7.134491522780568e-07 0.8047859282369955 7.134492730834528e-07 0.80591497746663 7.134494057087579e-07 0.8071413435168892 7.134495275023783e-07 0.8082555056211007 \
7.13449654106103e-07 0.8094015704683005 7.134497797196214e-07 0.8105266036187198 7.13449899211046e-07 0.8115857443778658 7.134500374092988e-07 0.8127973981963581 \
7.134501469085475e-07 0.8137473213416323 7.134502310566626e-07 0.8144713378799666 7.134503518607202e-07 0.8155017394983226 7.134504473695571e-07 0.8163089346032877 \
7.134505836603602e-07 0.8174496006492775 7.134507264244139e-07 0.8186303638797883 7.13450860857535e-07 0.8197292014569521 7.13450970729519e-07 0.8206175763825388 \
7.134511146291366e-07 0.8217677661037901 7.134512679567201e-07 0.8229768690765377 7.134513958055741e-07 0.8239722812379519 7.134515362029048e-07 0.8250521595273246 \
7.134516621078439e-07 0.8260088941474263 7.134518167240101e-07 0.8271688948348412 7.134519490793395e-07 0.8281489842609937 7.134520753461681e-07 0.8290730392392056 \
7.134521930066954e-07 0.8299245984162376 7.134523414090921e-07 0.8309852945996649 7.134525086032604e-07 0.8321626230293395 7.134526413805716e-07 0.8330844501529713 \
7.134528142817686e-07 0.8342675727345584 7.134529826990627e-07 0.8354015168591284 7.134531521935363e-07 0.8365246342267009 7.134533336304179e-07 0.8377070668209077 \
7.134534761865593e-07 0.8386219603417975 7.134535900974499e-07 0.8393441765511721 7.134537209736585e-07 0.8401643924869071 7.134538225966329e-07 0.8407940582489307 \
7.134539390368715e-07 0.8415078269750864 7.134540743300576e-07 0.8423269142909066 7.134542715951592e-07 0.8435017451489455 7.134544621144827e-07 0.844614933042255 \
7.13454672039296e-07 0.8458175693076773 7.134548528178267e-07 0.8468334846981137 7.134550501858462e-07 0.8479221976595614 7.134552240443405e-07 0.8488638701886076 \
7.134554065585833e-07 0.8498353939890455 7.134555779026935e-07 0.8507314120859523 7.13455752248258e-07 0.8516272398309612 7.134559276512583e-07 0.8525125793730954 \
7.134561038964482e-07 0.8533864315694911 7.134562936653265e-07 0.8543099749208749 7.134564844233441e-07 0.8552205033559714 7.1345668621255e-07 0.8561646193034282 \
7.134568789161161e-07 0.8570482883232282 7.134570883567926e-07 0.8579892478796384 7.134573180985592e-07 0.8589986827500428 7.134575835675109e-07 0.8601360945383778 \
7.134578822138556e-07 0.8613786760148464 7.134581606012222e-07 0.8625023989005415 7.134584447911769e-07 0.8636161469557806 7.134587192857839e-07 0.8646608622318305 \
7.134589913772806e-07 0.8656672252055042 7.134592615937267e-07 0.8666387059277968 7.134595187619145e-07 0.8675381145236246 7.134597913209795e-07 0.8684653318325959 \
7.1346006734232e-07 0.8693777905953765 7.13460337484171e-07 0.8702455402709716 7.134606372319546e-07 0.8711796653984102 7.134610081058123e-07 0.872294745819888 \
7.134613030287966e-07 0.8731503023941 7.134615572848448e-07 0.8738665406311316 7.134618555155771e-07 0.8746822274488602 7.134621291339016e-07 0.8754080260278182 \
7.134623652695491e-07 0.8760175227551726 7.134626056214058e-07 0.876622281264788 7.134628279637853e-07 0.8771680781109068 7.134630219681284e-07 0.8776338860468618 \
7.134633516912074e-07 0.8784037109613512 7.1346350686397e-07 0.8787567114621292 7.134638246164967e-07 0.879461652496718 7.134640034818579e-07 0.8798480920375044 \
7.134643459433237e-07 0.8805675499479563 7.134645300848474e-07 0.8809434933546246 7.134650049902839e-07 0.8818790560183651 7.134651723847029e-07 0.8821975058309585 \
7.134656382161285e-07 0.8830540251881659 7.134658190409674e-07 0.8833751042472839 7.134663130743468e-07 0.8842212008576973 7.134664544170556e-07 0.884455124402366 \
7.13467060806836e-07 0.8854193259359495 7.134672128789829e-07 0.8856514227360587 7.134678595574705e-07 0.8865980751852495 7.134679878538246e-07 0.8867785329419297 \
7.13468635979926e-07 0.8876550049536978 7.134687657724472e-07 0.8878236738033012 7.134695440340946e-07 0.8887860366092379 7.134696590259732e-07 0.8889208282599539 \
7.134705147583919e-07 0.8898661633196656 7.134706600215368e-07 0.8900169066926564 7.134716457777221e-07 0.8909664261264102 7.134718668828627e-07 0.8911622482549515 \
7.134730119973067e-07 0.8921020388386462 7.134731432072641e-07 0.8922053928944147 7.134743308657994e-07 0.8931033243919096 7.134744844860915e-07 0.8932130731307282 \
7.13475894522803e-07 0.8941348173026452 7.134761173296219e-07 0.8942660193790342 7.134777980203303e-07 0.8951452796684343 7.134781256415096e-07 0.8952966652167414 \
7.134803555826309e-07 0.8961896554712738 7.134809084965924e-07 0.8963788593752812 7.134844767111233e-07 0.8973573335043913 7.134848002235382e-07 0.8974284307984646 \
7.134911566318258e-07 0.8984120886469452 7.134917055346727e-07 0.8984686671268907 7.13544207609024e-07 0.8994658645395698 7.135448506378864e-07 0.8994692460188505 \
7.137369893085194e-07 0.9004073346715066 7.137371907224907e-07 0.9004708280105613 7.137411505004318e-07 0.8995366825576255 7.137413345272296e-07 0.8993953949813248 \
7.137426511245044e-07 0.8984641879157507 7.137428231683587e-07 0.8983566564859006 7.137447195446537e-07 0.8973720929359315 7.137448932508418e-07 0.897304621671452 \
7.137574671778748e-07 0.8982933655523699 7.137575523681118e-07 0.8983081509245614 7.137658192411513e-07 0.8993078551592517 7.137662939605717e-07 0.8993433667976791 \
7.142597948700116e-07 0.9002974142054325 7.142599143497356e-07 0.9003767372269074 7.142608071727864e-07 0.9012336455299185 7.142609534294226e-07 0.901423267690772 \
7.142615483221008e-07 0.9023325668564308 7.142616832929176e-07 0.9025673929107925 7.142621879687069e-07 0.9035294259428087 7.142623205796079e-07 0.9038000271808221 \
7.142627212069726e-07 0.9046475051114249 7.142628655723708e-07 0.9049556543240072 7.142632886935801e-07 0.9058123566484279 7.142633841506385e-07 0.9059850892484415 \
7.142648087094547e-07 0.9052205906349737 7.142649337473087e-07 0.9046352442223391 7.14265060157898e-07 0.9039223775493039 7.142651628066418e-07 0.9032486771507763 \
7.142652900219319e-07 0.9022944222362175 7.142654088677579e-07 0.9012801950564071 7.142655065202371e-07 0.9003603330664713 7.142655885222584e-07 0.8995243596151602 \
7.142656681858213e-07 0.8986589236008835 7.142657789639895e-07 0.8973708307079206 7.142658801400035e-07 0.8961049472956977 7.142659630844751e-07 0.8950067229086057 \
7.142660715298925e-07 0.8934921260891034 7.1426617999385e-07 0.8918872687155874 7.14266275049989e-07 0.8904106867557802 7.142663959226416e-07 0.8884444419111864 \
7.14266516699262e-07 0.8863849482818795 7.142666297444326e-07 0.8843763393508186 7.142667329151817e-07 0.8824794505619851 7.142668185153381e-07 0.8808620855018965 \
7.142668929893991e-07 0.8794251273161163 7.142669873129417e-07 0.8775673968166831 7.142670757738576e-07 0.8757888800524039 7.142671548468696e-07 0.8741711975775893 \
7.142672488342246e-07 0.872216793437976 7.142673301795292e-07 0.8704993514258973 7.14267425093555e-07 0.8684673705816817 7.14267518136275e-07 0.8664480751909672 \
7.142676149220692e-07 0.8643215060814092 7.142677382174414e-07 0.8615778533848952 7.142678516644525e-07 0.859022019682563 7.142679775164912e-07 0.8561558571929792 \
7.142681008446355e-07 0.8533196845306243 7.142682300229265e-07 0.850323637950593 7.14268370619783e-07 0.8470370034914 7.142684793995045e-07 0.8444782910716596 \
7.142686144592575e-07 0.8412850455921466 7.142687241195659e-07 0.8386804253780991 7.142688532993453e-07 0.8356002443501571 7.14268979483175e-07 0.8325812421138936 \
7.142691065735304e-07 0.8295317031556502 7.142692355958039e-07 0.826427745883674 7.142693446760448e-07 0.8237985689995477 7.142694845267009e-07 0.8204223029647078 \
7.142696239548932e-07 0.8170507778356514 7.142697567085239e-07 0.8138366863616762 7.142698867771992e-07 0.8106848159989707 7.142700104726457e-07 0.8076853837479523 \
7.142701474270357e-07 0.8043627031572629 7.142702611388824e-07 0.8016030849198694 7.142703886159226e-07 0.7985086235398901 7.14270499416994e-07 0.7958187897651571 \
7.142706186034521e-07 0.7929254985494992 7.142707319825085e-07 0.7901733724735396 7.142708662929012e-07 0.7869138859547327 7.142709733871686e-07 0.7843152933129034 \
7.142710894043116e-07 0.7815009627552112 7.142712185952754e-07 0.778367508739124 7.142713162077106e-07 0.7760002683782802 7.142714217871509e-07 0.773440790716327 \
7.142715304693198e-07 0.7708069008430674 7.142716328855832e-07 0.7683258101021144 7.142717262792412e-07 0.7660641808432364 7.142718458350171e-07 0.7631702213567544 \
7.142719383073787e-07 0.7609327305817616 7.14272030945494e-07 0.7586922094322426 7.142721293703097e-07 0.7563124992069843 7.142722373479616e-07 0.7537030947613649 \
7.142723336164742e-07 0.7513778334636231 7.142724198728768e-07 0.7492952979736797 7.142725227366661e-07 0.7468128004450286 7.14272601580994e-07 0.744910856519283 \
7.142727023870358e-07 0.7424801602439853 7.142728369152764e-07 0.7392377693660663 7.142729741401358e-07 0.7359316755186537 7.142731176199872e-07 0.7324773442723981 \
7.142732660441767e-07 0.7289066083419234 7.142734093054719e-07 0.7254625447335662 7.142735493824514e-07 0.7220977259655398 7.142737058083174e-07 0.7183435968963056 \
7.142738302100673e-07 0.715360858370426 7.14273951271848e-07 0.7124600029613375 7.1427410478411e-07 0.7087850045121084 7.142742395660554e-07 0.7055614325718365 \
7.142743656650877e-07 0.7025479112911024 7.142745088393713e-07 0.6991289103945657 7.142746289211628e-07 0.6962626602560111 7.142747581554913e-07 0.6931807499479741 \
7.142748646405391e-07 0.6906432840523983 7.142749769163615e-07 0.6879696524977363 7.142750732516476e-07 0.6856773754336868 7.142751760613402e-07 0.683232326200841 \
7.14275270865193e-07 0.6809792012818872 7.14275376187123e-07 0.6784784437814733 7.14275484625777e-07 0.6759058899658261 7.142755836350576e-07 0.673558569590366 \
7.142757003916503e-07 0.6707929011939652 7.142758084769278e-07 0.6682347329991606 7.142759184831366e-07 0.6656332609774134 7.142760045709786e-07 0.6635992664604092 \
7.142761341661182e-07 0.6605400273835189 7.142762267673658e-07 0.6583552307294462 7.142763225550924e-07 0.6560965362104854 7.142764075070783e-07 0.6540950852804182 \
7.142765268016021e-07 0.6512869789851043 7.142766140715398e-07 0.6492343850333612 7.142767047785614e-07 0.6471030993779646 7.14276805943536e-07 0.6447280068361273 \
7.142768857743593e-07 0.6428551652550211 7.142769745601937e-07 0.6407732405330839 7.142770522504205e-07 0.6389536101386547 7.142771140193683e-07 0.6375081226244841 \
7.142771777840134e-07 0.6360167668935747 7.142772410182331e-07 0.634538653569437 7.142772802588059e-07 0.6336218002627473 7.142773208978281e-07 0.6326726453797233 \
7.142774009823624e-07 0.6308039353694699 7.142774708865426e-07 0.6291742390428672 7.142775215232567e-07 0.6279942052995945 7.142775602728994e-07 0.6270914175114127 \
7.142775992678787e-07 0.6261832343283663 7.142776438826266e-07 0.6251445623164014 7.142776867390832e-07 0.6241478292286105 7.142777370536867e-07 0.6229782634938205 \
7.142777889908641e-07 0.6217719122409077 7.142778740584486e-07 0.6197972300178722 7.142779340388659e-07 0.6184052992407258 7.142780238260749e-07 0.61632338076978 \
7.142781002901565e-07 0.6145529519516876 7.142781798544472e-07 0.6127119801362371 7.142782608910593e-07 0.6108383709630588 7.142783501053817e-07 0.6087775861620425 \
7.142784409653938e-07 0.6066826282541496 7.142785281841023e-07 0.6046739453334793 7.142786219572931e-07 0.6025158549334848 7.142787236427564e-07 0.6001788642681311 \
7.142788232408485e-07 0.5978941858483342 7.142789350958888e-07 0.5953317151711254 7.14279051129026e-07 0.5926772450523136 7.142791727501318e-07 0.5899020947998995 \
7.142792771339459e-07 0.5875236635596754 7.142794219241658e-07 0.5842296531729801 7.142795345841267e-07 0.5816734289694181 7.14279643596094e-07 0.5792035939892568 \
7.142797360755373e-07 0.5771100174076607 7.142798295261765e-07 0.5749994714793375 7.142799218520404e-07 0.5729181236728181 7.142799944387413e-07 0.571283073141143 \
7.142800503929671e-07 0.5700232888304386 7.142801114612484e-07 0.5686498830286455 7.142802099507645e-07 0.5664400707212188 7.142802731622084e-07 0.5650238531380825 \
7.142803335881769e-07 0.5636708824310654 7.142804105365601e-07 0.5619492451093103 7.142804736951014e-07 0.5605380106414651 7.142805620087099e-07 0.558569506627369 \
7.14280633210033e-07 0.5569845302974165 7.14280719745787e-07 0.555060151797141 7.142808410985601e-07 0.5523665438352664 7.142809690278082e-07 0.5495364947125975 \
7.142810671584391e-07 0.5473694328713704 7.142811802824346e-07 0.5448752016832871 7.14281282350254e-07 0.5426314425864434 7.142814012991245e-07 0.5400217272291628 \
7.142815043868321e-07 0.5377630705755105 7.142816185939864e-07 0.5352670017334624 7.142817320096582e-07 0.532794946211756 7.14281859080713e-07 0.5300302694710822 \
7.142819829008019e-07 0.5273426867079006 7.142821276896071e-07 0.5242103332418484 7.142822635131097e-07 0.5212782585303676 7.142824185679684e-07 0.5179428401013338 \
7.142825794198527e-07 0.5144913885072363 7.142827581493005e-07 0.5106699876709851 7.1428294832834e-07 0.5066200804011861 7.142831582303622e-07 0.5021665212646098 \
7.142833869363468e-07 0.4973332357952056 7.142836408642852e-07 0.4919960258408594 7.142838817977506e-07 0.4869529241725989 7.142841779602358e-07 0.4807889695952298 \
7.14284467957623e-07 0.4747910561470179 7.142847742009557e-07 0.4684976697011882 7.142850948768875e-07 0.4619520863481486 7.142854227440541e-07 0.4553041925245184 \
7.142857629891091e-07 0.4484521981997251 7.142860884146544e-07 0.4419418052309769 7.142864103218021e-07 0.4355465312739703 7.142867405359072e-07 0.4290298934287748 \
7.142870965284996e-07 0.4220583188787752 7.142874154069286e-07 0.4158579595363656 7.14287752858691e-07 0.4093433989943853 7.142881807254075e-07 0.4011531841887147 \
7.142885294373556e-07 0.3945419525178304 7.142888370733193e-07 0.388759214407489 7.142892168998106e-07 0.3816861832573664 7.142895480893721e-07 0.3755780492082042 \
7.142898316974524e-07 0.370391509977049 7.142901425163967e-07 0.3647512908748707 7.142904218330045e-07 0.3597258263082204 7.142906483291526e-07 0.3556836811642302 \
7.142908640115378e-07 0.3518598964090484 7.142910612955428e-07 0.3483842179544538 7.142912662800023e-07 0.3447988491770444 7.142914785019664e-07 0.3411119200457455 \
7.142917338071541e-07 0.33670771290924 7.142919753294026e-07 0.3325734463267218 7.14292206706731e-07 0.3286464933807047 7.142924215592308e-07 0.3250253651850565 \
7.142926421183882e-07 0.3213332986541765 7.142928435443551e-07 0.3179852906236645 7.142930466126061e-07 0.3146379646143546 7.142932445082156e-07 0.3114011111455273 \
7.142934314693022e-07 0.3083651674074345 7.142936252695217e-07 0.3052406640298299 7.142938291861338e-07 0.3019773030815858 7.142940082554677e-07 0.2991336297844484 \
7.14294243846324e-07 0.2954229173226265 7.142944446504233e-07 0.2922868215109002 7.142946458293146e-07 0.2891696385850206 7.142948696390574e-07 0.2857334090862961 \
7.142950342018032e-07 0.2832271910241367 7.142952111291889e-07 0.2805503385691353 7.14295396922194e-07 0.2777610713150803 7.142955787376701e-07 0.2750538970423583 \
7.142957577624632e-07 0.2724132377985424 7.142959251076164e-07 0.2699606650006489 7.142960855365337e-07 0.2676371805838822 7.142962081102854e-07 0.2658719571410424 \
7.142963578748139e-07 0.2637236906090554 7.142964855719403e-07 0.2619099339733745 7.14296592880312e-07 0.2603957336038235 7.142967088809744e-07 0.2587625259947361 \
7.142968191895705e-07 0.2572125806747212 7.142969450687671e-07 0.2554509781935611 7.142970605506182e-07 0.2538402638894013 7.142971951315211e-07 0.2519757335310172 \
7.142973071947753e-07 0.2504255755821768 7.142974575341346e-07 0.2483447107137444 7.142975971599892e-07 0.2464124269747185 7.142977430518096e-07 0.2444035064209518 \
7.142978760124476e-07 0.2425734862730615 7.14297999574161e-07 0.2408709992523319 7.142981467838532e-07 0.2388417729476062 7.142982633706824e-07 0.2372355665500016 \
7.142984028258316e-07 0.23532008003217 7.142985370003013e-07 0.2334768281602104 7.142986629767574e-07 0.2317465561243653 7.142987823761605e-07 0.2301094434087779 \
7.142988772305854e-07 0.2288105340759602 7.142989903681845e-07 0.2272617792622066 7.142990706846421e-07 0.2261626001158484 7.142991582496985e-07 0.2249657246820506 \
7.142992837868356e-07 0.2232507767215072 7.142993894805427e-07 0.2218101326756785 7.142994791350539e-07 0.2205921574607158 7.14299549986253e-07 0.2196300825522397 \
7.142995930147826e-07 0.2190460135436258 7.142996353053263e-07 0.2184724035808872 7.142996776470424e-07 0.2178984240735344 7.142997498424615e-07 0.2169203674089526 \
7.142997922358173e-07 0.2163464205126744 7.14299827490656e-07 0.2158693585303403 7.142998716822395e-07 0.2152716287340076 7.142999412904664e-07 0.2143309212991285 \
7.142999756337965e-07 0.2138672544767182 7.143000200933248e-07 0.2132698436071631 7.143000877718061e-07 0.2123628126304402 7.143001741990649e-07 0.2112058698236149 \
7.143002488356675e-07 0.2102078598594563 7.143003301376756e-07 0.2091219706754807 7.143004270150593e-07 0.2078300362310651 7.143005529985482e-07 0.2061528795789772 \
7.143006555333841e-07 0.2047906894256944 7.143007570169014e-07 0.2034500128132261 7.143008580825969e-07 0.202119416354989 7.143009546968166e-07 0.2008491615811921 \
7.143010566612396e-07 0.1995112314821507 7.143011633834835e-07 0.1981153840927639 7.143012717886237e-07 0.1967018790395962 7.143013837827796e-07 0.1952465002768531 \
7.143014962499069e-07 0.1937897263683151 7.143016083232463e-07 0.1923454332378671 7.143017162157206e-07 0.1909603537828802 7.143018175986493e-07 0.1896629368444172 \
7.143019092360985e-07 0.1884941330679491 7.143020032117073e-07 0.1872990757663449 7.143020744780721e-07 0.1863957871745983 7.143021511533599e-07 0.1854271890400033 \
7.143022548124749e-07 0.184122202819407 7.143023284795955e-07 0.1831974022686171 7.143024018254956e-07 0.1822796569444652 7.143025152158449e-07 0.1808667181969195 \
7.143026030744852e-07 0.1797760932362061 7.143026869231621e-07 0.1787387947787487 7.143028158855897e-07 0.1771515524267008 7.143029177720844e-07 0.1759040172436072 \
7.143030234727908e-07 0.1746156056808686 7.143031251208657e-07 0.1733818993219825 7.143032559825841e-07 0.1718019019596718 7.143033631792215e-07 0.1705140034701537 \
7.14303492508118e-07 0.168969083715685 7.143036042046102e-07 0.167642098072289 7.143037045351886e-07 0.1664555496840579 7.143038003357432e-07 0.1653276075899142 \
7.143039111480153e-07 0.1640289617085985 7.143039985482962e-07 0.1630090521997956 7.143041098694133e-07 0.1617156184952586 7.143042028212722e-07 0.1606409001560029 \
7.143042903941501e-07 0.1596330843918451 7.143043920250233e-07 0.1584700928658864 7.14304476479078e-07 0.1575086241734052 7.143045515834574e-07 0.1566573095634876 \
7.143046294056998e-07 0.1557789554714152 7.143047097635688e-07 0.1548759612316424 7.143048108183989e-07 0.1537464547857493 7.143048932519626e-07 0.1528311848879565 \
7.143049855565143e-07 0.1518114053368895 7.143050624909871e-07 0.150965812476358 7.143051454135576e-07 0.1500585909391909 7.143052169442981e-07 0.1492793026301012 \
7.143053133277974e-07 0.1482344968214558 7.143053835562832e-07 0.1474766665551334 7.143054665365612e-07 0.1465853655470201 7.143055279788246e-07 0.1459298106834085 \
7.143055996612093e-07 0.1451677491870439 7.14305668289752e-07 0.1444408762699853 7.143057185582615e-07 0.1439102090153988 7.143057661380673e-07 0.143409423336876 \
7.143058201874179e-07 0.1428423132663369 7.143058795295158e-07 0.1422216078256897 7.143059475649228e-07 0.1415124633834424 7.14306023828345e-07 0.1407207186008814 \
7.143060921081446e-07 0.1400161356079559 7.143061868943229e-07 0.1390460813732662 7.143062764481352e-07 0.1381341561933974 7.143063481336088e-07 0.1374075731330657 \
7.143064320850176e-07 0.1365606113096345 7.143064973974727e-07 0.1359045398875483 7.143065588405982e-07 0.1352895588344758 7.143066331170967e-07 0.1345490408254265 \
7.143066953273574e-07 0.1339328028964004 7.143067632983656e-07 0.133265236037424 7.143068225054055e-07 0.1326856657519672 7.143068951778785e-07 0.1319767402814105 \
7.143069701979877e-07 0.1312477270463112 7.143070556514106e-07 0.1304208267333309 7.143071417517503e-07 0.1295914604616623 7.143072418772051e-07 0.1286317929389105 \
7.143073231668748e-07 0.127857435971709 7.143074249342227e-07 0.1268981149578782 7.143075091821821e-07 0.1261072369695883 7.143076079989111e-07 0.1251836587365037 \
7.143076808394557e-07 0.1245055382686853 7.143077608655429e-07 0.1237631876254407 7.14307831351338e-07 0.1231117958237987 7.143079038817605e-07 0.1224439308288319 \
7.143079813507563e-07 0.1217331219782777 7.143080887021039e-07 0.1207554316575004 7.143081893401196e-07 0.1198442997624752 7.143082619276735e-07 0.1191899427853172 \
7.143083307595137e-07 0.1185715582611356 7.143083965463339e-07 0.1179824683205609 7.143084661751317e-07 0.1173610347366148 7.143085365588769e-07 0.1167350538439435 \
7.143086117372495e-07 0.1160688810594495 7.143087159914846e-07 0.1151493019715505 7.143087911261386e-07 0.114489769343061 7.14308860041223e-07 0.1138870655592168 \
7.143089232460945e-07 0.1133369146236164 7.143089927874598e-07 0.1127339156958381 7.14309050088964e-07 0.1122385190692166 7.14309121730019e-07 0.1116210355509516 \
7.143091795650925e-07 0.1111240709857579 7.143092516865272e-07 0.1105063809580559 7.1430931410261e-07 0.1099736279351742 7.143093984241316e-07 0.1092565349771765 \
7.143094660201e-07 0.1086842173446869 7.143095748160323e-07 0.1077671916889585 7.143096791265638e-07 0.1068924975608609 7.14309758614772e-07 0.1062289053282379 \
7.143098461831824e-07 0.1055008617114655 7.143099096395349e-07 0.1049752776433979 7.143099713506517e-07 0.10446579874651 7.14310075190416e-07 0.103612238268202 \
7.143101578711175e-07 0.1029362225408096 7.143102563391439e-07 0.1021348761715451 7.14310340785582e-07 0.101450818648051 7.143104572630618e-07 0.1005121841703865 \
7.143105919965077e-07 0.09943411943161744 7.143107280660444e-07 0.0983541971400249 7.143108423854515e-07 0.09745369041838402 7.143109278525961e-07 0.09678457778867394 \
7.143110381342688e-07 0.09592640631053104 7.143111189226222e-07 0.09530159220710262 7.143112184734933e-07 0.09453592511176086 7.143113084215428e-07 0.09384821103094763 \
7.14311380924943e-07 0.09329669945188329 7.143114626670093e-07 0.09267796846073476 7.143115907872446e-07 0.09171467366828615 7.143116721993079e-07 0.09110674702409056 \
7.143117466312152e-07 0.09055373306570065 7.143118216050993e-07 0.08999936228352182 7.143119010240744e-07 0.08941505746347288 7.143120096849317e-07 0.08862052380504259 \
7.143121040449035e-07 0.08793517800096999 7.143121934400264e-07 0.08728987318634121 7.143123002057425e-07 0.086524181682867 7.143124187081826e-07 0.08568073755029131 \
7.143125602332527e-07 0.08468224831562859 7.143126933716762e-07 0.08375174214918565 7.143128342170073e-07 0.08277682112810406 7.143129832689884e-07 0.08175525972387458 \
7.143131190667175e-07 0.08083369778093191 7.143132605232322e-07 0.0798830809748103 7.143133957831475e-07 0.07898330517332906 7.143135371649882e-07 0.07805242629322809 \
7.143136842327612e-07 0.07709434677344783 7.143138359609018e-07 0.07611680364043326 7.143140013092032e-07 0.07506403321855706 7.143141651767208e-07 0.07403332863189842 \
7.143143414906486e-07 0.07293832728335037 7.143145309257505e-07 0.07177777688466977 7.14314741692455e-07 0.07050569389938771 7.143149614649522e-07 0.06920150027616521 \
7.143151964331044e-07 0.06783224552442871 7.143154553336539e-07 0.06635227408830123 7.14315750264117e-07 0.06470266364809808 7.143160546101784e-07 0.06304001691994518 \
7.143164165564573e-07 0.06111393619706453 7.143167326842125e-07 0.05947639552636011 7.143171740066774e-07 0.0572596911373907 7.143174875727195e-07 0.05573556853365672 \
7.14317911072189e-07 0.0537382660685313 7.143182550240425e-07 0.05216649213267931 7.143185952653102e-07 0.05065508790922631 7.143189061028997e-07 0.04931137323461653 \
7.143192005748017e-07 0.04807062469528345 7.143194942742994e-07 0.04686392507224969 7.143197691455356e-07 0.04576537019482012 7.143200446857014e-07 0.04468949010490332 \
7.143203097762297e-07 0.04367785045825667 7.143205865333108e-07 0.04264571401740119 7.143208698014357e-07 0.04161414314527601 7.143211677947347e-07 0.04055545327485047 \
7.14321427280131e-07 0.03965542606183669 7.143216573035691e-07 0.03887446236327848 7.143218769951559e-07 0.03814321686473518 7.14322101935296e-07 0.0374128399305801 \
7.1432242218897e-07 0.0363978329183388 7.143227099868201e-07 0.03550963653148703 7.143229863821537e-07 0.03467738358988744 7.143232702012828e-07 0.03384352473043348 \
7.143235083105866e-07 0.03315996078327022 7.143237926213707e-07 0.03236211345273886 7.143240345332207e-07 0.03169864947531036 7.143242696733945e-07 0.03106710921041438 \
7.143245113809233e-07 0.03043352335444016 7.143247483338566e-07 0.02982731501219571 7.143249786762739e-07 0.02925002048968134 7.143251924268523e-07 0.02872465224286764 \
7.14325398273815e-07 0.02822791768061097 7.143257906108381e-07 0.02730524204782691 7.143259790028487e-07 0.02687312495148303 7.143263546143072e-07 0.02603163971789 \
7.143265290810819e-07 0.02564950258131362 7.143269530155409e-07 0.02474274850847508 7.14327073769958e-07 0.02449086781212801 7.143275440207214e-07 0.02353384026002922 \
7.143276932357865e-07 0.02323677291035493 7.143280868679981e-07 0.02246740853134286 7.143282578943424e-07 0.02213909006726131 7.143287451732744e-07 0.02121869533024997 \
7.143288872209832e-07 0.02095326544309953 7.143294202372519e-07 0.01997576278857772 7.14329542401289e-07 0.01975737097014436 7.143300645590335e-07 0.01885981776906158 \
7.143302351373363e-07 0.01857989792133653 7.143307224503993e-07 0.01781360777737795 7.143308939733226e-07 0.01755501440977742 7.143315137600803e-07 0.01666567753024489 \
7.14331684684406e-07 0.0164316648397145 7.143323902353963e-07 0.01551160061118263 7.14332552852409e-07 0.01530799450170666 7.143333097458993e-07 0.01439879525764199 \
7.143334506625442e-07 0.01423641007536438 7.143343506613842e-07 0.01324361033368418 7.143344380106346e-07 0.01315122959105692 7.14335342363989e-07 0.01223321097894121 \
7.143354795559379e-07 0.01209984223734439 7.14336450212214e-07 0.01118944790767422 7.14336578130092e-07 0.01107451071402888 7.143377285400387e-07 0.01011008206277823 \
7.143378223420746e-07 0.01003687265682024 7.143390783878875e-07 0.009120584045805383 7.143392159292007e-07 0.009026502753623255 7.143407746836019e-07 0.008029670037698805 \
7.143408584862873e-07 0.007977066150721189 7.143424638651058e-07 0.00699828665725172 7.143425747634502e-07 0.006935886594503895 7.143445070098237e-07 0.005959177461785255 \
7.143446867147596e-07 0.005876661013304485 7.14346798505876e-07 0.004981749118765498 7.143471412910116e-07 0.004848482978762325 7.143496544570452e-07 0.003966891390423618 \
7.143501241787149e-07 0.003819799497680527 7.143537644949896e-07 0.002847564273158896 7.143542802321751e-07 0.002731633924241866 7.143596220620139e-07 0.001773027297371861 \
7.143599073822989e-07 0.001729522787584184 7.143651360301289e-07 0.0007540451492352357 7.143653101766958e-07 0.0007162692714263865 7.170136987690021e-07 -0.0001123232525192561 \
7.170138717942902e-07 -0.0002901710972538241 7.170144915460445e-07 -0.001202022686018724 7.170145801152216e-07 -0.001365806793032466 7.170149410863549e-07 -0.002110727959526865 \
7.1701506578065e-07 -0.002395793696299351 7.170154296225314e-07 -0.003299857180474864 7.170156008981996e-07 -0.003758114451912169 7.170158948960376e-07 -0.004576312838821549 \
7.170160051044431e-07 -0.004886880824040592 7.170162833584409e-07 -0.005643955697619643 7.170164046322499e-07 -0.00594200199557267 7.170174982543479e-07 -0.00517389603226481 \
7.170176213582281e-07 -0.004409713243767066 7.170177448263028e-07 -0.003462788751204457 7.170178649920999e-07 -0.002366010162083454 7.170179628537677e-07 -0.001346276287748183 \
7.170180695561039e-07 -0.0001076498664581183 7.170181813974884e-07 0.001328007358939307 7.170183173718548e-07 0.003256083960376262 7.170184394010113e-07 0.00514709866632534 \
7.170186278172891e-07 0.008343062029134115 7.170187688058191e-07 0.01093380316938193 7.170189215775225e-07 0.01391176330477175 7.170190642801506e-07 0.01683596409946878 \
7.170192186323876e-07 0.02013443377634912 7.170193744260432e-07 0.02358734537610087 7.170195304833402e-07 0.02715365164079262 7.170196778877403e-07 0.03060642997674319 \
7.170198265044852e-07 0.03415780069914553 7.170199819257017e-07 0.03793559522944389 7.170201403115321e-07 0.04184227512730877 7.170203052511541e-07 0.04596085539464361 \
7.170204795004229e-07 0.05035714787605008 7.170206584435391e-07 0.05491177248689325 7.17020847583032e-07 0.0597604232635115 7.170210503636104e-07 0.06498910043066243 \
7.170212697356368e-07 0.07067233091134768 7.170215005721334e-07 0.07667464705993039 7.170217473839692e-07 0.0831083675499642 7.1702201751608e-07 0.09016243555275107 \
7.170223107041881e-07 0.0978236474935409 7.170226343596258e-07 0.1062798466079799 7.17022997926912e-07 0.1157689210849182 7.170233902204302e-07 0.1259925151671456 \
7.170238386999148e-07 0.1376538644086695 7.170243603994003e-07 0.1511757390224034 7.170249727720439e-07 0.1669844191341421 7.170256494173591e-07 0.1843663871188266 \
7.170264363276495e-07 0.2044554566749352 7.170273175487439e-07 0.2267919980918504 7.170281372923844e-07 0.2474048556006221 7.170288657453285e-07 0.2655829647002126 \
7.17029507221317e-07 0.2814688958417333 7.170300831444853e-07 0.2956305456066151 7.170306204013019e-07 0.3087428400511723 7.17031124292597e-07 0.3209487846516751 \
7.17031601896145e-07 0.3324328152479784 7.170320800193788e-07 0.343838772307344 7.170325321182285e-07 0.3545331600964184 7.170330038845194e-07 0.365596737404158 \
7.170334475813599e-07 0.3759140547845509 7.170339695498976e-07 0.3879344734281669 7.170344970878305e-07 0.399956933836353 7.170348766025743e-07 0.4085271910771138 \
7.170354055641745e-07 0.4203606102508351 7.170358748832553e-07 0.4307444005277802 7.17036310038791e-07 0.4402814026247405 7.170367575161174e-07 0.4500002273945978 \
7.170371975395924e-07 0.4594737646471725 7.170376008413354e-07 0.4680814138276727 7.170379192411012e-07 0.4748254127722248 7.170382892190147e-07 0.4826007100982719 \
7.17038525472097e-07 0.4875314737878706 7.170387605434932e-07 0.4924129045770672 7.170390118828311e-07 0.4975994385012801 7.170393182698655e-07 0.5038799449729535 \
7.170395752283189e-07 0.5091120301871851 7.170397837026154e-07 0.5133309170973237 7.170399840849047e-07 0.5173683849445317 7.170401264786059e-07 0.5202244049244739 \
7.170402754030717e-07 0.5231993726577677 7.170404869493287e-07 0.5274019882470222 7.170407130069516e-07 0.5318780389403845 7.170409075493335e-07 0.5357103559602913 \
7.170410966812289e-07 0.539423417888626 7.170413261282767e-07 0.5439012399750046 7.170415086340828e-07 0.5474563135343053 7.170417459969518e-07 0.5520623276458133 \
7.1704201499126e-07 0.5572695987004129 7.170422639017101e-07 0.5620706638085723 7.170425079185314e-07 0.5667633705755619 7.170427802737437e-07 0.5719926523718327 \
7.170430416698736e-07 0.5769928369418796 7.170432993012793e-07 0.5819084237686675 7.17043546144628e-07 0.586601202059797 7.170437918903538e-07 0.5912552023551558 \
7.170440184678743e-07 0.5955288021520931 7.170442496200641e-07 0.5998646534936181 7.170444559004441e-07 0.6037202012184053 7.170446840212041e-07 0.6079592993751251 \
7.170449064011852e-07 0.6120725203834017 7.17045133377667e-07 0.6162454422471376 7.170453484306168e-07 0.6201823359462864 7.170455778001903e-07 0.6243500782103125 \
7.170458468230648e-07 0.6292041961704016 7.170460698367118e-07 0.6331993632081415 7.170462820912892e-07 0.6369772451758789 7.170464934888789e-07 0.6407176358819484 \
7.17046693558109e-07 0.644236566349866 7.170469231519586e-07 0.6482486956559365 7.170471639888863e-07 0.6524328529570182 7.170473457382733e-07 0.6555667906748446 \
7.170475342864999e-07 0.6588018260593631 7.170476873661394e-07 0.6614154033769962 7.170478593744213e-07 0.6643352515471471 7.170480095472396e-07 0.6668697017322168 \
7.170481460645293e-07 0.6691578850264722 7.170482956937163e-07 0.6716547631652277 7.170484234340851e-07 0.673777752640997 7.170485630202225e-07 0.6760856948620949 \
7.170486872589102e-07 0.6781310478824312 7.170488184087495e-07 0.6802827752320969 7.170489428500932e-07 0.6823179209931315 7.170490800809157e-07 0.6845542421253382 \
7.170492003290863e-07 0.6865048414796368 7.170493416605294e-07 0.6887891282595083 7.170494419916407e-07 0.6904033553735033 7.170495631093426e-07 0.6923460943304175 \
7.170496538868777e-07 0.6937948943079848 7.170497511453436e-07 0.6953408241330762 7.170498473532237e-07 0.6968660703265798 7.170499359670681e-07 0.6982647859968389 \
7.170500332550912e-07 0.6997938110311075 7.170501657237294e-07 0.7018622871835729 7.170503209139279e-07 0.7042674555997347 7.170504587918793e-07 0.7063866855441746 \
7.170506036461533e-07 0.7085960165693863 7.170507307079098e-07 0.7105202221428537 7.170508553934701e-07 0.7123960184768648 7.170509680988463e-07 0.7140814553427599 \
7.170510798891907e-07 0.7157437310299281 7.170511806678399e-07 0.7172341607972841 7.170513179462954e-07 0.7192525454101454 7.170514376303672e-07 0.7210013704967912 \
7.170515570598379e-07 0.7227365757678518 7.170516839430602e-07 0.7245692610776365 7.170518083607121e-07 0.7263556789600311 7.170519320935366e-07 0.728121726658988 \
7.170520586890633e-07 0.7299181396522603 7.170521890744641e-07 0.7317573312219798 7.170523118842844e-07 0.7334798522758219 7.170524473200596e-07 0.7353678990088863 \
7.170525486098379e-07 0.7367723836293941 7.170526562323338e-07 0.7382576460517265 7.170527457604157e-07 0.7394878879617913 7.170528603087849e-07 0.7410528648863303 \
7.170529483370413e-07 0.7422487366778059 7.170530554151068e-07 0.7436953530868765 7.170531854801004e-07 0.7454403311053276 7.170532967597954e-07 0.7469230742113165 \
7.170534013783547e-07 0.7483084058091373 7.170535254613402e-07 0.7499400420429273 7.170536737621685e-07 0.7518749696944975 7.170537951620328e-07 0.7534462209622173 \
7.170539096027802e-07 0.7549170836379747 7.170540499400977e-07 0.7567069362027918 7.170541917029811e-07 0.7584995177563068 7.170543095039188e-07 0.759977341175643 \
7.170544374807853e-07 0.761570846386187 7.170545791832092e-07 0.7633205808366864 7.170546966945226e-07 0.7647599110190483 7.170548422997917e-07 0.7665289162262866 \
7.170549639940993e-07 0.7679951561698679 7.170550827247088e-07 0.7694149786178283 7.170552050113037e-07 0.7708662727382939 7.170553320558196e-07 0.77236234268503 \
7.170554416997921e-07 0.7736439866494906 7.170555673867047e-07 0.7751025186690397 7.170556734018051e-07 0.776323977486031 7.170558089877718e-07 0.7778743028704433 \
7.170559339507686e-07 0.7792913979962601 7.170560598569209e-07 0.7807070123991936 7.17056175124167e-07 0.7819915514687489 7.170562814286401e-07 0.7831664991275713 \
7.17056419833432e-07 0.7846822315516878 7.170565691298821e-07 0.7862997378875561 7.170567146373276e-07 0.7878588534534761 7.170568340418389e-07 0.7891257303126159 \
7.170569691346634e-07 0.7905455128963393 7.170570903878263e-07 0.7918076974797237 7.170572333811048e-07 0.7932816011184505 7.170573775854105e-07 0.7947523458802197 \
7.170575031222391e-07 0.7960199014141693 7.170576221686117e-07 0.7972110037065316 7.170577341044954e-07 0.7983213107123885 7.170578389760473e-07 0.7993531099923881 \
7.170579342264591e-07 0.8002831901653534 7.170580705697046e-07 0.8016020813281191 7.170581873938354e-07 0.8027203407102198 7.170583067984452e-07 0.803852171037294 \
7.170584289052493e-07 0.8049980820693966 7.170585518602504e-07 0.8061401395390313 7.17058678828951e-07 0.8073073595000361 7.170588040685604e-07 0.8084467645495962 \
7.17058934640955e-07 0.8096220968518901 7.170590606314732e-07 0.8107441738369082 7.170591888173857e-07 0.8118738099374113 7.170592943471138e-07 0.8127947795787664 \
7.170593972188868e-07 0.8136847278655364 7.17059490214057e-07 0.8144826950388273 7.170596140106596e-07 0.8155354283166244 7.170597019789174e-07 0.8162769513478326 \
7.170598007099885e-07 0.8171027376706747 7.170599439751418e-07 0.8182889948057973 7.170600792538271e-07 0.8193962136425846 7.170601883684495e-07 0.8202800249700468 \
7.17060336451758e-07 0.8214657808291811 7.170604862226849e-07 0.8226492530953341 7.170606114572855e-07 0.8236267526687548 7.170607554487031e-07 0.8247372275730155 \
7.170608795047738e-07 0.8256825756473101 7.170610299680322e-07 0.8268152483647575 7.170611656788839e-07 0.8278240064655301 7.17061290697392e-07 0.828742521381556 \
7.170614084523219e-07 0.8295983347934622 7.170615544291349e-07 0.8306466023667578 7.170617209384522e-07 0.8318251482734692 7.170618518610281e-07 0.8327390940956469 \
7.170620252884657e-07 0.8339327615268647 7.170621934353481e-07 0.8350717495747054 7.170623632702772e-07 0.8362042975620877 7.170625441950479e-07 0.8373912937861997 \
7.170626872933069e-07 0.8383160748488641 7.170628013791983e-07 0.8390446117604563 7.170629315531841e-07 0.8398665237782376 7.170630333942663e-07 0.8405024977857931 \
7.170631502136154e-07 0.8412243379523001 7.170632870780449e-07 0.8420597162999857 7.170634848766686e-07 0.8432475311273343 7.170636764807397e-07 0.8443767279905872 \
7.170638859212215e-07 0.8455874169714939 7.170640678468519e-07 0.8466193100105236 7.170642649799575e-07 0.8477171434207121 7.170644383298479e-07 0.8486653666163242 \
7.170646213292317e-07 0.8496493024239481 7.17064792495495e-07 0.8505537352954988 7.170649671272818e-07 0.8514606693963016 7.170651423896692e-07 0.8523550102558151 \
7.170653185417845e-07 0.8532381479010797 7.170655088128237e-07 0.8541746551565574 7.170656994147745e-07 0.85509499218684 7.170659000624008e-07 0.8560449689899254 \
7.170660926729659e-07 0.8569390259424264 7.170663033306522e-07 0.8578972157030333 7.170665314560509e-07 0.8589122247267402 7.170667972133685e-07 0.8600655879592763 \
7.170670958378129e-07 0.8613244245924475 7.170673721693317e-07 0.862454900702886 7.170676564023905e-07 0.8635842083919951 7.17067930614306e-07 0.8646423892283146 \
7.170682028423722e-07 0.8656634505877856 7.170684730511913e-07 0.8666487272755322 7.170687302040671e-07 0.8675609437488442 7.170690027863351e-07 0.868501515423508 \
7.170692787713349e-07 0.8694269133137555 7.170695488729114e-07 0.8703069289141475 7.170698487348628e-07 0.8712546000783432 7.170702197689933e-07 0.8723856543073821 \
7.170705147067536e-07 0.8732530157608677 7.170707689975357e-07 0.8739790309043101 7.170710672549513e-07 0.8748056771600844 7.170713408634846e-07 0.8755409825400007 \
7.170715769915496e-07 0.8761583495732972 7.170718173369303e-07 0.876770807053994 7.170720396702121e-07 0.8773233906735478 7.170722336759598e-07 0.8777948466981503 \
7.17072563398506e-07 0.8785737911727464 7.170727185719444e-07 0.8789308835864816 7.170730363474729e-07 0.8796437246174529 7.1707321520917e-07 0.8800342982281311 \
7.170735576710472e-07 0.8807611334253193 7.170737417995192e-07 0.8811407335605206 7.170742166778565e-07 0.8820849466541889 7.170743840740528e-07 0.8824061830950772 \
7.170748499154564e-07 0.8832696475595492 7.17075030737665e-07 0.8835931319180218 7.170755247759143e-07 0.8844450822729043 7.170756661243274e-07 0.8846804878101884 \
7.170762724573853e-07 0.8856498028150036 7.170764245267248e-07 0.8858829444029697 7.170770712152002e-07 0.8868329272509302 7.170771995097231e-07 0.8870138524519416 \
7.170778476269279e-07 0.8878919388991984 7.170779774257915e-07 0.8880607713689423 7.170787556274809e-07 0.8890227771434612 7.170788706844142e-07 0.8891574578072456 \
7.170797263428482e-07 0.8901003239091128 7.170798717076157e-07 0.8902505899439886 7.1708085746403e-07 0.8911948786459364 7.170810785690402e-07 0.8913892999646706 \
7.170822236960191e-07 0.8923206810037944 7.170823549126185e-07 0.892422953350996 7.170836961242674e-07 0.8934189515818408 7.170838475232108e-07 0.8935240845833778 \
7.170853289614591e-07 0.8944568913393511 7.170855678408922e-07 0.8945912088657246 7.170873371610739e-07 0.8954685138428928 7.170877263108405e-07 0.895637400736999 \
7.170901199766275e-07 0.896526474291006 7.170905956894498e-07 0.8966764365754722 7.17094011699057e-07 0.8975478548673914 7.170946588490716e-07 0.8976786076740833 \
7.171021370136781e-07 0.8986646932675814 7.171028095907965e-07 0.8987192862546014 7.171952539953667e-07 0.8997188196574962 7.171959172280509e-07 0.8997241906476866 \
7.17385126389945e-07 0.900686595210158 7.173852884627892e-07 0.9007292695325627 7.173879339836764e-07 0.8998161167154269 7.173881025331538e-07 0.8996881690130656 \
7.173893792855451e-07 0.8987393243250013 7.173895814518808e-07 0.8986030018074492 7.173911895612673e-07 0.8976721249252815 7.173913816671926e-07 0.8975774045828077 \
7.174064950498387e-07 0.8985726115129884 7.174066831087563e-07 0.8986004060702872 7.174179880377676e-07 0.8995874924221801 7.174183614235164e-07 0.8996034751727418 \
7.179073737866979e-07 0.9005892719715856 7.179074845548976e-07 0.9006868984798269 7.179082372272589e-07 0.9015617873136611 7.179083390219455e-07 0.9017086238768567 \
7.179088744204902e-07 0.9025814930725723 7.179089769296628e-07 0.9027670217776843 7.179093691484816e-07 0.9035254014384071 7.17909509991429e-07 0.9038129158713877 \
7.179099510288813e-07 0.9047472953155866 7.179101365144842e-07 0.9051402477015744 7.179106528276013e-07 0.9061269394579334 7.17910737502694e-07 0.9062564181617988 \
7.179119721747438e-07 0.9053011091537977 7.179121293881559e-07 0.9045688862145235 7.179123212048176e-07 0.9034162411061901 7.179124880453484e-07 0.9021712267446264 \
7.179126350037462e-07 0.9008824031243315 7.179127491199424e-07 0.8997575350477262 7.179128789920322e-07 0.8983446880789033 7.179129901095502e-07 0.8970273815442567 \
7.179130829140294e-07 0.8958483937359277 7.17913171236719e-07 0.8946639786015808 7.179132744174779e-07 0.8932058048613533 7.179133666254135e-07 0.8918333298588224 \
7.179134541956102e-07 0.8904732289418564 7.179135681890766e-07 0.8886245408236838 7.179137299935004e-07 0.8858564722885236 7.179139149921176e-07 0.8825005184224666 \
7.179141071517853e-07 0.8788219124347386 7.179143085991385e-07 0.874780227084481 7.17914515009728e-07 0.8704697801294994 7.179147001816806e-07 0.8664790122147591 \
7.179148846894051e-07 0.862405115500708 7.179150578412963e-07 0.8585071391690239 7.179152428873213e-07 0.8542751393552932 7.179154202615245e-07 0.8501657390392787 \
7.179155970079552e-07 0.8460284987362284 7.179157631666058e-07 0.8421077870518131 7.179159252110445e-07 0.8382599993991456 7.17916091783925e-07 0.8342839555277276 \
7.179162504376617e-07 0.8304816347052207 7.179164413136869e-07 0.8258903812682129 7.179166162972586e-07 0.8216694867670907 7.179167862433925e-07 0.8175615830390965 \
7.179169514195675e-07 0.8135626411663678 7.179171246116744e-07 0.8093650119631921 7.179172956738769e-07 0.8052155696745213 7.179174637749139e-07 0.801136095357175 \
7.179176541098627e-07 0.7965156511928794 7.179178376918066e-07 0.7920591698039 7.179180456827317e-07 0.7870113041480956 7.179182682592422e-07 0.7816114142545842 \
7.17918457674258e-07 0.7770174196885687 7.17918650984654e-07 0.7723312127316435 7.179187944302406e-07 0.7688556734481145 7.179189438535907e-07 0.7652374066097742 \
7.179190630060629e-07 0.7623536300085233 7.179191757225444e-07 0.7596269484184472 7.179192849974512e-07 0.7569846861296079 7.179194210272094e-07 0.753697254849378 \
7.179195338230239e-07 0.750972995067179 7.1791965602098e-07 0.7480232093637929 7.179197676057526e-07 0.7453311011793381 7.179198923122156e-07 0.7423241425761796 \
7.179200466941668e-07 0.7386034578119585 7.179202134782327e-07 0.7345862494782525 7.179204306429212e-07 0.7293605768817599 7.1792062520351e-07 0.7246835946359503 \
7.179207855343955e-07 0.7208333202545074 7.179209609599985e-07 0.7166251500492028 7.179211507235728e-07 0.7120779400724765 7.179213394518973e-07 0.7075610435995559 \
7.179215212732643e-07 0.7032145396962334 7.179217058706759e-07 0.6988062725207448 7.179218429538112e-07 0.6955348514212173 7.179219962420495e-07 0.6918805091472418 \
7.179221916137951e-07 0.6872279990818534 7.179223477705467e-07 0.6835136309588888 7.179225057227664e-07 0.6797605476340507 7.179227039740297e-07 0.6750570282453686 \
7.179228973199278e-07 0.6704763548785364 7.179231338252739e-07 0.6648822204491218 7.179233200303777e-07 0.6604858901039825 7.179235576526979e-07 0.6548824851665868 \
7.179237444514521e-07 0.6504854738275335 7.179239250092116e-07 0.6462424706993735 7.179240880851561e-07 0.6424159959781919 7.179242326967206e-07 0.6390271817202816 \
7.179243732990705e-07 0.6357379642635244 7.179245001086568e-07 0.632774906490579 7.179246322451931e-07 0.6296924762754078 7.179247584891445e-07 0.6267508340255646 \
7.179248897527744e-07 0.6236963630311418 7.179250188505141e-07 0.6206978048938425 7.179251582761787e-07 0.6174624210713571 7.179253066461711e-07 0.6140261568477932 \
7.179255012030603e-07 0.6095278574984737 7.179256446489367e-07 0.6062198040692683 7.179258791091827e-07 0.6008245134060309 7.179260510074948e-07 0.5968818013610552 \
7.179262639280334e-07 0.5920102583789468 7.179264363946513e-07 0.5880775912131976 7.179265667191976e-07 0.5851108450968721 7.179266982755174e-07 0.5821241897920357 \
7.179268085055991e-07 0.5796262478458715 7.179269041598466e-07 0.5774603558442819 7.179270033938061e-07 0.5752182923213994 7.179270863119074e-07 0.5733484809858778 \
7.179271652275342e-07 0.5715706040143225 7.179272281563093e-07 0.5701535626562365 7.179272936647861e-07 0.5686800671140783 7.179273741508387e-07 0.5668736364148982 \
7.179274240168465e-07 0.5657560592102344 7.179274732056154e-07 0.5646541775062763 7.179275346754008e-07 0.5632780399140616 7.179275825969294e-07 0.5622058085646952 \
7.179276334416479e-07 0.5610687758404553 7.179276925419032e-07 0.5597501790023616 7.1792775115623e-07 0.5584442118409422 7.179278267823233e-07 0.5567607189607793 \
7.17927897341035e-07 0.5551915720267918 7.179279864710419e-07 0.5532116467156011 7.1792807569462e-07 0.5512351177508077 7.179281609982305e-07 0.5493490637975145 \
7.179282486251969e-07 0.5474138635528197 7.179283456271202e-07 0.545274424894262 7.179284499728913e-07 0.5429792414815097 7.179285662643155e-07 0.5404269323775457 \
7.17928672601932e-07 0.5380963700835184 7.179287843108152e-07 0.5356536306660374 7.179288966052949e-07 0.5332047801427824 7.179290238028543e-07 0.5304364255197962 \
7.17929146572528e-07 0.5277698476303582 7.179292887969246e-07 0.5246912237717902 7.179294251600566e-07 0.5217463069543907 7.179295773811234e-07 0.5184691491721333 \
7.179297370173294e-07 0.5150420887864461 7.179299129925215e-07 0.5112761258030903 7.179301015011087e-07 0.5072591542828934 7.179303085676897e-07 0.5028616940969075 \
7.179305335096623e-07 0.4981043078903621 7.179307849056188e-07 0.4928144328841237 7.17931021331185e-07 0.4878598554762091 7.179313184949192e-07 0.4816683149127979 \
7.179316091722113e-07 0.4756487143466775 7.17931917027196e-07 0.469313240945046 7.179322308529534e-07 0.4628991126846517 7.179325599943131e-07 0.4562163541974347 \
7.179328933724197e-07 0.4494927613461197 7.179332249990283e-07 0.4428490490857003 7.179335465484253e-07 0.4364504708187015 7.179338742242378e-07 0.4299742838549845 \
7.179342218438604e-07 0.4231546934710667 7.179345550651742e-07 0.4166645133789623 7.179349009744021e-07 0.4099771621835854 7.179353463882216e-07 0.4014400148089548 \
7.179357041780922e-07 0.3946500490499754 7.179360183349117e-07 0.3887397205534429 7.179364027453916e-07 0.3815756289527631 7.179367327200364e-07 0.3754830843203271 \
7.179370179301253e-07 0.3702633801070484 7.179373262203821e-07 0.3646649204592909 7.179376060174434e-07 0.3596257204303125 7.179378320117929e-07 0.3555880084110294 \
7.179380468497475e-07 0.3517755993421203 7.179382452848198e-07 0.3482769933469286 7.179384492243371e-07 0.3447071465415313 7.179386597603963e-07 0.3410461989361561 \
7.179389167345214e-07 0.3366091000429626 7.179391579951288e-07 0.3324763702393667 7.179393895688451e-07 0.3285420159269506 7.179396042222911e-07 0.3249208057821749 \
7.17939825046275e-07 0.3212218866489027 7.179400262928671e-07 0.3178749657716667 7.179402293821204e-07 0.3145250552959265 7.179404272269914e-07 0.3112865758726304 \
7.179406140799367e-07 0.3082497660855442 7.179408080166626e-07 0.3051208532403978 7.179410117613171e-07 0.30185834615803 7.179411904885829e-07 0.2990186060348319 \
7.179414281343783e-07 0.2952727068736475 7.179416278966111e-07 0.2921508861588616 7.179418295254275e-07 0.2890253490052915 7.179420549918856e-07 0.285561995332 \
7.17942221086285e-07 0.2830312764183137 7.179423997053871e-07 0.2803277612349699 7.179425814095884e-07 0.2775983111934518 7.179427700433048e-07 0.2747882307029562 \
7.179429474665079e-07 0.2721695222189568 7.179431246596455e-07 0.2695724116247911 7.179432847315606e-07 0.2672552081803913 7.179434051322385e-07 0.2655193337608355 \
7.179435529583031e-07 0.2633957862580221 7.179436815880755e-07 0.2615692882062232 7.179437837936585e-07 0.2601227034409412 7.179439020289393e-07 0.2584516051170885 \
7.179440224822997e-07 0.2567534139348401 7.179441461906177e-07 0.2550183706610066 7.179442644426428e-07 0.2533694204037282 7.179443922957732e-07 0.2515887492000971 \
7.179445125816039e-07 0.249915736161692 7.179446652612099e-07 0.2477917697339537 7.179448001739884e-07 0.2459264316518071 7.179449288134099e-07 0.2441493177932957 \
7.17945086528788e-07 0.2419705448111171 7.179452132100908e-07 0.2402201997919771 7.179453485361584e-07 0.2383592392624043 7.179454874487268e-07 0.2364550510890953 \
7.179456052210312e-07 0.2348405558720491 7.179457644918496e-07 0.2326580599570062 7.179459010137043e-07 0.2307878375452989 7.179460422456503e-07 0.2288626996658652 \
7.179461480586929e-07 0.2274220928889542 7.179462784016401e-07 0.2256484734765637 7.17946378112453e-07 0.2242944442559471 7.179464809338881e-07 0.2228991027388591 \
7.179465543495424e-07 0.2219046249368765 7.17946634181104e-07 0.2208265149641777 7.179467042283351e-07 0.2198809561195558 7.179467546314263e-07 0.2192009305305119 \
7.179468068832254e-07 0.2184966408607167 7.179468861207428e-07 0.2174292050927151 7.179469279646958e-07 0.2168658036437602 7.179469673046481e-07 0.216336351877609 \
7.179470103400575e-07 0.2157575332679269 7.179470545074838e-07 0.2151638767852215 7.179471282732236e-07 0.2141731338947761 7.179471637852206e-07 0.2136967174286463 \
7.179472115000211e-07 0.2130606706933813 7.17947272229561e-07 0.2122518321687151 7.179473404867867e-07 0.2113438957752176 7.179474130085659e-07 0.2103801801047663 \
7.179474856831929e-07 0.2094152724966429 7.179475939991808e-07 0.2079788886429202 7.179476916703231e-07 0.20668564243436 7.179478032218192e-07 0.2052110974836689 \
7.179479017572531e-07 0.2039136008387587 7.179480052503929e-07 0.2025572972554956 7.179481011521277e-07 0.2013021587886929 7.17948203780057e-07 0.1999606878451601 \
7.179483066031699e-07 0.1986207062101238 7.179484167227972e-07 0.1971897063011611 7.179485254183531e-07 0.1957815523781236 7.179486450955817e-07 0.1942360962608612 \
7.179487553732606e-07 0.192818053470401 7.179488634364806e-07 0.1914343471929882 7.179489885351485e-07 0.1898375077741012 7.179490785049817e-07 0.1886931806549971 \
7.179491571919347e-07 0.1876950225942949 7.17949234476806e-07 0.1867173468865102 7.179493209853825e-07 0.1856271834369256 7.179494199345929e-07 0.1843848109964498 \
7.179494904434582e-07 0.1835017733581451 7.179495618945114e-07 0.1826096997732476 7.179496670398458e-07 0.1813018727451555 7.179497462794755e-07 0.1803200401832796 \
7.179498273633695e-07 0.1793174195483187 7.179499208553101e-07 0.1781663090788374 7.179500216312847e-07 0.1769308188703378 7.179501713433884e-07 0.175105380089017 \
7.179502871327037e-07 0.1737009932372819 7.179504381380806e-07 0.1718807311127691 7.179505492465001e-07 0.1705485445502526 7.179506913729584e-07 0.168854666407182 \
7.179508090313791e-07 0.167460358327668 7.179509139359749e-07 0.1662230887079887 7.179510089985733e-07 0.1651069099307241 7.179511024298278e-07 0.1640147999883682 \
7.179512034764903e-07 0.1628388413495604 7.179512998233979e-07 0.1617223204899406 7.179513969756437e-07 0.1606011553546776 7.179514800242163e-07 0.1596469772300165 \
7.179515900618698e-07 0.1583897228513109 7.179516723644316e-07 0.1574542248873526 7.179517773641412e-07 0.156267858580057 7.179518550602102e-07 0.1553950893374849 \
7.179519378796887e-07 0.1544690878994293 7.179520195415937e-07 0.1535604570452941 7.179521088908843e-07 0.152571060794856 7.1795218460332e-07 0.1517364980793458 \
7.179522671659343e-07 0.1508307726525361 7.179523437473671e-07 0.1499942554682341 7.179524120352535e-07 0.1492531084507001 7.179525054022655e-07 0.1482449401818621 \
7.179525745556768e-07 0.1475015570698688 7.179526501800083e-07 0.1466917482325688 7.179527117291285e-07 0.1460354497178591 7.179527789778923e-07 0.1453208357145237 \
7.179528500398917e-07 0.1445684785944268 7.179529255373203e-07 0.143772322008306 7.179529844488598e-07 0.1431546944759192 7.179530611224699e-07 0.1423563022825049 \
7.179531414432115e-07 0.1415233898163201 7.179532145945195e-07 0.1407682091691316 7.179533087509407e-07 0.139800669784813 7.179533803551247e-07 0.1390684367429364 \
7.179534538159004e-07 0.1383201464810226 7.179535373276515e-07 0.1374732033664194 7.179536268067954e-07 0.1365744208092838 7.179536918717002e-07 0.1359252211013016 \
7.179538039977228e-07 0.1348115665849295 7.179538691838634e-07 0.1341670699454539 7.179539392221084e-07 0.1334770515823289 7.179539995271633e-07 0.1328849371768329 \
7.179540545379868e-07 0.1323464455745446 7.17954142654965e-07 0.1314871014507438 7.179541834412595e-07 0.131090685705856 7.179542871440105e-07 0.1300923774523848 \
7.179543304565801e-07 0.1296773144713907 7.17954391675178e-07 0.1290920262082728 7.179544365118974e-07 0.1286643765206081 7.179545241079233e-07 0.127831527987147 \
7.179545656618794e-07 0.1274377589706847 7.179546255233895e-07 0.1268718307679372 7.179546973671149e-07 0.1261946708524367 7.179547535798413e-07 0.1256664967939027 \
7.179548160673401e-07 0.125081039250218 7.179548902953231e-07 0.1243877959456236 7.179549649763283e-07 0.1236954937854857 7.179550521595407e-07 0.1228905551604285 \
7.179551205580918e-07 0.1222610287411191 7.17955201128775e-07 0.1215216597888775 7.179552824242559e-07 0.120778012781285 7.179553493407808e-07 0.1201677797529914 \
7.179554321577255e-07 0.1194156054679852 7.179554913464481e-07 0.1188799972037829 7.179555572674477e-07 0.1182853617472536 7.179556371414916e-07 0.1175675408705869 \
7.179557136372899e-07 0.1168828806096336 7.179557950994005e-07 0.1161574242846086 7.179558935702815e-07 0.1152852106851665 7.179559686806302e-07 0.114622623867465 \
7.179560716684202e-07 0.1137180076826871 7.179561458523715e-07 0.1130691786503039 7.17956243471825e-07 0.1122190343868764 7.179563392827803e-07 0.1113890351962442 \
7.179564351312053e-07 0.110562946039519 7.179565160694118e-07 0.1098685209805978 7.179566044526832e-07 0.1091134439098378 7.179567030526615e-07 0.108274944429282 \
7.179567758368655e-07 0.1076586405352824 7.17956865109775e-07 0.1069058608836731 7.179569270917884e-07 0.1063852406583179 7.179569896849556e-07 0.1058613310701875 \
7.179570749071042e-07 0.105150777260444 7.179571803694781e-07 0.1042758147594986 7.179572601999606e-07 0.1036167065755082 7.179573409142144e-07 0.1029530974056021 \
7.179574235279495e-07 0.1022768941101355 7.179574939725617e-07 0.1017026162492672 7.179575972319282e-07 0.1008648142128753 7.179576700720535e-07 0.1002767039768694 \
7.17957755712335e-07 0.09958839426015198 7.179578745140727e-07 0.09863954321822334 7.179579421518978e-07 0.09810250133474645 7.179580119020204e-07 0.09755100310752296 \
7.17958089237e-07 0.09694230106952094 7.179581816572539e-07 0.09621870517595056 7.17958253354782e-07 0.09566033062548993 7.179583391719417e-07 0.09499542738017568 \
7.17958441597192e-07 0.09420660575030523 7.17958534892083e-07 0.09349264652734962 7.179586312085565e-07 0.09276005482712441 7.179587081108176e-07 0.09217843893134048 \
7.179588015908053e-07 0.09147541043939374 7.179588808332317e-07 0.09088281005358793 7.17958995455426e-07 0.0900310686188453 7.179591250636858e-07 0.08907580221142102 \
7.179592583208766e-07 0.08810234090122065 7.179594023507657e-07 0.08705990691030199 7.179595595189095e-07 0.08593388720602639 7.179597092953871e-07 0.08487214151476249 \
7.179598717629785e-07 0.08373303262435308 7.179600149429843e-07 0.08273971668837025 7.179601676221069e-07 0.0816913199659166 7.179603018918778e-07 0.08077856892457436 \
7.179604436441555e-07 0.07982444400446118 7.179605786438163e-07 0.07892500874648442 7.179607206012136e-07 0.07798882638923543 7.179608674486441e-07 0.07703088995320664 \
7.17961019894053e-07 0.07604750978240994 7.179611851127757e-07 0.07499422991502351 7.179613492506213e-07 0.07396067809208305 7.17961526112024e-07 0.07286119333145537 \
7.179617164535802e-07 0.07169407515132428 7.179619274100931e-07 0.07042030845332216 7.179621478192316e-07 0.0691121699798517 7.17962383344393e-07 0.06773900533435212 \
7.179626437937673e-07 0.0662496528900723 7.179629394591772e-07 0.06459579389282195 7.179632445814627e-07 0.06292902455725519 7.179636095760241e-07 0.06098725515092194 \
7.179640044568393e-07 0.05894944116461652 7.179644108474933e-07 0.05692211719668253 7.179648265730353e-07 0.05491854459141238 7.179651893793582e-07 0.0532251207245777 \
7.179655339806477e-07 0.05166301626031383 7.179658491605098e-07 0.05027284652491828 7.179661446898748e-07 0.04900240867073854 7.179664426703825e-07 0.04775344010203557 \
7.179667184691725e-07 0.04662857640242725 7.179669972437683e-07 0.04551884372531381 7.179672611786382e-07 0.04449205559535935 7.179675372013766e-07 0.04344260531795661 \
7.179678161576297e-07 0.04240676967887352 7.179681298509632e-07 0.04127097799875453 7.179683658512502e-07 0.04043636567030678 7.179686216459875e-07 0.03955075129286261 \
7.17968881769487e-07 0.03867033103466553 7.179691519047594e-07 0.03778142289416799 7.179694311247467e-07 0.03688501536902895 7.179697129633963e-07 0.03600226561751176 \
7.17969989839066e-07 0.03515600409566183 7.179702689326649e-07 0.03432349610146775 7.179705018102724e-07 0.03364444121149882 7.179707856469893e-07 0.03283527291840588 \
7.179710257519236e-07 0.03216626441466421 7.179712655507463e-07 0.0315119836023277 7.179715048279204e-07 0.03087436846876356 7.179717400849421e-07 0.03026290129608995 \
7.179719710119639e-07 0.02967475842909434 7.17972186001007e-07 0.02913788335257221 7.179725881554596e-07 0.02816043724496065 7.179727868782784e-07 0.02768988489927659 \
7.179731605612946e-07 0.0268265706552881 7.179733473596173e-07 0.02640514011949098 7.179736949193038e-07 0.02563810810034544 7.179738168487671e-07 0.0253740445387235 \
7.179741993202075e-07 0.02456430406701914 7.179743700282367e-07 0.02421180751242828 7.179748271256211e-07 0.02328894863848502 7.179750127580069e-07 0.0229225623309489 \
7.179753762152597e-07 0.02221803970155307 7.179755965826125e-07 0.02179832126591805 7.179760543089696e-07 0.02093867417890744 7.179761897285988e-07 0.02068687731869814 \
7.179767196240474e-07 0.01972418011126781 7.17976838945017e-07 0.01951377505543128 7.179774047306961e-07 0.01856069823426573 7.17977569110437e-07 0.0182962226476828 \
7.179781876557339e-07 0.01735107502432094 7.179783577099332e-07 0.01710418363667701 7.17978889842166e-07 0.01636278834442301 7.179790869261418e-07 0.01610013864443424 \
7.179798100452149e-07 0.01517806887136661 7.179799746753809e-07 0.01497647803580381 7.179807238007678e-07 0.01409711804523418 7.179808571001203e-07 0.01394643716836554 \
7.179817173537587e-07 0.01301449210748497 7.179818524573793e-07 0.01287422877142914 7.179827950348197e-07 0.01193816285908547 7.179829586305737e-07 0.01178202925388569 \
7.179839599872008e-07 0.0108653384673985 7.179840975299883e-07 0.01074500730514941 7.179853196363712e-07 0.009765086624518643 7.179854265890839e-07 0.00968516078425012 \
7.179868307805774e-07 0.008707372520026449 7.179869356112841e-07 0.008639312158696611 7.179884704482461e-07 0.00767719340797631 7.179885657315476e-07 0.007617466071856052 \
7.179901745288685e-07 0.006680264535635283 7.179903086056076e-07 0.006609506832171614 7.179924056185594e-07 0.005610918814474722 7.179926361631908e-07 0.005510783990371394 \
7.179949591584346e-07 0.004586584533412417 7.179954404886379e-07 0.004413562233393853 7.179982780502688e-07 0.003511943147855551 7.179988229699549e-07 0.003360532104877318 \
7.180029471783516e-07 0.002408309874554541 7.180034909020111e-07 0.002305347543005144 7.180093621912368e-07 0.001333291345955189 7.180096050564211e-07 0.001286469439319215 \
7.180239329487719e-07 0.0002880570268237783 7.180240775074142e-07 0.0002853642807229123 7.206613564285127e-07 -0.0006859155495331031 7.206614959836499e-07 -0.000901903561740745 \
7.206620050775826e-07 -0.001859438188174024 7.206620945650851e-07 -0.002052812934985279 7.206624579599451e-07 -0.00291126965001638 7.206625489820155e-07 -0.003143482006111167 \
7.206629144200523e-07 -0.004127275145644371 7.206630246806194e-07 -0.004436819103926468 7.206633367277739e-07 -0.005309594399865315 7.206634394426211e-07 -0.005584800160857357 \
7.206638032904767e-07 -0.006384516484886619 7.206639680812085e-07 -0.006586298968823262 7.206645476774082e-07 -0.005791490933239759 7.206647227875511e-07 -0.004914057272375438 \
7.206648394794852e-07 -0.004132845175365214 7.206649660640905e-07 -0.003100877896798674 7.206650678730126e-07 -0.002132773363901063 7.206651883617227e-07 -0.0008283127610571584 \
7.206652788087988e-07 0.0002599396317828252 7.206653766989304e-07 0.001541559978017447 7.206654757632395e-07 0.002943971508909197 7.206656465705158e-07 0.005594911825788154 \
7.206658683385387e-07 0.00944046646559993 7.206660642423845e-07 0.01317281463966807 7.206662231237664e-07 0.01639870563256729 7.206663875522632e-07 0.01989779506365397 \
7.206665419182936e-07 0.02331070396473752 7.20666700690818e-07 0.02693200463312963 7.20666847428777e-07 0.03036422445567413 7.206669960527481e-07 0.0339113704936035 \
7.20667151667245e-07 0.03768995713197771 7.206673089092589e-07 0.04156499463828727 7.206674738020576e-07 0.04567927910670353 7.206676472215783e-07 0.05005184210758699 \
7.20667825915293e-07 0.05459761989277153 7.206680145311307e-07 0.05943075613080645 7.206682154312735e-07 0.06460909294799391 7.206684348880646e-07 0.0702927970720964 \
7.206686644343515e-07 0.07626037976612585 7.20668910133291e-07 0.08266408948881369 7.206691786982297e-07 0.08967663153997742 7.206694700401444e-07 0.09728936802005522 \
7.206697917081718e-07 0.1056939239977524 7.20670152022263e-07 0.1150987971742611 7.206705430017012e-07 0.1252892839303718 7.206709864165172e-07 0.1368209045172546 \
7.206715027296045e-07 0.1502062239570841 7.206721089348208e-07 0.16586000516691 7.206727801918478e-07 0.1831102247110778 7.206735596915048e-07 0.20301830483439 \
7.206744320013885e-07 0.2251413938832897 7.206752623367137e-07 0.2460320778586349 7.206759936670634e-07 0.264292249712138 7.206766416128433e-07 0.280346965484095 \
7.206772249233171e-07 0.29469740877147 7.20677760655584e-07 0.3077798509628869 7.20678263914169e-07 0.3199778888071559 7.2067874911767e-07 0.3316516836183861 \
7.206792280403756e-07 0.3430829066939081 7.20679674471008e-07 0.3536501814456421 7.206801488007181e-07 0.3647819492304352 7.206805979917124e-07 0.3752331958288908 \
7.206810884639695e-07 0.3865396207984229 7.206816170367225e-07 0.3985997842463301 7.206819881810624e-07 0.4069920784971888 7.20682515935418e-07 0.4188173133762567 \
7.206829782921778e-07 0.4290642331729484 7.206834506243178e-07 0.4394285229343968 7.206839324090407e-07 0.4498981261869666 7.206839654481592e-07 0.4506126593745911 \
7.206840032071518e-07 0.45142837879914 7.20684078725137e-07 0.4530572051633331 7.206842297611073e-07 0.4563088938659436 7.206844372803726e-07 0.460764549126051 \
7.206846253191842e-07 0.4647825567212808 7.206848443283984e-07 0.469441659996985 7.206850871594094e-07 0.4745824626509371 7.206853869350374e-07 0.4808894567257585 \
7.206856247281871e-07 0.4858624696070272 7.206858879495879e-07 0.4913374535260851 7.206861488471327e-07 0.4967277906005185 7.206863784012197e-07 0.5014431429135263 \
7.206866014614136e-07 0.506003872007333 7.206868030374043e-07 0.5100983586086808 7.206869518674631e-07 0.51310967141356 7.206871961785157e-07 0.5180317772556589 \
7.206873287837491e-07 0.5206893064287169 7.206874681403308e-07 0.5234717264876519 7.206876791057241e-07 0.5276623644271943 7.206878539796058e-07 0.5311266030493931 \
7.206881220278524e-07 0.5364094032095129 7.206883170535098e-07 0.5402319029111832 7.206884966150174e-07 0.5437361368949839 7.206887475711459e-07 0.5486228351952749 \
7.206890249792569e-07 0.5540035987981641 7.206893089285589e-07 0.5594901708581531 7.206895645658505e-07 0.5644152233389156 7.206898555480696e-07 0.570006772487656 \
7.206901158537539e-07 0.5749917787111524 7.206903842978736e-07 0.5801232573974072 7.206906270630042e-07 0.5847450403362237 7.206908835942051e-07 0.5896146675871002 \
7.206911097576483e-07 0.59388771440121 7.206913470991427e-07 0.5983512154742827 7.206915564878602e-07 0.6022720321566808 7.206917702606284e-07 0.6062574570422776 \
7.206920237134688e-07 0.6109557890491497 7.206922265678164e-07 0.6146943332140289 7.206924193723378e-07 0.6182333111593361 7.206926096773651e-07 0.6217090173923294 \
7.20692800335854e-07 0.6251694921350958 7.206930029137796e-07 0.6288260100903066 7.206932656625421e-07 0.6335359534764116 7.206934946302321e-07 0.6376100987349322 \
7.206937145778672e-07 0.6414991146358265 7.206939402625401e-07 0.6454625140719233 7.206941491499661e-07 0.6491091855837361 7.206943708035853e-07 0.652957810138281 \
7.206945556930106e-07 0.6561429680377227 7.206947457075645e-07 0.6594017273991298 7.206948958626861e-07 0.6619630641908443 7.206950707405929e-07 0.6649292185271485 \
7.206952164613094e-07 0.6673855496832628 7.206953524938416e-07 0.6696641287411549 7.206955008561211e-07 0.672138295335571 7.206956303038335e-07 0.6742883907026684 \
7.206957641695307e-07 0.6764996355878535 7.206958925139303e-07 0.6786115243545502 7.206960179020585e-07 0.6806677490053815 7.20696147367755e-07 0.6827843190971332 \
7.206962783489701e-07 0.6849171426143115 7.206964267220724e-07 0.6873221141612875 7.206965347848267e-07 0.6890667486235877 7.206966633164996e-07 0.6911333958680312 \
7.206967987562836e-07 0.6933004139195943 7.206969236906071e-07 0.6952876996714908 7.206970494478751e-07 0.6972799977491608 7.206971559637663e-07 0.6989584331773744 \
7.206972730816549e-07 0.7007929859467624 7.206973916214007e-07 0.7026383448210159 7.206975149247975e-07 0.704545102273978 7.206976180976957e-07 0.7061304255463237 \
7.206977690688591e-07 0.7084341141567283 7.206978853230652e-07 0.7101955266062138 7.206980158834539e-07 0.7121605601685687 7.206981344459821e-07 0.7139335830373704 \
7.206982405198518e-07 0.7155108922888329 7.206983405447915e-07 0.716990346352101 7.206984778700066e-07 0.719009255813789 7.206985965313623e-07 0.7207429633399333 \
7.20698718230586e-07 0.7225107522614664 7.206988434131514e-07 0.7243181860083944 7.206989654329652e-07 0.7260693242762759 7.206990934647186e-07 0.7278954552757622 \
7.206992179464579e-07 0.7296603419865877 7.206993462457807e-07 0.7314685590147565 7.20699473339584e-07 0.7332489547570846 7.206995993644231e-07 0.7350034830462163 \
7.2069970210311e-07 0.7364262918236342 7.206998167758556e-07 0.7380063527755659 7.206998981819179e-07 0.7391232259175492 7.207000173814378e-07 0.7407496908814458 \
7.20700110023778e-07 0.7420059782745783 7.207002481828348e-07 0.7438668850244906 7.207003792383344e-07 0.7456179978167152 7.207005093705019e-07 0.7473439783685625 \
7.207006143445769e-07 0.7487266533969134 7.207007534844189e-07 0.7505456565005918 7.207009074287187e-07 0.7525407731682957 7.207010293729986e-07 0.7541080835708853 \
7.207011769193594e-07 0.7559892974429111 7.20701298924537e-07 0.7575320275232224 7.207014476244666e-07 0.7593968175435225 7.207015816710922e-07 0.7610632318338031 \
7.207017039243472e-07 0.7625711443351471 7.207018167902567e-07 0.763953046884334 7.207019596412246e-07 0.7656882893306027 7.207020863641194e-07 0.7672149413549471 \
7.207022021689945e-07 0.7685995877768005 7.207023319108228e-07 0.7701390587657672 7.207024476492105e-07 0.7715019052061673 7.207025706016372e-07 0.7729391548276606 \
7.20702688317297e-07 0.7743051053122872 7.207027942872732e-07 0.7755262985206828 7.207029106984675e-07 0.7768586864857919 7.207030173164003e-07 0.7780703956921795 \
7.207031295151206e-07 0.7793369495935717 7.207032161836896e-07 0.7803089322889447 7.207033195691813e-07 0.7814603789665585 7.207034327334326e-07 0.7827108149434853 \
7.207035383807155e-07 0.783868819044773 7.207036477202729e-07 0.7850578567336689 7.207037548972878e-07 0.786214126597127 7.20703884303365e-07 0.7875981444497275 \
7.207039967207505e-07 0.7887899291890393 7.207041201084897e-07 0.7900869036018625 7.207042375588255e-07 0.7913106402786101 7.207043810857437e-07 0.7927918312347375 \
7.20704496005322e-07 0.7939667362870242 7.207046347277351e-07 0.7953719780830618 7.207047727598755e-07 0.7967562205547866 7.207048822530295e-07 0.7978444364842524 \
7.207049832714595e-07 0.7988406866985471 7.207050843594198e-07 0.7998302780396641 7.207052167466157e-07 0.8011146558616069 7.207053354720369e-07 0.8022550163876687 \
7.207054572565424e-07 0.8034134048507504 7.207055763463359e-07 0.8045351524060473 7.207056975508532e-07 0.8056657048884367 7.207058291946645e-07 0.8068811249615274 \
7.207059522127028e-07 0.8080052413861453 7.207060798230233e-07 0.8091594649786741 7.20706210891683e-07 0.8103325925767672 7.207063342120463e-07 0.8114249716726942 \
7.207064421363105e-07 0.8123719892944993 7.207065499317031e-07 0.8133095350680949 7.20706631652631e-07 0.8140147772069938 7.207067485202474e-07 0.815015186305849 \
7.207068395812563e-07 0.8157880755829442 7.207069737498875e-07 0.8169164295805346 7.2070711832076e-07 0.8181184617099191 7.207072518231266e-07 0.8192158725965917 \
7.207073617890375e-07 0.8201107352847025 7.207075056546974e-07 0.8212684563313245 7.207076589602621e-07 0.8224861772268215 7.207077866985553e-07 0.8234883060891934 \
7.207079273408908e-07 0.8245786478120171 7.207080531244555e-07 0.8255423809867173 7.207082077424273e-07 0.8267124309768116 7.207083401541937e-07 0.8277017767197102 \
7.207084664337981e-07 0.8286345641820314 7.20708584064113e-07 0.8294941055817234 7.207087322309758e-07 0.8305638349826423 7.207088993752207e-07 0.8317531470681401 \
7.207090319938809e-07 0.832683775428688 7.207092049385689e-07 0.8338803479528284 7.207093733252244e-07 0.8350269493631071 7.207095428597541e-07 0.8361634673386688 \
7.207097242289089e-07 0.8373596561587384 7.207098668614913e-07 0.8382862741713709 7.207099807973396e-07 0.8390176620397163 7.207101115711344e-07 0.8398476357987267 \
7.207102132250742e-07 0.8404856735008092 7.207103297188026e-07 0.8412091703399448 7.207104652363492e-07 0.8420405885319162 7.20710662580143e-07 0.8432318270427018 \
7.20710853245141e-07 0.8443612543037786 7.207110631019802e-07 0.8455804035625291 7.207112440391043e-07 0.8466117334714958 7.207114413745908e-07 0.8477160230260256 \
7.207116151614274e-07 0.8486711109012058 7.207117977428814e-07 0.8496572451898022 7.207119690624607e-07 0.850566499179887 7.207121434475075e-07 0.8514760798656241 \
7.207123188310518e-07 0.8523748177975867 7.207124950632094e-07 0.8532619682996843 7.207126849014517e-07 0.8542000584728613 7.207128756376654e-07 0.8551245802328369 \
7.20713077434399e-07 0.856083442102113 7.207132701277752e-07 0.8569809170305027 7.207134797560765e-07 0.857937542729613 7.207137091938401e-07 0.8589615588718806 \
7.207139749904801e-07 0.8601183337444025 7.207142735657076e-07 0.8613802063570262 7.207145514672209e-07 0.8625196921548358 7.207148356776948e-07 0.8636511027355716 \
7.207151100894824e-07 0.8647118800460076 7.207153822523641e-07 0.8657341977214618 7.207156524214556e-07 0.8667205537246333 7.207159096161393e-07 0.8676338760342862 \
7.207161821558104e-07 0.868575115807136 7.207164581902908e-07 0.8695013130444248 7.207167283429861e-07 0.8703818891200001 7.207170280497876e-07 0.8713292845176382 \
7.207173988672581e-07 0.8724597217497643 7.207176937859212e-07 0.8733269024855727 7.207179480301993e-07 0.8740525764960509 7.207182462541985e-07 0.8748787854419284 \
7.20718519878969e-07 0.8756137195941651 7.207187560179586e-07 0.8762307200963571 7.207189963736862e-07 0.8768427579093606 7.207192187193381e-07 0.8773949085683344 \
7.207194127230722e-07 0.877865919014753 7.207197424471962e-07 0.878644045115768 7.207198976198553e-07 0.8790007149587372 7.207202153732479e-07 0.879712598742095 \
7.207203942386052e-07 0.8801026384247937 7.207207367000935e-07 0.8808283583858193 7.207209208412926e-07 0.8812073588304842 7.207213957461144e-07 0.8821499412898334 \
7.207215631406012e-07 0.8824705695712217 7.207220289718891e-07 0.8833323038036038 7.207222097967714e-07 0.8836551183393088 7.207227038300281e-07 0.8845051821644966 \
7.207228451726029e-07 0.8847400410050358 7.207234515631179e-07 0.8857071861637142 7.207236036356849e-07 0.8859397703602404 7.207242503137576e-07 0.8868873789663725 \
7.207243786102466e-07 0.8870678433440622 7.207250267232453e-07 0.8879435266410994 7.207251565285235e-07 0.8881118897635528 7.20725934785608e-07 0.8890711781604964 \
7.207260497804227e-07 0.8892053868933587 7.207269055110619e-07 0.8901454611437621 7.207270507776287e-07 0.8902951528450479 7.207280365337324e-07 0.8912364417375994 \
7.207282576409459e-07 0.8914302300078862 7.207294027520271e-07 0.892358484239638 7.207295339601743e-07 0.8924604119362172 7.207308752633695e-07 0.8934531785430913 \
7.207310266510304e-07 0.8935579568409697 7.207325081098674e-07 0.8944876667405802 7.207327469902294e-07 0.894621531696939 7.207345164619858e-07 0.8954958910368339 \
7.207349055688235e-07 0.8956641700186337 7.207372993342322e-07 0.8965498195158238 7.207377748942228e-07 0.8966991754584082 7.20741837950387e-07 0.8976977719002629 \
7.207423294244079e-07 0.8977905759376156 7.207506459514872e-07 0.8987839664765119 7.207515658053768e-07 0.8988472044554419 7.208777709459031e-07 0.8998441026240215 \
7.20878784754255e-07 0.8998514601858095 7.210704973474114e-07 0.8990059056521554 7.210707273489741e-07 0.8988405173838494 7.210723422215349e-07 0.8978439928078279 \
7.210725199353886e-07 0.8977495532019018 7.210892857104285e-07 0.8987316330193963 7.210894216988253e-07 0.8987497732072308 7.211048844279385e-07 0.8997471920221268 \
7.211051522925305e-07 0.8997526389354535 7.215889776197985e-07 0.9006560548284696 7.215890984089986e-07 0.9007687033315858 7.215898861800374e-07 0.9017381658104292 \
7.215900203187565e-07 0.901943163319478 7.215905139335305e-07 0.9027850367016239 7.21590658833145e-07 0.9030569221572713 7.215910546405301e-07 0.9038490360455199 \
7.215911744361842e-07 0.9041001886668685 7.215915586097176e-07 0.9049189780371781 7.215916707313647e-07 0.9051556495331843 7.215921780523356e-07 0.9061253139956988 \
7.215922720511916e-07 0.90626859229291 7.215934307008982e-07 0.9055667778886739 7.215935336638317e-07 0.9051589876696525 7.215936175067007e-07 0.9047707260375384 \
7.215937512467522e-07 0.9040404158978201 7.215938519641334e-07 0.9033957423200318 7.215939595799192e-07 0.9026166239542108 7.215940771531732e-07 0.9016533104038295 \
7.21594165418223e-07 0.90085556431878 7.215942850516912e-07 0.8996698288011099 7.215943823733892e-07 0.8986166602050341 7.215944933908277e-07 0.8973222354192386 \
7.215945955004155e-07 0.8960407982554908 7.21594678931815e-07 0.8949326975987755 7.215947831128826e-07 0.8934749428758865 7.215948741996462e-07 0.8921321265381427 \
7.215949667404319e-07 0.8907058396397178 7.215950618944299e-07 0.8891776325191247 7.215951764494069e-07 0.88725933118288 7.215952652925089e-07 0.8857137884271823 \
7.215953635316906e-07 0.8839502506198179 7.215954489018647e-07 0.8823735982707064 7.215955298021067e-07 0.8808434949738935 7.215956027633997e-07 0.8794355441897157 \
7.215956697820454e-07 0.8781198554636557 7.215957383931237e-07 0.8767515715160701 7.215958218880357e-07 0.8750591081124355 7.215958840153663e-07 0.8737811510706814 \
7.215959469979638e-07 0.8724704924326797 7.215960421537152e-07 0.8704632161180945 7.215961427643534e-07 0.8683077530860182 7.215962226435446e-07 0.8665738309361769 \
7.21596306905814e-07 0.8647250601592834 7.215963860160736e-07 0.8629723295901451 7.215964488315189e-07 0.8615696597604833 7.215965362885537e-07 0.8596016864744445 \
7.215966021820844e-07 0.8581079708060287 7.215966702436265e-07 0.856556281928966 7.215967195561343e-07 0.8554267461646872 7.215967747929236e-07 0.85415654045335 \
7.215968155325295e-07 0.8532164928603474 7.215968618342831e-07 0.8521450198670055 7.21596892048343e-07 0.8514441160591502 7.215969210896252e-07 0.8507691938976955 \
7.215969517282201e-07 0.8500558939662993 7.215970130054096e-07 0.8486254874746039 7.215970660779718e-07 0.8473828229799116 7.215971197331653e-07 0.8461232012188223 \
7.215971823904472e-07 0.8446482873934593 7.215972456733951e-07 0.8431545995644786 7.21597336171269e-07 0.8410121009440262 7.215974331690495e-07 0.8387078554355326 \
7.215975161465499e-07 0.8367307351423475 7.215975981509053e-07 0.8347721678896715 7.215976872193065e-07 0.8326403548070889 7.215977717326431e-07 0.8306135893189693 \
7.215978625915234e-07 0.8284303722590877 7.21597954526378e-07 0.8262176456275642 7.215980569573085e-07 0.8237486178045141 7.215981570753404e-07 0.8213320995840899 \
7.215982718962233e-07 0.8185572053828121 7.215983841027604e-07 0.8158423448209959 7.215985090963053e-07 0.8128151787794674 7.215986403567133e-07 0.8096337870015397 \
7.215987856277547e-07 0.8061104108175116 7.215989401353681e-07 0.8023613213197434 7.215991115759888e-07 0.7981999722344618 7.215992756257814e-07 0.794217661721315 \
7.215994600412032e-07 0.7897413884478564 7.215996665335768e-07 0.7847307375046715 7.215998560274197e-07 0.7801344622909899 7.216000494211825e-07 0.775444374634302 \
7.216002499880374e-07 0.7705834242206392 7.21600397552439e-07 0.7670092004965298 7.216005275638895e-07 0.7638619034739171 7.216006624283031e-07 0.7605987503374771 \
7.216007689187539e-07 0.7580234999254772 7.216009006085467e-07 0.7548403390839162 7.216010070329759e-07 0.7522693550468039 7.21601150211605e-07 0.7488125398635642 \
7.216013113387162e-07 0.7449250928176189 7.216014295655331e-07 0.7420746008290786 7.21601599798354e-07 0.7379721584775248 7.216017657246235e-07 0.7339761998059781 \
7.216019852669538e-07 0.7286940862104242 7.216021784540779e-07 0.724050920820232 7.216023533680413e-07 0.719851304223293 7.216025203151389e-07 0.7158476177432674 \
7.216027078061003e-07 0.711355754450834 7.216028952345367e-07 0.7068709122373377 7.216030635710959e-07 0.7028473835914892 7.216032564016302e-07 0.6982428782038785 \
7.216033964513774e-07 0.694901318858167 7.216035527086664e-07 0.6911769338170629 7.216037468781132e-07 0.6865540563080536 7.216039059846016e-07 0.6827702245679255 \
7.216040643446318e-07 0.679008548037742 7.216042596617401e-07 0.6743756772263459 7.216044700905194e-07 0.6693917663527935 7.216047227926646e-07 0.6634173774538097 \
7.216049024606155e-07 0.6591769455535931 7.216051540374889e-07 0.6532475027332399 7.21605354410306e-07 0.6485340174553987 7.216055260641582e-07 0.6445032789616798 \
7.216056847562747e-07 0.6407814961122935 7.21605823964202e-07 0.637522316374186 7.216059602882518e-07 0.6343349641335875 7.216060875012759e-07 0.6313646237382058 \
7.216062169938336e-07 0.6283457899522861 7.216063449851212e-07 0.6253646753452949 7.216064760596301e-07 0.6223174651643489 7.216066067717051e-07 0.6192830747181834 \
7.216067493797575e-07 0.6159760732208495 7.216068921032355e-07 0.612672916206165 7.216070446510367e-07 0.6091471600588 7.216071891550245e-07 0.6058158037532523 \
7.216073531732721e-07 0.6020406322262999 7.216074906379333e-07 0.5988837056407329 7.216076254549489e-07 0.5957940466067043 7.216077469535923e-07 0.5930134750293682 \
7.216078858038965e-07 0.5898448108574432 7.216079994507128e-07 0.5872554148224447 7.216081508608854e-07 0.5838116422847746 7.216082645795603e-07 0.5812320812748947 \
7.216083839926513e-07 0.5785269636915771 7.216084726731778e-07 0.5765205397309219 7.216085638182693e-07 0.5744630259469776 7.216086291571447e-07 0.5729901393713442 \
7.216086936268468e-07 0.5715377831648228 7.21608744447459e-07 0.5703933076453638 7.216088034223984e-07 0.569066051987989 7.216088708671063e-07 0.5675516747474645 \
7.216089379592979e-07 0.5660472084764079 7.216089908797418e-07 0.5648615894615425 7.216090865272254e-07 0.5627204246953637 7.216091437083616e-07 0.5614413394337 \
7.216091975109775e-07 0.5602399192081799 7.216092592530825e-07 0.5588634520375642 7.216093450862141e-07 0.5569525037715509 7.216094277818617e-07 0.5551133137453282 \
7.216095539105889e-07 0.552313430559463 7.216096890096645e-07 0.5493247407981657 7.21609787329828e-07 0.5471534914294828 7.216098999078897e-07 0.5446716589975775 \
7.216100024523052e-07 0.5424173856211837 7.216101225611308e-07 0.5397821662853191 7.216102242487819e-07 0.5375541863492928 7.216103397527456e-07 0.5350300289250629 \
7.216104546438613e-07 0.5325260225312031 7.216105811211341e-07 0.5297740207092871 7.216107063383296e-07 0.5270565158317848 7.216108531843122e-07 0.5238798967507053 \
7.216109886424457e-07 0.5209557060405445 7.216111462030545e-07 0.5175672114705414 7.216113083572293e-07 0.5140875588169389 7.216114890683071e-07 0.5102248342695275 \
7.216116813160603e-07 0.5061308236654174 7.216118940383231e-07 0.5016182665703952 7.216121259434839e-07 0.4967183500883584 7.216123831371877e-07 0.4913135654247419 \
7.216126226904983e-07 0.4863004534671564 7.216129246203734e-07 0.4800178499336004 7.216132123868145e-07 0.4740665530855001 7.216135251890574e-07 0.4676409412178996 \
7.21613845020806e-07 0.4611139840073785 7.216141846574089e-07 0.4542292677834274 7.216145118732278e-07 0.4476411633207955 7.216148470347967e-07 0.4409363684817221 \
7.216151642914576e-07 0.4346351592989786 7.216154981114363e-07 0.4280489847791872 7.2161584979678e-07 0.4211625252737479 7.21616163864498e-07 0.4150547397555842 \
7.216164868937019e-07 0.4088175946446666 7.216169278730989e-07 0.4003732788922496 7.216172702759421e-07 0.3938810608698495 7.216175707238305e-07 0.3882325136127223 \
7.216179460534016e-07 0.3812375944419973 7.216182761286298e-07 0.3751439175705365 7.216185594064112e-07 0.3699597784791666 7.216188599137726e-07 0.3645020109013299 \
7.216191395612329e-07 0.3594637112692664 7.216193634235237e-07 0.3554634414471464 7.216195752745134e-07 0.35170280677964 7.216197776231135e-07 0.3481338771034005 \
7.216199787581392e-07 0.3446120049995081 7.216201845356566e-07 0.3410324794262659 7.216204455143708e-07 0.3365252478245505 7.216206850045531e-07 0.3324209773202946 \
7.216209176796239e-07 0.3284665339262754 7.216211317612159e-07 0.3248537323113044 7.21621352906983e-07 0.3211475567840967 7.21621553789873e-07 0.3178053707831449 \
7.216217571810749e-07 0.3144500223650613 7.216219548494876e-07 0.3112139453100684 7.216221410931751e-07 0.3081862077816076 7.216223360742573e-07 0.3050391973134606 \
7.216225395365023e-07 0.3017803754370622 7.216227174774077e-07 0.2989521325826759 7.216229532011122e-07 0.2952356640875101 7.216231513339656e-07 0.2921385263640672 \
7.216233526780327e-07 0.2890160050544278 7.216235769672296e-07 0.2855690750291008 7.216237418971287e-07 0.2830551950838826 7.216239195258139e-07 0.2803657404651576 \
7.216241039249613e-07 0.2775946687427531 7.216242877463063e-07 0.2748547260732712 7.216244662029787e-07 0.2722194282383935 7.216246381032459e-07 0.2696976713509589 \
7.216247986436533e-07 0.2673699088296289 7.216249201257115e-07 0.265617282026588 7.216250730472386e-07 0.2634201198254058 7.21625200480934e-07 0.2616085083773952 \
7.216253046546046e-07 0.2601317890528609 7.216254215590816e-07 0.2584775571399547 7.216255365705729e-07 0.2568557450124987 7.216256609328034e-07 0.2551103168403305 \
7.216257765070866e-07 0.2534925198640895 7.216259106146075e-07 0.2516172680784447 7.216260256018485e-07 0.2500177396912131 7.216261793514453e-07 0.2478798443778067 \
7.216263161546457e-07 0.2459790966208961 7.216264507404529e-07 0.2441094379339017 7.216266066045887e-07 0.2419575875351012 7.216267312534115e-07 0.2402378086535915 \
7.216268704689347e-07 0.2383186229544463 7.2162700069296e-07 0.236525770455347 7.216271210458007e-07 0.2348769158236033 7.216272564390845e-07 0.233027137746051 \
7.216274076440629e-07 0.2309620730808924 7.21627542400533e-07 0.2291249940296414 7.216276470867202e-07 0.2277003186426776 7.216277696228612e-07 0.2260366668203369 \
7.2162790456742e-07 0.2242086518061946 7.216279996831675e-07 0.2229209267876512 7.216281149432224e-07 0.2213657311907907 7.216281974762018e-07 0.2202562617028589 \
7.216282686815329e-07 0.2192992955643472 7.216283173890172e-07 0.2186449771734718 7.216283645839733e-07 0.2180112263680214 7.216284111327915e-07 0.2173864029843717 \
7.216284645213553e-07 0.2166701476649976 7.216285018980251e-07 0.2161690444847812 7.216285392831377e-07 0.2156680710113931 7.21628579604508e-07 0.2151283464800275 \
7.216286508546475e-07 0.2141753141901174 7.216286850689041e-07 0.2137180869447317 7.216287314635346e-07 0.2131018213873352 7.216287919072008e-07 0.2122998083652294 \
7.216288609101202e-07 0.2113853596849882 7.216289262050716e-07 0.210520730631805 7.216289941831954e-07 0.2096212333552783 7.21629110629525e-07 0.2080823984153433 \
7.216292005517136e-07 0.2068957989735914 7.216293082176197e-07 0.2054771097790837 7.216294042789353e-07 0.2042146625011118 7.216295076575089e-07 0.2028641889872041 \
7.216296043425436e-07 0.2016026287683381 7.216297071523967e-07 0.2002625524503448 7.216298079123679e-07 0.1989526210414513 7.216299190580346e-07 0.1975116692735505 \
7.216300260975285e-07 0.1961279675313261 7.216301440040637e-07 0.1946083430154048 7.216302521143875e-07 0.1932197128021231 7.216303614129877e-07 0.1918224631760269 \
7.216304820447392e-07 0.1902849927564414 7.216305769453309e-07 0.1890796997295432 7.216307055062502e-07 0.18745262875399 7.216307985410385e-07 0.1862801166370808 \
7.216309009375946e-07 0.1849947785893032 7.216309889048857e-07 0.1838942174288659 7.216310871755573e-07 0.182668828510528 7.216311837761789e-07 0.1814691026470878 \
7.216312704146923e-07 0.1803971466393716 7.216313568237044e-07 0.1793305247657973 7.216314526608142e-07 0.1781527189679156 7.216315573876885e-07 0.1768710765218302 \
7.216317031999754e-07 0.1750963017969037 7.216318191679068e-07 0.1736923427161618 7.216319756317111e-07 0.1718092975148396 7.2163208681163e-07 0.1704786474822015 \
7.216322270616306e-07 0.1688098560703619 7.216323500730352e-07 0.1673544160765056 7.216324565640335e-07 0.1661007559767333 7.216325528894916e-07 0.1649724583647661 \
7.216326503229586e-07 0.1638357962207703 7.216327541762373e-07 0.1626293386330815 7.216328459768101e-07 0.1615673458739011 7.216329443645254e-07 0.1604337426303964 \
7.216330272831698e-07 0.1594828374885931 7.216331226515033e-07 0.1583950132920943 7.216332052138515e-07 0.1574587876231885 7.216333077985372e-07 0.1563016192679324 \
7.21633384076854e-07 0.1554454316211293 7.216334726624787e-07 0.1544557264474612 7.216335448319838e-07 0.1536532700165102 7.21633626541473e-07 0.1527486200895024 \
7.216337002202809e-07 0.1519363404455653 7.216337804404094e-07 0.1510573496788611 7.216338521684844e-07 0.1502755532525617 7.216339204254628e-07 0.149534520573691 \
7.216340181414224e-07 0.1484788062294206 7.216340875916062e-07 0.147731872792437 7.216341703430852e-07 0.1468455801890639 7.216342303799947e-07 0.1462052652532956 \
7.216343006186586e-07 0.1454587420502366 7.216343720461929e-07 0.1447037411390827 7.216344525596947e-07 0.1438588888651768 7.216345158225991e-07 0.1431977449412327 \
7.216345934965784e-07 0.1423892845091393 7.216346828063428e-07 0.141463758692191 7.216347521699289e-07 0.1407479403162204 7.216348501181492e-07 0.1397418416088305 \
7.216349404626691e-07 0.1388188591118084 7.216350262429942e-07 0.1379520826379384 7.216350938967789e-07 0.1372719511642241 7.216351602046294e-07 0.1366075914250998 \
7.21635238824321e-07 0.1358227655030745 7.216353195192301e-07 0.135020537018139 7.216353779218939e-07 0.1344419857224206 7.216354386744168e-07 0.1338420332148588 \
7.21635532580729e-07 0.1329184183639811 7.216355749782324e-07 0.1325029080242558 7.21635654222426e-07 0.1317336600863391 7.216356945925846e-07 0.1313430593815061 \
7.216357842934634e-07 0.130477658168832 7.216358232415503e-07 0.1301029732927899 7.216359188572358e-07 0.1291862249441596 7.216359577410651e-07 0.1288146335111444 \
7.216360509758409e-07 0.1279263274670414 7.2163611931843e-07 0.1272775968534341 7.216361716392852e-07 0.1267823325594629 7.21636253739999e-07 0.1260075984242486 \
7.216363249033783e-07 0.1253406747583812 7.216364028563663e-07 0.1246136378429537 7.216364819761022e-07 0.1238779526756392 7.21636560619333e-07 0.1231489004754178 \
7.216366406542416e-07 0.122409328367501 7.216367023886578e-07 0.1218405706457005 7.216367759836405e-07 0.1211645344030958 7.216368593634578e-07 0.120401093559758 \
7.216369234601888e-07 0.1198161795466899 7.216369928987769e-07 0.119184869057559 7.216370659217155e-07 0.1185234239195788 7.216371507966272e-07 0.1177582144838446 \
7.216372301594785e-07 0.117046673033812 7.21637314893136e-07 0.1162898833629492 7.216374056044255e-07 0.1154830714735263 7.216374811875037e-07 0.1148135241260771 \
7.216375469154284e-07 0.1142333070693714 7.21637606975201e-07 0.1137047561823949 7.216376765809174e-07 0.1130943456353956 7.216377429999685e-07 0.1125141752866663 \
7.216378224112315e-07 0.1118230150855203 7.216379126741611e-07 0.1110406875128299 7.216379817184612e-07 0.1104447270551955 7.216380562735805e-07 0.1098035355921305 \
7.216381447575012e-07 0.1090456469739195 7.216382238656483e-07 0.1083709350695736 7.216382937340289e-07 0.1077773127978274 7.216383747433988e-07 0.1070920034756896 \
7.216384309482126e-07 0.106618206733547 7.216384936074922e-07 0.1060916009495399 7.216385587540976e-07 0.105545887371837 7.216386300897257e-07 0.1049504956797945 \
7.216387503861013e-07 0.1039516085561449 7.216388019396736e-07 0.103525508500865 7.216388570887417e-07 0.1030709598036589 7.216389477859257e-07 0.1023262935955709 \
7.216390301757782e-07 0.1016530765296615 7.216391257555855e-07 0.1008759670630478 7.216392329651519e-07 0.1000092507657299 7.216393366245584e-07 0.09917656019160864 \
7.21639422832161e-07 0.09848810438956324 7.216395090743862e-07 0.09780303991321163 7.216395886154605e-07 0.09717448010577609 7.216396686283335e-07 0.09654538840876434 \
7.216397599166613e-07 0.09583163072761708 7.216398416620796e-07 0.09519620281310773 7.216399305889172e-07 0.09450872319168514 7.216400203662241e-07 0.09381864801001834 \
7.216400973288722e-07 0.09323024625953365 7.216401876536891e-07 0.0925435244861572 7.216402514624153e-07 0.09206084550525626 7.216403239259826e-07 0.09151514907748673 \
7.216403880546354e-07 0.09103438864950099 7.216404663020107e-07 0.09045054736970405 7.216405660032922e-07 0.08971110930136832 7.216406400564437e-07 0.08916512281998501 \
7.216407266649787e-07 0.08852997392441805 7.216408729646849e-07 0.08746544055362569 7.216409836769482e-07 0.08666684197409438 7.216410939866262e-07 0.08587717033461532 \
7.216412361822689e-07 0.08486839672072237 7.216413762347203e-07 0.08388450488753585 7.216415188805342e-07 0.08289222299161547 7.21641667651249e-07 0.08186778387581196 \
7.216418043639349e-07 0.08093569403044946 7.21641946484565e-07 0.07997640434545976 7.21642081061545e-07 0.07907728405019222 7.216422212814229e-07 0.07814997945867638 \
7.216423690282293e-07 0.07718353387841098 7.216425189824149e-07 0.07621348085094087 7.216426836982467e-07 0.07516037195605636 7.216428472843634e-07 0.07412732798506308 \
7.216430219327157e-07 0.07303837372665309 7.21643208986408e-07 0.07188781219077654 7.216434189729257e-07 0.0706159374129187 7.216436370461739e-07 0.06931715807027321 \
7.216438703663275e-07 0.06795188046253516 7.216441248458817e-07 0.0664909822812602 7.2164441780254e-07 0.06484528303377844 7.21644719953089e-07 0.06318745987130532 \
7.216450576747916e-07 0.06138078634948794 7.216454527833931e-07 0.05932807220464856 7.216458202346361e-07 0.05747953410674719 7.216462378424018e-07 0.05544691527644593 \
7.216465828383762e-07 0.0538196438399016 7.216469333806655e-07 0.05221302159193914 7.21647248341029e-07 0.0508087490907442 7.216475475823956e-07 0.049508488261462 \
7.216478469482477e-07 0.04824029756235761 7.216481221909583e-07 0.04710512226277328 7.216484056545245e-07 0.04596497870754415 7.216486672549465e-07 0.04493681260994405 \
7.216489447070712e-07 0.04387103439794762 7.216492207665063e-07 0.04283531238677037 7.216495290362429e-07 0.04170718945545093 7.216497514688635e-07 0.0409114719535993 \
7.21650039009947e-07 0.03990505631995635 7.216502752428795e-07 0.0390969788355163 7.216505937045547e-07 0.03803800466874574 7.21650844115589e-07 0.03722710566490722 \
7.216511671003914e-07 0.03620720400565681 7.216514254364062e-07 0.03541203096995557 7.216517154102846e-07 0.03454066075983582 7.216519452051025e-07 0.0338658635512188 \
7.216522301004437e-07 0.03304787219836024 7.216524698465629e-07 0.03237513696606491 7.216527104811323e-07 0.03171392889024889 7.216529495996188e-07 0.03107212555077287 \
7.216531855385298e-07 0.03045460689686571 7.21653416367391e-07 0.02986254663395104 7.216536313939185e-07 0.02932175456294728 7.216540335597597e-07 0.0283374222946415 \
7.2165423211788e-07 0.02786401170979088 7.216546058190658e-07 0.02699470773596776 7.216547926322608e-07 0.02657042318767052 7.216551386335081e-07 0.02580176906824739 \
7.216552605769465e-07 0.02553595448027303 7.216556434299635e-07 0.02472011952872977 7.216558038641491e-07 0.02438657631284594 7.216562468653031e-07 0.02348572425118655 \
7.216564174793446e-07 0.02314627247835563 7.216567380559406e-07 0.02251902970747987 7.216569383408681e-07 0.0221336684630111 7.216573852788009e-07 0.02128811173678137 \
7.216575132229166e-07 0.02104854104185888 7.21658001100276e-07 0.02014826272243131 7.216581360775529e-07 0.01990454278080647 7.216586183290713e-07 0.0190640092473091 \
7.216587806551861e-07 0.01879235028057063 7.216592670495271e-07 0.01801148170254873 7.216594300771863e-07 0.01776103207540622 7.216601102988766e-07 0.01676849304257711 \
7.216602493826144e-07 0.01657541006259178 7.216609818771476e-07 0.01560782569993242 7.216611407707804e-07 0.01540693214221847 7.21661923851867e-07 0.01445869962397344 \
7.216620696444218e-07 0.01428952172302696 7.216629204257814e-07 0.01334248985256295 7.21663031529053e-07 0.01322388191882306 7.216639648234166e-07 0.0122699293983148 \
7.216640986614658e-07 0.01213902814618388 7.21665057199482e-07 0.01123495036716388 7.216651783165509e-07 0.01112486091825863 7.216663004003486e-07 0.01017270671243764 \
7.216664059016017e-07 0.01008921053061839 7.216677349760139e-07 0.009112307258623473 7.216678551802884e-07 0.009029744095492466 7.21669403542048e-07 0.008036808760534916 \
7.216694843298185e-07 0.007986285493236449 7.216710552093519e-07 0.007024564730313319 7.216711226255508e-07 0.006986095570813155 7.216730433922295e-07 0.006001386377072119 \
7.216732301941131e-07 0.005914747648762168 7.216755456080605e-07 0.0049318160947762 7.216759451349076e-07 0.004777795182599986 7.216785089444083e-07 0.003889929704329555 \
7.216790078153284e-07 0.003736330440833864 7.216826375393169e-07 0.002784984367379526 7.216831882332917e-07 0.002663729254427667 7.216885866736714e-07 0.001711392372544448 \
7.216888999412434e-07 0.001662511220227468 7.216938922337913e-07 0.0006970413096974805 7.216940762528259e-07 0.0006571176749162138 7.243425553956096e-07 -0.0002691198397987355 \
7.243427114545721e-07 -0.0004551674219448388 7.243432594384271e-07 -0.001322174727784445 7.243433723764198e-07 -0.001539785040943742 7.243438016313498e-07 -0.002474302920374066 \
7.24343907888515e-07 -0.002730173903076456 7.243441906906666e-07 -0.003454402452283872 7.243443042852103e-07 -0.003760966378165151 7.243446428397891e-07 -0.004705104513819927 \
7.243447552637498e-07 -0.005021586953003071 7.243450835416506e-07 -0.005887841248467669 7.243451910801718e-07 -0.006130875888161453 7.243460710062032e-07 -0.005789627805322099 \
7.243462462122502e-07 -0.004910736584223327 7.243463630430133e-07 -0.004127745010746014 7.243464899101376e-07 -0.00309221842859156 7.243465914428628e-07 -0.002125750314016509 \
7.243467128641333e-07 -0.0008095618968406578 7.243468030290462e-07 0.0002767910803854594 7.243469002126957e-07 0.001550247908954045 7.243469982869597e-07 0.002938803805678211 \
7.243471655080454e-07 0.005530627736217106 7.243473878133234e-07 0.009378371294171852 7.24347573551714e-07 0.01290572951649239 7.243477976330495e-07 0.01747895571448658 \
7.243479572777817e-07 0.02091945933227325 7.243481217671113e-07 0.02459614091902196 7.243482715915693e-07 0.0280452875125503 7.243484209914613e-07 0.03156498790849799 \
7.243485705227667e-07 0.03515592969144176 7.243487246026613e-07 0.03891669635189081 7.243488867868089e-07 0.0429309674228065 7.24349053210035e-07 0.0470989728378523 \
7.243492291435082e-07 0.05154884981278444 7.24349410271779e-07 0.05616867911875007 7.243496024027047e-07 0.06110225049351239 7.24349810098117e-07 0.0664648391313285 \
7.243500320181979e-07 0.07222051812179281 7.243502672196803e-07 0.07834079218654426 7.243505194059892e-07 0.08491829088081257 7.24350795545224e-07 0.09213111703448683 \
7.243510966667007e-07 0.1000001933597138 7.243514285865622e-07 0.1086702418150647 7.243518059053303e-07 0.1185147411083515 7.243522041953866e-07 0.1288888856248832 \
7.243526735037065e-07 0.1410822143415975 7.243532195292308e-07 0.1552200475789812 7.243538544895379e-07 0.1715918832733369 7.243545538901292e-07 0.1895291194622146 \
7.243553721290551e-07 0.2103807608661494 7.243562778230217e-07 0.2332840710921665 7.243570673340878e-07 0.253091928008631 7.243577710929056e-07 0.2706124241987875 \
7.243583889437195e-07 0.2858796548825839 7.243589545671311e-07 0.2997575097153312 7.243594763024047e-07 0.3124620269501652 7.243599740861211e-07 0.3244932238414255 \
7.243604577240811e-07 0.3360954048923613 7.243609145982154e-07 0.3469667650518959 7.243613874391095e-07 0.3581213589834248 7.243618270524661e-07 0.3684065070151987 \
7.24362314929562e-07 0.379719432411247 7.243628457299845e-07 0.3919028193132517 7.243633436253595e-07 0.4032143644097119 7.24363775002613e-07 0.41292177789323 \
7.243642618898012e-07 0.4237731225600331 7.243647619892433e-07 0.4348012155672935 7.243651066099338e-07 0.4423321287141763 7.243654600037776e-07 0.4500000647748709 \
7.243658877736168e-07 0.4592134948422093 7.243662796346881e-07 0.4675816212925634 7.243665799290445e-07 0.4739471552041949 7.243669218601248e-07 0.4811428413521782 \
7.243672651945704e-07 0.4883132334011818 7.24367525955058e-07 0.4937215836208605 7.243677680115876e-07 0.4987106167174703 7.243680340100556e-07 0.5041617362307154 \
7.243682934982395e-07 0.5094435946950286 7.243684834145396e-07 0.5132872703533161 7.243686986491408e-07 0.5176241792560061 7.243688371999001e-07 0.5204025546691405 \
7.243689820806791e-07 0.5232962183003332 7.243691954947458e-07 0.5275364624051522 7.243693975193604e-07 0.5315382148201082 7.243695902480239e-07 0.5353370730264509 \
7.243697755034039e-07 0.5389735557287745 7.243699525009277e-07 0.5424323215059959 7.243702617642632e-07 0.5484573594957171 7.243705229123106e-07 0.5535233414883098 \
7.243708247314805e-07 0.5593562770234363 7.243710801601219e-07 0.5642781701956761 7.243713725156194e-07 0.5698968483756405 7.243716319698132e-07 0.5748654731717864 \
7.243719020897901e-07 0.5800301911327002 7.243721441003479e-07 0.5846380733684551 7.243724016101459e-07 0.5895273573494454 7.243726280544834e-07 0.5938057549890672 \
7.243728649429657e-07 0.5982619499065401 7.24373074987873e-07 0.6021962733001386 7.243732879185847e-07 0.6061670177072124 7.24373541397282e-07 0.6108668889270118 \
7.24373744692931e-07 0.6146150465592417 7.243739363811141e-07 0.6181346807088086 7.243741250074785e-07 0.6215812235468744 7.243743123254166e-07 0.6249823889551316 \
7.243745179374062e-07 0.6286953279350977 7.243747677606248e-07 0.6331759959753138 7.243749715724034e-07 0.6368063379741715 7.243751792111211e-07 0.6404826298163093 \
7.24375371862737e-07 0.6438748386876914 7.243756164748105e-07 0.6481531432733096 7.243758643733136e-07 0.6524620620600715 7.243760442082188e-07 0.6555644139995785 \
7.243762349822552e-07 0.6588391718544121 7.24376388158437e-07 0.6614554104590837 7.243765598271469e-07 0.6643705886591137 7.243767102939677e-07 0.6669108747194671 \
7.243768468979714e-07 0.6692010654183506 7.243769963383726e-07 0.6716954191563786 7.243771240725234e-07 0.6738189269502312 7.2437726394477e-07 0.6761323074508511 \
7.243773880219049e-07 0.6781756764962316 7.243775193832699e-07 0.6803315871556701 7.243776435547311e-07 0.6823627547057004 7.243777813315919e-07 0.6846081866267727 \
7.243779015758122e-07 0.6865586181592046 7.243780436284174e-07 0.6888545186016138 7.243781438561225e-07 0.6904668682779994 7.243782651601134e-07 0.6924123325129877 \
7.243783561353879e-07 0.6938641504265992 7.243784535186708e-07 0.695411869780077 7.24378550601538e-07 0.6969507228893711 7.243786398841583e-07 0.6983595753378042 \
7.243787378559427e-07 0.699898781449533 7.243788681310304e-07 0.7019319515314388 7.243790215432551e-07 0.7043083163565919 7.243791571090672e-07 0.7063909659299702 \
7.24379301449562e-07 0.708591461371511 7.243794273204452e-07 0.710496752775434 7.243795523478311e-07 0.712376488910674 7.243796666301914e-07 0.7140841686551523 \
7.243797776133355e-07 0.7157331888171029 7.243798773084045e-07 0.7172065512867005 7.243800143526226e-07 0.7192196995505324 7.243801333798347e-07 0.7209572005600779 \
7.24380253677943e-07 0.7227029412191364 7.243803801768634e-07 0.7245276185835638 7.243805041084668e-07 0.7263044524160376 7.243806283948001e-07 0.7280754330070212 \
7.243807547599529e-07 0.7298652243312684 7.243808845716946e-07 0.7316925631262517 7.243810084102138e-07 0.7334254795816325 7.243811411911006e-07 0.735272086289578 \
7.243812420423058e-07 0.7366670415914529 7.243813552339755e-07 0.738224777043618 7.243814420199563e-07 0.7394137384482823 7.243815586452529e-07 0.7410021813026957 \
7.243816479345105e-07 0.7422110784210975 7.243817591113937e-07 0.7437075443329063 7.243818883701577e-07 0.7454347509364776 7.243820022291937e-07 0.7469455276109591 \
7.243821066334058e-07 0.74832188588007 7.243822310004373e-07 0.7499498655229884 7.243823782406158e-07 0.7518616907275563 7.243824985209068e-07 0.753411006437983 \
7.243826144254458e-07 0.7548933175676444 7.243827545012897e-07 0.7566706674475765 7.243828971129601e-07 0.7584645678799224 7.243830150672032e-07 0.7599365027959469 \
7.243831418837122e-07 0.7615071445339606 7.243832827668561e-07 0.7632375905494565 7.243834025603537e-07 0.7646969139886852 7.243835475192107e-07 0.7664484133613445 \
7.243836690779962e-07 0.7679052725436226 7.243837881174897e-07 0.7693214142140735 7.243839097488533e-07 0.7707575700077021 7.243840377178316e-07 0.772256936813787 \
7.243841469330139e-07 0.7735272422640712 7.243842718238922e-07 0.774969549136603 7.24384378939953e-07 0.7761978171588899 7.243845121931473e-07 0.7777146071439789 \
7.243846392965933e-07 0.7791497354387434 7.243847610475684e-07 0.7805132846941326 7.243848776321507e-07 0.7818078758210534 7.24384983459753e-07 0.7829735233300771 \
7.243851228258954e-07 0.7844949153190801 7.243852718976943e-07 0.786105286864636 7.24385419626362e-07 0.7876841235632186 7.243855389322396e-07 0.7889471147195867 \
7.243856729390521e-07 0.7903527806482344 7.243857933652268e-07 0.791604423795974 7.243859349104043e-07 0.7930616786923709 7.243860823364166e-07 0.7945638089648995 \
7.243862068109251e-07 0.7958198087139573 7.24386325854918e-07 0.7970105506108808 7.243864374452016e-07 0.7981174590942314 7.243865426744905e-07 0.7991530841216606 \
7.24386638185594e-07 0.8000862307887144 7.243867742475476e-07 0.8014036057482816 7.243868911236816e-07 0.8025237700417888 7.243870102773536e-07 0.8036549841722296 \
7.24387132589548e-07 0.8048050501807249 7.243872558616218e-07 0.8059526272620129 7.243873823583984e-07 0.8071184350969989 7.243875078610622e-07 0.8082633544790385 \
7.243876385869669e-07 0.8094437311890262 7.243877641549387e-07 0.8105658358439867 7.243878932098035e-07 0.8117072367686948 7.243879990659606e-07 0.8126345588578442 \
7.243881002348365e-07 0.8135133322873783 7.243881948546566e-07 0.8143286754242188 7.243883191357402e-07 0.8153900871385379 7.243884088474262e-07 0.816149614585347 \
7.243885078849502e-07 0.8169816577628611 7.243886456628271e-07 0.8181280288377792 7.243887801986773e-07 0.81923501721715 7.243888886049436e-07 0.8201180631035904 \
7.243890385184473e-07 0.8213254631869725 7.243891890970255e-07 0.8225223201378843 7.243893145921802e-07 0.8235077122548546 7.243894584387069e-07 0.8246238332260477 \
7.243895830219706e-07 0.8255790649890803 7.243897318751914e-07 0.8267066458678887 7.24389868023775e-07 0.827725029289517 7.243899930476024e-07 0.8286494160599757 \
7.243901107545823e-07 0.8295103773055483 7.243902563935804e-07 0.8305630309532103 7.243904227748753e-07 0.8317484146982921 7.243905533585645e-07 0.8326660250626342 \
7.243907268806749e-07 0.8338683097812621 7.243908950025776e-07 0.8350147136930499 7.243910648651803e-07 0.8361549927788252 7.243912457668832e-07 0.8373497079260466 \
7.243913888761651e-07 0.8382806519784776 7.24391502965127e-07 0.839013953006387 7.243916331276035e-07 0.8398410866028793 7.243917349727342e-07 0.8404811280669765 \
7.243918517989402e-07 0.8412075886390841 7.243919886903802e-07 0.8420483852080155 7.243921864976039e-07 0.843243620449199 7.243923781227506e-07 0.8443797466267589 \
7.24392587554618e-07 0.8455974227529048 7.243927695012999e-07 0.8466352798309468 7.243929666301539e-07 0.8477391449715804 7.243931399710144e-07 0.8486924050423899 \
7.243933229793209e-07 0.8496814535024207 7.243934941423557e-07 0.8505903669473519 7.243936687794506e-07 0.851501688465695 7.243938440392814e-07 0.8524001683007644 \
7.243940201897297e-07 0.8532872510191711 7.243942104700295e-07 0.8542278331088334 7.243944010691599e-07 0.8551519386507073 7.243946016923949e-07 0.8561055033533737 \
7.243947943009499e-07 0.8570028516027762 7.243950049816413e-07 0.8579644845832216 7.243952330831089e-07 0.8589827023971403 7.243954988710916e-07 0.860139640227508 \
7.243957974838522e-07 0.8614018215255795 7.243960737724907e-07 0.8625348754565382 7.243963580090102e-07 0.8636666213345715 7.243966322137804e-07 0.8647267940813509 \
7.243969044486385e-07 0.8657495569722869 7.243971746527798e-07 0.8667361702337206 7.243974318083905e-07 0.867649441901348 7.24397704388604e-07 0.8685908808535525 \
7.2439798037489e-07 0.8695169452638583 7.24398250477721e-07 0.870397355937691 7.243985503347982e-07 0.8713451925332844 7.243989213624563e-07 0.8724761722512941 \
7.243992162997666e-07 0.8733433185969293 7.243994705892065e-07 0.8740690226522811 7.243997688459906e-07 0.874895168896023 7.244000424554269e-07 0.8756299040683481 \
7.244002785839137e-07 0.8762466977562872 7.244005189298274e-07 0.8768585021646264 7.244007412634921e-07 0.8774104263690854 7.244009352691695e-07 0.8778812671168952 \
7.244012649918855e-07 0.8786590883967833 7.244014201653189e-07 0.8790156160651978 7.244017379413894e-07 0.8797272612331356 7.244019168030317e-07 0.8801171459162566 \
7.244022592648612e-07 0.8808425821290963 7.244024433930206e-07 0.881221400612852 7.244029182707539e-07 0.8821634994206867 7.24403085666965e-07 0.8824839765989225 \
7.244035515089055e-07 0.8833452998114757 7.244037323309576e-07 0.8836679564577563 7.244042263693833e-07 0.8845176198113115 7.24404367718007e-07 0.8847523712107549 \
7.244049740520726e-07 0.8857188576377059 7.244051261213959e-07 0.8859512996759633 7.244057728095585e-07 0.8868983431897121 7.244059011041699e-07 0.8870786909355212 \
7.244065492212318e-07 0.8879538337624689 7.244066790202949e-07 0.8881220828502663 7.244074572237723e-07 0.8890807033877333 7.244075722787339e-07 0.8892148977954012 \
7.244084279402064e-07 0.8901543051721961 7.244085733010758e-07 0.8903040038307473 7.244095590571272e-07 0.8912446482480114 7.244097801624957e-07 0.8914382978987679 \
7.244109252894234e-07 0.8923659558950503 7.244110565064392e-07 0.8924678262926897 7.244123977150129e-07 0.8934599079028542 7.244125491142719e-07 0.8935646301988298 \
7.244140305519949e-07 0.8944937559627255 7.244142694313731e-07 0.8946275407274444 7.24416038746979e-07 0.8955013787854181 7.244164278981914e-07 0.8956696032899972 \
7.244188215611417e-07 0.8965547188539188 7.244192972701398e-07 0.8967039926079825 7.244233604302104e-07 0.8977020505850396 7.24423851854269e-07 0.8977948037134476 \
7.244321684538219e-07 0.898787348739254 7.244330883529499e-07 0.8988506593152591 7.245765735834803e-07 0.8998476076348748 7.245776920164557e-07 0.8998537475785264 \
7.247827836359558e-07 0.898985773748599 7.247830107254573e-07 0.8988224379910277 7.247846203322555e-07 0.8978282360369357 7.247847977407988e-07 0.8977338482811539 \
7.248017048890995e-07 0.8987315468430059 7.248018143281978e-07 0.8987460089186867 7.248175950494439e-07 0.8997418097871094 7.248178913753395e-07 0.8997476966799167 \
7.25301325027745e-07 0.9007060148833608 7.253014540780854e-07 0.9008313386292994 7.253021042279306e-07 0.9016292186224167 7.253022937236614e-07 0.9019133038041363 \
7.253027969456399e-07 0.9027675859898705 7.253029324182996e-07 0.9030208676018907 7.253033328770163e-07 0.9038195223753869 7.253034648149532e-07 0.9040958310886574 \
7.253038660300166e-07 0.9049509627747726 7.253039642901936e-07 0.9051582028152527 7.253044301640043e-07 0.9060587574877488 7.253045916627274e-07 0.9063060456044927 \
7.253057356752504e-07 0.9055153668657776 7.253058806545959e-07 0.9049059606760256 7.253060592073535e-07 0.9039396653125833 7.253062394026313e-07 0.9027054491383806 \
7.253063820935605e-07 0.9015369228101149 7.253064992531646e-07 0.9004524619440171 7.253065882345255e-07 0.8995505656965809 7.253066798781777e-07 0.8985529714258781 \
7.253068129901104e-07 0.8969831049011855 7.253069067111929e-07 0.8957895978311226 7.253069978500017e-07 0.8945634483845346 7.253071111423133e-07 0.8929516940777753 \
7.253072142512257e-07 0.8913998138690341 7.253073105184064e-07 0.8898830246517148 7.253074296555228e-07 0.8879200664089764 7.253075982407715e-07 0.8849885378698126 \
7.253077600122727e-07 0.8820195265790133 7.253079532313317e-07 0.8782956415026882 7.253081387944432e-07 0.8745571577041361 7.253083490607478e-07 0.8701566079887386 \
7.253085313097885e-07 0.8662213066841463 7.253087161731834e-07 0.8621339172744639 7.253088888583302e-07 0.8582419637438897 7.253090749664033e-07 0.8539816046497358 \
7.253092527824913e-07 0.849858603441091 7.253094334990721e-07 0.8456251963850057 7.253095986373313e-07 0.8417258760277182 7.253097639114333e-07 0.837798995916667 \
7.253099271590958e-07 0.8339004324287677 7.253100857493695e-07 0.8300982805770993 7.253102626737713e-07 0.8258418712800655 7.253104591875839e-07 0.8211009660847696 \
7.253106267441254e-07 0.8170498602679914 7.253107934845439e-07 0.8130123908857781 7.253109679080616e-07 0.8087844286215062 7.253111372776842e-07 0.8046757316210446 \
7.253113054767785e-07 0.8005936994537799 7.25311494325046e-07 0.7960093488074458 7.253116851408819e-07 0.7913773844868103 7.253118935230917e-07 0.7863203192056716 \
7.25312119942597e-07 0.7808277108969495 7.253123091427939e-07 0.7762391340290878 7.253125192894832e-07 0.7711455503222944 7.253126680579875e-07 0.7675418410361046 \
7.25312799050976e-07 0.7643705172588006 7.25312936616212e-07 0.7610417440783073 7.253130423674414e-07 0.7584842184275663 7.253131771410751e-07 0.7552262509102785 \
7.253132889738005e-07 0.7525244432456109 7.253134184089644e-07 0.7493992292091655 7.253135735976883e-07 0.7456545577979357 7.253136852334406e-07 0.7429626190147979 \
7.253138448080549e-07 0.7391166470929011 7.253140201296882e-07 0.7348935218456193 7.253142325051509e-07 0.7297828120356423 7.253144253876789e-07 0.7251458607116523 \
7.253145820889711e-07 0.7213823872711312 7.253147687636618e-07 0.716903961299824 7.253149576500111e-07 0.7123775767926828 7.253151485342027e-07 0.70780884692282 \
7.253153352821382e-07 0.7033444557767304 7.253155183669542e-07 0.698972331957095 7.253156556859353e-07 0.6956951921588121 7.253158089288925e-07 0.6920418367118417 \
7.253160040575431e-07 0.6873949992893974 7.253161613518718e-07 0.6836535194673684 7.25316320746467e-07 0.6798660670227984 7.253165164902601e-07 0.6752219404489795 \
7.253167086893939e-07 0.6706682621108646 7.253169436410222e-07 0.6651105611269369 7.2531713111727e-07 0.6606839627962382 7.253173683544038e-07 0.6550894036851447 \
7.253175575343661e-07 0.6506361170423679 7.253177381501785e-07 0.6463915264929231 7.253179018447415e-07 0.6425504277539856 7.253180463961504e-07 0.6391628119244788 \
7.2531818686792e-07 0.6358764726647652 7.253183139687074e-07 0.6329064225879303 7.253184462761836e-07 0.6298198307262635 7.253185728632297e-07 0.626870110582017 \
7.253187034434976e-07 0.62383130535404 7.253188327128966e-07 0.6208285625908692 7.253189718197929e-07 0.6176004736356133 7.253191203301029e-07 0.6141606483517721 \
7.253193098786583e-07 0.6097777958748198 7.253194555819144e-07 0.6064170107178907 7.253196906324778e-07 0.601007464699683 7.253198736317494e-07 0.5968099615921 \
7.253200979734226e-07 0.5916778694808832 7.253202691466717e-07 0.5877753019413697 7.253204014804909e-07 0.5847634284691802 7.253205332770303e-07 0.5817721407249107 \
7.253206398209335e-07 0.5793579518205488 7.25320735711292e-07 0.5771868999037388 7.25320828211542e-07 0.5750974572268882 7.25320920638905e-07 0.5730134868920421 \
7.253209930672115e-07 0.5713818265150021 7.25321048796317e-07 0.5701269325864891 7.253211099054046e-07 0.5687522410723198 7.253212066700799e-07 0.5665806864277688 \
7.253212681615945e-07 0.5652027770813386 7.253213272142164e-07 0.5638802801505602 7.253214028408818e-07 0.5621878686488651 7.253214698636601e-07 0.5606896577364279 \
7.253215434607697e-07 0.5590483558003441 7.253216110667724e-07 0.5575429304381756 7.253217271358289e-07 0.5549610936632026 7.253218273422345e-07 0.5527359403974305 \
7.253219393494243e-07 0.5502565947066531 7.253220338414751e-07 0.5481686943853854 7.253221549961725e-07 0.5454955387196141 7.253222551839389e-07 0.5432910220514219 \
7.253223711744508e-07 0.5407443765731218 7.253224788782884e-07 0.5383833065966291 7.253225884569768e-07 0.5359861028148916 7.253227005784206e-07 0.5335400310751951 \
7.253228275156047e-07 0.5307765704644959 7.253229496651232e-07 0.5281221248815906 7.253230894260376e-07 0.525095489155881 7.253232265641538e-07 0.522132778766487 \
7.253233765292441e-07 0.5189020692106626 7.253235353022474e-07 0.5154923220538846 7.253237093279043e-07 0.511765695450105 7.25323896158028e-07 0.5077823379664483 \
7.253241011259935e-07 0.5034264211640872 7.253243238349422e-07 0.4987133299464507 7.25324576739139e-07 0.4933874474923696 7.253248116930461e-07 0.4884604410272814 \
7.253251079613078e-07 0.4822828691822955 7.253253977512661e-07 0.4762763831984252 7.253257040870848e-07 0.4699660956099861 7.253260164056119e-07 0.4635767846525711 \
7.253263549710683e-07 0.4566963260653934 7.25326678082485e-07 0.4501741115777416 7.253270164777878e-07 0.4433881855507311 7.253273403090533e-07 0.4369378830387565 \
7.25327664703474e-07 0.4305204627449936 7.253280076377602e-07 0.4237851826852676 7.253283469185779e-07 0.4171698123421442 7.253286863932123e-07 0.4105997181257849 \
7.253291295050583e-07 0.4020958655332711 7.253294915732268e-07 0.3952155038183801 7.253298121249644e-07 0.3891775711374149 7.253301990595345e-07 0.3819561902961204 \
7.253305269297949e-07 0.3758957719299574 7.253308120888516e-07 0.3706704968427373 7.253311304576463e-07 0.3648820026298218 7.253314132885732e-07 0.3597820188690578 \
7.253316419773369e-07 0.3556924369094372 7.253318598701416e-07 0.3518226517641353 7.253320551194862e-07 0.3483769517668343 7.253322620275856e-07 0.344751588202948 \
7.253324768243417e-07 0.3410137651016431 7.253327290508921e-07 0.3366564674340092 7.253329710462047e-07 0.3325077909124976 7.253332018984844e-07 0.3285822460490526 \
7.253334167466747e-07 0.3249550452085373 7.253336371033643e-07 0.3212604562488142 7.253338386742641e-07 0.3179050685021769 7.253340417582105e-07 0.3145531374773136 \
7.253342396555968e-07 0.3113121771742085 7.253344267548364e-07 0.3082694484595072 7.253346206551794e-07 0.3051385396431291 7.253348257035143e-07 0.3018527636900292 \
7.253350059382659e-07 0.2989872106339772 7.253352418362774e-07 0.2952669081535775 7.253354431238275e-07 0.2921198200609627 7.253356445146313e-07 0.2889965001417216 \
7.253358691637942e-07 0.2855437159941698 7.253360345437678e-07 0.2830223598911593 7.253362123481056e-07 0.280330186126118 7.253363960043191e-07 0.277570343839212 \
7.253365812460764e-07 0.2748090658167894 7.253367593914542e-07 0.2721781298892599 7.253369329835173e-07 0.2696316866093095 7.253370933483699e-07 0.267306655456324 \
7.253372144595526e-07 0.2655585721882695 7.253373676543406e-07 0.2633570345323199 7.253374949857891e-07 0.2615475749425888 7.253375983136284e-07 0.2600830587034867 \
7.25337715638424e-07 0.2584225376281647 7.253378334453811e-07 0.2567591557214636 7.253379574091473e-07 0.2550199666844239 7.253380743933137e-07 0.2533821414201824 \
7.253382051894417e-07 0.2515535495016885 7.253383223995523e-07 0.2499173892700276 7.253384756526766e-07 0.2477853623028658 7.253386111831973e-07 0.2459029165157107 \
7.253387428644058e-07 0.244074199323236 7.253388994573169e-07 0.2419017673596028 7.253390246538746e-07 0.2401755227310949 7.253391603715014e-07 0.2383060149301216 \
7.253392927986628e-07 0.2364844144139329 7.253394127723238e-07 0.2348355337769661 7.253395758201609e-07 0.232606585912384 7.253397146272525e-07 0.230713852557009 \
7.253398531009718e-07 0.2288300961780371 7.253399586457211e-07 0.2273962817971701 7.253400870074011e-07 0.2256537837490921 7.253401911350241e-07 0.2242444877898851 \
7.253402916510259e-07 0.222886569499566 7.253403666954022e-07 0.2218745444235658 7.253404440284576e-07 0.2208349692306942 7.253405187916369e-07 0.2198305887827458 \
7.253405967553143e-07 0.218785487158918 7.253406516218243e-07 0.2180503923904892 7.253407081185998e-07 0.2172938400168352 7.253407515721192e-07 0.2167123195211523 \
7.253407916131654e-07 0.2161767335077376 7.253408308521132e-07 0.2156521099473339 7.2534087172635e-07 0.2151058606261434 7.253409258788401e-07 0.2143825797409383 \
7.253409642959715e-07 0.2138698309421548 7.253410035846784e-07 0.2133480458229882 7.253410651213864e-07 0.2125332203444249 7.253411270989155e-07 0.2117131287842428 \
7.253411835756643e-07 0.2109664019951111 7.253412482072544e-07 0.2101124842966758 7.25341343715876e-07 0.2088522205996687 7.253414310316075e-07 0.207701294711168 \
7.253415276412079e-07 0.2064291756790013 7.253416248707622e-07 0.2051510266126755 7.253417257178229e-07 0.2038307158897115 7.253418263175943e-07 0.2025192706911573 \
7.253419228088913e-07 0.2012627769767186 7.253420249910648e-07 0.1999338657614989 7.253421286307215e-07 0.1985898465970496 7.253422384047342e-07 0.1971698847140261 \
7.253423475797596e-07 0.1957617939809042 7.253424676778517e-07 0.1942174441246506 7.253425776973761e-07 0.1928086337505992 7.253426858092847e-07 0.1914295694688549 \
7.253428088379842e-07 0.1898652723262108 7.253428989485537e-07 0.1887234630454603 7.253430063140445e-07 0.1873671680421656 7.253430831253526e-07 0.1864004060894758 \
7.253431665706206e-07 0.1853535952511875 7.253432561024323e-07 0.1842338297700716 7.253433406678985e-07 0.1831790839553313 7.253434203840386e-07 0.1821880912968773 \
7.253435217092421e-07 0.1809331989518758 7.253436300564713e-07 0.1795959386230563 7.253437265321694e-07 0.1784102562612937 7.253438519099859e-07 0.1768766438339704 \
7.253439846934562e-07 0.1752616821119887 7.253441024642794e-07 0.1738362801839788 7.253442481158562e-07 0.1720835746408261 7.25344358713008e-07 0.1707596463148658 \
7.25344500843447e-07 0.1690680578777541 7.253446165530702e-07 0.1676985735146403 7.253447220270831e-07 0.166456424915798 7.253448165437424e-07 0.1653485352650968 \
7.253449121811146e-07 0.1642320043563913 7.253450092529585e-07 0.1631032360400927 7.253451083042123e-07 0.161956192050434 7.253452022277692e-07 0.1608730077890209 \
7.253452875034443e-07 0.1598934595213354 7.253453878832364e-07 0.1587475631033795 7.253454721860728e-07 0.1577906478848196 7.253455745855819e-07 0.1566342854655733 \
7.253456519798444e-07 0.1557646215197878 7.253457443247582e-07 0.154731814591042 7.253458145762303e-07 0.1539498814072817 7.253459107506593e-07 0.1528844393027091 \
7.253459875753224e-07 0.152038051282755 7.253460663454741e-07 0.1511758489440315 7.253461402383946e-07 0.150370438825067 7.253462079361381e-07 0.1496353997608715 \
7.253463040000261e-07 0.1485973848112393 7.25346373572453e-07 0.1478489919002561 7.253464574616254e-07 0.1469503328160803 7.253465185934615e-07 0.146298213254472 \
7.253465908615431e-07 0.1455309799806117 7.253466633001062e-07 0.1447677488542132 7.253467442811468e-07 0.1439178685120187 7.253468103556157e-07 0.1432275520600639 \
7.253468877561137e-07 0.1424219220725307 7.253469771315706e-07 0.1414956876531561 7.253470479922162e-07 0.1407644282175171 7.253471468792833e-07 0.1397487730030469 \
7.253472241981922e-07 0.1389620820751095 7.253473062434185e-07 0.1381330876879582 7.253473943545299e-07 0.1372467208126059 7.25347461981677e-07 0.1365690714953818 \
7.253475422788589e-07 0.1357674830239305 7.253476170628882e-07 0.1350239185327315 7.253476850640654e-07 0.1343502586094245 7.253477317469739e-07 0.1338891847862563 \
7.253478209985674e-07 0.1330118383700247 7.253478592216168e-07 0.1326395291833771 7.253479282135268e-07 0.1319690872918072 7.253479809615963e-07 0.1314578750898332 \
7.253480639543783e-07 0.1306559489775353 7.253481041328288e-07 0.1302688434457458 7.253481966502028e-07 0.1293805059784019 7.253482353685699e-07 0.1290098403727171 \
7.25348309129285e-07 0.1283055160094505 7.253483707572868e-07 0.1277188748199021 7.253484427849764e-07 0.1270353589407805 7.253485109520081e-07 0.1263909833196726 \
7.253485855741692e-07 0.1256908956540175 7.253486674266349e-07 0.1249253613889138 7.253487508807973e-07 0.124147338931438 7.25348823832511e-07 0.1234692772477456 \
7.253488965594407e-07 0.122795332839617 7.253489565494355e-07 0.1222410931008323 7.253490429174471e-07 0.121445549533078 7.253491038861646e-07 0.1208856452315438 \
7.253491622719555e-07 0.1203507897957366 7.253492279066196e-07 0.119751336354628 7.253492872608612e-07 0.1192111367930785 7.253493552926419e-07 0.1185941868697126 \
7.253494525870119e-07 0.11771710490035 7.253495310789918e-07 0.1170124163111649 7.25349621315123e-07 0.1162055395685231 7.253497171618085e-07 0.1153523005684616 \
7.253497921195047e-07 0.1146878351828532 7.253498964789213e-07 0.1137670532163148 7.25349983267518e-07 0.1130053589403202 7.25350092924934e-07 0.1120476726212376 \
7.253501744789968e-07 0.1113387926087848 7.253502700926292e-07 0.1105114393564785 7.253503468048225e-07 0.10985058581598 7.253504417232868e-07 0.1090364400125625 \
7.253505175463918e-07 0.1083889268999046 7.253505952460492e-07 0.1077282965354292 7.253506775775e-07 0.1070311517075373 7.253507371427637e-07 0.1065286079538068 \
7.253508009005013e-07 0.1059924133642201 7.253508619951089e-07 0.1054803128126646 7.253509578588471e-07 0.1046801683739134 7.253510027219415e-07 0.1043071445723913 \
7.253510859626872e-07 0.1036173314376927 7.25351135082509e-07 0.1032117000904133 7.253512441312713e-07 0.1023149933518279 7.253512889673535e-07 0.1019479364619093 \
7.253513792285848e-07 0.1012117400678687 7.25351420105203e-07 0.1008795969612472 7.25351490563617e-07 0.1003088525914566 7.253515768510381e-07 0.09961307626065434 \
7.253516686285974e-07 0.09887705578174606 7.253517381566897e-07 0.09832225024344161 7.25351816683849e-07 0.09769854072774181 7.253519074125254e-07 0.09698178745350861 \
7.25351983228664e-07 0.09638605854785212 7.253520652414071e-07 0.09574500473888557 7.253521469944435e-07 0.09510943278387665 7.253522375022672e-07 0.09440967388330095 \
7.253523270615645e-07 0.09372126988887708 7.253524126713984e-07 0.09306698857649189 7.253525054508964e-07 0.09236212353634379 7.25352586338857e-07 0.0917510971760913 \
7.253526874678274e-07 0.09099177263830999 7.253527679613525e-07 0.09039108594384238 7.253528522042178e-07 0.08976589684797046 7.253529260492651e-07 0.08922077348043934 \
7.253530028987433e-07 0.08865632925481931 7.253530910391124e-07 0.08801255002475737 7.253531711034815e-07 0.08743108261130086 7.253532641396717e-07 0.08675939571108145 \
7.253533821403849e-07 0.08591369538214398 7.253535245136123e-07 0.08490278100234279 7.253536687619621e-07 0.08388867104764453 7.253538110896711e-07 0.08289807427203813 \
7.253539606674147e-07 0.08186746790234835 7.253540969811606e-07 0.08093761126893445 7.253542391015919e-07 0.0799778356000513 7.253543736550197e-07 0.07907840240745091 \
7.253545140077296e-07 0.07814980287393705 7.253546616898023e-07 0.0771833418413561 7.253548118052992e-07 0.07621180464723754 7.253549765257764e-07 0.07515824360926991 \
7.253551401551281e-07 0.07412455432658185 7.25355314933688e-07 0.07303438636984133 7.253555021863042e-07 0.07188220095900363 7.253557122313081e-07 0.07060976590783831 \
7.253559304415312e-07 0.06930979572898451 7.253561638986196e-07 0.06794333957253913 7.253564187446379e-07 0.06648001693367038 7.253567118391949e-07 0.06483321328442151 \
7.253570141789572e-07 0.06317411115207273 7.253573287658326e-07 0.06148945259513613 7.253577250265267e-07 0.05942677493938087 7.253580587436718e-07 0.05774249301432461 \
7.253584660545011e-07 0.05574994498853819 7.253587939392599e-07 0.05419380357502902 7.253591506298989e-07 0.05254809000207299 7.253594638680598e-07 0.05114243792209583 \
7.25359766835193e-07 0.04981740498512215 7.253600643757185e-07 0.04854875663330436 7.253603431552737e-07 0.04739109061078805 7.253606261551692e-07 0.04624570307560639 \
7.253608878954772e-07 0.04521055793698023 7.253611671343698e-07 0.04413130357485813 7.253614392402902e-07 0.0431040186124033 7.253617466070471e-07 0.04197194005652995 \
7.25361968409948e-07 0.04117329707315532 7.253622748704282e-07 0.04009446155587663 7.253625010598812e-07 0.03931650950691581 7.253627399772065e-07 0.03851359500741255 \
7.253629644010393e-07 0.03777663690506906 7.253631666633204e-07 0.03712468825868943 7.253633677059489e-07 0.03648814235703791 7.253637194799833e-07 0.03540095449820539 \
7.253639697258209e-07 0.03464776841732944 7.253642160441007e-07 0.03392252499723709 7.253644973769646e-07 0.03311308780599518 7.253647404679504e-07 0.03242954897046491 \
7.253649759417007e-07 0.03178112583711486 7.25365217601206e-07 0.03113119522156456 7.253654544834836e-07 0.03050988948014832 7.25365685016041e-07 0.02991733361391674 \
7.253658989845686e-07 0.02937801894285819 7.253661049271158e-07 0.02886851641492237 7.253664976516027e-07 0.02792196059063811 7.253666857292829e-07 0.02747992420741849 \
7.253670611682488e-07 0.02661861215736662 7.253672360424775e-07 0.02622659266649364 7.253676593654915e-07 0.02530049759795254 7.253677806148756e-07 0.02504150687334681 \
7.253682211765283e-07 0.02412433837770948 7.253683636746476e-07 0.02383402682615681 7.253686957281575e-07 0.02316883068419595 7.253688786936821e-07 0.02280879143785283 \
7.25369267997886e-07 0.02205689891561978 7.253694363435941e-07 0.02173705378531499 7.253699084579932e-07 0.02085107653961301 7.253700482027269e-07 0.0205916297664938 \
7.253705437828048e-07 0.01969297428531048 7.253706710082374e-07 0.01946923320191776 7.253712389173419e-07 0.01851512288677271 7.253714031712902e-07 0.0182513999453204 \
7.253720130430285e-07 0.0173209960017622 7.253721727282572e-07 0.01708922829277545 7.253726996397978e-07 0.01635462467776483 7.253729041570907e-07 0.01608193551804103 \
7.253736276344778e-07 0.01515939662837778 7.253737930766099e-07 0.01495683325581705 7.253745396363563e-07 0.01408081084911163 7.253746729395689e-07 0.01393008075245666 \
7.253755331241552e-07 0.01299799962960837 7.2537566920557e-07 0.01285670227674402 7.253766097994594e-07 0.01192267652923807 7.253767735725333e-07 0.01176632439256516 \
7.253777747514646e-07 0.01084959205883911 7.253779122291872e-07 0.01072929995296418 7.253790829267985e-07 0.009787962024485789 7.253791753231659e-07 0.009718668544398181 \
7.253805933990138e-07 0.008725931027897449 7.253806803751621e-07 0.00866912727384293 7.253822213707925e-07 0.00770199130002063 7.253823306868067e-07 0.007633428668288294 \
7.253839739346292e-07 0.006673746291950173 7.253841067919082e-07 0.006603544020797993 7.253862011722062e-07 0.005605323336654431 7.25386409576941e-07 0.00551468736035817 \
7.25388763913366e-07 0.004577307911602986 7.253892374721227e-07 0.004407121484391641 7.253921229089795e-07 0.003492041675788492 7.253926525733264e-07 0.00334538389506189 \
7.253968608005519e-07 0.00237996320858989 7.253973742348033e-07 0.002283557532494709 7.254031334854955e-07 0.001325291758975802 7.254033680667129e-07 0.001279502680325907 \
7.254180358940879e-07 0.0002809017338477542 7.2541814896418e-07 0.0002788534805396912 7.280551690439302e-07 -0.0006849217749926401 7.280553352056057e-07 -0.0009443270389602415 \
7.28055814074993e-07 -0.001850320037528519 7.280559067946197e-07 -0.002050462221988249 7.280562720196971e-07 -0.002913187630468476 7.280563636768137e-07 -0.00314709230904735 \
7.280567297831652e-07 -0.004133001189868674 7.280568399302907e-07 -0.004442309109773816 7.280571506685428e-07 -0.005311341427314526 7.280572524071878e-07 -0.005583925258601597 \
7.280576161113131e-07 -0.00638370916272213 7.280577809576364e-07 -0.006585924750287024 7.280583607549566e-07 -0.005792290386912202 7.280585355894154e-07 -0.004916934050781314 \
7.280586522790152e-07 -0.00413641027497409 7.280587787087076e-07 -0.00310656561120747 7.280588807309105e-07 -0.002137079422087956 7.280590005773929e-07 -0.0008406209844352954 \
7.280590912146293e-07 0.0002489246187367611 7.280591896346795e-07 0.001536790859923857 7.280592893583236e-07 0.002948496343048522 7.280594568423325e-07 0.005545701385567424 \
7.280596754209339e-07 0.009327395936412004 7.280598614912559e-07 0.0128572688386996 7.280600828738638e-07 0.01737012273305725 7.280602435339974e-07 0.02082840415615294 \
7.280604069996469e-07 0.02447866954313523 7.280605576351642e-07 0.02794359528291388 7.280607066909169e-07 0.03145289236167962 7.280608561536706e-07 0.03504014479003619 \
7.280610101846837e-07 0.03879791952579481 7.28061172300943e-07 0.04280891157365373 7.280613383304077e-07 0.04696567134311741 7.280615142832281e-07 0.05141478668696391 \
7.280616949538655e-07 0.05602187592747932 7.280618867748118e-07 0.06094655248807559 7.280620938803164e-07 0.06629309753158302 7.280623154520462e-07 0.07203901748582854 \
7.280625501862155e-07 0.07814662931008168 7.280628017257828e-07 0.08470684589377442 7.280630771678493e-07 0.09190125212984442 7.280633773636676e-07 0.09974607960254324 \
7.280637082958778e-07 0.108390578238945 7.280640839626117e-07 0.1181923833971668 7.280644815454798e-07 0.1285487285136021 7.280649483700824e-07 0.1406786766767902 \
7.280654913626172e-07 0.1547396794802719 7.2806612478764e-07 0.1710742296429572 7.280668207276906e-07 0.1889259607126788 7.280676362848004e-07 0.2097135943149445 \
7.280685463129037e-07 0.2327316641523666 7.280693395691243e-07 0.2526372689279454 7.280700450441999e-07 0.2702038474981599 7.280706639884678e-07 0.2855008995781749 \
7.280712310944079e-07 0.2994177966724069 7.280717541744141e-07 0.3121574438576628 7.280722531532068e-07 0.3242197130846058 7.280727371932143e-07 0.3358335658028451 \
7.280731924200473e-07 0.3466679577370423 7.280736669320091e-07 0.3578644504627745 7.280741068407172e-07 0.368158604789619 7.28074592685345e-07 0.3794271463718566 \
7.280751242881185e-07 0.3916316501999784 7.280756269514167e-07 0.4030538969706937 7.280760560236697e-07 0.4127111343288326 7.280765470403382e-07 0.4236561147984291 \
7.280770484704186e-07 0.434714731975362 7.280773950150088e-07 0.442288187401736 7.280777504243856e-07 0.4500000616404133 7.280781776521144e-07 0.4592019891792938 \
7.280785698516369e-07 0.4675774400278049 7.280788702333951e-07 0.4739448723400065 7.280792120451548e-07 0.4811381049525967 7.280795554849688e-07 0.4883107756756314 \
7.280798162200955e-07 0.4937186470393492 7.280800582500485e-07 0.4987071765458648 7.280803241952914e-07 0.5041573145298286 7.280805814645868e-07 0.509394255416739 \
7.280807715836905e-07 0.5132422368582924 7.280809851098511e-07 0.5175451019736222 7.280811248001571e-07 0.5203466115392713 7.280812710004491e-07 0.5232668091041763 \
7.280814849883502e-07 0.5275186200231483 7.280816930046097e-07 0.5316389396023125 7.28081885465879e-07 0.5354321131715788 7.280820705821105e-07 0.5390651926504321 \
7.280822449555567e-07 0.5424725330931349 7.280825494976333e-07 0.5484058192982523 7.280828100565151e-07 0.5534602958276967 7.280831114875445e-07 0.5592859190791987 \
7.28083365805138e-07 0.5641865993769294 7.280836586613278e-07 0.5698153316805189 7.280839178744798e-07 0.5747800306938655 7.280841889508118e-07 0.579963273174682 \
7.280844307945713e-07 0.5845680738798381 7.280846882997289e-07 0.5894577538325241 7.280849150436047e-07 0.5937419314630586 7.280851520444243e-07 0.5982006324572362 \
7.280853622309862e-07 0.6021379329905048 7.280855749915204e-07 0.6061060319396779 7.280858278702861e-07 0.6107954169450593 7.280860315335544e-07 0.6145509252949414 \
7.280862222509359e-07 0.6180531102377972 7.280864095873744e-07 0.6214768531423983 7.28086598465652e-07 0.6249070011644339 7.280868066654474e-07 0.6286671070650327 \
7.280870509975622e-07 0.6330499453121026 7.280872505640949e-07 0.6366057789565548 7.280874547098357e-07 0.6402215701419991 7.2808763934909e-07 0.643474671963314 \
7.28087908884781e-07 0.6481901084955864 7.280881365916373e-07 0.652149230294136 7.280883242633752e-07 0.6553888277830079 7.280885051635201e-07 0.6584949378977958 \
7.280886647046018e-07 0.661221510907812 7.280888351670024e-07 0.6641177016088209 7.280889869184431e-07 0.6666817235716488 7.280891245614551e-07 0.6689905419339194 \
7.280892735563185e-07 0.6714784915997724 7.280894012981823e-07 0.6736028790357499 7.28089544284695e-07 0.675968899142866 7.280896660677513e-07 0.6779749688503388 \
7.28089802351161e-07 0.6802121872853304 7.280899221800626e-07 0.682172759947357 7.280900687756233e-07 0.6845626218370968 7.280901872485649e-07 0.6864845934661837 \
7.280902831819268e-07 0.6880368302455475 7.280903757015115e-07 0.6895284278106264 7.280904807620224e-07 0.6912169000724893 7.280905788439078e-07 0.6927871490736753 \
7.280907159592253e-07 0.6949707622226827 7.28090835157868e-07 0.6968607547931925 7.280909450978383e-07 0.6985951241089645 7.280910825970815e-07 0.7007503743809057 \
7.280912140269831e-07 0.7027960765825516 7.280913462564986e-07 0.7048392108129343 7.280914594338973e-07 0.7065756917706891 7.280916138667517e-07 0.708927873976708 \
7.280917446467452e-07 0.7109048231498766 7.280918673154548e-07 0.7127465601965561 7.280919735837112e-07 0.7143329262278221 7.280920959637349e-07 0.7161490373358268 \
7.280921978172318e-07 0.7176517022913665 7.280923319551315e-07 0.7196190116794019 7.280924526481716e-07 0.7213783352064487 7.280925717899705e-07 0.7231049829175343 \
7.280926968079846e-07 0.7249059312823601 7.280928266477907e-07 0.7267645120560844 7.280929464599617e-07 0.7284691779696002 7.280930754532131e-07 0.730293808329565 \
7.280932075602773e-07 0.7321507998840678 7.280933258660953e-07 0.7338038328985433 7.280934691267862e-07 0.7357927618453034 7.280935715814729e-07 0.7372070005703254 \
7.280936677883586e-07 0.7385290937783453 7.280937728059804e-07 0.7399656334130889 7.280938835775113e-07 0.7414708009413548 7.280939852560522e-07 0.7428439364018735 \
7.280940882175066e-07 0.7442258341871242 7.280942051436606e-07 0.7457850038572696 7.280943339039365e-07 0.747489965072781 7.28094435062908e-07 0.7488201182152049 \
7.280945839319522e-07 0.7507626302114226 7.280947316114891e-07 0.75267249971878 7.280948509768551e-07 0.7542038164026367 7.280949974606996e-07 0.7560679527984652 \
7.280951206361903e-07 0.7576223900169708 7.280952614398646e-07 0.7593848990234215 7.28095398032531e-07 0.7610800595258669 7.280955201903812e-07 0.7625841275516777 \
7.280956328467787e-07 0.7639610711610054 7.280957745729197e-07 0.7656796138775311 7.280959007394198e-07 0.767196844592689 7.280960161567243e-07 0.768574452686535 \
7.280961464649039e-07 0.7701179991486644 7.280962621775718e-07 0.7714782821591826 7.280963850018603e-07 0.7729116492687436 7.280965028461285e-07 0.7742769236963016 \
7.280966084761185e-07 0.7754922619072108 7.280967238495534e-07 0.7768108638983861 7.280968291127158e-07 0.7780056027231214 7.28096940062529e-07 0.7792565499870431 \
7.280970264670305e-07 0.7802246528436213 7.280971305008506e-07 0.7813823422463088 7.28097244396594e-07 0.7826398494046257 7.280973474300135e-07 0.7837684443710583 \
7.280974555127141e-07 0.7849432998269023 7.280975637643696e-07 0.7861107422109641 7.280976991816163e-07 0.7875582910536544 7.280978118557238e-07 0.7887521292973186 \
7.280979362797841e-07 0.7900592323105087 7.28098054252648e-07 0.7912877959129118 7.280981987206026e-07 0.7927781272271259 7.280983163897418e-07 0.7939806363584788 \
7.280984522695815e-07 0.7953567374150946 7.280985870139538e-07 0.7967081403609936 7.280986980849332e-07 0.7978123285366109 7.280987979742732e-07 0.7987978371087655 \
7.280988996542306e-07 0.7997937268659365 7.28099032867897e-07 0.8010867894381996 7.280991512407162e-07 0.8022243628210853 7.280992727817904e-07 0.8033812848148773 \
7.280993921454423e-07 0.8045065422543012 7.280995132768187e-07 0.80563739819571 7.28099644976236e-07 0.8068544426691319 7.280997679845129e-07 0.8079795872959963 \
7.280998958281203e-07 0.8091371804586788 7.281000267346398e-07 0.8103101881504271 7.281001503277979e-07 0.8114062915203997 7.28100257500303e-07 0.8123479140825919 \
7.281003649295023e-07 0.8132835730547656 7.281004475986205e-07 0.8139979974227743 7.281005653103806e-07 0.8150069815425507 7.281006559159858e-07 0.8157770472204025 \
7.281007865694307e-07 0.8168774959419571 7.28100930959301e-07 0.8180800468042847 7.281010641337151e-07 0.8191766687328477 7.281011740251065e-07 0.8200725423139092 \
7.281013176239916e-07 0.8212302325252553 7.281014710146833e-07 0.8224508494407716 7.281015990929081e-07 0.8234574467428303 7.281017388802764e-07 0.8245431382086058 \
7.281018651298391e-07 0.8255122018650548 7.281020197283917e-07 0.8266841987320058 7.281021519393684e-07 0.8276738265999063 7.281022781661507e-07 0.8286078934539939 \
7.281023959138743e-07 0.8294698388787296 7.281025449866676e-07 0.8305480062617677 7.281027123182206e-07 0.8317406852496945 7.281028455394968e-07 0.8326770812274722 \
7.281030183208196e-07 0.8338744310092966 7.281031868261935e-07 0.8350236380668206 7.281033562054924e-07 0.8361608866600232 7.281035378407611e-07 0.8373606451951652 \
7.281036801740827e-07 0.8382866867625347 7.281037940110689e-07 0.8390185116470331 7.28103925192579e-07 0.8398522525089582 7.28104026724794e-07 0.8404903982372576 \
7.281041430090543e-07 0.8412135669902132 7.281042776438077e-07 0.8420406924792603 7.281044746666439e-07 0.8432316292878405 7.281046647721864e-07 0.8443592803112207 \
7.281048748954985e-07 0.8455816023960827 7.281050552136042e-07 0.8466107566581813 7.281052526767047e-07 0.8477171937062282 7.281054267458196e-07 0.8486750118570332 \
7.2810560906524e-07 0.8496608982186138 7.281057804803757e-07 0.8505716849290491 7.281059545936528e-07 0.8514808063694008 7.281061303246211e-07 0.8523822271368225 \
7.281063064363214e-07 0.8532696099472232 7.281064960541732e-07 0.8542074684498208 7.281066868356705e-07 0.8551330189126392 7.281068884317469e-07 0.8560917259710515 \
7.281070811660049e-07 0.856990088884472 7.281072900378257e-07 0.8579439907476532 7.281075207402632e-07 0.8589743400177088 7.281077851832272e-07 0.8601259267840322 \
7.281080840059149e-07 0.8613896125360476 7.281083639602158e-07 0.8625380186322354 7.281086480860817e-07 0.8636694076724545 7.281089228550569e-07 0.8647317823994775 \
7.281091947122167e-07 0.8657531067718063 7.281094650893342e-07 0.8667403371654003 7.281097221678555e-07 0.8676533221001362 7.281099947926866e-07 0.868594905839151 \
7.281102707598356e-07 0.8695208838709013 7.281105408640932e-07 0.8704012674911344 7.281108407401039e-07 0.8713491368600049 7.281112118011625e-07 0.8724801680184872 \
7.2811150674079e-07 0.8733472453740196 7.281117610365479e-07 0.8740729094291386 7.281120592974738e-07 0.8748989982677786 7.281123329040153e-07 0.8756336613858092 \
7.281125690299577e-07 0.876250392688866 7.281128093740557e-07 0.8768621356511911 7.281130317061818e-07 0.8774140071409635 7.28113225712247e-07 0.8778848105679672 \
7.281135554349973e-07 0.8786625669521169 7.281137106085256e-07 0.8790190643519731 7.281140283876062e-07 0.879730644938159 7.281142072488645e-07 0.8801204696806418 \
7.28114549710761e-07 0.8808457867651537 7.281147338373631e-07 0.8812245477320809 7.28115208711942e-07 0.8821665346129511 7.281153761083518e-07 0.8824869809105039 \
7.281158419518538e-07 0.883348261932613 7.281160227735482e-07 0.8836708855253055 7.281165168126507e-07 0.8845204537290557 7.28116658162059e-07 0.8847551796839913 \
7.281172645001219e-07 0.8857215808967022 7.281174165693362e-07 0.8859539944113424 7.281180632563559e-07 0.8869009218298172 7.281181915512387e-07 0.8870812460539503 \
7.28118839667745e-07 0.8879562712787433 7.281189694676407e-07 0.8881245027440973 7.281197476783404e-07 0.8890830197250962 7.281198627254718e-07 0.8892171882189283 \
7.281207183963142e-07 0.8901564861234483 7.281208637440773e-07 0.8903061494816453 7.281218494996487e-07 0.8912466483555094 7.281220706077111e-07 0.8914402669210102 \
7.281232157277145e-07 0.892367747196105 7.281233469391586e-07 0.8924695935232408 7.281246882116238e-07 0.8934615053489913 7.281248396029001e-07 0.8935661991834861 \
7.281263210551204e-07 0.8944951400107031 7.28126559934816e-07 0.8946288932334222 7.281283293566538e-07 0.895502508848118 7.281287184779452e-07 0.895670668133377 \
7.281311122106538e-07 0.8965556062201232 7.281315877505925e-07 0.8967047758494365 7.281356508198176e-07 0.8977025964496719 7.281361422956535e-07 0.8977953148389237 \
7.281444588927962e-07 0.8987880790885289 7.281453787942481e-07 0.8988514070442593 7.282992423701678e-07 0.8998485708192639 7.283028854964575e-07 0.8998628537402877 \
7.285296142766716e-07 0.8989664306490068 7.285298446165833e-07 0.8988008565867064 7.285314595368805e-07 0.897804750401333 7.285316372691665e-07 0.8977103535805105 \
7.285484036692715e-07 0.8986978311584225 7.285485397684024e-07 0.8987160394686986 7.285637106086718e-07 0.8997133888183054 7.285639877135077e-07 0.899719468756186 \
7.290480289064218e-07 0.9005852143835333 7.290482022410388e-07 0.9007408621809421 7.290488627306383e-07 0.9015135064485434 7.290490287958205e-07 0.9017527716291757 \
7.29049555130528e-07 0.9026184054967997 7.290497462444475e-07 0.9029704910143604 7.290501104654996e-07 0.9036902342402512 7.290502896649214e-07 0.9040628043424317 \
7.290506515515937e-07 0.9048333795345931 7.290508466611638e-07 0.9052442844328937 7.290513790595253e-07 0.9062266394381637 7.290515614131638e-07 0.9064623886473868 \
7.29052553393556e-07 0.905594670761786 7.290527149341233e-07 0.9049318860608667 7.290528829265756e-07 0.9040378649110347 7.290530427580612e-07 0.9029782421366458 \
7.29053180254799e-07 0.9018984154159868 7.290533131621115e-07 0.9007052793196499 7.290534395875788e-07 0.8994328447569792 7.290535469868187e-07 0.8982475863895881 \
7.290536514834769e-07 0.8970047013543965 7.290537655331467e-07 0.8955451342423859 7.290538555027343e-07 0.8943225684615312 7.290539603213726e-07 0.8928208677113324 \
7.290540497696118e-07 0.891473284704788 7.290541321453926e-07 0.8901820884368528 7.290542232383926e-07 0.8887006634027688 7.290543605744706e-07 0.8863657732814155 \
7.290544590674027e-07 0.8846195012157601 7.290545711411527e-07 0.8825649218508906 7.290547020241858e-07 0.880080778639088 7.290548384952159e-07 0.8774018563482072 \
7.290549919493788e-07 0.8742910281085086 7.290551510437468e-07 0.8709679977889497 7.290553153276494e-07 0.867445283300377 7.290554719957506e-07 0.8640104344288071 \
7.290556240865311e-07 0.860615744772629 7.290557778002063e-07 0.857132398554192 7.290559373623813e-07 0.853469801378647 7.290560924510828e-07 0.8498714074018293 \
7.290562661304016e-07 0.8458039138600054 7.290564291612693e-07 0.8419559450883216 7.290565908036839e-07 0.8381170660338335 7.290567534504205e-07 0.8342344554797501 \
7.290569148689274e-07 0.8303657475978833 7.29057083463406e-07 0.8263109424305363 7.290572663565042e-07 0.8219002364007665 7.290574341852182e-07 0.8178440888239877 \
7.290576024710332e-07 0.8137703061148112 7.290577732990846e-07 0.8096302849976138 7.290579454736421e-07 0.8054541271740473 7.290581132355611e-07 0.8013830614994394 \
7.290582968650184e-07 0.7969255463994016 7.290584682714962e-07 0.7927646873948894 7.290586537148024e-07 0.7882638003278283 7.290588203854536e-07 0.7842196820467244 \
7.290589892715847e-07 0.7801233737411432 7.290591734278818e-07 0.7756572567105651 7.290593680379105e-07 0.7709405333854473 7.290595152932414e-07 0.7673736106648734 \
7.29059641923832e-07 0.7643079795643375 7.290597837806443e-07 0.7608754495129878 7.290598881844221e-07 0.7583505812556488 7.290600205770739e-07 0.7551502542766809 \
7.290601301612705e-07 0.7525028097975122 7.290602633259231e-07 0.7492875979647342 7.290604195076851e-07 0.7455190770546114 7.290605327371121e-07 0.7427887939149777 \
7.290606952584763e-07 0.7388718945951063 7.290608674392915e-07 0.7347246296492568 7.290610634440439e-07 0.7300078517193382 7.290612278340228e-07 0.7260553905833119 \
7.290613802307036e-07 0.7223944885043934 7.290615439058578e-07 0.718466402706526 7.290617118315579e-07 0.7144406657912139 7.290618916719357e-07 0.7101336212543717 \
7.29062067965886e-07 0.7059164985576465 7.290622390405214e-07 0.7018286413152719 7.29062407358697e-07 0.6978099102718778 7.290625606248286e-07 0.6941537154717222 \
7.290627225083983e-07 0.6902960245155986 7.290629014599385e-07 0.6860364417190952 7.290630356714899e-07 0.6828448068431195 7.290631391777877e-07 0.6803854168085423 \
7.290632384622005e-07 0.6780286039046017 7.290633399166766e-07 0.6756220912380299 7.290634323732756e-07 0.6734303711245889 7.29063516962075e-07 0.6714267031582685 \
7.290636105394115e-07 0.6692114082407524 7.290637270816306e-07 0.6664546942583044 7.290638365591918e-07 0.6638675763958631 7.29063949672203e-07 0.6611971533414394 \
7.290640727909702e-07 0.6582923426231613 7.290641970172829e-07 0.6553636581362478 7.290643677774271e-07 0.6513432847262797 7.290645262260144e-07 0.6476181700514572 \
7.290646985138371e-07 0.6435738126612673 7.290648444919037e-07 0.6401512360303271 7.290649862851197e-07 0.6368325564797357 7.290651178835739e-07 0.6337564355289309 \
7.290652480468588e-07 0.630718219665797 7.290653735717995e-07 0.6277924818644975 7.290655053547071e-07 0.6247239543970449 7.290656352782026e-07 0.6217046839485236 \
7.290657715867779e-07 0.6185408917806742 7.290659162003453e-07 0.615188962872713 7.290660756925359e-07 0.611499189008522 7.290662491526524e-07 0.6074939486938447 \
7.290664201599544e-07 0.6035554342946753 7.290666515285226e-07 0.5982402936372396 7.290668949905284e-07 0.5926661367297537 7.29067069111016e-07 0.5886942528256315 \
7.290672153830934e-07 0.5853638081576373 7.290673497553115e-07 0.58231230528805 7.290674668502066e-07 0.5796585826255305 7.290675626145531e-07 0.5774900935424465 \
7.290676614610954e-07 0.5752566196463251 7.290677454384142e-07 0.5733628024369305 7.290678230524635e-07 0.571614165956722 7.290678843779373e-07 0.5702331258704825 \
7.290679490585755e-07 0.5687779664863769 7.290680303667114e-07 0.5669528575016536 7.290680804367073e-07 0.5658306078972934 7.290681297572688e-07 0.5647256890740617 \
7.29068191677069e-07 0.5633393552914843 7.290682395088942e-07 0.5622690492396486 7.290682900136796e-07 0.5611395143522533 7.290683500757169e-07 0.559799205480933 \
7.290684093585124e-07 0.5584782058326896 7.290684844152261e-07 0.5568072508052372 7.290685540978827e-07 0.5552574373576753 7.290686396864491e-07 0.5533559356568912 \
7.290687267538207e-07 0.5514265885063823 7.290688104163413e-07 0.5495763264044081 7.290688965613662e-07 0.5476734676082877 7.290689922659868e-07 0.5455621222678217 \
7.290690965509387e-07 0.5432673229847179 7.290692112181133e-07 0.5407497407899529 7.290693199365744e-07 0.5383664115638558 7.290694295088142e-07 0.5359693749054023 \
7.290695418135745e-07 0.5335193270114367 7.290696685891956e-07 0.530759392645703 7.290697908664272e-07 0.5281021910076299 7.290699309524048e-07 0.5250685463469849 \
7.290700679697626e-07 0.5221084647952599 7.290702182711349e-07 0.5188705764247719 7.290703771663761e-07 0.5154582091324615 7.290705515002589e-07 0.5117250894133971 \
7.29070738517481e-07 0.5077378180012799 7.290709438354859e-07 0.5033745272871338 7.290711556776788e-07 0.498891131759938 7.29071408479721e-07 0.4935662239713107 \
7.2907161056737e-07 0.4893264048484654 7.290718451606752e-07 0.4844277613141263 7.290720812752721e-07 0.4795194943790256 7.290723344517689e-07 0.474283574581623 \
7.290726449817317e-07 0.4679020429045382 7.290728630397102e-07 0.4634451779596257 7.290730364853443e-07 0.4599153839204358 7.290732129777809e-07 0.4563351808422506 \
7.290734924595774e-07 0.4506930409909046 7.290737247034844e-07 0.4460279192631412 7.290740117970731e-07 0.44029020239849 7.290742296431809e-07 0.435960758243863 \
7.290744396957687e-07 0.4318042429497612 7.290746408936045e-07 0.4278406951573778 7.290748233137655e-07 0.4242617300271556 7.290749972087507e-07 0.4208637793449936 \
7.290751620728668e-07 0.4176529694331993 7.290753208268398e-07 0.4145718140694327 7.290754870737866e-07 0.4113577680628809 7.290756357189934e-07 0.4084923702366076 \
7.29075788087249e-07 0.4055658186126443 7.290759301504317e-07 0.4028468403491589 7.290760995263099e-07 0.3996150665462138 7.290762199082301e-07 0.3973276483660343 \
7.290763298814939e-07 0.3952449223617059 7.290764448068948e-07 0.3930732253581283 7.290765970484751e-07 0.3902080468194818 7.290767092695403e-07 0.3881039677199808 \
7.290768164620408e-07 0.386098874836553 7.290769689902896e-07 0.383254723448244 7.290770971374193e-07 0.380874963946598 7.290772199854116e-07 0.3786015923730871 \
7.290773990837881e-07 0.375299968600122 7.290775481684202e-07 0.3725653942578417 7.290777158758077e-07 0.3695018296724824 7.290778712734425e-07 0.3666748141177644 \
7.290779954402882e-07 0.3644243980538668 7.290781093321555e-07 0.3623666676050148 7.290782307755259e-07 0.3601804966264144 7.290784109272934e-07 0.3569532670533712 \
7.290785774151135e-07 0.3539878629329621 7.290787678342229e-07 0.3506138544217919 7.290789595908186e-07 0.3472380408565978 7.29079142640212e-07 0.344035729794033 \
7.290792916122767e-07 0.3414435189591631 7.290794115521823e-07 0.3393660536257183 7.290795342136651e-07 0.3372483242714233 7.290796572441514e-07 0.3351324902755385 \
7.29079802148562e-07 0.3326515017845288 7.290799054613373e-07 0.3308907757076019 7.290799991908464e-07 0.3292979229163631 7.290800898511484e-07 0.3277620998585528 \
7.29080200972602e-07 0.3258853746017661 7.290803081455789e-07 0.3240820510456246 7.290804064202303e-07 0.3224338250618513 7.290805188247763e-07 0.3205545940512134 \
7.290806827646764e-07 0.3178277446588927 7.290808444025551e-07 0.3151576097143818 7.290809921893013e-07 0.3127316247504084 7.290811544345159e-07 0.3100832165115083 \
7.290813144650734e-07 0.3074868334344322 7.290814667283717e-07 0.3050304870660137 7.290816201002421e-07 0.3025703731928215 7.29081778808771e-07 0.3000411640344692 \
7.290819432578998e-07 0.297437246442505 7.290821104849764e-07 0.2948063590562646 7.290822635965136e-07 0.292412731930112 7.290824466944405e-07 0.2895700146919417 \
7.290826370021783e-07 0.2866380344427262 7.290827859052365e-07 0.2843603072871506 7.290829598425416e-07 0.2817165165722222 7.290831367199302e-07 0.2790484233348025 \
7.290832843171486e-07 0.2768363681311815 7.290834739488486e-07 0.2740172295061162 7.290836239507675e-07 0.2718052906662373 7.290837610609577e-07 0.2697943906627059 \
7.290839025914007e-07 0.2677397479842996 7.290840160502698e-07 0.2661005451260196 7.290841523405964e-07 0.2641384584581135 7.290842824172175e-07 0.2622807416655737 \
7.290844006714701e-07 0.2606037730704709 7.290845185270662e-07 0.2589348966568543 7.290846494208768e-07 0.2570853888657079 7.290847896596348e-07 0.2551145527343576 \
7.290849051542211e-07 0.2534976852533538 7.290850340055979e-07 0.2516957519945816 7.290851491515796e-07 0.2500885525459272 7.290853024625469e-07 0.2479513765689386 \
7.290854403163083e-07 0.2460367343642474 7.290855797779604e-07 0.2441002375748529 7.29085735245815e-07 0.2419427021952501 7.290858600284303e-07 0.2402176526454788 \
7.290859998933384e-07 0.2382916534360561 7.290861285955144e-07 0.2365220787132559 7.290862495543663e-07 0.234860341242685 7.290863665996657e-07 0.2332541163798121 \
7.290864926007302e-07 0.2315368940272461 7.290865893203229e-07 0.2302195772445239 7.290866814091961e-07 0.2289683907689286 7.290867958266674e-07 0.2274152998827935 \
7.29086894197314e-07 0.2260807986508055 7.290870113441077e-07 0.2244933520241092 7.290871144352256e-07 0.2231010305483718 7.290872199499517e-07 0.2216798666278746 \
7.290873008680116e-07 0.2205933880575098 7.290873745391968e-07 0.2196046443759679 7.290874172684338e-07 0.2190314036349237 7.290874603985789e-07 0.2184540235451489 \
7.290875111960606e-07 0.217774515685755 7.290875483709393e-07 0.217277430841393 7.29087589041954e-07 0.2167338127731004 7.290876318337554e-07 0.2161620985357572 \
7.29087668244897e-07 0.2156758299561118 7.290877101698877e-07 0.2151161507306283 7.290877647120985e-07 0.2143884526296278 7.290878031708564e-07 0.2138756926875936 \
7.290878427976257e-07 0.2133496230586122 7.290879046301276e-07 0.212531488259555 7.290879663565786e-07 0.2117156525305126 7.290880224938542e-07 0.210974237875411 \
7.290880861490836e-07 0.210134110843225 7.290881802401172e-07 0.2088936328424611 7.290882670483761e-07 0.2077505933124353 7.290883610050201e-07 0.2065146061917991 \
7.290884590472537e-07 0.2052266823513323 7.290885606346195e-07 0.2038976009052371 7.290886615435679e-07 0.2025832113009377 7.290887582793767e-07 0.2013244528083448 \
7.290888604043477e-07 0.1999972806373927 7.290889637359054e-07 0.1986583046056677 7.29089073618507e-07 0.1972379690671278 7.290891825607647e-07 0.1958337611883887 \
7.290893023958847e-07 0.1942937175364915 7.290894126797513e-07 0.1928822800638286 7.290895205584963e-07 0.191507108810815 7.290896466212543e-07 0.1899051957406391 \
7.290897364889607e-07 0.1887671190866151 7.290898469672999e-07 0.1873723090993208 7.290899245002487e-07 0.1863971337376019 7.290900088239919e-07 0.1853400660204312 \
7.2909009641205e-07 0.1842452710069853 7.290901842046441e-07 0.18315095174413 7.290902659245155e-07 0.1821357652581398 7.290903634861928e-07 0.1809282658474054 \
7.29090470197344e-07 0.1796118512064394 7.29090570679026e-07 0.178377576484793 7.290906948502375e-07 0.1768595317522179 7.290908287417607e-07 0.1752320886156309 \
7.290909476539533e-07 0.1737937102924047 7.290910980541468e-07 0.1719851742607024 7.290912088892401e-07 0.1706594030660365 7.29091348655982e-07 0.168997130456427 \
7.290914671812901e-07 0.1675953052211382 7.29091572608521e-07 0.1663548750207849 7.290916673183802e-07 0.1652455210322802 7.290917606281543e-07 0.1641568522804657 \
7.290918615342704e-07 0.1629842804551663 7.290919569521023e-07 0.1618800504313296 7.290920541430254e-07 0.1607598891027116 7.29092135704507e-07 0.1598237474547246 \
7.290922410209518e-07 0.1586229753023833 7.290923245006587e-07 0.1576763029943549 7.290924260299495e-07 0.1565306813704828 7.290925032604858e-07 0.1556635090415242 \
7.290925941325229e-07 0.154647919213242 7.290926634838334e-07 0.1538765336840219 7.290927480678846e-07 0.1529397840535594 7.290928224610911e-07 0.1521208717489242 \
7.290929018312932e-07 0.151251902275755 7.290929764189645e-07 0.1504388356812226 7.290930456405211e-07 0.1496871728711989 7.290931403213281e-07 0.1486640077242138 \
7.29093210087093e-07 0.1479134441579097 7.290932945316558e-07 0.147008717574758 7.290933560970015e-07 0.1463518850554192 7.290934301394932e-07 0.1455673550676988 \
7.290935035250168e-07 0.1447940960774066 7.290935849602585e-07 0.1439395015691976 7.290936544094048e-07 0.1432139999234875 7.290937295111024e-07 0.1424323701137583 \
7.290938194231735e-07 0.1415006120834361 7.290938965067932e-07 0.1407052977810757 7.290939956173774e-07 0.1396885207473417 7.290940651574398e-07 0.138983077430453 \
7.290941464759156e-07 0.1381612812129989 7.290942166443246e-07 0.1374549162714094 7.290942956124377e-07 0.1366629455350578 7.290943745907204e-07 0.1358740351737466 \
7.290944469125105e-07 0.1351544405911459 7.290945162779692e-07 0.1344667589602006 7.290945649819766e-07 0.1339854049281765 7.290946557443483e-07 0.1330945614011112 \
7.290946877658758e-07 0.1327823711724506 7.290947758698441e-07 0.131925672678654 7.290948083638864e-07 0.1316105445757083 7.290949070315436e-07 0.1306564447580443 \
7.290949506875193e-07 0.130235859061297 7.290950286693357e-07 0.1294866595045693 7.290950660002936e-07 0.1291289430202982 7.290951681516938e-07 0.128153223240932 \
7.290952355956539e-07 0.1275115375392494 7.290953007486116e-07 0.1268935577290946 7.290953666546259e-07 0.1262729746041904 7.290954378066093e-07 0.1256052797936485 \
7.290955207439704e-07 0.1248293808775363 7.290956061394507e-07 0.1240331657139879 7.290956822268445e-07 0.1233259817834828 7.290957626875214e-07 0.1225806238777534 \
7.290958207714622e-07 0.1220441728027253 7.29095892104936e-07 0.1213870835332726 7.290959768933693e-07 0.1206085709991845 7.290960380484021e-07 0.1200487744399507 \
7.290961081348534e-07 0.1194096117168642 7.290961706401422e-07 0.1188419501154776 7.290962366450903e-07 0.1182453094891599 7.290963054178569e-07 0.1176255789053269 \
7.290963748744814e-07 0.1170017375875525 7.29096458038731e-07 0.1162574953874909 7.290965311562548e-07 0.1156056107435251 7.29096601870241e-07 0.1149774116339468 \
7.290966612219237e-07 0.1144518657417393 7.290967665191356e-07 0.1135239342411639 7.290968123866298e-07 0.1131212254602471 7.290968993406834e-07 0.1123603821649216 \
7.290969423544638e-07 0.1119852310621949 7.290969872212111e-07 0.1115947726395539 7.29097076954706e-07 0.1108164664143028 7.290971478390573e-07 0.110204256460374 \
7.290972266925708e-07 0.109525796983828 7.290972894703463e-07 0.1089876103666232 7.290973494647019e-07 0.1084750215669379 7.290974604624741e-07 0.1075310013968523 \
7.2909754121676e-07 0.1068475792877216 7.290976536800859e-07 0.1059005796323111 7.290977048246292e-07 0.1054717782906781 7.290977878097979e-07 0.1047785948356612 \
7.290978459745031e-07 0.1042945647727652 7.290979602125029e-07 0.1033482075721767 7.290980101159701e-07 0.1029366076865433 7.290980958575694e-07 0.1022320954501846 \
7.290981448890196e-07 0.1018307629303728 7.290982274554409e-07 0.101157455862875 7.290982983877772e-07 0.1005815064560546 7.290983665381274e-07 0.1000302812267231 \
7.290984441484433e-07 0.0994053199805509 7.290985164918144e-07 0.09882546240595018 7.29098594067778e-07 0.09820656846618626 7.290986827384393e-07 0.09750287271560702 \
7.290987565532273e-07 0.09692010793638871 7.290988381442348e-07 0.09627924899616347 7.290989162827031e-07 0.09566870926115327 7.290990020324936e-07 0.09500229249765579 \
7.290990897294021e-07 0.09432453920671229 7.290991836389668e-07 0.09360304191323381 7.290992800982851e-07 0.09286661217778783 7.290993587289458e-07 0.09226977907248698 \
7.290994614525456e-07 0.09149473120661993 7.290995452801958e-07 0.09086620530027881 7.290996660323776e-07 0.08996702094116031 7.29099795302029e-07 0.08901247130467421 \
7.290999511904931e-07 0.08787237469953549 7.291001062900762e-07 0.08675000010972149 7.291002633058824e-07 0.08562614142917294 7.291004433267348e-07 0.08435280068725284 \
7.291005938476015e-07 0.08330035525696428 7.291007422216237e-07 0.08227363395463329 7.291008798388548e-07 0.08133079092382095 7.291010197585049e-07 0.08038162993974078 \
7.291011563654933e-07 0.07946425488810546 7.291012950927907e-07 0.07854214404995859 7.291014404036529e-07 0.07758663187171365 7.29101588151466e-07 0.07662571164688473 \
7.291017467483332e-07 0.07560598447141591 7.29101911000851e-07 0.07456266320243836 7.291020800179273e-07 0.07350246718885647 7.291022619069209e-07 0.07237646636762114 \
7.291024625290194e-07 0.07115268999588262 7.291026764065622e-07 0.0698691158856425 7.291029040406938e-07 0.0685263410462881 7.291031456262355e-07 0.06712722147996912 \
7.29103427215414e-07 0.06552977831071743 7.291037243695345e-07 0.06388229915275011 7.291040478026115e-07 0.06213267023812474 7.291044389620309e-07 0.0600758559534558 \
7.29104840456333e-07 0.05803293250078725 7.291052173970595e-07 0.05617754872181892 7.291055845107909e-07 0.05442503025024555 7.291059346274713e-07 0.05280240270907886 \
7.291062539331247e-07 0.05136309724710254 7.291065582574072e-07 0.05002640192327024 7.291068551633125e-07 0.04875503464657577 7.291071371636386e-07 0.04757867888787161 \
7.291074175969432e-07 0.04643900623749339 7.291076823205669e-07 0.04538777697325767 7.291079582182789e-07 0.04431704973151576 7.291082326831432e-07 0.04327654260273706 \
7.291085311024235e-07 0.04217254828989973 7.291087576184799e-07 0.04135316230013186 7.291090695313176e-07 0.04025053053625379 7.291092897861088e-07 0.03948972371590862 \
7.291095070508635e-07 0.03875470657060948 7.291097167735126e-07 0.03806113111453101 7.291100269559001e-07 0.03705828856757609 7.291102495537778e-07 0.03635538859683734 \
7.29110496919279e-07 0.03559019656168042 7.291107693256555e-07 0.03476651972027592 7.291109899582094e-07 0.03411384091885184 7.291112742384597e-07 0.03329124852897781 \
7.291115121517525e-07 0.0326183788879464 7.291117502411636e-07 0.03195887699386461 7.291119854964916e-07 0.03132132139405813 7.291122142751987e-07 0.03071728735992773 \
7.291124470059478e-07 0.03011490821398154 7.291126663089891e-07 0.02955843195412813 7.291128702520595e-07 0.02905055018162466 7.291132691617956e-07 0.02808303002558106 \
7.291134563160508e-07 0.02764052191221165 7.29113828521772e-07 0.0267814187683372 7.29114015473295e-07 0.02635997027055515 7.291143848272416e-07 0.02554620807076183 \
7.291145384804101e-07 0.02521471147941385 7.291149546945643e-07 0.02434161493068329 7.291151601823807e-07 0.02392065165079968 7.291154991903413e-07 0.02323955384462723 \
7.291156818850693e-07 0.02287916718068597 7.291161389789784e-07 0.02199597290476789 7.291162687197143e-07 0.02174967209293581 7.291167221401377e-07 0.02089828923199067 \
7.2911686451243e-07 0.0206336680476187 7.291173940791905e-07 0.01967289368906444 7.291175202861975e-07 0.01945139161001456 7.291180825206353e-07 0.01850749734048266 \
7.29118245259022e-07 0.01824627541187189 7.291188094390871e-07 0.01738327200207762 7.291189611831539e-07 0.01716165742474803 7.291196628626383e-07 0.01618760396393164 \
7.291198329517282e-07 0.01596324388168 7.291204880096042e-07 0.01513221026437959 7.291206545239163e-07 0.01492874613340729 7.291213876376757e-07 0.01406966818047924 \
7.291215209008543e-07 0.01391906482409888 7.291223725580289e-07 0.01299647369571925 7.291225105004775e-07 0.01285324185793544 7.291234505599668e-07 0.0119198170026788 \
7.291236143216039e-07 0.01176347583728811 7.291246015550385e-07 0.01085909507266535 7.291247361441145e-07 0.0107410715025141 7.291258775835447e-07 0.009819907073012045 \
7.291259858224434e-07 0.009738548299709823 7.29127309069827e-07 0.00880579379490502 7.291274418155253e-07 0.008718202093769473 7.291289643166501e-07 0.007760835273143199 \
7.29129076858719e-07 0.007690148685505111 7.291307691503061e-07 0.00669558715138598 7.291309094168914e-07 0.00662113250846694 7.291329824261937e-07 0.005629132576249021 \
7.291331749877106e-07 0.005545002188831318 7.291353851975589e-07 0.004656096148610405 7.291357919842319e-07 0.004507219767123045 7.291386137242085e-07 0.003590578528330178 \
7.291391350199587e-07 0.00344214578404881 7.291433471210094e-07 0.002447529662748036 7.291438996838773e-07 0.002340875287107731 7.291497829734169e-07 0.001359168649576994 \
7.291500322464151e-07 0.001311490127959886 7.291631823674653e-07 0.0003136950974005476 7.291632991504353e-07 0.0003112730584132499 7.589900000000112e-07 3.042397160644726e-06 \
8.027466670270133e-07 -0.0009024818035526668 8.027467394426294e-07 -0.001022682652537627 8.027471754673471e-07 -0.001858525046639076 8.027472623617301e-07 -0.002046124893065343 \
8.027476170650433e-07 -0.00288168582347465 8.027477166116442e-07 -0.003135075204051477 8.027479768813486e-07 -0.003828199033013717 8.027481172037501e-07 -0.004216406518003108 \
8.027483446898323e-07 -0.004856871791621592 8.027484818972713e-07 -0.005239031028659006 8.0274886679612e-07 -0.006187559915121 8.027489988933068e-07 -0.006423332025500122 \
8.027496873363354e-07 -0.005917035979538006 8.027498442650688e-07 -0.005202654566481615 8.027499719142313e-07 -0.004414133290428114 8.027500994560215e-07 -0.003433350487145549 \
8.027502171302334e-07 -0.002355902309038119 8.027503162699201e-07 -0.001320627313728655 8.027504216526298e-07 -9.507383675133965e-05 8.02750535559933e-07 0.001369964538583592 \
8.027506666153286e-07 0.003229572948258866 8.027507919785475e-07 0.005172303930030842 8.027509838204114e-07 0.008432154569684791 8.027511274902044e-07 0.01107975669588844 \
8.027512854720173e-07 0.01417105828876112 8.027514340716643e-07 0.01723098336859398 8.02751587122593e-07 0.02051714008521248 8.027517461875692e-07 0.02405720796424875 \
8.027518992577779e-07 0.02756764950178633 8.027520476048421e-07 0.03105219347129199 8.027521967112841e-07 0.03462388853332505 8.027523512757131e-07 0.03838854885099419 \
8.027525119616768e-07 0.04235886888523473 8.027526766408631e-07 0.04647718198980624 8.027528531638066e-07 0.05093664320808645 8.027530321756059e-07 0.05549818742091989 \
8.027532229484479e-07 0.0603932190016783 8.027534277958001e-07 0.06567927942044927 8.02753648293053e-07 0.07139554989571946 8.027538812110213e-07 0.07745499876455469 \
8.027541304587992e-07 0.08395499695136356 8.027544033803265e-07 0.09108394918256098 8.027547001733835e-07 0.09884095133633181 8.027550276098956e-07 0.1073964775374675 \
8.027553974236946e-07 0.1170487607486894 8.027557923699754e-07 0.1273407304921971 8.027562504585283e-07 0.1392499850125259 8.02756782558388e-07 0.1530377249371455 \
8.027574081103967e-07 0.169180864038255 8.027580941024627e-07 0.1867931863309214 8.027588969458781e-07 0.2072766958045763 8.027597962582095e-07 0.2300508264895909 \
8.027606966983226e-07 0.2526618731709107 8.027614985898552e-07 0.2726215666318766 8.027621940969961e-07 0.2897857674353052 8.02762826931282e-07 0.3052728323588638 \
8.027634223397734e-07 0.3197161646377594 8.027639693828152e-07 0.3328722959176427 8.027645031431616e-07 0.3455929446372428 8.027650223825863e-07 0.3578476146335662 \
8.027655297740486e-07 0.3697097539883151 8.02766033395218e-07 0.3813674725871593 8.027665451381145e-07 0.3930934709428262 8.027670522991229e-07 0.404595334768291 \
8.027675825951367e-07 0.4164962117964878 8.027680687086257e-07 0.4272847049163567 8.027685468169473e-07 0.437781779057129 8.027689862490711e-07 0.4473362978389137 \
8.027691094085348e-07 0.4500002106608159 8.027693557274626e-07 0.4553046876287923 8.027696989994585e-07 0.4626558934952216 8.027700104364589e-07 0.4692815017887791 \
8.027702611477242e-07 0.4745855323881177 8.027705319768676e-07 0.480281321066213 8.027708684587769e-07 0.4873122872019196 8.027712244673881e-07 0.4946959640027882 \
8.027715417375557e-07 0.5012322602315481 8.027717806181048e-07 0.506122906570856 8.027720216462867e-07 0.5110269393752048 8.027722735779908e-07 0.5161276795544476 \
8.027725137318346e-07 0.5209621749612534 8.027727364832964e-07 0.5254248476203834 8.027729250409435e-07 0.5291850880529715 8.027731397909867e-07 0.5334523706207774 \
8.027733543393783e-07 0.5376948565446859 8.027736131036701e-07 0.5427871977552768 8.027738639312417e-07 0.5477009885064807 8.027741193501039e-07 0.5526782776843104 \
8.027744703926295e-07 0.5594898819265107 8.027747350009544e-07 0.5645984056527484 8.027750014175097e-07 0.569709962982798 8.027752619318197e-07 0.5746801970751495 \
8.027755290218824e-07 0.5797469183389945 8.027757721599624e-07 0.5843213438768613 8.02776027852189e-07 0.5890994944692448 8.027762556711592e-07 0.5933243819692556 \
8.027764932159792e-07 0.5976999800355528 8.027767046064655e-07 0.6015679915939678 8.027769167472246e-07 0.6054277082074113 8.027771059366022e-07 0.6088479815213901 \
8.027772370949197e-07 0.6112112531841202 8.02777369391478e-07 0.6135871094428261 8.02777554614204e-07 0.6169015645304802 8.027777166365907e-07 0.6197943209800671 \
8.027778750557552e-07 0.6226100751126036 8.027780091676215e-07 0.6249846001944386 8.027781814887287e-07 0.6280247049765127 8.027783104275314e-07 0.6302937061188456 \
8.027784308050438e-07 0.6324061607157294 8.027785713339148e-07 0.634864734791624 8.027787644194073e-07 0.6382321981637986 8.027789142301853e-07 0.6408363654380513 \
8.027790815377795e-07 0.6437327988167145 8.027792625920029e-07 0.6468572757970242 8.027794659184326e-07 0.6503523798695617 8.027796487715879e-07 0.6534819287355287 \
8.027798193958343e-07 0.6563879501053153 8.027799968600741e-07 0.6594029650344411 8.027801628390247e-07 0.6622113135173925 8.027803200758144e-07 0.6648594636266301 \
8.02780460561866e-07 0.6672075432495704 8.027806042919945e-07 0.6695987751186935 8.027807373389854e-07 0.6718055529208897 8.02780879311128e-07 0.6741523780906628 \
8.027809993716612e-07 0.6761293215200647 8.027811443097483e-07 0.6785098354674278 8.027812603067976e-07 0.6804095298668216 8.027813798866854e-07 0.6823647593763783 \
8.027814788466604e-07 0.68397755359623 8.027815973550785e-07 0.6859039329668146 8.027816843993602e-07 0.6873150904607619 8.027818064101794e-07 0.6892866586554622 \
8.027819053327907e-07 0.6908817703737582 8.027819972281661e-07 0.6923536807698466 8.027820971967053e-07 0.6939486118486815 8.02782195442366e-07 0.6955126686751646 \
8.027822871561283e-07 0.6969676095571918 8.027823912890696e-07 0.698613189139943 8.02782527015812e-07 0.7007470979739818 8.027826816242742e-07 0.7031613517373301 \
8.027828167319862e-07 0.7052558942641604 8.027829630685318e-07 0.7075085519458914 8.027830915360734e-07 0.7094732734147607 8.02783215720207e-07 0.7113609898537658 \
8.027833256245073e-07 0.7130225953369277 8.027834422075758e-07 0.7147759898693785 8.027835423854066e-07 0.7162749667021007 8.027836794742156e-07 0.7183149847558421 \
8.027837994632423e-07 0.7200901405411056 8.027839185766902e-07 0.7218426783097279 8.02784045072077e-07 0.723693513465353 8.02784170939449e-07 0.7255245570057045 \
8.027842935604676e-07 0.7272980597885179 8.027844211779915e-07 0.7291334326655684 8.027845514267828e-07 0.7309957624152177 8.02784673019733e-07 0.73272442801297 \
8.027848117884253e-07 0.7346853525547948 8.02784912196869e-07 0.7360963845229137 8.027850155842573e-07 0.7375412410987998 8.027851092446996e-07 0.7388443755773992 \
8.027852208662966e-07 0.7403895158541485 8.027853073348996e-07 0.7415798421827293 8.027854081980103e-07 0.7429609798983192 8.027855402947323e-07 0.7447573558536402 \
8.027856494960337e-07 0.7462323422761349 8.027857540276638e-07 0.747635567415085 8.027858776741446e-07 0.7492836897664436 8.027860263705797e-07 0.7512497161812216 \
8.027861482512389e-07 0.7528480713857697 8.02786261855803e-07 0.7543274008692354 8.027864023754882e-07 0.7561429069656862 8.027865435649301e-07 0.7579511824827749 \
8.027866613111062e-07 0.7594470562859095 8.027867900007656e-07 0.7610693809796742 8.027869325554126e-07 0.7628512182523866 8.027870484119641e-07 0.7642872416835913 \
8.027871941752296e-07 0.7660789429779771 8.02787316007677e-07 0.7675637574673733 8.02787434476374e-07 0.7689965471136999 8.02787557264006e-07 0.7704700089613156 \
8.027876834168885e-07 0.7719718272910862 8.027877937859393e-07 0.7732757954107932 8.02787919217035e-07 0.7747465774777432 8.027880246987464e-07 0.775974259539018 \
8.027881578651757e-07 0.7775122819577122 8.027882805466309e-07 0.7789173428708996 8.027884153096743e-07 0.7804473432620218 8.027885259809625e-07 0.7816923373676121 \
8.027886353025911e-07 0.7829118427552927 8.027887704350255e-07 0.7844048889494442 8.027889212140504e-07 0.7860523747618094 8.02789061582958e-07 0.7875692293014268 \
8.027891812944828e-07 0.7888502570533434 8.027893195488234e-07 0.7903153082715967 8.027894429191593e-07 0.7916096503654788 8.027895880177844e-07 0.7931164937536124 \
8.027897277580435e-07 0.7945521172774316 8.027898549394667e-07 0.7958455533278409 8.027899739792201e-07 0.7970449251022731 8.027900863374111e-07 0.7981670522831598 \
8.027901905661905e-07 0.79919939674296 8.027902859050021e-07 0.8001364844871954 8.027904221931121e-07 0.8014634245741865 8.027905390856556e-07 0.8025894467082511 \
8.02790658725145e-07 0.8037305025474466 8.027907806067165e-07 0.8048811831579785 8.027909029850537e-07 0.8060245537852575 8.027910310137332e-07 0.8072081965553952 \
8.027911556585317e-07 0.8083483262222385 8.027912861572795e-07 0.8095291977395493 8.027914126177069e-07 0.8106611567088965 8.027915397436747e-07 0.8117869190804841 \
8.027916448611512e-07 0.8127087429624065 8.027917501113405e-07 0.8136235164943317 8.027918412515906e-07 0.8144090748259969 8.027919646696249e-07 0.8154632009865571 \
8.027920517482738e-07 0.8162003374872545 8.02792151070959e-07 0.8170344894488412 8.027922959927027e-07 0.8182390501293432 8.027924322612063e-07 0.8193582434421302 \
8.027925417234846e-07 0.8202477434185359 8.027926878435863e-07 0.8214214001843773 8.027928392021979e-07 0.8226208465286928 8.027929650061201e-07 0.8236052915965452 \
8.027931094167793e-07 0.824721541823094 8.027932340177295e-07 0.8256729463037898 8.027933847297913e-07 0.8268094083523665 8.027935201010499e-07 0.8278169867326588 \
8.02793645303979e-07 0.8287379047458127 8.027937629733617e-07 0.829593908450195 8.027939088013387e-07 0.8306418458276996 8.027940752973201e-07 0.8318207857986918 \
8.027942061544082e-07 0.8327345044534114 8.027943796038485e-07 0.833928356718921 8.027945477223224e-07 0.8350667646575466 8.027947175961246e-07 0.8361988603660855 \
8.027948984507536e-07 0.8373843006762304 8.027950416331349e-07 0.8383085120571983 8.027951557464787e-07 0.8390361588138326 8.027952858124697e-07 0.8398559950134801 \
8.027953876877057e-07 0.8404909448220066 8.027955045669982e-07 0.8412116130393378 8.027956416789287e-07 0.8420465258793415 8.027958395595721e-07 0.843231707656198 \
8.027960313457652e-07 0.8443585547012582 8.027962407088286e-07 0.8455646258450146 8.027964228224064e-07 0.846593677725298 8.027966199171782e-07 0.8476867969181797 \
8.02796793185875e-07 0.8486305714188691 8.02796976264561e-07 0.8496104335327738 8.027971474015872e-07 0.8505103231661706 8.027973220804384e-07 0.8514128411730317 \
8.02797497318728e-07 0.8523022053693007 8.027976734583674e-07 0.8531802340241421 8.027978638096238e-07 0.8541115036082744 8.027980543867704e-07 0.855025905954957 \
8.027982548181928e-07 0.8559685891497206 8.027984474106693e-07 0.8568563992305701 8.027986582738063e-07 0.8578086227668252 8.027988861871822e-07 0.8588150784816577 \
8.027991522177188e-07 0.8599606428795262 8.027994507388009e-07 0.8612090806949765 8.027997266924815e-07 0.8623286542354505 8.028000109545961e-07 0.8634483918036945 \
8.028002851030457e-07 0.8644969441068078 8.02800557392313e-07 0.8655088801415273 8.028008275580887e-07 0.8664846790737442 8.028010847361862e-07 0.8673881555543895 \
8.028013572993529e-07 0.868319368003445 8.02801633304697e-07 0.8692355072818493 8.028019034186287e-07 0.870106770567397 8.028022032450018e-07 0.8710447971670072 \
8.028025742222908e-07 0.8721640818024149 8.028028691540118e-07 0.8730224021943973 8.028031234323761e-07 0.873740732376842 8.028034216772072e-07 0.8745584461000401 \
8.028036952852192e-07 0.8752856917963749 8.028039314154438e-07 0.8758961959341748 8.028041717609792e-07 0.8765017794770257 8.028043940971676e-07 0.8770481951318053 \
8.028045881024504e-07 0.8775144010549708 8.028049178237936e-07 0.8782846129827527 8.028050729968194e-07 0.8786376896881318 8.028053907524075e-07 0.8793424631377607 \
8.028055696169827e-07 0.8797286397841958 8.028059120784622e-07 0.8804474051285093 8.028060962178168e-07 0.880822800830328 8.028065711184753e-07 0.881756283451624 \
8.028067385131538e-07 0.8820737784441692 8.028072043462e-07 0.8829272622221894 8.028073851704931e-07 0.8832470363605239 8.028078792047928e-07 0.8840891816604841 \
8.028080205486687e-07 0.8843218944112644 8.028086269405856e-07 0.8852805359894154 8.028087790117662e-07 0.8855111592597558 8.028094256914359e-07 0.8864506941541785 \
8.028095539876422e-07 0.8866295550025313 8.028102021648148e-07 0.8874976172723908 8.028103319236755e-07 0.8876644392549727 8.028111001444974e-07 0.8886037370453904 \
8.02811229881009e-07 0.8887539063021698 8.028120833066544e-07 0.8896836309705964 8.028122265650877e-07 0.8898301468060963 8.02813212785821e-07 0.890764641901611 \
8.02813434267227e-07 0.8909571971396437 8.028145773086277e-07 0.8918770673440963 8.028147072981167e-07 0.8919774876506176 8.028160589233886e-07 0.8929731820841386 \
8.028162092835701e-07 0.89307657739048 8.028176899161688e-07 0.8939986636922405 8.028179288179339e-07 0.8941315911431026 8.028196933116327e-07 0.894999985510941 \
8.02820000994978e-07 0.8951330875684044 8.028225222661808e-07 0.8960612226716312 8.028229593174219e-07 0.8961978289811912 8.028268627296431e-07 0.8971619289239613 \
8.028271095114498e-07 0.8972094058147089 8.028346860012845e-07 0.8981998139535015 8.028348019130313e-07 0.8982099955090975 8.028539004457352e-07 0.8992062631372056 \
8.028542978885091e-07 0.8992194728667773 8.030047133235902e-07 0.9002121614362558 8.03004979381947e-07 0.9002436812458944 8.030102475320152e-07 0.8993470931706574 \
8.030104539029323e-07 0.899191170936528 8.030119320157425e-07 0.8982046351054961 8.030121124663984e-07 0.8981003355419954 8.030143349480612e-07 0.8971299612768925 \
8.030145410405756e-07 0.897079983173831 8.030249493066813e-07 0.8980580240048047 8.03025087164257e-07 0.8980839755683444 8.030318845132984e-07 0.8990685088718567 \
8.030320700847658e-07 0.8990874390200084 8.035282992589679e-07 0.9000706848616691 8.035283590548139e-07 0.9000975977971888 8.035296126054321e-07 0.9010828413531861 \
8.035297182980354e-07 0.9012097231395001 8.035303764287524e-07 0.9021613947651476 8.035305136110212e-07 0.9023918767045529 8.035310366376408e-07 0.9033649777562528 \
8.035310995012334e-07 0.9034908765919824 8.035315720967825e-07 0.904476514442582 8.035316234105955e-07 0.9045863669199017 8.035320893739313e-07 0.9055619780118375 \
8.035321215783922e-07 0.9056252631670594 8.035328386771295e-07 0.9066212416280413 8.035329231134018e-07 0.9066528951765993 8.035335231797813e-07 0.9059679814895146 \
8.035336430373927e-07 0.9055903401525059 8.03533774200172e-07 0.9050640446667092 8.035339090199249e-07 0.9043926011431642 8.035340571549842e-07 0.9034897747335404 \
8.035341947143354e-07 0.902493211317788 8.035343349260954e-07 0.9013135799985507 8.035344335882046e-07 0.9003872218501816 8.03534519272014e-07 0.8995148096066522 \
8.035346018362133e-07 0.8986166894493001 8.035347166188419e-07 0.8972773101170661 8.03534797717086e-07 0.8962642459447687 8.03534877134364e-07 0.8952218112132616 \
8.035349825888917e-07 0.8937633947192651 8.035351052301954e-07 0.8919606744930825 8.035352049542743e-07 0.890414036797163 8.035353751486853e-07 0.8876203405523397 \
8.035355213337766e-07 0.8850727273800474 8.035356895519253e-07 0.8819879035815887 8.035358617130214e-07 0.8786780617039783 8.035360460991142e-07 0.8749807502679057 \
8.035362306654577e-07 0.8711418063496947 8.035364149129437e-07 0.8671917613865908 8.035366002486072e-07 0.8631174608718694 8.035367746363354e-07 0.8592060069639053 \
8.035369573402717e-07 0.8550405244181323 8.035371326873658e-07 0.8509893565349284 8.035373150168772e-07 0.8467313026054767 8.035375053303062e-07 0.8422468264612591 \
8.035376756604352e-07 0.838204894125699 8.035378421840737e-07 0.8342320488410089 8.035380047549371e-07 0.830337741667393 8.035381546161599e-07 0.8267359097041467 \
8.03538305792179e-07 0.8230937075736249 8.035384949376529e-07 0.8185270080344306 8.035386406557074e-07 0.8150026134285653 8.035388156466743e-07 0.8107652770601156 \
8.035389641182174e-07 0.807166938184282 8.035391360056827e-07 0.8029987283123258 8.035393050739222e-07 0.7988973224349885 8.035394692526315e-07 0.7949140139776875 \
8.035396285801686e-07 0.7910485911592836 8.035397890297762e-07 0.7871568543472617 8.035399908491573e-07 0.7822630953020117 8.035401392968916e-07 0.7786646206504594 \
8.03540293464276e-07 0.77492821376164 8.035404305476362e-07 0.7716074476660475 8.035405399330824e-07 0.7689587163513494 8.035406458665383e-07 0.7663946531324515 \
8.035407728808854e-07 0.7633217481666642 8.035408872438541e-07 0.7605561828888391 8.035409900916761e-07 0.7580702160470256 8.035411116819926e-07 0.7551325442760125 \
8.035412224592672e-07 0.7524575925939972 8.035413393080924e-07 0.7496376180588871 8.035414500928178e-07 0.7469652567786068 8.035415684589191e-07 0.7441116745915923 \
8.035416932860144e-07 0.7411038668912771 8.035418458478099e-07 0.7374292753756717 8.035419797447979e-07 0.7342062928952946 8.035421007762374e-07 0.7312947572377408 \
8.035422649737523e-07 0.7273475399259534 8.035424423346987e-07 0.7230877912371642 8.035426245451075e-07 0.7187161681757385 8.035428055423725e-07 0.7143786395952922 \
8.035429862063157e-07 0.7100537072471783 8.035431763578828e-07 0.7055071781827296 8.035433641177768e-07 0.7010230964996226 8.035435646508815e-07 0.696237807975249 \
8.035437733363431e-07 0.6912646166759551 8.035439809799077e-07 0.6863227581165517 8.03544208547776e-07 0.6809140411171237 8.035444008226102e-07 0.6763521085712711 \
8.035446380878582e-07 0.6707310800019505 8.035448313661221e-07 0.6661595641347996 8.035450640988686e-07 0.6606646229758047 8.035452696563363e-07 0.6558174602470968 \
8.035455020097575e-07 0.6503484594495911 8.035456970117276e-07 0.6457674053103037 8.035459002403361e-07 0.6410004262200759 8.035460800928814e-07 0.6367906205544323 \
8.035462591993118e-07 0.6326052789263827 8.035464225765257e-07 0.628795088826817 8.035465946259304e-07 0.6247880828503264 8.035467581187693e-07 0.6209892715878097 \
8.035469339085876e-07 0.6169100951581823 8.035471158475732e-07 0.6126978430086294 8.035473043313055e-07 0.6083422542008314 8.035475107637273e-07 0.6035858951323969 \
8.035476900783897e-07 0.5994633272559844 8.035478872572566e-07 0.5949432360761027 8.035480963453974e-07 0.5901646611556908 8.035483020946604e-07 0.5854760387944159 \
8.035485426053479e-07 0.5800160304866983 8.035487157334496e-07 0.5760958285528379 8.035488806274518e-07 0.5723746772837877 8.035490614880267e-07 0.5683014035092815 \
8.035492187741233e-07 0.5647722902613652 8.035493877569178e-07 0.5609879409349005 8.035495678633789e-07 0.5569709657351898 8.035497208465059e-07 0.5535669615732179 \
8.035498525609507e-07 0.5506462283231492 8.035499999486508e-07 0.5473865746199473 8.03550087374242e-07 0.5454560063082221 8.035501722454816e-07 0.5435860258811447 \
8.035502708746939e-07 0.5414171943998213 8.035503429668553e-07 0.5398340751058975 8.035504400578744e-07 0.5377039800781129 8.035505256482576e-07 0.5358302678688993 \
8.03550590729134e-07 0.5344081412607664 8.035507143295019e-07 0.5317121235594142 8.035508087537724e-07 0.52965475734789 8.035509062769941e-07 0.5275349985745696 \
8.035510791376451e-07 0.5237893654184622 8.035512141331662e-07 0.5208709659121862 8.035513683166277e-07 0.5175498113398643 8.03551542781984e-07 0.5138002600288881 \
8.035516945879704e-07 0.510550000123414 8.03551840818953e-07 0.5074290310664136 8.03551984717826e-07 0.5043644611166801 8.035521277396695e-07 0.5013276181140283 \
8.035522233495175e-07 0.499301733014788 8.035523177934733e-07 0.4973032961550828 8.03552438849414e-07 0.4947494705229025 8.035525337277098e-07 0.4927525559781179 \
8.035526495585533e-07 0.4903172469328811 8.035527368224019e-07 0.4884854516151125 8.035528192528481e-07 0.4867593351188191 8.035529146608015e-07 0.484765406725184 \
8.035530153710815e-07 0.4826639978995959 8.035531122314731e-07 0.4806459052877932 8.035532509612246e-07 0.4777646955734051 8.035533866660861e-07 0.4749532752442271 \
8.035535871508094e-07 0.4708139964547478 8.035538024649621e-07 0.4663911383470885 8.03553984040267e-07 0.462674698484628 8.035541830122363e-07 0.4586189944293299 \
8.035543535777573e-07 0.455154096457448 8.035545279314447e-07 0.4516251957269069 8.035546968646987e-07 0.4482170126441485 8.035548694618603e-07 0.4447467276163349 \
8.035550520681902e-07 0.4410867902598327 8.035552406170554e-07 0.4373240875354826 8.035554340845929e-07 0.4334777823509549 8.035556424052317e-07 0.4293535036700135 \
8.035558567504624e-07 0.4251286740881063 8.035560824557922e-07 0.4207018662297695 8.035563089991604e-07 0.4162771402745992 8.035565711759108e-07 0.4111844468197049 \
8.035568202097347e-07 0.4063709766754009 8.035571213084326e-07 0.4005865607947761 8.035574107292502e-07 0.3950673729298416 8.03557718243529e-07 0.3892455819062323 \
8.035580404399244e-07 0.3831936848847286 8.035583681704071e-07 0.3770882112794804 8.035587006001628e-07 0.3709500980558715 8.035590303291706e-07 0.3649083177186754 \
8.035593515587582e-07 0.3590729273462687 8.03559682375082e-07 0.3531219177045733 8.035600247306453e-07 0.3470224718704957 8.035603243716774e-07 0.3417374346434491 \
8.035606541592421e-07 0.3359723367088904 8.035609810531851e-07 0.3303128110141857 8.03561319032532e-07 0.3245206193888226 8.035616280036957e-07 0.3192755432624759 \
8.035619528016686e-07 0.31382336954194 8.035622684318663e-07 0.3085864885517507 8.035625734190322e-07 0.3035810258414895 8.035628287576776e-07 0.2994330834535801 \
8.035630936208339e-07 0.295170851203172 8.035633807035186e-07 0.2905978071194348 8.035636036732975e-07 0.2870801635277143 8.035638032125665e-07 0.2839591363066187 \
8.035640128685797e-07 0.2807045410859125 8.035641931251209e-07 0.2779290029372279 8.035643554698416e-07 0.2754463208250681 8.035645059048155e-07 0.2731629026725527 \
8.035646569101241e-07 0.2708866524077067 8.035648538007149e-07 0.2679392949564011 8.035649849454786e-07 0.2659970646012914 8.035651096820175e-07 0.2641561221543183 \
8.035652612740598e-07 0.2619266655689588 8.035653572422309e-07 0.2605306204207966 8.035654537935995e-07 0.2591282589302421 8.035655784133887e-07 0.2573209601776467 \
8.035657209899234e-07 0.255257422470362 8.035658799234579e-07 0.25296979123958 8.035660125895253e-07 0.251062957019046 8.035661961582939e-07 0.2484301322588876 \
8.035663773934596e-07 0.2458327969660818 8.035665889075646e-07 0.2428051031600066 8.035667914973991e-07 0.2399069804317323 8.035669580538466e-07 0.2375282895552967 \
8.03567168273059e-07 0.2345337828133105 8.03567341690945e-07 0.2320692345528927 8.035675705336728e-07 0.2288260787734411 8.035677911684244e-07 0.2257162440502939 \
8.035679668301377e-07 0.2232503232699662 8.035681472906433e-07 0.2207258962977968 8.035683180470208e-07 0.2183528725291195 8.035684982432871e-07 0.2158619697278009 \
8.035686649739047e-07 0.2135675266585953 8.035688140953261e-07 0.2115251542210239 8.035689699053442e-07 0.2094125291275523 8.035691050857695e-07 0.2075875692769576 \
8.035692551671966e-07 0.2055694209972212 8.035693876128229e-07 0.2037957203154137 8.035695281573595e-07 0.2019220745191926 8.035696452261238e-07 0.2003748851744883 \
8.035697749337302e-07 0.1986681706274326 8.035698969911991e-07 0.1970700654731777 8.035700195346348e-07 0.1954731161836187 8.035701375539584e-07 0.1939418157697267 \
8.035702725767313e-07 0.1921981789937757 8.035704172011819e-07 0.1903420634523806 8.035705455516812e-07 0.1887049708672087 8.03570669186156e-07 0.1871351133418249 \
8.035707667362788e-07 0.1859021016257166 8.035708818092082e-07 0.1844539912642748 8.035709755078878e-07 0.1832809848801438 8.035710742920116e-07 0.1820493959460708 \
8.035711972265529e-07 0.1805230483556907 8.035712929805559e-07 0.1793400249325384 8.035714220681073e-07 0.177753298391591 8.035715245334772e-07 0.1764993061988986 \
8.035716227869744e-07 0.1753029542432101 8.035717428741866e-07 0.1738483570896001 8.035718454234049e-07 0.1726127298531683 8.035719558810641e-07 0.1712877101305652 \
8.035720843709282e-07 0.1697552709290656 8.035721758557693e-07 0.1686698090598139 8.03572280340358e-07 0.1674358120019214 8.035723552770941e-07 0.1665544493622226 \
8.03572444845591e-07 0.1655049734124585 8.035724954106002e-07 0.164914347906921 8.035725453889763e-07 0.1643318187475747 8.035726103580609e-07 0.163576534137217 \
8.035726458720287e-07 0.1631646263336159 8.035727180712023e-07 0.162329174921529 8.035727852002974e-07 0.1615546732967998 8.035728444300317e-07 0.160873195114598 \
8.035728881756305e-07 0.1603710314414745 8.035729358224586e-07 0.1598254649913795 8.03573006202993e-07 0.1590230739426561 8.03573088541159e-07 0.1580883269013631 \
8.035731667127594e-07 0.1572048664554128 8.035732487657084e-07 0.1562816770844126 8.035733414693307e-07 0.1552436243401225 8.035734642494945e-07 0.153877370231325 \
8.035735633955882e-07 0.1527810927807017 8.035736648959354e-07 0.1516651170047695 8.035737661711264e-07 0.1505582666538253 8.035738626629107e-07 0.1495093242781697 \
8.035739620809454e-07 0.1484346886615803 8.03574046381569e-07 0.1475281828465028 8.035741393202594e-07 0.1465342051547719 8.035742219212e-07 0.1456551508734999 \
8.03574330687285e-07 0.1445034822456445 8.035744363302651e-07 0.1433917535370727 8.035745179898545e-07 0.1425365900703354 8.03574611735024e-07 0.1415598856352903 \
8.035747053029709e-07 0.1405903867550886 8.035747881874616e-07 0.139735765814107 8.035748763466362e-07 0.1388313836440244 8.035749561327221e-07 0.1380170907865772 \
8.035750497281216e-07 0.1370669869522621 8.035751396606458e-07 0.1361590166429519 8.035752102110423e-07 0.1354501541392388 8.035752799712188e-07 0.1347521119166949 \
8.035753941201259e-07 0.1336164586193709 8.035754760987401e-07 0.1328058651355588 8.035755637040425e-07 0.1319440719770354 8.035756632052385e-07 0.1309710196939938 \
8.035757723852409e-07 0.1299110174488692 8.03575874550573e-07 0.1289256009328031 8.035759820107788e-07 0.1278959836800649 8.035761020450569e-07 0.1267549558890445 \
8.035761962530915e-07 0.1258657925752028 8.035763272321949e-07 0.1246390638240933 8.035764266598964e-07 0.1237164070883829 8.035765357815822e-07 0.1227104370444639 \
8.035766446347502e-07 0.1217138859540913 8.035767369441536e-07 0.120874257454373 8.035768497844843e-07 0.1198547128626846 8.035769467965243e-07 0.118986084968971 \
8.035770510628723e-07 0.1180628196869088 8.035771600298026e-07 0.1171053395831002 8.035772595693683e-07 0.1162371554254778 8.035773765620782e-07 0.1152245300989246 \
8.035774636628686e-07 0.1144761644999183 8.0357757295452e-07 0.1135478691973115 8.035776544795827e-07 0.1128618460838699 8.035777542545759e-07 0.1120273350449922 \
8.035778716797259e-07 0.1110526766231405 8.035779734648438e-07 0.1102143708571793 8.035780612037922e-07 0.1094962336869811 8.035781420032999e-07 0.1088432886892514 \
8.035782289543191e-07 0.1081456845520918 8.035783097409447e-07 0.1075007757815706 8.035783999475114e-07 0.1067842832273628 8.03578490898266e-07 0.1060655611559195 \
8.035785795687901e-07 0.1053685613006139 8.035786785836106e-07 0.1045946508745568 8.035787722897869e-07 0.1038723470842792 8.035788661490627e-07 0.1031520741219857 \
8.035789669765109e-07 0.1023817709659086 8.035790716074088e-07 0.1015861061604995 8.03579195570165e-07 0.1006484085638475 8.035792929694782e-07 0.09991551135558702 \
8.035794132274253e-07 0.09901872452754552 8.035795240953005e-07 0.09819831936474602 8.035796285683363e-07 0.09742874659471555 8.035797458050451e-07 0.09656937225591002 \
8.035798475993662e-07 0.09582695326576983 8.035799455749167e-07 0.09511577589263259 8.035800860794065e-07 0.09410164141823299 8.035801911572026e-07 0.09334832721827611 \
8.035802897700187e-07 0.09264549593674179 8.035803824848273e-07 0.09198739948435641 8.035804686832123e-07 0.09137785861853052 8.035805625961876e-07 0.09071637432184691 \
8.035806596969337e-07 0.09003559055802626 8.035807691179881e-07 0.08927317549644689 8.035808701015371e-07 0.08857281843916648 8.035809637594832e-07 0.08792605868920525 \
8.035810379341552e-07 0.08741581771673042 8.03581175834007e-07 0.08647193599618339 8.035812481910108e-07 0.08597917321277694 8.035813835122141e-07 0.08506274029062395 \
8.035814694238194e-07 0.08448410751389913 8.03581614152054e-07 0.08351486081643937 8.035817103826189e-07 0.0828744112740944 8.035817982183981e-07 0.08229260392026354 \
8.035819140173062e-07 0.08152964121883956 8.035820291457576e-07 0.08077575264951149 8.035821429121899e-07 0.08003553900012179 8.035822831696827e-07 0.0791300282244784 \
8.035824245457162e-07 0.07822490276368012 8.035825741817577e-07 0.07727536491519127 8.035827186706131e-07 0.07636690312463701 8.035828698447241e-07 0.07542565384097814 \
8.035830192155436e-07 0.07450459906593411 8.03583168562251e-07 0.0735926433331697 8.035833285177668e-07 0.07262574717347114 8.035834846646777e-07 0.07169171823582712 \
8.035836591531124e-07 0.07065947636250877 8.035838288622191e-07 0.0696671357044583 8.035840140413029e-07 0.0685979885997255 8.035842107623799e-07 0.06747763456279594 \
8.035844212801997e-07 0.06629631776014881 8.03584643312255e-07 0.06507007089066431 8.035848735242763e-07 0.0638195278444372 8.035851160353819e-07 0.06252626147401 \
8.035853766894672e-07 0.06116236403900636 8.035856565885314e-07 0.05972739422233359 8.035859501722554e-07 0.05825544847408989 8.035862651082392e-07 0.05671370145268265 \
8.035866079141644e-07 0.05507846134953124 8.035869573807585e-07 0.0534565727116736 8.035873662849151e-07 0.05161746230842366 8.035877129499425e-07 0.05010669351290297 \
8.035881003649954e-07 0.04846839895323611 8.035884445827877e-07 0.04705645202362623 8.035887680090468e-07 0.04576625679949029 8.035890730548091e-07 0.04458093278443617 \
8.035893659168059e-07 0.04347099288378908 8.035896500577229e-07 0.04242242262004604 8.03589926078015e-07 0.04142902112907627 8.03590192930566e-07 0.04049015932812138 \
8.035904618227892e-07 0.03956531631184226 8.035907378832112e-07 0.03863769040165695 8.035910254787821e-07 0.03769451689421055 8.035912650444082e-07 0.03692662498323904 \
8.03591554211835e-07 0.03602084344675294 8.035917700034379e-07 0.03535960341037672 8.035919577204763e-07 0.03479599077274986 8.035921558495825e-07 0.03421285035004928 \
8.03592518724446e-07 0.03317032497347058 8.035927768662759e-07 0.03244834222605905 8.035930865791899e-07 0.0316030971185694 8.035933520493286e-07 0.03089664771451467 \
8.035936201684081e-07 0.03019941363307669 8.035938990424389e-07 0.02949128999862272 8.035941452288756e-07 0.02888043298519722 8.035943758602853e-07 0.02832033800396738 \
8.035946141502041e-07 0.02775711540944564 8.035948491575684e-07 0.02721270742060762 8.03595076940031e-07 0.02669509678424227 8.035954855523029e-07 0.02579039168486155 \
8.03595661854632e-07 0.02540904040268441 8.03596016332316e-07 0.02465798827491217 8.035962002032882e-07 0.02427641469830137 8.035965351520103e-07 0.02359448510613503 \
8.035966990607275e-07 0.02326678168937357 8.035970913313035e-07 0.02249905491676728 8.035972473220689e-07 0.02220010404946675 8.035976789254263e-07 0.02138321689778962 \
8.035978163148065e-07 0.0211255367654138 8.03598333123589e-07 0.02017559010600388 8.035984586594828e-07 0.01995091418019728 8.035989159010076e-07 0.01915998482559782 \
8.035990750469891e-07 0.01889493739859509 8.035996822854669e-07 0.01793263500095189 8.03599816822955e-07 0.01772934138481063 8.036004800869477e-07 0.01678091027541291 \
8.036006734103788e-07 0.01651856846389665 8.036013410670396e-07 0.01565087920017967 8.03601502655887e-07 0.01544858341705342 8.036022578911399e-07 0.01454101846553843 \
8.036024074521069e-07 0.01436800730673201 8.036032977899311e-07 0.01338293844200974 8.036033964478168e-07 0.01327873262558703 8.03604353121314e-07 0.01230993787860994 \
8.036044742310216e-07 0.01219243157195396 8.036054657237297e-07 0.01126376273051215 8.036056292524602e-07 0.01111855113153209 8.036067591745355e-07 0.01018247077230436 \
8.036068716217739e-07 0.01009565848301377 8.036082494452621e-07 0.009103273453806031 8.036083883905334e-07 0.009009747578659758 8.036099427888683e-07 0.008018073335410726 \
8.0361005485534e-07 0.00794673960805117 8.036116998381698e-07 0.006958154532207958 8.036118070906645e-07 0.006899512253112593 8.036137515841525e-07 0.005937533026687714 \
8.036139584821097e-07 0.005843834961138424 8.036162973698525e-07 0.00487227039639981 8.036167213562637e-07 0.004712306502041247 8.036194935894604e-07 0.003780857497341114 \
8.036199418985521e-07 0.003647790772321777 8.03623582397237e-07 0.00272553831825111 8.036240790530716e-07 0.002619503085887757 8.036298301734959e-07 0.001650572925599863 \
8.036301169553824e-07 0.001609446887446839 8.036354719440668e-07 0.0006353228983793809 8.036356773006917e-07 0.0005920420449145349 8.062827120745073e-07 -0.0002718533828215428 \
8.062828679501106e-07 -0.0004579010352009555 8.062834162652027e-07 -0.001326296959495401 8.062835290488787e-07 -0.001543805653187533 8.062839635410184e-07 -0.002491429791030493 \
8.062840393661749e-07 -0.002673591589873599 8.062843960167732e-07 -0.003590195133438418 8.062845230658532e-07 -0.003936807634339821 8.062848015662471e-07 -0.004716444651655622 \
8.062849096507304e-07 -0.005020876868076652 8.06285253249855e-07 -0.00592430224391268 8.062853602437201e-07 -0.006162325733041658 8.062862596141159e-07 -0.005653094509861465 \
8.062864380475456e-07 -0.004687598829536962 8.062865437709605e-07 -0.003940993102967527 8.062866688337377e-07 -0.002883597584075996 8.062867624178337e-07 -0.001971418478057775 \
8.062868402573964e-07 -0.001132968824455395 8.062869203293945e-07 -0.0001977429743171 8.062870427022046e-07 0.001370578777960296 8.062871609580771e-07 0.003041212838230153 \
8.062872796071872e-07 0.004860750887681821 8.06287393089626e-07 0.006730904986417607 8.062874965327644e-07 0.008536402178002854 8.062876111920181e-07 0.01064190690353853 \
8.062878017758113e-07 0.0143607330143792 8.062879355659492e-07 0.01711819191720031 8.062880858195148e-07 0.02033933849841947 8.062882409887624e-07 0.02378599874269359 \
8.062883963808114e-07 0.0273434151175349 8.062885440880426e-07 0.03080849965087477 8.062886930776678e-07 0.03437359286003162 8.062888480687509e-07 0.03814545786868043 \
8.062890074393647e-07 0.04208062121327779 8.062891723727755e-07 0.04620305710844342 8.062893473191045e-07 0.0506208066052034 8.062895264491763e-07 0.05518387280380205 \
8.062897162384316e-07 0.06005265756871143 8.062899199354002e-07 0.06530840376289772 8.062901397459318e-07 0.07100650943730057 8.062903714973765e-07 0.07703584544314998 \
8.062906193226736e-07 0.08349927754587044 8.062908906436034e-07 0.09058756662233436 8.062911853563813e-07 0.09829181712822582 8.062915106140292e-07 0.106792896697727 \
8.062918768597348e-07 0.1163551101154179 8.062922701564477e-07 0.1266079356677421 8.062927228093435e-07 0.1383809089651769 8.062932485245107e-07 0.1520098384503803 \
8.06293867738049e-07 0.1679979965193872 8.062945484823656e-07 0.1854865650013753 8.062953421573203e-07 0.2057488551561759 8.062962309229534e-07 0.2282732214494322 \
8.062970443122153e-07 0.2487218262351868 8.062977660617924e-07 0.2667261628598245 8.062984017258004e-07 0.282460740414376 8.062989734425617e-07 0.2965101025186013 \
8.062995089968458e-07 0.3095696210007924 8.063000123552588e-07 0.3217495654069301 8.063004886827014e-07 0.3331878525640654 8.063009626063057e-07 0.3444754071334732 \
8.063014200780245e-07 0.3552759747331513 8.063018860582939e-07 0.3661792384270033 8.063023350461038e-07 0.376592601923634 8.063028311526457e-07 0.3879857357798637 \
8.063033509145081e-07 0.3998002499051578 8.063037303191525e-07 0.4083447473225827 8.063041703278757e-07 0.4181679450526055 8.063046400968135e-07 0.4285466970600206 \
8.063051256177522e-07 0.4391589006481625 8.063055650658585e-07 0.4486701556983262 8.063056268188068e-07 0.4500002248264944 8.063057503247037e-07 0.4526540461147197 \
8.063059973364976e-07 0.4579447795386873 8.063062499314088e-07 0.463325462421476 8.063064475025243e-07 0.467511453725808 8.063066730742714e-07 0.4722681264242033 \
8.06306994642268e-07 0.4790073975813253 8.063072634214966e-07 0.4846013351959894 8.0630748207297e-07 0.4891262574467725 8.063076921769364e-07 0.4934547887280634 \
8.063079185824616e-07 0.4980921872304203 8.063081276876522e-07 0.5023516957637455 8.063083170899106e-07 0.5061927337048852 8.06308441251129e-07 0.5086969563931187 \
8.063085680062259e-07 0.5112441466129884 8.06308728004704e-07 0.5144514110933732 8.063089756476561e-07 0.5193914248715521 8.063091542341148e-07 0.5229351592435862 \
8.063093251876918e-07 0.5263079149198099 8.063095865372878e-07 0.5314455197962068 8.063098126088702e-07 0.5358634945234868 8.063100157405374e-07 0.5398188128751134 \
8.063101809712675e-07 0.5430252218652345 8.063103377582877e-07 0.5460612552756139 8.063105269149052e-07 0.5497137532216215 8.063107287826584e-07 0.5535976061995346 \
8.06310952933981e-07 0.5578986282275192 8.063111913163461e-07 0.5624617013850463 8.06311426077985e-07 0.566941985223824 8.063116563486904e-07 0.5713275351537204 \
8.063118621413239e-07 0.5752375533958141 8.063120671255381e-07 0.5791255875933676 8.063123099407797e-07 0.5837094709690289 8.063125646983618e-07 0.588493349632063 \
8.063127929267932e-07 0.5927514274590796 8.063130307656651e-07 0.5971656109489694 8.063132430431007e-07 0.6010807441713891 8.063134548365055e-07 0.6049674646600495 \
8.06313708720774e-07 0.6095919957414236 8.063139133143013e-07 0.6132953190650409 8.063141650376543e-07 0.6178178328453598 8.063143528271743e-07 0.6211736970442716 \
8.063146057002513e-07 0.6256587164710262 8.063148041096133e-07 0.6291560967673944 8.06314983842284e-07 0.6323071487074056 8.063152541130913e-07 0.6370161336915187 \
8.063154713968567e-07 0.6407803561788556 8.063156519232363e-07 0.6438916924996977 8.063158530841307e-07 0.6473460740030906 8.063160216675126e-07 0.650231451944099 \
8.063162260257197e-07 0.6537144072723954 8.063163716887783e-07 0.6561873372238678 8.063165362473771e-07 0.6589728476742622 8.063167057165934e-07 0.6618316558839334 \
8.063168592566751e-07 0.664412775690417 8.06317000490202e-07 0.6667750288922751 8.063171440660136e-07 0.6691685747430841 8.063172772961389e-07 0.6713840140331436 \
8.063174191964593e-07 0.6737368819239464 8.063175394300862e-07 0.6757233098298149 8.063176840811383e-07 0.6781085120392751 8.063178002998435e-07 0.6800197521569988 \
8.063179193821632e-07 0.6819757159594566 8.063180179604766e-07 0.6835903813535821 8.063181355581833e-07 0.6855122399681081 8.063182229941461e-07 0.6869376986921233 \
8.063183477402322e-07 0.6889650632873403 8.063184475472963e-07 0.6905825000046129 8.063185400370926e-07 0.6920753042469043 8.063186413211772e-07 0.6937043390836264 \
8.063187391142832e-07 0.695273833970533 8.063188303850745e-07 0.6967333967490603 8.063189328429049e-07 0.6983656370917724 8.063190657521355e-07 0.7004728611232253 \
8.063192207675414e-07 0.7029137789397926 8.063193556492269e-07 0.7050222373350452 8.063195011450183e-07 0.7072806469370021 8.063196289996853e-07 0.709252249158637 \
8.063197534579805e-07 0.7111597484283609 8.063198647836849e-07 0.7128563623504806 8.063199788137126e-07 0.7145852226468989 8.063200793249296e-07 0.7161013069709498 \
8.063202165260769e-07 0.7181590832501857 8.063203364719788e-07 0.7199473375636642 8.06320455641778e-07 0.7217141075019444 8.063205825867916e-07 0.7235855504531626 \
8.063207073542093e-07 0.7254141264975077 8.063208308495973e-07 0.7272133847865295 8.063209576308702e-07 0.7290498056238117 8.063210882203554e-07 0.730930225429108 \
8.063212104322583e-07 0.7326797786847141 8.063213474902716e-07 0.7346298644824388 8.063214487056265e-07 0.7360619656663578 8.063215536745619e-07 0.7375401619041119 \
8.06321645165995e-07 0.7388229997694907 8.06321758241356e-07 0.7404001534680551 8.063218455422403e-07 0.7416107338190071 8.063219500055705e-07 0.7430512000342341 \
8.063220807687029e-07 0.7448411286358657 8.063221906822003e-07 0.7463352048609909 8.063222953419585e-07 0.7477488743938407 8.0632241917362e-07 0.7494094725133206 \
8.063225679269713e-07 0.751387874302702 8.06322689842132e-07 0.7529958494242643 8.063228036963924e-07 0.7544867042370438 8.063229441958499e-07 0.7563117925204224 \
8.063230855193645e-07 0.7581313010100689 8.063232032989715e-07 0.7596352654099263 8.063233316974594e-07 0.7612620174900669 8.063234740211609e-07 0.7630496612437514 \
8.063235904103157e-07 0.7644991888858087 8.063237361339775e-07 0.7662987831554334 8.063238579138671e-07 0.7677897310961733 8.06323976478797e-07 0.7692300520321635 \
8.063240990922458e-07 0.7707078417740018 8.063242255436291e-07 0.77221964326554 8.06324335666584e-07 0.7735261258099556 8.063244611887263e-07 0.7750039859681491 \
8.06324566849672e-07 0.7762386743660952 8.063247020268293e-07 0.7778058706872942 8.063248256373457e-07 0.7792267957652825 8.06324955634725e-07 0.7807078764205345 \
8.06325068606223e-07 0.7819831642610904 8.063251765001111e-07 0.7831908181350914 8.063253130307933e-07 0.7847046126527283 8.063254631517019e-07 0.7863508260127218 \
8.063256054160057e-07 0.7878933964149381 8.063257249975189e-07 0.7891771019825847 8.063258618086489e-07 0.7906313890246753 8.063259843124129e-07 0.7919206245676671 \
8.06326128984341e-07 0.7934276941869095 8.063262697694142e-07 0.794878360380241 8.063263965852094e-07 0.796171745508174 8.063265156326017e-07 0.7973744708066829 \
8.063266278955628e-07 0.7984986270115709 8.063267322833333e-07 0.7995352562746869 8.063268275603949e-07 0.8004739840425704 8.063269639028913e-07 0.8018044219089175 \
8.063270807679598e-07 0.8029326473252685 8.063272003644895e-07 0.8040757482679398 8.063273222502993e-07 0.8052288531124292 8.063274448385593e-07 0.8063765489401953 \
8.06327572579618e-07 0.8075599074701925 8.06327697362526e-07 0.8087035441861687 8.063278278629006e-07 0.8098867241643505 8.063279542295968e-07 0.8110199871086299 \
8.06328081578389e-07 0.8121498004723215 8.063281867911793e-07 0.8130740322933268 8.063282914951838e-07 0.8139855427426806 8.063283830253901e-07 0.8147757515715357 \
8.063285063983601e-07 0.8158311616195392 8.063285933524083e-07 0.8165684017534872 8.063286922082447e-07 0.8173999442793862 8.063288367108844e-07 0.8186029267949408 \
8.063289730365725e-07 0.8197243345631372 8.063290824450085e-07 0.8206145128367788 8.06329228461948e-07 0.821788834531623 8.063293802030074e-07 0.8229927727264784 \
8.063295061195854e-07 0.8239792970156907 8.063296505686489e-07 0.8250971468990039 8.063297752648171e-07 0.8260503472050121 8.063299258788342e-07 0.8271873005969326 \
8.063300612493022e-07 0.8281959289694237 8.063301864729373e-07 0.8291179217777711 8.063303041288969e-07 0.8299746468143927 8.063304499105104e-07 0.8310230722388168 \
8.063306163942599e-07 0.8322027532553667 8.063307472150236e-07 0.8331167337813133 8.063309206750455e-07 0.834311196379941 8.063310887878414e-07 0.8354501125721271 \
8.063312586689692e-07 0.8365827385393307 8.063314395126275e-07 0.8377685497174457 8.06331582704692e-07 0.8386931238161603 8.063316968221893e-07 0.8394210074154138 \
8.063318268737995e-07 0.8402408682651782 8.063319287535162e-07 0.8408758513273116 8.063320456411388e-07 0.841596551294542 8.063321827868591e-07 0.8424315815669623 \
8.063323806960721e-07 0.8436167827761205 8.063325725154114e-07 0.8447436440637145 8.063327818661576e-07 0.8459494874145237 8.063329640177679e-07 0.8469786287449077 \
8.063331611039906e-07 0.8480715276019779 8.063333343567188e-07 0.8490148531186206 8.063335174509634e-07 0.8499943787178993 8.063336885824298e-07 0.8508936588199895 \
8.063338632702718e-07 0.8517955326875627 8.063340385042872e-07 0.8526841769874772 8.063342146411542e-07 0.8535614892404448 8.063344050084938e-07 0.8544920815553035 \
8.063345955808446e-07 0.8554057038167108 8.063347959768378e-07 0.8563474066245403 8.063349885664634e-07 0.8572344253714166 8.06335199466375e-07 0.858185963363946 \
8.063354273418617e-07 0.8591913103610016 8.063356934247181e-07 0.8603357477151101 8.063359919268544e-07 0.8615822374427254 8.063362678163234e-07 0.8627000332972231 \
8.063365520834927e-07 0.8638181192989086 8.063368262214432e-07 0.8648650323418529 8.06337098522366e-07 0.8658754039994767 8.063373686785625e-07 0.8668495780678541 \
8.063376258626988e-07 0.8677515347235455 8.063378984216134e-07 0.8686810999091764 8.063381744693315e-07 0.8695957110915412 8.063384445895985e-07 0.8704649939918846 \
8.063387444494889e-07 0.8714007440816277 8.063391154301144e-07 0.8725171209518352 8.063394103525362e-07 0.8733732402027278 8.063396646282709e-07 0.8740897163373675 \
8.06339962841735e-07 0.8749052413925265 8.063402364113466e-07 0.8756305047096297 8.063404725347486e-07 0.8762394088953867 8.063407128598863e-07 0.8768433401198644 \
8.063409351938211e-07 0.8773882060838187 8.063411292002539e-07 0.8778530214284207 8.063414589096811e-07 0.8786208714695904 8.0634161408109e-07 0.87897283049042 \
8.063419317234906e-07 0.8796750328643211 8.063421106040348e-07 0.8800599154915705 8.063424530647979e-07 0.8807759898408113 8.063426372672098e-07 0.8811501695110489 \
8.063431122965131e-07 0.8820806183873429 8.06343279683462e-07 0.8823969901232691 8.063437454598435e-07 0.8832471741583867 8.063439262991872e-07 0.8835657112976044 \
8.063444203088052e-07 0.8844044135654346 8.063445616237109e-07 0.8846360992458032 8.063451678673265e-07 0.8855901496945974 8.063453199425257e-07 0.8858196526512701 \
8.063459666625989e-07 0.8867549368993356 8.063460949492666e-07 0.8869330782847171 8.063467431586864e-07 0.8877977435561634 8.063468728829849e-07 0.8879638504720397 \
8.063476413020527e-07 0.8888993076310558 8.063477710739033e-07 0.8890488273083775 8.063486247365088e-07 0.8899738047157748 8.063487677615613e-07 0.8901192131187072 \
8.063497540670479e-07 0.8910487927319016 8.063499755535999e-07 0.8912403904783051 8.063511183781384e-07 0.8921548233216382 8.063512482580762e-07 0.8922544308366913 \
8.063526007584981e-07 0.8932425879319322 8.063527510414313e-07 0.8933452769452155 8.063542315756977e-07 0.8942627870546499 8.063544704854918e-07 0.8943950258099049 \
8.063562525184327e-07 0.8952625983306248 8.063566382658602e-07 0.895426813549116 8.063590404240788e-07 0.8963023915260389 8.063595153600486e-07 0.8964490046842035 \
8.063634332871646e-07 0.8974035634625627 8.063639032474093e-07 0.8974927205890085 8.063722720353867e-07 0.8984807567386782 8.063724925457144e-07 0.8984960697096243 \
8.064170720742926e-07 0.8994905034760702 8.064182734601915e-07 0.8995076493514624 8.065540832686942e-07 0.9004821828323031 8.065542622454191e-07 0.9005421539807538 \
8.065577071203374e-07 0.8996085030263692 8.065578799041918e-07 0.8994755022453073 8.065592062238996e-07 0.8985168769831137 8.06559392989208e-07 0.8983970610744239 \
8.065611771942332e-07 0.8974304740967198 8.065613893245152e-07 0.8973403978332656 8.065747300202991e-07 0.8983331062395279 8.065748433081446e-07 0.8983517458922662 \
8.065835466612414e-07 0.8993273409280406 8.065840944718199e-07 0.8993637478389299 8.070766218437148e-07 0.9003542216796759 8.070767175825666e-07 0.9004233209197793 \
8.070776601319424e-07 0.9014023545001312 8.070778225852538e-07 0.9016297223302431 8.070783892915005e-07 0.9025464066367429 8.070784964622121e-07 0.9027401250447874 \
8.070788897705639e-07 0.9035002370985188 8.07079022567928e-07 0.9037710185404622 8.070794021690344e-07 0.9045728679206633 8.070795323837805e-07 0.9048512534150681 \
8.070799937900729e-07 0.9057878278182891 8.070801130371311e-07 0.9060008176934132 8.070815426461655e-07 0.9050557440230738 8.070816263162926e-07 0.9046580283931719 \
8.07081751622122e-07 0.9039622140338933 8.070818594362906e-07 0.9032622438705011 8.070819784306371e-07 0.9023800387125585 8.070820938028541e-07 0.9014106868475621 \
8.070821838997508e-07 0.900578017289966 8.070822953474548e-07 0.8994526603282017 8.070823814266029e-07 0.8985125975436928 8.070824873922515e-07 0.8972736935213672 \
8.070825871606176e-07 0.8960214106762436 8.070826681562277e-07 0.8949470092681954 8.070827778041954e-07 0.8934133399212493 8.070828633916056e-07 0.8921520042367302 \
8.070829555142148e-07 0.8907345325087322 8.070830437335979e-07 0.8893220116766375 8.070831525083507e-07 0.8875100775672261 8.070832354013855e-07 0.8860780350921965 \
8.070833439750574e-07 0.8841400608632336 8.070834362012525e-07 0.8824412727986957 8.070835208217502e-07 0.8808423775446282 8.0708360666218e-07 0.8791839877465467 \
8.070836858770599e-07 0.8776224824828824 8.070837619650304e-07 0.8760960492665846 8.070838543013987e-07 0.874210837196514 8.070839141777347e-07 0.8729702140710593 \
8.070839715660191e-07 0.8717685933706794 8.070840335611921e-07 0.8704574090763495 8.070840968400434e-07 0.8691057216070059 8.07084146911381e-07 0.8680269866686803 \
8.070841963535335e-07 0.8669542389500936 8.070842600232402e-07 0.8655623656543436 8.070843359706592e-07 0.8638877358586781 8.070843848016709e-07 0.8628032002737418 \
8.070844333256242e-07 0.8617197496806845 8.070845090373469e-07 0.8600184098866027 8.070845762461247e-07 0.8584975010852487 8.070846189526311e-07 0.8575263577286506 \
8.070846628552044e-07 0.8565244243916033 8.070847506603508e-07 0.8545103166059256 8.070848135135196e-07 0.8530605771626394 8.070848721831767e-07 0.8517018597088126 \
8.070849083617784e-07 0.8508614974547222 8.070849431802581e-07 0.8500510151036469 8.070849782062432e-07 0.8492340038666518 8.070850482582133e-07 0.8475953578585981 \
8.07085096728698e-07 0.8464581214772323 8.070851406734991e-07 0.8454248116355969 8.070851861912554e-07 0.8443523575543517 8.070852500921663e-07 0.8428433081697474 \
8.070853162185395e-07 0.8412777165526386 8.07085421348608e-07 0.8387809254526315 8.070855092832832e-07 0.8366857089760468 8.070855882285648e-07 0.834800137446173 \
8.070856763936022e-07 0.8326899670047023 8.070857632095988e-07 0.8306078985741704 8.070858511012832e-07 0.8284959280419055 8.070859423503732e-07 0.8262996967350639 \
8.070860451122409e-07 0.8238226494465998 8.070861436157165e-07 0.8214450402687625 8.070862559486315e-07 0.8187302447322098 8.070863689227678e-07 0.8159967029774419 \
8.070864902106627e-07 0.8130591602364435 8.070866207178166e-07 0.8098958628758253 8.070867497637196e-07 0.8067658935936169 8.070869032393198e-07 0.8030416153605923 \
8.070870685235404e-07 0.799029304640783 8.070872362647446e-07 0.7949567682299736 8.070874327883338e-07 0.7901857478752816 8.07087637550659e-07 0.7852160332972318 \
8.070878502277153e-07 0.7800563994093253 8.070880508476619e-07 0.7751902022758907 8.070882517063895e-07 0.7703212856706637 8.070884017284074e-07 0.766686939713112 \
8.070885322635739e-07 0.7635264252913375 8.070886666810141e-07 0.7602735436595947 8.070887728765445e-07 0.7577048602246427 8.070889061828773e-07 0.754482067181252 \
8.070890132158028e-07 0.7518959494812111 8.070891562917044e-07 0.7484409822837247 8.070893207978459e-07 0.7444713482725677 8.070894416150924e-07 0.74155777711076 \
8.070896127217564e-07 0.7374334100931738 8.070897736123088e-07 0.733558046396253 8.070899902049296e-07 0.7283457217000903 8.070901834606308e-07 0.7236999380850822 \
8.07090362395765e-07 0.7194029726762079 8.070905292123874e-07 0.7154015770462002 8.070907154183522e-07 0.7109395231330657 8.070909033515934e-07 0.7064416825495208 \
8.070910692736985e-07 0.7024749886985119 8.07091261631787e-07 0.6978803202016938 8.07091402988682e-07 0.6945068232011449 8.070915599964439e-07 0.6907636199298515 \
8.070917559760889e-07 0.6860965106368763 8.070919184101942e-07 0.6822325558671515 8.070920795863762e-07 0.6784034260021697 8.070922718945738e-07 0.6738409413562468 \
8.070924895564538e-07 0.6686845685784016 8.070927375777557e-07 0.6628199086538362 8.07092915635219e-07 0.6586162961343578 8.070931641790282e-07 0.6527567611811057 \
8.070933667862709e-07 0.6479896840619462 8.07093536596938e-07 0.6440011601507294 8.070936952131239e-07 0.6402799599229552 8.070938337435587e-07 0.637035894415233 \
8.070939699513215e-07 0.6338503464729111 8.070940962626978e-07 0.6309003762865483 8.07094225721933e-07 0.6278810604265532 8.070943540536725e-07 0.6248911458464299 \
8.070944853836027e-07 0.6218374290191309 8.070946174102147e-07 0.6187713222160208 8.070947615700951e-07 0.6154276788919771 8.07094905778687e-07 0.6120888358645944 \
8.070950534337911e-07 0.6086753592300279 8.070952004901491e-07 0.6052842859263143 8.070953583041756e-07 0.6016504852589418 8.070954909098278e-07 0.5986039825107707 \
8.070956223747947e-07 0.5955897059985247 8.070957418045935e-07 0.5928552647156846 8.070958778732863e-07 0.5897484304797134 8.070959928015483e-07 0.5871283594046445 \
8.070961439122688e-07 0.5836892419704927 8.070962585613367e-07 0.5810871834776226 8.070963764990063e-07 0.5784138884735546 8.070964662802944e-07 0.576381560286313 \
8.070965565996887e-07 0.5743415774978985 8.070966232905592e-07 0.5728373329037385 8.070966888523723e-07 0.5713590910263378 8.070967398944957e-07 0.5702089751121119 \
8.070968015962151e-07 0.5688198806440578 8.070968646860707e-07 0.5674025889664359 8.070969290444246e-07 0.5659586381304559 8.070969824382235e-07 0.5647616504486359 \
8.070970750808061e-07 0.5626864159088959 8.070971516880784e-07 0.5609719030357503 8.070972075131406e-07 0.5597256439368602 8.070972765672667e-07 0.5581857825097393 \
8.070973834553926e-07 0.5558054549196561 8.070974611990176e-07 0.5540764009223496 8.070975620491173e-07 0.5518382286767042 8.070976877299716e-07 0.5490568313009737 \
8.070977879716568e-07 0.5468419758621708 8.070978998893402e-07 0.5443739014182352 8.070980031552469e-07 0.5421024366463116 8.070981229045887e-07 0.5394737463112931 \
8.070982246374689e-07 0.5372436950013484 8.070983401572132e-07 0.5347185748314579 8.070984551922987e-07 0.5322102907975605 8.07098581673211e-07 0.529456475824718 \
8.070987070470086e-07 0.5267350629320526 8.070988538629319e-07 0.5235577714138258 8.070989894263806e-07 0.5206304261698983 8.070991471246342e-07 0.5172373565578411 \
8.070993094436886e-07 0.5137528589513558 8.070994902675846e-07 0.5098871206809381 8.070996827159053e-07 0.5057874350093188 8.070998956212086e-07 0.5012700264709963 \
8.071001278026081e-07 0.4963634062180514 8.071003850931866e-07 0.4909555076455908 8.071006247190101e-07 0.4859407514401474 8.071009264344461e-07 0.479662588092526 \
8.071012143537997e-07 0.4737079198104491 8.071015272426188e-07 0.4672821326282255 8.071018469808238e-07 0.4607585360408045 8.071021865759847e-07 0.4538766993710576 \
8.071025134784829e-07 0.4472977926730654 8.071028490368641e-07 0.4405887635920606 8.071031661327867e-07 0.4342949501181722 8.071035003705415e-07 0.4277061431972559 \
8.071038518016635e-07 0.4208322784122511 8.071041663278176e-07 0.4147233751108969 8.071044895053079e-07 0.4084912998479469 8.071049306200656e-07 0.400057814108821 \
8.071052727361034e-07 0.3935812134363078 8.071055726806328e-07 0.3879522399691127 8.071059478116385e-07 0.3809760137481454 8.071062775558776e-07 0.3749002425561211 \
8.071065607988036e-07 0.3697269896098562 8.071068609450588e-07 0.3642865787664632 8.071071405472531e-07 0.3592589179584539 8.071073643233647e-07 0.3552676761685443 \
8.071075761036954e-07 0.3515151294490645 8.071077785371594e-07 0.3479514629380864 8.071079796284271e-07 0.3444362246481504 8.071081853428453e-07 0.3408632458568372 \
8.071084529657171e-07 0.3362478643926977 8.071086918970112e-07 0.3321601360780691 8.071089254030739e-07 0.3281974319442653 8.071091388684736e-07 0.3246000376975314 \
8.071093602460465e-07 0.3208952602338652 8.071095602096931e-07 0.3175728982722026 8.07109764482006e-07 0.3142073831356898 8.071099618288777e-07 0.3109812293225088 \
8.071101472014048e-07 0.3079732989686547 8.071103433077958e-07 0.3048147723336881 8.071105455849362e-07 0.3015820927993307 8.071107212432327e-07 0.2988007390096292 \
8.0711090711339e-07 0.295878328903569 8.071111140927825e-07 0.2926488196724605 8.071112994143739e-07 0.2897857719971084 8.071114946411815e-07 0.2867989994419413 \
8.071116504155309e-07 0.28443329608414 8.071118291723129e-07 0.2817356906084737 8.071120102032329e-07 0.2790344478478936 8.071121601003466e-07 0.2768142575519123 \
8.071123611437743e-07 0.273859574769726 8.071125102589039e-07 0.2716833853889438 8.071126487983334e-07 0.2696726034832688 8.071128006734089e-07 0.2674956304896134 \
8.071129151475376e-07 0.2658586287383957 8.071130466774682e-07 0.2639823142040156 8.071131724359562e-07 0.2622048582339201 8.071132767763623e-07 0.2607341604582348 \
8.071133897557217e-07 0.2591418073851619 8.071135060842464e-07 0.2575033437579446 8.071136490116675e-07 0.2554974228347739 8.071137622731725e-07 0.2539102348881249 \
8.071138964299053e-07 0.2520298733123076 8.071140069027096e-07 0.2504818583075984 8.071141623352846e-07 0.2483006006477398 8.071143032203834e-07 0.2463217957442577 \
8.071144546129539e-07 0.2441928603691365 8.071146097750345e-07 0.2420086586735095 8.071147391842833e-07 0.2401849910837116 8.071148738963765e-07 0.2382868210192302 \
8.071150115942014e-07 0.2363478190565156 8.071151293462172e-07 0.2346905900295477 8.071152886704099e-07 0.2324499447852502 8.071154259326363e-07 0.2305210708572645 \
8.071155666789934e-07 0.2285488733964877 8.071156724701667e-07 0.2270688194984586 8.071158024115645e-07 0.2252532503786337 8.071159029480281e-07 0.2238506847401111 \
8.071160052817357e-07 0.2224250970611539 8.071160790103171e-07 0.2214012665004395 8.071161582442603e-07 0.2203047212273054 8.071162292155075e-07 0.2193236206014474 \
8.071162806785351e-07 0.218612902325451 8.071163336269881e-07 0.2178825126218075 8.071164127819908e-07 0.2167921001391954 8.071164550546258e-07 0.2162104926182252 \
8.071164948991708e-07 0.2156628374086678 8.071165381228203e-07 0.2150692779925967 8.071165790298225e-07 0.2145080585354088 8.071166491522843e-07 0.2135474129702876 \
8.071166828372557e-07 0.2130867492099046 8.071167276666377e-07 0.212477723463 8.071167865237998e-07 0.2116792343136102 8.071168513092605e-07 0.2108017053965978 \
8.071169087900245e-07 0.2100241135398916 8.071169692190328e-07 0.209207737948094 8.071170662554631e-07 0.2078991976528634 8.07117150945123e-07 0.2067595417901527 \
8.071172598558851e-07 0.2052972881712416 8.071173562566921e-07 0.2040065614180294 8.071174512733293e-07 0.2027428333585779 8.071175547051274e-07 0.2013717100485363 \
8.071176496344728e-07 0.2001158751783069 8.071177526548994e-07 0.198757993281026 8.071178577373321e-07 0.1973779917312911 8.071179670461462e-07 0.1959482000350934 \
8.07118077489628e-07 0.1945091075764383 8.071181937799036e-07 0.1929996650696684 8.071183037098964e-07 0.1915811184357085 8.071184133723204e-07 0.1901717999899754 \
8.071185150889654e-07 0.1888694322720079 8.071186080436791e-07 0.1876837490531375 8.071187007725689e-07 0.1865049219968967 8.07118774458125e-07 0.1855719169757668 \
8.071188572993398e-07 0.1845269810791141 8.071189318853364e-07 0.1835895008849975 8.071190016086783e-07 0.1827150226754214 8.071190683270854e-07 0.1818808699270075 \
8.071191641704113e-07 0.1806871657728035 8.071192468771838e-07 0.1796611249561687 8.071193404410075e-07 0.1785035608809835 8.071194353370949e-07 0.1773351434884491 \
8.071195467074053e-07 0.1759704596301353 8.071196883497589e-07 0.1742450478777388 8.071198035966121e-07 0.1728486436789435 8.071199481442513e-07 0.1711076225712051 \
8.071200597399285e-07 0.1697708811114609 8.07120200958902e-07 0.1680898955975501 8.071203166961755e-07 0.1667201145354908 8.071204226568607e-07 0.1654722325850081 \
8.071205214164775e-07 0.164314417410061 8.071206177596498e-07 0.1631901152369615 8.071207064174022e-07 0.1621596955203892 8.071208317516727e-07 0.1607099933926625 \
8.071209262770884e-07 0.1596224416957933 8.071210240160401e-07 0.1585042187118262 8.071211321109171e-07 0.1572745454417887 8.071212267786046e-07 0.1562036643369483 \
8.071213342264514e-07 0.1549951394274829 8.071214253154951e-07 0.1539767092330788 8.071215320872067e-07 0.1527896463435911 8.071216354804728e-07 0.1516469620792683 \
8.071217465609577e-07 0.1504267727114754 8.071218357869394e-07 0.1494522115900035 8.071219212668682e-07 0.1485231035185812 8.071220051920548e-07 0.1476157397758405 \
8.071220748986192e-07 0.1468658175993407 8.071221535366968e-07 0.1460232248551682 8.071222318479541e-07 0.1451880611912267 8.071223024838273e-07 0.1444378248611795 \
8.071223879746948e-07 0.1435337156153706 8.071224753636722e-07 0.1426139614481139 8.071225569511858e-07 0.1417594571206545 8.071226542701372e-07 0.1407454482154784 \
8.071227349596596e-07 0.139910090776864 8.071228257446906e-07 0.1389752404035735 8.07122947088963e-07 0.1377336220260025 8.071230361386038e-07 0.13682812281983 \
8.071231346554539e-07 0.1358318692385875 8.071232217417229e-07 0.1349560640726983 8.071233321526109e-07 0.1338550874529322 8.071234206114333e-07 0.1329791517134813 \
8.071235213400266e-07 0.1319874611681985 8.071236261295802e-07 0.1309622419763913 8.07123720519813e-07 0.1300442429014473 8.07123817024605e-07 0.1291112112475518 \
8.071239165112583e-07 0.1281591654439075 8.071240029124292e-07 0.1273384721630967 8.071240978925598e-07 0.1264411177628728 8.071242020813879e-07 0.1254629331099751 \
8.071243112001386e-07 0.124445178694 8.071244055505945e-07 0.1235704029653004 8.07124517846343e-07 0.1225411084520107 8.071246133096966e-07 0.1216733466577494 \
8.071247175205872e-07 0.1207311846737792 8.071248068659445e-07 0.1199276649878674 8.071248772532174e-07 0.1192980345746366 8.071249526392512e-07 0.1186268760051257 \
8.071250287714207e-07 0.1179522201461119 8.071250977489183e-07 0.1173458504859956 8.071251802680908e-07 0.1166263596898966 8.071252522115779e-07 0.1160015972854393 \
8.071253342903043e-07 0.1152916772467617 8.0712541862478e-07 0.1145654108773922 8.07125496418619e-07 0.113898375935255 8.071255891835211e-07 0.1131065723182637 \
8.071257047873425e-07 0.1121254933399327 8.071258106929114e-07 0.1112341778178403 8.071258883498311e-07 0.1105854195321705 8.071259766463023e-07 0.1098504899494786 \
8.071260567033545e-07 0.1091866403929743 8.071261536294793e-07 0.1083861389179563 8.07126248864964e-07 0.1076031391441806 8.071263374361587e-07 0.1068780200140514 \
8.071264387442598e-07 0.1060523297458165 8.071265442899472e-07 0.1051963702337609 8.071266534843118e-07 0.1043160928234657 8.071267616019328e-07 0.1034503663302994 \
8.071268815196937e-07 0.1024949450012773 8.071269828815214e-07 0.1016914181115986 8.071270888911508e-07 0.100855068690839 8.071272146827802e-07 0.09986840123414902 \
8.071273442400857e-07 0.09885896724496235 8.071274799154405e-07 0.09780904711780367 8.071276559873036e-07 0.09645781830037269 8.071278197878237e-07 0.09521257997344186 \
8.071279826125652e-07 0.09398642071914091 8.071280677512003e-07 0.09334985726464029 8.07128137589223e-07 0.09282999162688726 8.071282070848283e-07 0.09231474740697931 \
8.071282810434879e-07 0.09176875214326782 8.071283771983754e-07 0.09106241641841166 8.071284516137407e-07 0.09051841344162129 8.071285296033096e-07 0.08995079828656057 \
8.071286060521396e-07 0.08939693755534793 8.071286935462239e-07 0.08876614459792892 8.071287957229341e-07 0.08803382885421264 8.071288842873223e-07 0.08740269463919083 \
8.071289939528099e-07 0.08662585268124241 8.071291100092174e-07 0.08580942306245626 8.07129251558034e-07 0.0848216759818637 8.071293844270176e-07 0.08390253510334872 \
8.071295251873281e-07 0.08293727564630923 8.071296748969478e-07 0.08192024575105315 8.071298106088348e-07 0.08100683753927941 8.07129952125717e-07 0.08006309454860433 \
8.071300872475906e-07 0.07917070961097784 8.071302285200282e-07 0.07824718349428782 8.071303756129204e-07 0.07729532867436953 8.07130527122786e-07 0.07632524417621221 \
8.071306924984999e-07 0.07527819040792309 8.071308562596901e-07 0.07425356708383206 8.071310323896319e-07 0.07316505371836476 8.071312215286099e-07 0.07201151367936541 \
8.071314322022336e-07 0.07074528708793332 8.071316517688556e-07 0.06944624562626683 8.071318865352622e-07 0.06808094281860989 8.071321449277002e-07 0.06660616301228137 \
8.071324395923604e-07 0.06496103773121734 8.071327436716829e-07 0.06330286177969326 8.071331045821629e-07 0.06138472526627536 8.071334404990352e-07 0.05964719353945821 \
8.07133880676406e-07 0.05743991201668189 8.071342590438091e-07 0.05560437501227136 8.071347015027716e-07 0.05352996728430704 8.071350555229165e-07 0.05192508193542229 \
8.071354420396717e-07 0.05022502935509546 8.07135786643729e-07 0.04875485597254389 8.071361086186649e-07 0.04741934964807833 8.07136412152492e-07 0.04619304551845941 \
8.071367070734883e-07 0.04503122626702559 8.071369895557667e-07 0.04394770877170886 8.071372666361775e-07 0.04291147062934708 8.071375323636684e-07 0.04194013461971725 \
8.071378035943552e-07 0.0409708748276704 8.071380798533722e-07 0.04000619535229137 8.071383697525942e-07 0.03901828782233653 8.071385981289875e-07 0.03825741181922668 \
8.071389030130543e-07 0.03726495139513845 8.071391196849104e-07 0.03657573971894532 8.071393110416373e-07 0.03597943984071691 8.071395096361558e-07 0.03537298232318693 \
8.071398395514967e-07 0.03438820140908775 8.071400814971701e-07 0.03368375433354889 8.071403968092223e-07 0.03278771666975258 8.071406669292072e-07 0.03203957074185158 \
8.071409233008807e-07 0.03134567005659093 8.071412033128806e-07 0.03060515313352298 8.071414489686567e-07 0.02997014710356035 8.071416817043017e-07 0.02938120249260199 \
8.07141924434299e-07 0.02878348292867495 8.071421611615635e-07 0.02821317433052753 8.071423898079743e-07 0.0276732289298247 8.071428070936344e-07 0.02671456010533928 \
8.071430022743283e-07 0.02627749693639509 8.071433834414109e-07 0.02544369227895442 8.071435606942329e-07 0.02506446942885681 8.071439031456877e-07 0.02434654114125227 \
8.0714405641412e-07 0.02403127656358269 8.071444314325841e-07 0.02327616399748992 8.071445690667252e-07 0.02300530455388665 8.071450533333593e-07 0.02207084195640928 \
8.071451729527604e-07 0.02184403312078184 8.071455899915636e-07 0.02106026682208277 8.07145733393791e-07 0.02079332360769017 8.071462546051726e-07 0.01984598817089831 \
8.071463823790427e-07 0.0196205814374062 8.071469667914166e-07 0.01863359713481367 8.071471392268229e-07 0.01835589372257288 8.071477433235728e-07 0.01743644241612937 \
8.071479047552141e-07 0.01720262545858322 8.071485447014338e-07 0.01631831686205014 8.071487230176005e-07 0.016083210242981 8.071493710016487e-07 0.01526127675881721 \
8.071495362552397e-07 0.01505930898173208 8.071502725571753e-07 0.01419381259610907 8.071504068332254e-07 0.01404154276213586 8.071512039327433e-07 0.01317592498067951 \
8.071513445303544e-07 0.01302934089458718 8.07152309873577e-07 0.0120661300044765 8.071524742123827e-07 0.01190857475316222 8.071534749435119e-07 0.01099048917119646 \
8.07153612213369e-07 0.01087009009405628 8.071547509078863e-07 0.009949273443646761 8.071548650857872e-07 0.009863136028526375 8.071562457306217e-07 0.008889755784408603 \
8.071564000878327e-07 0.00878832203975914 8.071579465820611e-07 0.00781340401000951 8.071580309437644e-07 0.007760176032106158 8.07159716371082e-07 0.006770348169342283 \
8.071598398995725e-07 0.00670487246831437 8.071618897141387e-07 0.005720970231232756 8.071620861142965e-07 0.005634691917282852 8.071644047936537e-07 0.004698942116576918 \
8.071648654079885e-07 0.004530544077955615 8.071676055035305e-07 0.003639937533647344 8.071681236485673e-07 0.00349159181499799 8.071722742898753e-07 0.002502201117031859 \
8.071728121398824e-07 0.002396807933581942 8.0717889437533e-07 0.001421603691354927 8.071791533557404e-07 0.001378272220758726 8.071844761190904e-07 0.0003814093765652445 \
8.071845892761344e-07 0.0003711807182531981 8.098307063923701e-07 -0.0004615907568095335 8.098308688313385e-07 -0.0006852153244161934 8.098313698328069e-07 -0.001554404032531494 \
8.098314540153697e-07 -0.001725199767551738 8.098318555381938e-07 -0.002626792336557519 8.098319448731606e-07 -0.002845673237760077 8.098322314649696e-07 -0.0035898660494722 \
8.098323590334992e-07 -0.003937855927128601 8.098326777451613e-07 -0.004830400105952924 8.098327919463135e-07 -0.00515011308870196 8.098330743466381e-07 -0.005887653497963378 \
8.098332045728569e-07 -0.006177415671381139 8.09834182925754e-07 -0.005220113099403402 8.098343702332871e-07 -0.004004368716724641 8.098345016776888e-07 -0.002901539130564616 \
8.098346071052425e-07 -0.001869327786897239 8.098346928227261e-07 -0.0009323217369615201 8.098347747492127e-07 4.151965372454519e-05 8.098348957860361e-07 0.001618129410352471 \
8.098349947146828e-07 0.003024565667809575 8.098351531113568e-07 0.005482561958548801 8.098353705585867e-07 0.00923691162542661 8.098355517808095e-07 0.0126653356758144 \
8.09835763874906e-07 0.01697021734206094 8.098359268985627e-07 0.02046388365739064 8.098360875209784e-07 0.02403759527126768 8.098362410612209e-07 0.02755862871109176 \
8.098363891179022e-07 0.031036270750196 8.098365381988111e-07 0.03460722192241437 8.098366927287224e-07 0.03837091703902212 8.098368533795379e-07 0.04234026030123839 \
8.098370180342185e-07 0.04645786783841532 8.098371945751168e-07 0.05091770581196236 8.098373735379687e-07 0.05547793877747508 8.098375642811338e-07 0.0603721650098247 \
8.09837769062163e-07 0.06565647483694508 8.098379895344491e-07 0.07137203566208646 8.098382223941741e-07 0.0774299331224613 8.098384715816505e-07 0.08392829098722057 \
8.098387444237776e-07 0.09105513637423955 8.098390411275777e-07 0.09880974921055499 8.098393684539683e-07 0.1073623706929605 8.098397381053548e-07 0.11701033799881 \
8.098401329771689e-07 0.1273002725707723 8.098405908154096e-07 0.1392030195235975 8.098411226222496e-07 0.1529832553757746 8.09841747860046e-07 0.1691182447448397 \
8.098424336075175e-07 0.1867241161332086 8.098432360033912e-07 0.2071957342970069 8.098441348021829e-07 0.2299563735557614 8.098449404156323e-07 0.2501946571168963 \
8.098456541669657e-07 0.2679877251922811 8.098462837288477e-07 0.2835633151515627 8.098468540922982e-07 0.2975737963344939 8.098473850476803e-07 0.3105173405876944 \
8.098478868351306e-07 0.3226580892822354 8.098483661296844e-07 0.3341673054699896 8.098488316851033e-07 0.3452566901045974 8.098492954815109e-07 0.3562094254686541 \
8.098497512295406e-07 0.3668794056881832 8.098502114496752e-07 0.3775613305945491 8.098507497336462e-07 0.3899285626759094 8.098512505841796e-07 0.4013172511919189 \
8.098516508068632e-07 0.4103337945930838 8.09852157667644e-07 0.421642452039157 8.098526436338564e-07 0.4323669409017459 8.098530431485677e-07 0.4410997362599856 \
8.098534537606271e-07 0.4500002277813482 8.098538826870601e-07 0.4592207708982954 8.098542842014423e-07 0.4677760623951868 8.098545915918886e-07 0.4742753916877908 \
8.098549418336473e-07 0.4816249679276425 8.098552950738506e-07 0.4889795533930016 8.0985554824443e-07 0.4942125642332652 8.098557811883199e-07 0.4989990073547648 \
8.098560228316108e-07 0.5039392821429431 8.098562478222295e-07 0.5085102868389438 8.098564398583375e-07 0.5123881070394828 8.098566246700343e-07 0.5161059569497825 \
8.098568469603498e-07 0.5205538992744256 8.098570136717574e-07 0.5238726938135662 8.098572308883524e-07 0.5281726418673847 8.098574339672442e-07 0.5321820613122353 \
8.098576113786994e-07 0.5356681922482178 8.098577994510863e-07 0.5393528234657015 8.098580354832655e-07 0.5439555888699217 8.098583013652895e-07 0.5491186112539347 \
8.098585231271783e-07 0.5534070305875756 8.098588031850331e-07 0.5588091140818973 8.098590461848179e-07 0.5634839438879177 8.09859321538161e-07 0.5687575845994758 \
8.098595665335015e-07 0.5734440561015828 8.098598068277204e-07 0.5780305526007354 8.098600478670233e-07 0.5826153106864888 8.09860305457841e-07 0.5874946531182738 \
8.098605408246178e-07 0.5919209497705462 8.09860772126727e-07 0.5962518282209535 8.098609946534482e-07 0.6003950532231523 8.098612030130559e-07 0.6042587207462122 \
8.098614408548706e-07 0.6086392006348278 8.098616517150853e-07 0.612499186772883 8.09861907322267e-07 0.617151767543529 8.098621060500327e-07 0.620751700070918 \
8.098623816826772e-07 0.6257066023742009 8.098626044387981e-07 0.6296824120643636 8.098628978099215e-07 0.6348814180513288 8.098631305799232e-07 0.6389753720667986 \
8.098633507813091e-07 0.6428252659334456 8.098635520519211e-07 0.6463216644290061 8.098637693407936e-07 0.6500784077528632 8.098639440567036e-07 0.6530842133917786 \
8.098641303213334e-07 0.6562672470877895 8.098643090603859e-07 0.6593113758161715 8.098644717643992e-07 0.6620700940033843 8.098646370334099e-07 0.6648583661366954 \
8.098647803012238e-07 0.6672607123132118 8.098649195316479e-07 0.669583864918244 8.098650593322145e-07 0.6719085596965743 8.098651941074222e-07 0.6741424479378803 \
8.098653216016632e-07 0.6762463034350935 8.098654545557746e-07 0.6784344250006583 8.098655761601248e-07 0.680430207161383 8.098657045733663e-07 0.6825336955632141 \
8.098658203404208e-07 0.6844241240890321 8.098659183815936e-07 0.686020684362688 8.098660190776997e-07 0.687656981754083 8.098661288314626e-07 0.689434454762776 \
8.098662455994178e-07 0.6913211166705923 8.098663368261915e-07 0.6927889453402305 8.098664460316048e-07 0.6945396927028351 8.098665471403262e-07 0.6961566646470493 \
8.098666425406181e-07 0.6976767415743361 8.098667520226425e-07 0.6994136821864276 8.098668864742773e-07 0.7015344809028976 8.098670354932137e-07 0.7038694457768003 \
8.098671644232324e-07 0.7058755144243859 8.09867311083691e-07 0.7081418729260142 8.098674378680718e-07 0.7100885084081828 8.09867562465961e-07 0.7119899232102255 \
8.098676743197281e-07 0.7136874821928206 8.098677872756922e-07 0.7153928249203609 8.098678878290892e-07 0.716903336497302 8.098680251105923e-07 0.7189542886859326 \
8.098681449794518e-07 0.7207346491296758 8.09868264162204e-07 0.7224952472954583 8.098683911643136e-07 0.7243608783177121 8.098685157126648e-07 0.726179956024653 \
8.098686393836757e-07 0.7279757435764195 8.09868765971953e-07 0.7298035010246171 8.098688965411881e-07 0.7316777339938921 8.098690190562223e-07 0.7334262671520465 \
8.098691552997129e-07 0.7353588786631546 8.09869256742486e-07 0.7367901064855561 8.098693627659689e-07 0.7382789144707947 8.098694532971524e-07 0.7395446819117977 \
8.098695671233782e-07 0.7411267287627761 8.098696547849604e-07 0.742338113895605 8.098697606802376e-07 0.7437932991468792 8.098698910335325e-07 0.7455718205320391 \
8.098700016011402e-07 0.7470699275523445 8.098701062716114e-07 0.7484790865773925 8.098702302331429e-07 0.7501360792234356 8.098703787905969e-07 0.752105598322839 \
8.098705004731933e-07 0.7537054667443914 8.098706145848825e-07 0.7551949470168074 8.098707550054835e-07 0.7570132059451244 8.098708965335436e-07 0.7588296197226846 \
8.098710143228133e-07 0.7603289862386273 8.098711425226351e-07 0.7619481626911874 8.098712845904682e-07 0.7637269294216019 8.098714014655762e-07 0.7651780119234867 \
8.098715471393621e-07 0.7669714049983392 8.098716688778096e-07 0.7684572223066155 8.098717875183015e-07 0.7698939375992205 8.098719099845946e-07 0.7713653733660819 \
8.098720367016846e-07 0.7728756341192486 8.098721466036787e-07 0.7741754302862822 8.098722722190223e-07 0.7756497674172792 8.098723780294306e-07 0.7768823528242577 \
8.098725141995533e-07 0.7784559787239111 8.098726385466015e-07 0.7798807766277074 8.098727659718769e-07 0.7813271999647126 8.098728805279563e-07 0.7826155184370988 \
8.098729872082259e-07 0.7838050786084815 8.098731251508229e-07 0.785328674235108 8.098732746003193e-07 0.7869612315653352 8.098734194525364e-07 0.7885256944569791 \
8.098735388882871e-07 0.7898026796320731 8.0987367431316e-07 0.7912364721526877 8.098737958074809e-07 0.7925100718437531 8.098739391665555e-07 0.7939977458315933 \
8.09874082600237e-07 0.7954699260458764 8.098742084112467e-07 0.7967479640295563 8.098743274579285e-07 0.7979459892863545 8.098744394715731e-07 0.7990632136113104 \
8.098745442634543e-07 0.8000996927221937 8.098746394563032e-07 0.8010335634530776 8.098747758668286e-07 0.8023587211299719 8.098748926790048e-07 0.8034813603122919 \
8.098750121402484e-07 0.8046180202255495 8.098751341806002e-07 0.8057672874017472 8.098752570806968e-07 0.8069126780167393 8.098753842000532e-07 0.8080849010520604 \
8.098755093419151e-07 0.8092265787736463 8.098756398931421e-07 0.8104047139317369 8.09875765969389e-07 0.811530109085512 8.098758939660489e-07 0.8126603425876329 \
8.09875999427297e-07 0.8135823118114501 8.098761026965977e-07 0.814477091043954 8.098761953499457e-07 0.8152732203909091 8.098763190441811e-07 0.8163262937528154 \
8.098764066640956e-07 0.8170655553659417 8.098765053301514e-07 0.8178914289762149 8.098766488771538e-07 0.819080619224994 8.098767844633066e-07 0.8201904093102529 \
8.09876893653288e-07 0.8210742465492874 8.098770411027471e-07 0.8222539401850584 8.09877191506449e-07 0.8234410273756358 8.098773169754118e-07 0.8244188977545531 \
8.098774611413952e-07 0.8255287290252299 8.098775854299598e-07 0.8264738611628292 8.098777359002562e-07 0.8276038147969816 8.098778715066145e-07 0.8286089145501508 \
8.098779966016159e-07 0.8295251220930787 8.098781143174532e-07 0.8303776282987162 8.098782602030521e-07 0.8314210189912619 8.098784266961482e-07 0.8325942517713072 \
8.098785575628507e-07 0.833503494447128 8.098787310074616e-07 0.8346911703335461 8.098788991402021e-07 0.8358239212093587 8.098790689939496e-07 0.8369500705213252 \
8.098792498869552e-07 0.838129582835239 8.098793930212162e-07 0.8390486258646698 8.098795071191618e-07 0.8397723391454259 8.098796372463217e-07 0.8405879656882547 \
8.098797391021787e-07 0.8412191375388212 8.098798559475988e-07 0.8419354178465567 8.098799929193963e-07 0.84276453896487 8.098801907591422e-07 0.843942473808897 \
8.098803824446297e-07 0.8450620046306492 8.09880591850993e-07 0.8462610422160779 8.098807738618767e-07 0.8472832413425977 8.098809709773334e-07 0.8483697584184032 \
8.098811442904468e-07 0.8493077402131245 8.098813273256562e-07 0.8502809338042043 8.098814984787831e-07 0.8511747489972419 8.098816731317363e-07 0.8520708361396651 \
8.098818483828913e-07 0.8529540285731302 8.098820245303913e-07 0.8538259128238825 8.098822148367787e-07 0.8547503816925358 8.098824054277479e-07 0.8556583881771193 \
8.098826059797907e-07 0.8565949481971697 8.098827985825884e-07 0.8574764650234362 8.098830093312883e-07 0.8584213553684483 8.098832373621857e-07 0.8594210644592908 \
8.098835032419522e-07 0.8605573106989262 8.098838018200941e-07 0.8617960322792503 8.098840779837292e-07 0.8629075153790151 8.098843622302292e-07 0.8640180616030438 \
8.098846364142308e-07 0.8650581816846495 8.098849086694401e-07 0.8660616517296992 8.098851788589146e-07 0.8670295451208139 8.098854360232381e-07 0.8679256252637404 \
8.098857085969722e-07 0.8688492356117473 8.098859846024351e-07 0.8697577927663542 8.09886254710518e-07 0.8706213441784563 8.098865545689378e-07 0.8715508809746347 \
8.098869255828163e-07 0.8726599440782473 8.098872205155291e-07 0.873510245983525 8.098874748008954e-07 0.8742218447789023 8.098877730441707e-07 0.8750318897722944 \
8.098880466409288e-07 0.8757523113099853 8.098882827679075e-07 0.8763571312809064 8.098885231072054e-07 0.876957042728428 8.098887454408612e-07 0.8774982514557473 \
8.098889394467937e-07 0.8779599514934209 8.098892691652286e-07 0.8787226653583874 8.098894243380191e-07 0.8790722725343518 8.098897420714095e-07 0.8797700114458387 \
8.098899209390604e-07 0.880152324917399 8.098902634005339e-07 0.8808637455080008 8.098904475523682e-07 0.8812353200296749 8.098909224784184e-07 0.8821594045029107 \
8.098910898716537e-07 0.8824737723885729 8.098915556929604e-07 0.8833186808430151 8.098917365204472e-07 0.883635209600208 8.098922305497856e-07 0.8844687288968743 \
8.098923718877728e-07 0.8846990198924604 8.098929782491027e-07 0.8856473543416146 8.098931303209551e-07 0.8858754372639542 8.098937770089477e-07 0.8868048391838264 \
8.09893905303109e-07 0.8869818633102416 8.098945534965822e-07 0.8878410756373726 8.098946832451334e-07 0.8880061989117775 8.09895451498601e-07 0.8889361126992519 \
8.098955812406254e-07 0.8890847997417872 8.098964346975575e-07 0.8900046759307325 8.098965779246734e-07 0.8901495209380393 8.098975641580769e-07 0.8910738355210844 \
8.09897785636141e-07 0.8912643084423501 8.098989286536885e-07 0.8921737958641509 8.098990586319893e-07 0.8922730011388891 8.099004103389882e-07 0.8932565980587214 \
8.099005606923423e-07 0.8933589605607284 8.099020413157679e-07 0.8942730372387374 8.099022802190699e-07 0.8944047337041336 8.099040613442277e-07 0.8952702388217941 \
8.099044473255946e-07 0.8954343910560414 8.099068488716345e-07 0.896309305076933 8.099073238084202e-07 0.8964562995603377 8.099111419701395e-07 0.8973944547681553 \
8.099116244593364e-07 0.897487269196476 8.099195104748493e-07 0.898471373493449 8.099201266375397e-07 0.8985180228791175 8.100152826123788e-07 0.899508178894561 \
8.100167732145567e-07 0.8995204306067698 8.101280612887406e-07 0.9005118233983579 8.101282376257435e-07 0.9005706457326812 8.10131860757067e-07 0.8996048713171836 \
8.101320419550936e-07 0.8994654179496379 8.101333530765704e-07 0.8985275682722235 8.101335349539761e-07 0.8984123497545736 8.101353579441702e-07 0.8974436520388238 \
8.101355178574244e-07 0.8973766233009967 8.10148668688723e-07 0.8983720910457982 8.101487796702764e-07 0.8983905835035384 8.101576012543832e-07 0.8993863063850064 \
8.101581480238466e-07 0.8994226481040219 8.106507199766804e-07 0.9003987622903815 8.106507897691656e-07 0.9004496773542636 8.106516224219291e-07 0.9012853800543292 \
8.10651748468094e-07 0.9014513953152168 8.106523289889574e-07 0.9023435091985418 8.106524699532118e-07 0.9025895326188698 8.106528690912907e-07 0.9033428289365844 \
8.106530192408315e-07 0.9036449200440446 8.106534623221535e-07 0.9045762589490434 8.106536194942561e-07 0.9049121924877023 8.106540651209874e-07 0.9058152254958243 \
8.106541635773263e-07 0.9059929146639856 8.106555802587203e-07 0.9052304871087643 8.10655711415865e-07 0.904616184869324 8.10655880423041e-07 0.9036290332250884 \
8.106560457149166e-07 0.9024406226812831 8.106561519806978e-07 0.9015554774641358 8.106562554175281e-07 0.9006052096506509 8.106563411842469e-07 0.8997486040545581 \
8.106564306782332e-07 0.8987887485205278 8.106565549226324e-07 0.8973492764100613 8.106566730035805e-07 0.8958624931586439 8.10656760219672e-07 0.8946938835082598 \
8.10656884526716e-07 0.8929289312882503 8.106569915106438e-07 0.8913158670103165 8.106570913423478e-07 0.8897378501708729 8.106572176331741e-07 0.8876466417139378 \
8.106573858217852e-07 0.884705368138502 8.10657541521538e-07 0.8818365157686672 8.106577381263672e-07 0.8780362649814708 8.106579217476166e-07 0.8743271923380105 \
8.106581332550105e-07 0.8698916163736473 8.106583140648106e-07 0.8659808238081558 8.106584986458582e-07 0.8618945354625286 8.106586716498537e-07 0.8579913311618118 \
8.106588570505038e-07 0.8537436868396935 8.106590361336512e-07 0.8495884889292737 8.106592197227131e-07 0.8452850234109005 8.106593864844182e-07 0.8413449312544377 \
8.10659554574996e-07 0.8373487193315756 8.106597176841669e-07 0.8334514816705533 8.106598728704026e-07 0.829729402178684 8.10660045969282e-07 0.8255639501984255 \
8.106602319597376e-07 0.8210763864673301 8.106603965802215e-07 0.8170961425007568 8.106605614501323e-07 0.8131038678717658 8.106607367821644e-07 0.8088537582860886 \
8.106609012086681e-07 0.8048648186953292 8.106610698442787e-07 0.8007719922541914 8.106612606476452e-07 0.7961398815555145 8.106614461718183e-07 0.7916360074082958 \
8.106616551006281e-07 0.7865651471012967 8.106618799176179e-07 0.7811107659751856 8.106620697327054e-07 0.77650678233121 8.106622715901883e-07 0.7716133355283564 \
8.106624158608268e-07 0.76811790639139 8.106625575043926e-07 0.7646880872338248 8.106626852021021e-07 0.7615975116975136 8.106627962479434e-07 0.7589113686396982 \
8.106629248105796e-07 0.7558028559024855 8.106630573760869e-07 0.7525995467138866 8.106631706977831e-07 0.7498629233610832 8.106633070324095e-07 0.7465723252212872 \
8.106634134316607e-07 0.7440058350410135 8.106635726504468e-07 0.7401674766516904 8.10663745028142e-07 0.7360137588823189 8.106639072753859e-07 0.7321074183421575 \
8.106640796243437e-07 0.7279612819449855 8.10664239010527e-07 0.7241302920521341 8.106644468157138e-07 0.7191408067115369 8.106646073553789e-07 0.7152908836069264 \
8.106647998447152e-07 0.7106793324906435 8.10664985361064e-07 0.7062404417184839 8.106651552371092e-07 0.7021802791355866 8.106653471069472e-07 0.6975984806629684 \
8.106654933309622e-07 0.6941099299715526 8.106656536173094e-07 0.6902897983225644 8.10665856006145e-07 0.6854719661536142 8.106660372946089e-07 0.681161582477689 \
8.106662061160356e-07 0.6771536053116509 8.106663919619108e-07 0.6727470762459599 8.106665978927511e-07 0.6678715161770782 8.10666765819558e-07 0.6639016226084196 \
8.106669260812615e-07 0.6601182542089066 8.106671649337354e-07 0.65448589698252 8.106673326948486e-07 0.6505369020837752 8.10667513768288e-07 0.6462813620835641 \
8.106676749231988e-07 0.642499550819208 8.106678211904597e-07 0.6390715923276049 8.106679598785689e-07 0.6358268652274862 8.106680892356148e-07 0.6328040340451749 \
8.106682186201701e-07 0.6297855584526113 8.106683469414899e-07 0.6267952385336898 8.106684771436295e-07 0.6237652412672913 8.106686061600735e-07 0.6207683673242944 \
8.106687447356331e-07 0.6175525629501428 8.106688928112201e-07 0.6141227553162802 8.106690791385052e-07 0.60981438109949 8.106692268222044e-07 0.6064079319686639 \
8.106694619864099e-07 0.600995965122186 8.106696544341406e-07 0.5965821560879089 8.106698950039548e-07 0.5910808370261941 8.106700640513256e-07 0.587228367631822 \
8.1067020171775e-07 0.5840969866928536 8.106703298227265e-07 0.581191110277254 8.10670443409422e-07 0.5786182870235701 8.106705347742257e-07 0.5765512826027382 \
8.106706241961132e-07 0.5745328691003393 8.106706914578463e-07 0.573016830490748 8.106707574780489e-07 0.5715297341779608 8.106708095317241e-07 0.5703577032508095 \
8.106708737705931e-07 0.5689124506700958 8.106709353071159e-07 0.5675311492520995 8.106709995886598e-07 0.5660899724818867 8.106710527797555e-07 0.5648985048860162 \
8.106711451255398e-07 0.5628316153148989 8.106712217014408e-07 0.5611191615154557 8.10671277545091e-07 0.5598732849310241 8.106713468881998e-07 0.5583285932816697 \
8.106714527394756e-07 0.5559733466166974 8.106715304312799e-07 0.5542469170533902 8.106716310298676e-07 0.5520159549745236 8.106717590630782e-07 0.5491849411292137 \
8.106718585604598e-07 0.5469885705929382 8.106719711258113e-07 0.544508366501287 8.106720741701315e-07 0.5422442603473754 8.106721942190172e-07 0.5396115972585003 \
8.106722958334261e-07 0.5373863339265779 8.10672411457693e-07 0.5348611538529422 8.106725265738741e-07 0.5323536236546169 8.106726530109181e-07 0.529604142030661 \
8.106727785251858e-07 0.5268822104345234 8.106729252048618e-07 0.5237112381511962 8.106730608755697e-07 0.5207845659358002 8.106732186414087e-07 0.5173942078023266 \
8.106733810633494e-07 0.5139116507621072 8.106735619718178e-07 0.5100482739823553 8.106737545639721e-07 0.5059503908118104 8.106739675557428e-07 0.5014368974673542 \
8.106741999884594e-07 0.4965308659362653 8.106744575093731e-07 0.49112491222925 8.106746974735513e-07 0.4861095397820235 8.106749986779056e-07 0.4798501326413723 \
8.106752869755341e-07 0.4738957353990632 8.106756000618611e-07 0.4674739717793394 8.106759195881406e-07 0.4609631488871989 8.106762590854062e-07 0.4540919149088484 \
8.106765852755183e-07 0.4475353831519197 8.106769217567802e-07 0.4408159131180407 8.106772384675873e-07 0.4345373385230166 8.106775725526604e-07 0.4279587671099637 \
8.106779242615287e-07 0.4210864038135054 8.106782387463783e-07 0.4149846225409808 8.106785621928357e-07 0.4087533091618546 8.106790031209485e-07 0.400331870031168 \
8.106793449160247e-07 0.3938679283557566 8.106796443500685e-07 0.3882534014213259 8.10680018872672e-07 0.3812944595528024 8.106803482503896e-07 0.375233915169682 \
8.10680631354694e-07 0.3700684563936956 8.106809310997049e-07 0.3646408765157301 8.106812105955488e-07 0.3596219010422631 8.10681434267487e-07 0.3556377385586224 \
8.106816459791946e-07 0.3518907610576284 8.106818484819267e-07 0.3483292724130969 8.10682049543475e-07 0.3448190020587957 8.106822552213836e-07 0.3412518188287665 \
8.106824735968597e-07 0.3374887625241871 8.106827173592565e-07 0.3333167726275162 8.106829441158293e-07 0.3294678078423895 8.106831640268007e-07 0.3257615367192951 \
8.106833824514083e-07 0.3221060038181086 8.106835864764178e-07 0.318715141566024 8.106837883342075e-07 0.3153870758963987 8.106839886575955e-07 0.3121102802474151 \
8.10684175271502e-07 0.309079115007194 8.106843725731086e-07 0.3058982938882217 8.10684581156335e-07 0.3025606704206737 8.106847867910569e-07 0.2992974534031506 \
8.106850115231367e-07 0.2957609785165763 8.106852284189794e-07 0.2923771984023277 8.106854360983307e-07 0.2891642611511841 8.106856671491776e-07 0.2856239464683982 \
8.10685841949429e-07 0.2829684481899911 8.10686021147604e-07 0.2802647299798244 8.106861900221201e-07 0.2777348429135014 8.106864183453933e-07 0.274348458173166 \
8.106865950826614e-07 0.2717528218126659 8.106867633653918e-07 0.2693020894036587 8.106869358321621e-07 0.2668230333489093 8.106870699344411e-07 0.264903804409765 \
8.10687215894446e-07 0.2628277003548514 8.106873545899465e-07 0.2608803500812688 8.106874768715512e-07 0.2591684246570544 8.106876109903814e-07 0.2572942758553639 \
8.106877400914858e-07 0.2554978336754472 8.106878595252204e-07 0.2538430842138498 8.106879863604196e-07 0.2520939183506197 8.106881060014414e-07 0.2504447954274527 \
8.106882556176352e-07 0.2483797066042054 8.106883904811462e-07 0.2465170278296022 8.106885200385601e-07 0.2447289494531232 8.106886771033789e-07 0.2425624627506451 \
8.106888010990138e-07 0.2408491463446025 8.106889412471491e-07 0.2389135279283614 8.106890711400503e-07 0.2371200701944942 8.106891917576704e-07 0.2354534357320198 \
8.106893542306008e-07 0.2332087289724075 8.106895002846996e-07 0.2311905595759856 8.106896386054838e-07 0.2292825126447264 8.106897465327019e-07 0.2277949627009887 \
8.106898773176092e-07 0.225993474229161 8.106899758236256e-07 0.22463752857886 8.106900799069717e-07 0.2232056532573264 8.106901527838363e-07 0.2222046546567725 \
8.10690234937313e-07 0.2210804129356655 8.106903023463979e-07 0.2201585377209549 8.106903490506606e-07 0.2195201149856669 8.106903984680202e-07 0.2188449488487562 \
8.10690489422163e-07 0.2176035744446363 8.10690555816576e-07 0.2166983392055156 8.106906027798693e-07 0.2160586379972232 8.106906530910749e-07 0.2153737902794619 \
8.106907122404248e-07 0.2145693142997165 8.106907550863284e-07 0.2139870779821451 8.10690798893629e-07 0.2133941263688522 8.106908684238941e-07 0.2124566309962414 \
8.106909553407081e-07 0.2112864027023158 8.106910365295633e-07 0.2101949018929156 8.106911224290263e-07 0.2090416531541652 8.106912165752074e-07 0.2077796428137634 \
8.10691308329081e-07 0.2065517647617813 8.106914036255171e-07 0.2052788208685862 8.106915001042082e-07 0.2039945431316728 8.106916009294901e-07 0.2026602783061639 \
8.106916968855022e-07 0.2013924147365721 8.10691799571213e-07 0.2000377255165624 8.106919026075664e-07 0.1986831378210229 8.10692012697906e-07 0.1972405340748948 \
8.106921214497938e-07 0.1958206085628783 8.106922411717489e-07 0.1942631948714586 8.106923516146512e-07 0.1928328887741874 8.106924596174587e-07 0.1914411844406488 \
8.10692584973803e-07 0.1898318066870429 8.106926779079788e-07 0.1886434908940876 8.106927562787551e-07 0.1876443873000938 8.10692832918829e-07 0.1866698667869858 \
8.106929154301432e-07 0.1856249297118943 8.106929849397592e-07 0.1847473639743596 8.106930508953872e-07 0.1839166514106665 8.106931151627221e-07 0.1831089953192083 \
8.106932271462069e-07 0.1817072258029639 8.106933212001736e-07 0.1805353135896268 8.106934288419354e-07 0.1791985758407087 8.106935353149934e-07 0.1778827552324552 \
8.106936553069198e-07 0.1764073736674057 8.106937933595455e-07 0.174720142305475 8.106939095201004e-07 0.1733081217455876 8.106940716169029e-07 0.1713503924599185 \
8.106941867054195e-07 0.1699688234017716 8.106943266910192e-07 0.1682987764548305 8.106944438970947e-07 0.1669083002780509 8.106945548164474e-07 0.1655990025649634 \
8.106946524449328e-07 0.1644521190704843 8.106947472954812e-07 0.1633427224865242 8.106948633498935e-07 0.161991523106341 8.106949548984438e-07 0.1609305136382055 \
8.106950510074198e-07 0.1598214181625073 8.106951452255533e-07 0.1587403933520305 8.106952387261563e-07 0.1576732160104884 8.106953323234782e-07 0.1566104070550305 \
8.106954280050165e-07 0.1555300824433628 8.106955185929211e-07 0.1545132165873678 8.106956096060781e-07 0.1534969984004868 8.106957051545556e-07 0.1524358767948732 \
8.106957958202681e-07 0.1514342506187442 8.106958988926307e-07 0.1503020548964867 8.106959713440796e-07 0.1495100717445464 8.106960504448726e-07 0.148649146151682 \
8.106961249930914e-07 0.1478424742503694 8.106961960245005e-07 0.1470770917224498 8.106962687889816e-07 0.1462962409077327 8.106963434061566e-07 0.1454990959398698 \
8.106964133891184e-07 0.1447543557055888 8.106964875500381e-07 0.143968261688537 8.106965412953772e-07 0.1434005634796054 8.106965945789318e-07 0.1428396203849428 \
8.106966597746903e-07 0.1421555039833398 8.106967310807313e-07 0.141411576573238 8.106967954507931e-07 0.1407432786314442 8.106968688027537e-07 0.1399847409254479 \
8.106969294203206e-07 0.1393607073002494 8.106970154538046e-07 0.1384787080092832 8.106970914048206e-07 0.1377037134581418 8.106971813727262e-07 0.1367902106004182 \
8.106972630996835e-07 0.1359645165492482 8.106973457896614e-07 0.1351360437760365 8.106974283459692e-07 0.1343145513298757 8.106975339081246e-07 0.1332698421778018 \
8.106976157754081e-07 0.1324642397250402 8.106977131428679e-07 0.1315110876582503 8.106978031437286e-07 0.130634908321232 8.106978911139876e-07 0.1297829978838479 \
8.106979740438426e-07 0.1289892226181523 8.106980482809344e-07 0.1282822873521282 8.106981479319927e-07 0.1273377645104763 8.106982436870517e-07 0.1264350619688987 \
8.106983305344566e-07 0.1256206895242312 8.106984205359939e-07 0.1247808744623497 8.106985008686744e-07 0.1240346855852102 8.10698587562703e-07 0.1232365419604467 \
8.106986863930319e-07 0.1223331159004786 8.106987764751697e-07 0.1215131568528167 8.106988867184272e-07 0.1205141992263624 8.106989739498661e-07 0.1197275966302077 \
8.106990425230003e-07 0.1191120727131645 8.106991271853926e-07 0.1183553887582162 8.106991936928736e-07 0.1177634990399222 8.106992651487992e-07 0.1171309945267847 \
8.10699334822604e-07 0.1165184920865242 8.106994121596921e-07 0.1158409171037389 8.106995079029744e-07 0.1150054407698888 8.106995791578869e-07 0.1143861389207103 \
8.106996465274203e-07 0.1138025718558601 8.106997149641909e-07 0.113211685696446 8.106997905545423e-07 0.1125613765304429 8.106998812963886e-07 0.1117840233035959 \
8.106999640001163e-07 0.1110788257213999 8.107000775991873e-07 0.1101151050704521 8.107001874748991e-07 0.1091895325357105 8.107002796742132e-07 0.1084169374841771 \
8.107004036235445e-07 0.1073835127717347 8.107004919878671e-07 0.1066505015902263 8.107006314468373e-07 0.1055001025916527 8.107007307435381e-07 0.1046863788921388 \
8.107008233935897e-07 0.1039306459201802 8.10700933598102e-07 0.1030359883605075 8.107010188925421e-07 0.1023467905686673 8.107011037933451e-07 0.101663637589173 \
8.107011867443086e-07 0.1009989740617136 8.107013092542103e-07 0.1000225794851696 8.107014311960625e-07 0.09905761200121259 8.10701557818349e-07 0.09806258992746317 \
8.107016706304718e-07 0.09718220909187772 8.107018152059563e-07 0.09606278874246346 8.107019529198845e-07 0.09500564015228773 8.107020696106742e-07 0.09411672853020667 \
8.107021973542416e-07 0.0931507147971556 8.107022970187578e-07 0.09240236948627445 8.107023764526374e-07 0.09180921593916676 8.107024751879353e-07 0.09107599640376031 \
8.10702553063239e-07 0.09050081472416407 8.107026345291548e-07 0.08990210528957472 8.107027092464628e-07 0.0893557072655629 8.107027897762005e-07 0.08876971652456604 \
8.107029086085259e-07 0.08791061481419053 8.107029982690621e-07 0.08726673116015753 8.107031031831091e-07 0.08651800316437093 8.107032346576667e-07 0.08558693768262025 \
8.107033957658019e-07 0.08445695903909305 8.107035359474972e-07 0.08348350561263763 8.107036844501031e-07 0.08246223579158835 8.10703821170292e-07 0.08153124812726546 \
8.107039611820024e-07 0.08058696725890066 8.10704098179202e-07 0.07967195061625794 8.107042367898133e-07 0.07875532825288725 8.107043812626999e-07 0.07780967510081127 \
8.107045288089374e-07 0.07685421131041187 8.107046863126477e-07 0.07584560580436887 8.107048507078841e-07 0.07480523464991846 8.107050187999819e-07 0.07375451744755303 \
8.10705199799341e-07 0.07263751640721161 8.107053985126234e-07 0.07142823309373261 8.10705611921415e-07 0.07014922396308329 8.107058380853001e-07 0.06881630383186611 \
8.107060786456225e-07 0.06742468841361035 8.107063562065354e-07 0.06585179211508728 8.107066534109385e-07 0.06420523370201831 8.107069717116617e-07 0.06248365192299224 \
8.107073616959619e-07 0.06043183534616462 8.107077605227481e-07 0.05839861031494715 8.107082029946869e-07 0.05621846258761681 8.107085879755897e-07 0.05438828987170503 \
8.107090000221824e-07 0.05249218901100536 8.10709351759698e-07 0.05092353490091287 8.107096872643497e-07 0.04946969867921969 8.107099977632445e-07 0.04816021644386199 \
8.107102917000642e-07 0.04695194805701195 8.107105844309968e-07 0.04577883625507727 8.107108592742044e-07 0.04470700909733757 8.107111331179271e-07 0.04366353526031765 \
8.107113988076876e-07 0.04267398813878486 8.107116741167033e-07 0.04167180388267511 8.107119586736206e-07 0.04066026046469497 8.107122549717362e-07 0.03963283340811159 \
8.107125138471216e-07 0.03875659098599576 8.107127418035275e-07 0.03800131046948733 8.107129605287219e-07 0.03729095380188759 8.107131803834488e-07 0.03659437723507575 \
8.107135212495136e-07 0.03554043311314246 8.107137972903942e-07 0.03470953269536187 8.107140907211691e-07 0.03384790442147732 8.107143732890922e-07 0.03303898052111545 \
8.107146281985287e-07 0.03232625790162248 8.107149088829883e-07 0.03155947796597136 8.107151547163818e-07 0.03090318379665042 8.107153868776701e-07 0.03029616297556957 \
8.107156272150079e-07 0.02968398395812225 8.107158628518431e-07 0.02909722707395018 8.107160910630208e-07 0.0285403787496557 8.107165078357495e-07 0.02755138287878544 \
8.107167023611269e-07 0.02710176794309662 8.107170886015322e-07 0.02623051698020805 8.10717267770925e-07 0.0258356865503758 8.107176189981086e-07 0.02507792837274256 \
8.107177869041566e-07 0.0247229612172224 8.107181711668122e-07 0.02392944198669211 8.107182864485406e-07 0.02369675911063252 8.107187284963782e-07 0.02282172072611499 \
8.107189503116516e-07 0.02239223679446916 8.107194739313108e-07 0.02139838041889957 8.107196292938196e-07 0.02110714647916685 8.107201469998876e-07 0.02015295207761772 \
8.10720272033152e-07 0.01992792118872039 8.10720796234659e-07 0.01901759738223179 8.107209324540342e-07 0.01879045572456909 8.107215387304897e-07 0.01783210191617334 \
8.10721705739623e-07 0.01758082406519646 8.107223489472666e-07 0.01666064795441237 8.107225280915353e-07 0.0164167113061686 8.107232182502689e-07 0.01551958953683085 \
8.107233818701531e-07 0.01531511209162885 8.107241423508398e-07 0.01440332854054019 8.107242893929629e-07 0.01423371673427115 8.107251072646214e-07 0.01333087949608782 \
8.107252268131342e-07 0.01320411419549955 8.107261426746556e-07 0.01227329163592313 8.107262840275722e-07 0.01213544173166964 8.107272325031483e-07 0.01124488043697059 \
8.107273911425862e-07 0.01110230805801717 8.1072857354363e-07 0.01011356759191894 8.107286716440201e-07 0.01003725601038859 8.107299332554799e-07 0.009120360285939955 \
8.107300676693303e-07 0.009028655389366201 8.107316082406548e-07 0.008043892937307966 8.107316892739986e-07 0.007992925041580451 8.107332778679313e-07 0.007023242357651564 \
8.10733410759078e-07 0.006948518507451114 8.107353874624202e-07 0.005952856104192286 8.107355692005682e-07 0.005869662958407677 8.107376715542283e-07 0.004980929874643355 \
8.107381123459968e-07 0.004810448874467742 8.107407675608551e-07 0.003892108290451164 8.107412441403943e-07 0.003745909362026665 8.107448822226149e-07 0.00279447349697209 \
8.107454077460605e-07 0.002678838783887205 8.107510138108453e-07 0.001700248310874221 8.107513248985468e-07 0.001653333728976835 8.107564592262457e-07 0.0006858192122199529 \
8.107566532060193e-07 0.0006440832883579712 8.134045769148618e-07 -0.0002037173203380238 8.13404741115283e-07 -0.0003889174928863678 8.134053144580912e-07 -0.001270938904608877 \
8.134053893922784e-07 -0.001411855863724778 8.134058499760551e-07 -0.002393592696522268 8.134059619168068e-07 -0.002660411672198376 8.134062151887948e-07 -0.003300974950034667 \
8.134063815720996e-07 -0.003745951779090856 8.134066765678695e-07 -0.004566571567208835 8.134067880554425e-07 -0.00488071790655901 8.134070674282164e-07 -0.005641221413069743 \
8.134071883865554e-07 -0.005938820066262044 8.134082823393884e-07 -0.005180465225493313 8.134084064716309e-07 -0.004410796826645887 8.134085308790491e-07 -0.003456122327429311 \
8.134086504354286e-07 -0.002364170815481491 8.134087485798049e-07 -0.001341064316055312 8.13408855004127e-07 -0.0001052154991983786 8.134089672399721e-07 0.001336046702817826 \
8.134091021958209e-07 0.003249882807978809 8.134092247823306e-07 0.005149402351921401 8.134094136442457e-07 0.008353592055059769 8.134095548265784e-07 0.01094873860302964 \
8.134097081879224e-07 0.01393943619118621 8.134098515614266e-07 0.01687898420971235 8.134100057528669e-07 0.02017576688295359 8.134101618928252e-07 0.02363796584892512 \
8.134103176188778e-07 0.02719811802828209 8.134104651125568e-07 0.03065407560139007 8.134106137843234e-07 0.03420778369279751 8.134107691144076e-07 0.03798436241030867 \
8.134109277402875e-07 0.04189786275883118 8.134110926734479e-07 0.0460171220807938 8.134112670963364e-07 0.05041857973200652 8.134114460857363e-07 0.05497510627343041 \
8.134116353855968e-07 0.05982852266675163 8.134118383936027e-07 0.06506368941101938 8.134120578706689e-07 0.07075025585284363 8.134122889353304e-07 0.07675903373893865 \
8.134125359956494e-07 0.08319974270080552 8.134128064206373e-07 0.0902619122132732 8.134130999843244e-07 0.09793335781011638 8.13413424033306e-07 0.1064001814721126 \
8.134137882548562e-07 0.1159066558703892 8.134141808063258e-07 0.1261372395632307 8.134146303042508e-07 0.1378252442462487 8.134151530964837e-07 0.1513754922073403 \
8.134157666942191e-07 0.1672157090591849 8.134164444550933e-07 0.184625848284817 8.134172327202124e-07 0.2047487967247964 8.134181155530715e-07 0.22712469896725 \
8.134189338390288e-07 0.2476994923478653 8.13419661268608e-07 0.2658503723959502 8.134203013816357e-07 0.2817009601644404 8.134208756853502e-07 0.2958213763442377 \
8.134214132513172e-07 0.3089396094373287 8.134219172487761e-07 0.3211464104224903 8.1342239337143e-07 0.3325930942309646 8.134228712594449e-07 0.3439912352478621 \
8.134233245925507e-07 0.3547121966731367 8.134237958852586e-07 0.3657614311162562 8.134242385610846e-07 0.3760518588326446 8.134247570598719e-07 0.3879885572071845 \
8.134252842219918e-07 0.3999987293386327 8.134256631316234e-07 0.4085537955782026 8.134261930471662e-07 0.4204060347738258 8.13426622963746e-07 0.429919877745455 \
8.134270766645208e-07 0.4398653393542544 8.134275433780367e-07 0.4500002271552926 8.134279810592672e-07 0.4594210430579985 8.134283890215308e-07 0.468120704286539 \
8.134287084545645e-07 0.4748816926501604 8.134290805898365e-07 0.4826992142337162 8.134293155719776e-07 0.4876010339127531 8.13429549178225e-07 0.4924491904621348 \
8.134297971906478e-07 0.4975647713404599 8.134300955920777e-07 0.5036796627825791 8.134303519484798e-07 0.5088948470128004 8.134305642417896e-07 0.5131878547336713 \
8.134307582598616e-07 0.5170959594548015 8.134309052463942e-07 0.5200432695146362 8.134310592244046e-07 0.523118600542271 8.134312771061537e-07 0.5274469616807909 \
8.134315302104802e-07 0.5324525256580425 8.134317400493245e-07 0.5365797337241586 8.134319515026335e-07 0.5407247601751553 8.134322337095337e-07 0.5462280430697679 \
8.134324632548168e-07 0.5506821559930507 8.134326791510236e-07 0.5548604062613707 8.134329613725408e-07 0.560308769190463 8.134332126802682e-07 0.5651538146135803 \
8.134335103411598e-07 0.5708625224168123 8.134337605680607e-07 0.5756519166658941 8.134340169315557e-07 0.5805516059354519 8.134342573415698e-07 0.585116682128892 \
8.134345155213861e-07 0.5900038400537884 8.134347391135916e-07 0.5942175703762435 8.134349776231628e-07 0.5986919452581434 8.134351852078614e-07 0.6025689278491061 \
8.134354017304866e-07 0.6065904171332736 8.134356510330918e-07 0.6111939272561876 8.134358561065347e-07 0.6149609706257601 8.134361073788606e-07 0.6195555361399968 \
8.134363106008859e-07 0.6232455818254186 8.134365074727913e-07 0.6267987644955494 8.134367007643072e-07 0.630267737067843 8.134369555427622e-07 0.6348113783570861 \
8.13437185753374e-07 0.638887973644319 8.134374031071848e-07 0.6427143472883045 8.134377015129075e-07 0.6479268061885751 8.134379169157571e-07 0.6516657345437264 \
8.134381181394756e-07 0.6551344108237934 8.134382930609834e-07 0.6581323437428509 8.134384581262539e-07 0.6609495238976936 8.134386275947745e-07 0.6638251431769452 \
8.134387797316125e-07 0.666392827642013 8.134389176422984e-07 0.6687037209181631 8.134390664784122e-07 0.6711867545200138 8.134391945930142e-07 0.6733159837320549 \
8.134393378158276e-07 0.6756849429836936 8.134394590900775e-07 0.6776819274526149 8.134395966887616e-07 0.6799401191146522 8.13439716069216e-07 0.6818929034138137 \
8.134398631769623e-07 0.6842914131385206 8.134399803786277e-07 0.6861933934268433 8.13440073884205e-07 0.6877071857403232 8.134401648738969e-07 0.6891752279197846 \
8.134402676159613e-07 0.6908280855439021 8.134403691335249e-07 0.6924555900607121 8.134404875166308e-07 0.6943444167618776 8.134405996372169e-07 0.6961264383846065 \
8.134407171927181e-07 0.6979868779962457 8.134409023430049e-07 0.7008959348649784 8.13441033535213e-07 0.7029413755586562 8.134411697037527e-07 0.7050491462541959 \
8.13441291222456e-07 0.7069171228306749 8.134414311454679e-07 0.7090538254196674 8.134415350881169e-07 0.7106315721465845 8.134416462491006e-07 0.712309798010818 \
8.134417505089649e-07 0.7138759052437967 8.134418801470564e-07 0.7158124745844324 8.134419770777692e-07 0.7172526339884565 8.134421160000041e-07 0.7193052800722975 \
8.134422355492926e-07 0.7210612846995991 8.134423551218654e-07 0.7228080613301419 8.134424808972429e-07 0.7246353354365959 8.134426076155856e-07 0.7264656873164689 \
8.134427296554369e-07 0.728218443613998 8.134428578038805e-07 0.7300486655261287 8.13442987872205e-07 0.7318956587421809 8.134431088632273e-07 0.7336041830685722 \
8.134432496338107e-07 0.7355801168346318 8.134433506033799e-07 0.7369898206659778 8.134434522042367e-07 0.7384020079314992 8.134435482245479e-07 0.7397310783624924 \
8.134436591374029e-07 0.7412570822736337 8.134437467850298e-07 0.7424563811251772 8.134438466394006e-07 0.7438154404043728 8.134439814045385e-07 0.7456370856934184 \
8.13444097699018e-07 0.747198032089633 8.13444201190815e-07 0.7485782798032956 8.134443254462628e-07 0.7502239458264747 8.134444703592029e-07 0.7521280942578691 \
8.134445883397714e-07 0.753666143975803 8.134447072708787e-07 0.7552056331692281 8.134448468504184e-07 0.7569980918234445 8.13444991202808e-07 0.7588357421297242 \
8.134451092636163e-07 0.7603265096672839 8.134452340853355e-07 0.7618908200857619 8.13445373916531e-07 0.7636286950759973 8.134454986794279e-07 0.7651662633748356 \
8.134456421928987e-07 0.7669199865864609 8.134457628783764e-07 0.7683824344671055 8.13445883722124e-07 0.7698356273746885 8.134460033670484e-07 0.7712633747646481 \
8.134461330746874e-07 0.7727989859455529 8.134462418184901e-07 0.7740766298596218 8.134463644662266e-07 0.7755070372682662 8.134464742429112e-07 0.7767778749889983 \
8.13446603267025e-07 0.7782599816788072 8.134467350433437e-07 0.7797610257751375 8.134468483559198e-07 0.7810403609326458 8.134469694418617e-07 0.7823954393038701 \
8.134470733144949e-07 0.7835479431998941 8.134472155975173e-07 0.785111775748914 8.134473638006658e-07 0.7867227488076519 8.134475226942011e-07 0.7884297907063792 \
8.134476428872233e-07 0.7897074707829422 8.134477924539297e-07 0.7912811323018302 8.134479165691467e-07 0.7925734175081853 8.134480422734438e-07 0.7938699048627912 \
8.134481452190109e-07 0.7949224966762399 8.134482595901654e-07 0.7960823495211882 8.134483720644089e-07 0.7972131756542409 8.134484623369833e-07 0.7981137961420948 \
8.134485516778793e-07 0.7989989930139054 8.134486769038166e-07 0.800229513878344 8.134487846751798e-07 0.8012785338618679 8.134489143429785e-07 0.8025281307685926 \
8.134490357222573e-07 0.8036855380110038 8.134491522780568e-07 0.8047859282369955 8.134492730834528e-07 0.80591497746663 8.134494057087579e-07 0.8071413435168892 \
8.134495275023783e-07 0.8082555056211007 8.13449654106103e-07 0.8094015704683005 8.134497797196214e-07 0.8105266036187198 8.13449899211046e-07 0.8115857443778658 \
8.134500374092988e-07 0.8127973981963581 8.134501469085475e-07 0.8137473213416323 8.134502310566626e-07 0.8144713378799666 8.134503518607202e-07 0.8155017394983226 \
8.134504473695571e-07 0.8163089346032877 8.134505836603602e-07 0.8174496006492775 8.13450726424414e-07 0.8186303638797883 8.13450860857535e-07 0.8197292014569521 \
8.13450970729519e-07 0.8206175763825388 8.134511146291367e-07 0.8217677661037901 8.134512679567201e-07 0.8229768690765377 8.134513958055741e-07 0.8239722812379519 \
8.134515362029047e-07 0.8250521595273246 8.134516621078439e-07 0.8260088941474263 8.134518167240101e-07 0.8271688948348412 8.134519490793395e-07 0.8281489842609937 \
8.134520753461681e-07 0.8290730392392056 8.134521930066954e-07 0.8299245984162376 8.134523414090921e-07 0.8309852945996649 8.134525086032604e-07 0.8321626230293395 \
8.134526413805716e-07 0.8330844501529713 8.134528142817686e-07 0.8342675727345584 8.134529826990627e-07 0.8354015168591284 8.134531521935362e-07 0.8365246342267009 \
8.134533336304179e-07 0.8377070668209077 8.134534761865592e-07 0.8386219603417975 8.134535900974499e-07 0.8393441765511721 8.134537209736586e-07 0.8401643924869071 \
8.134538225966329e-07 0.8407940582489307 8.134539390368715e-07 0.8415078269750864 8.134540743300576e-07 0.8423269142909066 8.134542715951592e-07 0.8435017451489455 \
8.134544621144827e-07 0.844614933042255 8.13454672039296e-07 0.8458175693076773 8.134548528178267e-07 0.8468334846981137 8.134550501858461e-07 0.8479221976595614 \
8.134552240443405e-07 0.8488638701886076 8.134554065585833e-07 0.8498353939890455 8.134555779026935e-07 0.8507314120859523 8.13455752248258e-07 0.8516272398309612 \
8.134559276512583e-07 0.8525125793730954 8.134561038964482e-07 0.8533864315694911 8.134562936653265e-07 0.8543099749208749 8.134564844233441e-07 0.8552205033559714 \
8.1345668621255e-07 0.8561646193034282 8.134568789161161e-07 0.8570482883232282 8.134570883567926e-07 0.8579892478796384 8.134573180985592e-07 0.8589986827500428 \
8.134575835675109e-07 0.8601360945383778 8.134578822138555e-07 0.8613786760148464 8.134581606012222e-07 0.8625023989005415 8.134584447911769e-07 0.8636161469557806 \
8.134587192857839e-07 0.8646608622318305 8.134589913772806e-07 0.8656672252055042 8.134592615937267e-07 0.8666387059277968 8.134595187619145e-07 0.8675381145236246 \
8.134597913209795e-07 0.8684653318325959 8.1346006734232e-07 0.8693777905953765 8.13460337484171e-07 0.8702455402709716 8.134606372319546e-07 0.8711796653984102 \
8.134610081058123e-07 0.872294745819888 8.134613030287966e-07 0.8731503023941 8.134615572848448e-07 0.8738665406311316 8.134618555155771e-07 0.8746822274488602 \
8.134621291339016e-07 0.8754080260278182 8.134623652695491e-07 0.8760175227551726 8.134626056214058e-07 0.876622281264788 8.134628279637853e-07 0.8771680781109068 \
8.134630219681285e-07 0.8776338860468618 8.134633516912074e-07 0.8784037109613512 8.1346350686397e-07 0.8787567114621292 8.134638246164967e-07 0.879461652496718 \
8.134640034818579e-07 0.8798480920375044 8.134643459433237e-07 0.8805675499479563 8.134645300848474e-07 0.8809434933546246 8.134650049902838e-07 0.8818790560183651 \
8.134651723847029e-07 0.8821975058309585 8.134656382161285e-07 0.8830540251881659 8.134658190409674e-07 0.8833751042472839 8.134663130743468e-07 0.8842212008576973 \
8.134664544170557e-07 0.884455124402366 8.13467060806836e-07 0.8854193259359495 8.134672128789829e-07 0.8856514227360587 8.134678595574705e-07 0.8865980751852495 \
8.134679878538246e-07 0.8867785329419297 8.13468635979926e-07 0.8876550049536978 8.134687657724472e-07 0.8878236738033012 8.134695440340946e-07 0.8887860366092379 \
8.134696590259732e-07 0.8889208282599539 8.134705147583919e-07 0.8898661633196656 8.134706600215368e-07 0.8900169066926564 8.13471645777722e-07 0.8909664261264102 \
8.134718668828627e-07 0.8911622482549515 8.134730119973067e-07 0.8921020388386462 8.134731432072641e-07 0.8922053928944147 8.134743308657994e-07 0.8931033243919096 \
8.134744844860915e-07 0.8932130731307282 8.13475894522803e-07 0.8941348173026452 8.13476117329622e-07 0.8942660193790342 8.134777980203303e-07 0.8951452796684343 \
8.134781256415096e-07 0.8952966652167414 8.134803555826309e-07 0.8961896554712738 8.134809084965923e-07 0.8963788593752812 8.134844767111233e-07 0.8973573335043913 \
8.134848002235382e-07 0.8974284307984646 8.134911566318258e-07 0.8984120886469452 8.134917055346726e-07 0.8984686671268907 8.13544207609024e-07 0.8994658645395698 \
8.135448506378865e-07 0.8994692460188505 8.137369893085194e-07 0.9004073346715066 8.137371907224907e-07 0.9004708280105613 8.137411505004317e-07 0.8995366825576255 \
8.137413345272296e-07 0.8993953949813248 8.137426511245044e-07 0.8984641879157507 8.137428231683587e-07 0.8983566564859006 8.137447195446537e-07 0.8973720929359315 \
8.137448932508418e-07 0.897304621671452 8.137574671778747e-07 0.8982933655523699 8.137575523681117e-07 0.8983081509245614 8.137658192411513e-07 0.8993078551592517 \
8.137662939605717e-07 0.8993433667976791 8.142597948700116e-07 0.9002974142054325 8.142599143497356e-07 0.9003767372269074 8.142608071727864e-07 0.9012336455299185 \
8.142609534294225e-07 0.901423267690772 8.142615483221008e-07 0.9023325668564308 8.142616832929175e-07 0.9025673929107925 8.142621879687069e-07 0.9035294259428087 \
8.142623205796079e-07 0.9038000271808221 8.142627212069726e-07 0.9046475051114249 8.142628655723707e-07 0.9049556543240072 8.142632886935802e-07 0.9058123566484279 \
8.142633841506385e-07 0.9059850892484415 8.142648087094547e-07 0.9052205906349737 8.142649337473087e-07 0.9046352442223391 8.14265060157898e-07 0.9039223775493039 \
8.142651628066418e-07 0.9032486771507763 8.142652900219319e-07 0.9022944222362175 8.142654088677579e-07 0.9012801950564071 8.14265506520237e-07 0.9003603330664713 \
8.142655885222584e-07 0.8995243596151602 8.142656681858213e-07 0.8986589236008835 8.142657789639895e-07 0.8973708307079206 8.142658801400036e-07 0.8961049472956977 \
8.142659630844751e-07 0.8950067229086057 8.142660715298924e-07 0.8934921260891034 8.1426617999385e-07 0.8918872687155874 8.14266275049989e-07 0.8904106867557802 \
8.142663959226416e-07 0.8884444419111864 8.14266516699262e-07 0.8863849482818795 8.142666297444326e-07 0.8843763393508186 8.142667329151816e-07 0.8824794505619851 \
8.142668185153381e-07 0.8808620855018965 8.14266892989399e-07 0.8794251273161163 8.142669873129417e-07 0.8775673968166831 8.142670757738576e-07 0.8757888800524039 \
8.142671548468695e-07 0.8741711975775893 8.142672488342247e-07 0.872216793437976 8.142673301795293e-07 0.8704993514258973 8.14267425093555e-07 0.8684673705816817 \
8.14267518136275e-07 0.8664480751909672 8.142676149220692e-07 0.8643215060814092 8.142677382174413e-07 0.8615778533848952 8.142678516644525e-07 0.859022019682563 \
8.142679775164912e-07 0.8561558571929792 8.142681008446355e-07 0.8533196845306243 8.142682300229265e-07 0.850323637950593 8.142683706197831e-07 0.8470370034914 \
8.142684793995045e-07 0.8444782910716596 8.142686144592575e-07 0.8412850455921466 8.142687241195659e-07 0.8386804253780991 8.142688532993453e-07 0.8356002443501571 \
8.142689794831749e-07 0.8325812421138936 8.142691065735304e-07 0.8295317031556502 8.142692355958039e-07 0.826427745883674 8.142693446760448e-07 0.8237985689995477 \
8.142694845267009e-07 0.8204223029647078 8.142696239548932e-07 0.8170507778356514 8.142697567085239e-07 0.8138366863616762 8.142698867771991e-07 0.8106848159989707 \
8.142700104726457e-07 0.8076853837479523 8.142701474270357e-07 0.8043627031572629 8.142702611388824e-07 0.8016030849198694 8.142703886159226e-07 0.7985086235398901 \
8.142704994169941e-07 0.7958187897651571 8.142706186034521e-07 0.7929254985494992 8.142707319825085e-07 0.7901733724735396 8.142708662929012e-07 0.7869138859547327 \
8.142709733871686e-07 0.7843152933129034 8.142710894043117e-07 0.7815009627552112 8.142712185952753e-07 0.778367508739124 8.142713162077106e-07 0.7760002683782802 \
8.142714217871509e-07 0.773440790716327 8.142715304693198e-07 0.7708069008430674 8.142716328855832e-07 0.7683258101021144 8.142717262792412e-07 0.7660641808432364 \
8.142718458350171e-07 0.7631702213567544 8.142719383073787e-07 0.7609327305817616 8.142720309454939e-07 0.7586922094322426 8.142721293703097e-07 0.7563124992069843 \
8.142722373479616e-07 0.7537030947613649 8.142723336164742e-07 0.7513778334636231 8.142724198728768e-07 0.7492952979736797 8.142725227366661e-07 0.7468128004450286 \
8.14272601580994e-07 0.744910856519283 8.142727023870358e-07 0.7424801602439853 8.142728369152764e-07 0.7392377693660663 8.142729741401358e-07 0.7359316755186537 \
8.142731176199872e-07 0.7324773442723981 8.142732660441767e-07 0.7289066083419234 8.142734093054718e-07 0.7254625447335662 8.142735493824513e-07 0.7220977259655398 \
8.142737058083174e-07 0.7183435968963056 8.142738302100673e-07 0.715360858370426 8.14273951271848e-07 0.7124600029613375 8.1427410478411e-07 0.7087850045121084 \
8.142742395660554e-07 0.7055614325718365 8.142743656650877e-07 0.7025479112911024 8.142745088393713e-07 0.6991289103945657 8.142746289211628e-07 0.6962626602560111 \
8.142747581554914e-07 0.6931807499479741 8.142748646405391e-07 0.6906432840523983 8.142749769163615e-07 0.6879696524977363 8.142750732516476e-07 0.6856773754336868 \
8.142751760613401e-07 0.683232326200841 8.14275270865193e-07 0.6809792012818872 8.14275376187123e-07 0.6784784437814733 8.142754846257769e-07 0.6759058899658261 \
8.142755836350576e-07 0.673558569590366 8.142757003916503e-07 0.6707929011939652 8.142758084769277e-07 0.6682347329991606 8.142759184831366e-07 0.6656332609774134 \
8.142760045709786e-07 0.6635992664604092 8.142761341661182e-07 0.6605400273835189 8.142762267673658e-07 0.6583552307294462 8.142763225550924e-07 0.6560965362104854 \
8.142764075070783e-07 0.6540950852804182 8.142765268016021e-07 0.6512869789851043 8.142766140715398e-07 0.6492343850333612 8.142767047785613e-07 0.6471030993779646 \
8.14276805943536e-07 0.6447280068361273 8.142768857743593e-07 0.6428551652550211 8.142769745601937e-07 0.6407732405330839 8.142770522504205e-07 0.6389536101386547 \
8.142771140193683e-07 0.6375081226244841 8.142771777840134e-07 0.6360167668935747 8.142772410182331e-07 0.634538653569437 8.142772802588059e-07 0.6336218002627473 \
8.142773208978281e-07 0.6326726453797233 8.142774009823624e-07 0.6308039353694699 8.142774708865426e-07 0.6291742390428672 8.142775215232567e-07 0.6279942052995945 \
8.142775602728994e-07 0.6270914175114127 8.142775992678787e-07 0.6261832343283663 8.142776438826266e-07 0.6251445623164014 8.142776867390832e-07 0.6241478292286105 \
8.142777370536866e-07 0.6229782634938205 8.142777889908641e-07 0.6217719122409077 8.142778740584486e-07 0.6197972300178722 8.142779340388659e-07 0.6184052992407258 \
8.142780238260749e-07 0.61632338076978 8.142781002901565e-07 0.6145529519516876 8.142781798544472e-07 0.6127119801362371 8.142782608910593e-07 0.6108383709630588 \
8.142783501053817e-07 0.6087775861620425 8.142784409653937e-07 0.6066826282541496 8.142785281841023e-07 0.6046739453334793 8.142786219572931e-07 0.6025158549334848 \
8.142787236427564e-07 0.6001788642681311 8.142788232408484e-07 0.5978941858483342 8.142789350958888e-07 0.5953317151711254 8.14279051129026e-07 0.5926772450523136 \
8.142791727501318e-07 0.5899020947998995 8.142792771339459e-07 0.5875236635596754 8.142794219241658e-07 0.5842296531729801 8.142795345841267e-07 0.5816734289694181 \
8.14279643596094e-07 0.5792035939892568 8.142797360755373e-07 0.5771100174076607 8.142798295261766e-07 0.5749994714793375 8.142799218520404e-07 0.5729181236728181 \
8.142799944387413e-07 0.571283073141143 8.142800503929671e-07 0.5700232888304386 8.142801114612484e-07 0.5686498830286455 8.142802099507645e-07 0.5664400707212188 \
8.142802731622084e-07 0.5650238531380825 8.142803335881769e-07 0.5636708824310654 8.142804105365601e-07 0.5619492451093103 8.142804736951014e-07 0.5605380106414651 \
8.142805620087098e-07 0.558569506627369 8.14280633210033e-07 0.5569845302974165 8.142807197457869e-07 0.555060151797141 8.142808410985601e-07 0.5523665438352664 \
8.142809690278082e-07 0.5495364947125975 8.142810671584392e-07 0.5473694328713704 8.142811802824346e-07 0.5448752016832871 8.14281282350254e-07 0.5426314425864434 \
8.142814012991245e-07 0.5400217272291628 8.142815043868321e-07 0.5377630705755105 8.142816185939865e-07 0.5352670017334624 8.142817320096582e-07 0.532794946211756 \
8.14281859080713e-07 0.5300302694710822 8.14281982900802e-07 0.5273426867079006 8.142821276896071e-07 0.5242103332418484 8.142822635131097e-07 0.5212782585303676 \
8.142824185679684e-07 0.5179428401013338 8.142825794198527e-07 0.5144913885072363 8.142827581493005e-07 0.5106699876709851 8.1428294832834e-07 0.5066200804011861 \
8.142831582303622e-07 0.5021665212646098 8.142833869363468e-07 0.4973332357952056 8.142836408642852e-07 0.4919960258408594 8.142838817977505e-07 0.4869529241725989 \
8.142841779602358e-07 0.4807889695952298 8.142844679576231e-07 0.4747910561470179 8.142847742009557e-07 0.4684976697011882 8.142850948768875e-07 0.4619520863481486 \
8.142854227440541e-07 0.4553041925245184 8.142857629891091e-07 0.4484521981997251 8.142860884146545e-07 0.4419418052309769 8.142864103218021e-07 0.4355465312739703 \
8.142867405359073e-07 0.4290298934287748 8.142870965284996e-07 0.4220583188787752 8.142874154069286e-07 0.4158579595363656 8.14287752858691e-07 0.4093433989943853 \
8.142881807254075e-07 0.4011531841887147 8.142885294373556e-07 0.3945419525178304 8.142888370733194e-07 0.388759214407489 8.142892168998105e-07 0.3816861832573664 \
8.142895480893721e-07 0.3755780492082042 8.142898316974524e-07 0.370391509977049 8.142901425163967e-07 0.3647512908748707 8.142904218330045e-07 0.3597258263082204 \
8.142906483291526e-07 0.3556836811642302 8.142908640115378e-07 0.3518598964090484 8.142910612955428e-07 0.3483842179544538 8.142912662800023e-07 0.3447988491770444 \
8.142914785019663e-07 0.3411119200457455 8.142917338071541e-07 0.33670771290924 8.142919753294026e-07 0.3325734463267218 8.142922067067309e-07 0.3286464933807047 \
8.142924215592308e-07 0.3250253651850565 8.142926421183882e-07 0.3213332986541765 8.142928435443551e-07 0.3179852906236645 8.142930466126061e-07 0.3146379646143546 \
8.142932445082156e-07 0.3114011111455273 8.142934314693022e-07 0.3083651674074345 8.142936252695217e-07 0.3052406640298299 8.142938291861338e-07 0.3019773030815858 \
8.142940082554677e-07 0.2991336297844484 8.14294243846324e-07 0.2954229173226265 8.142944446504233e-07 0.2922868215109002 8.142946458293146e-07 0.2891696385850206 \
8.142948696390573e-07 0.2857334090862961 8.142950342018032e-07 0.2832271910241367 8.142952111291889e-07 0.2805503385691353 8.14295396922194e-07 0.2777610713150803 \
8.142955787376702e-07 0.2750538970423583 8.142957577624632e-07 0.2724132377985424 8.142959251076164e-07 0.2699606650006489 8.142960855365336e-07 0.2676371805838822 \
8.142962081102854e-07 0.2658719571410424 8.142963578748139e-07 0.2637236906090554 8.142964855719403e-07 0.2619099339733745 8.14296592880312e-07 0.2603957336038235 \
8.142967088809744e-07 0.2587625259947361 8.142968191895705e-07 0.2572125806747212 8.14296945068767e-07 0.2554509781935611 8.142970605506182e-07 0.2538402638894013 \
8.142971951315211e-07 0.2519757335310172 8.142973071947753e-07 0.2504255755821768 8.142974575341346e-07 0.2483447107137444 8.142975971599893e-07 0.2464124269747185 \
8.142977430518096e-07 0.2444035064209518 8.142978760124476e-07 0.2425734862730615 8.14297999574161e-07 0.2408709992523319 8.142981467838532e-07 0.2388417729476062 \
8.142982633706824e-07 0.2372355665500016 8.142984028258316e-07 0.23532008003217 8.142985370003013e-07 0.2334768281602104 8.142986629767575e-07 0.2317465561243653 \
8.142987823761605e-07 0.2301094434087779 8.142988772305854e-07 0.2288105340759602 8.142989903681845e-07 0.2272617792622066 8.142990706846421e-07 0.2261626001158484 \
8.142991582496985e-07 0.2249657246820506 8.142992837868356e-07 0.2232507767215072 8.142993894805427e-07 0.2218101326756785 8.142994791350539e-07 0.2205921574607158 \
8.14299549986253e-07 0.2196300825522397 8.142995930147827e-07 0.2190460135436258 8.142996353053263e-07 0.2184724035808872 8.142996776470424e-07 0.2178984240735344 \
8.142997498424615e-07 0.2169203674089526 8.142997922358173e-07 0.2163464205126744 8.14299827490656e-07 0.2158693585303403 8.142998716822394e-07 0.2152716287340076 \
8.142999412904665e-07 0.2143309212991285 8.142999756337964e-07 0.2138672544767182 8.143000200933248e-07 0.2132698436071631 8.143000877718061e-07 0.2123628126304402 \
8.143001741990649e-07 0.2112058698236149 8.143002488356675e-07 0.2102078598594563 8.143003301376756e-07 0.2091219706754807 8.143004270150593e-07 0.2078300362310651 \
8.143005529985482e-07 0.2061528795789772 8.143006555333841e-07 0.2047906894256944 8.143007570169014e-07 0.2034500128132261 8.143008580825969e-07 0.202119416354989 \
8.143009546968166e-07 0.2008491615811921 8.143010566612396e-07 0.1995112314821507 8.143011633834835e-07 0.1981153840927639 8.143012717886237e-07 0.1967018790395962 \
8.143013837827796e-07 0.1952465002768531 8.14301496249907e-07 0.1937897263683151 8.143016083232463e-07 0.1923454332378671 8.143017162157206e-07 0.1909603537828802 \
8.143018175986493e-07 0.1896629368444172 8.143019092360985e-07 0.1884941330679491 8.143020032117072e-07 0.1872990757663449 8.143020744780721e-07 0.1863957871745983 \
8.1430215115336e-07 0.1854271890400033 8.143022548124749e-07 0.184122202819407 8.143023284795955e-07 0.1831974022686171 8.143024018254956e-07 0.1822796569444652 \
8.143025152158449e-07 0.1808667181969195 8.143026030744851e-07 0.1797760932362061 8.143026869231621e-07 0.1787387947787487 8.143028158855897e-07 0.1771515524267008 \
8.143029177720844e-07 0.1759040172436072 8.143030234727907e-07 0.1746156056808686 8.143031251208657e-07 0.1733818993219825 8.143032559825841e-07 0.1718019019596718 \
8.143033631792215e-07 0.1705140034701537 8.14303492508118e-07 0.168969083715685 8.143036042046102e-07 0.167642098072289 8.143037045351886e-07 0.1664555496840579 \
8.143038003357432e-07 0.1653276075899142 8.143039111480153e-07 0.1640289617085985 8.143039985482962e-07 0.1630090521997956 8.143041098694134e-07 0.1617156184952586 \
8.143042028212721e-07 0.1606409001560029 8.143042903941501e-07 0.1596330843918451 8.143043920250233e-07 0.1584700928658864 8.14304476479078e-07 0.1575086241734052 \
8.143045515834574e-07 0.1566573095634876 8.143046294056999e-07 0.1557789554714152 8.143047097635688e-07 0.1548759612316424 8.143048108183989e-07 0.1537464547857493 \
8.143048932519626e-07 0.1528311848879565 8.143049855565143e-07 0.1518114053368895 8.14305062490987e-07 0.150965812476358 8.143051454135576e-07 0.1500585909391909 \
8.143052169442981e-07 0.1492793026301012 8.143053133277974e-07 0.1482344968214558 8.143053835562832e-07 0.1474766665551334 8.143054665365612e-07 0.1465853655470201 \
8.143055279788245e-07 0.1459298106834085 8.143055996612093e-07 0.1451677491870439 8.14305668289752e-07 0.1444408762699853 8.143057185582615e-07 0.1439102090153988 \
8.143057661380673e-07 0.143409423336876 8.14305820187418e-07 0.1428423132663369 8.143058795295158e-07 0.1422216078256897 8.143059475649228e-07 0.1415124633834424 \
8.14306023828345e-07 0.1407207186008814 8.143060921081446e-07 0.1400161356079559 8.143061868943229e-07 0.1390460813732662 8.143062764481352e-07 0.1381341561933974 \
8.143063481336088e-07 0.1374075731330657 8.143064320850176e-07 0.1365606113096345 8.143064973974727e-07 0.1359045398875483 8.143065588405982e-07 0.1352895588344758 \
8.143066331170967e-07 0.1345490408254265 8.143066953273574e-07 0.1339328028964004 8.143067632983657e-07 0.133265236037424 8.143068225054055e-07 0.1326856657519672 \
8.143068951778785e-07 0.1319767402814105 8.143069701979877e-07 0.1312477270463112 8.143070556514106e-07 0.1304208267333309 8.143071417517503e-07 0.1295914604616623 \
8.143072418772051e-07 0.1286317929389105 8.143073231668748e-07 0.127857435971709 8.143074249342227e-07 0.1268981149578782 8.143075091821821e-07 0.1261072369695883 \
8.143076079989111e-07 0.1251836587365037 8.143076808394557e-07 0.1245055382686853 8.143077608655429e-07 0.1237631876254407 8.143078313513379e-07 0.1231117958237987 \
8.143079038817606e-07 0.1224439308288319 8.143079813507563e-07 0.1217331219782777 8.143080887021039e-07 0.1207554316575004 8.143081893401196e-07 0.1198442997624752 \
8.143082619276735e-07 0.1191899427853172 8.143083307595138e-07 0.1185715582611356 8.143083965463339e-07 0.1179824683205609 8.143084661751317e-07 0.1173610347366148 \
8.143085365588768e-07 0.1167350538439435 8.143086117372496e-07 0.1160688810594495 8.143087159914846e-07 0.1151493019715505 8.143087911261386e-07 0.114489769343061 \
8.143088600412231e-07 0.1138870655592168 8.143089232460945e-07 0.1133369146236164 8.143089927874598e-07 0.1127339156958381 8.14309050088964e-07 0.1122385190692166 \
8.14309121730019e-07 0.1116210355509516 8.143091795650924e-07 0.1111240709857579 8.143092516865272e-07 0.1105063809580559 8.1430931410261e-07 0.1099736279351742 \
8.143093984241316e-07 0.1092565349771765 8.143094660201e-07 0.1086842173446869 8.143095748160323e-07 0.1077671916889585 8.143096791265639e-07 0.1068924975608609 \
8.14309758614772e-07 0.1062289053282379 8.143098461831824e-07 0.1055008617114655 8.143099096395349e-07 0.1049752776433979 8.143099713506517e-07 0.10446579874651 \
8.14310075190416e-07 0.103612238268202 8.143101578711175e-07 0.1029362225408096 8.143102563391439e-07 0.1021348761715451 8.14310340785582e-07 0.101450818648051 \
8.143104572630618e-07 0.1005121841703865 8.143105919965077e-07 0.09943411943161744 8.143107280660444e-07 0.0983541971400249 8.143108423854515e-07 0.09745369041838402 \
8.143109278525961e-07 0.09678457778867394 8.143110381342688e-07 0.09592640631053104 8.143111189226222e-07 0.09530159220710262 8.143112184734933e-07 0.09453592511176086 \
8.143113084215428e-07 0.09384821103094763 8.14311380924943e-07 0.09329669945188329 8.143114626670093e-07 0.09267796846073476 8.143115907872446e-07 0.09171467366828615 \
8.143116721993079e-07 0.09110674702409056 8.143117466312152e-07 0.09055373306570065 8.143118216050992e-07 0.08999936228352182 8.143119010240744e-07 0.08941505746347288 \
8.143120096849317e-07 0.08862052380504259 8.143121040449035e-07 0.08793517800096999 8.143121934400264e-07 0.08728987318634121 8.143123002057425e-07 0.086524181682867 \
8.143124187081826e-07 0.08568073755029131 8.143125602332527e-07 0.08468224831562859 8.143126933716761e-07 0.08375174214918565 8.143128342170072e-07 0.08277682112810406 \
8.143129832689884e-07 0.08175525972387458 8.143131190667175e-07 0.08083369778093191 8.143132605232322e-07 0.0798830809748103 8.143133957831475e-07 0.07898330517332906 \
8.143135371649882e-07 0.07805242629322809 8.143136842327612e-07 0.07709434677344783 8.143138359609018e-07 0.07611680364043326 8.143140013092032e-07 0.07506403321855706 \
8.143141651767208e-07 0.07403332863189842 8.143143414906487e-07 0.07293832728335037 8.143145309257505e-07 0.07177777688466977 8.14314741692455e-07 0.07050569389938771 \
8.143149614649522e-07 0.06920150027616521 8.143151964331044e-07 0.06783224552442871 8.143154553336539e-07 0.06635227408830123 8.14315750264117e-07 0.06470266364809808 \
8.143160546101784e-07 0.06304001691994518 8.143164165564573e-07 0.06111393619706453 8.143167326842125e-07 0.05947639552636011 8.143171740066774e-07 0.0572596911373907 \
8.143174875727196e-07 0.05573556853365672 8.14317911072189e-07 0.0537382660685313 8.143182550240425e-07 0.05216649213267931 8.143185952653102e-07 0.05065508790922631 \
8.143189061028997e-07 0.04931137323461653 8.143192005748017e-07 0.04807062469528345 8.143194942742994e-07 0.04686392507224969 8.143197691455355e-07 0.04576537019482012 \
8.143200446857014e-07 0.04468949010490332 8.143203097762297e-07 0.04367785045825667 8.143205865333108e-07 0.04264571401740119 8.143208698014357e-07 0.04161414314527601 \
8.143211677947347e-07 0.04055545327485047 8.14321427280131e-07 0.03965542606183669 8.143216573035691e-07 0.03887446236327848 8.143218769951559e-07 0.03814321686473518 \
8.14322101935296e-07 0.0374128399305801 8.1432242218897e-07 0.0363978329183388 8.1432270998682e-07 0.03550963653148703 8.143229863821537e-07 0.03467738358988744 \
8.143232702012828e-07 0.03384352473043348 8.143235083105866e-07 0.03315996078327022 8.143237926213707e-07 0.03236211345273886 8.143240345332207e-07 0.03169864947531036 \
8.143242696733945e-07 0.03106710921041438 8.143245113809233e-07 0.03043352335444016 8.143247483338565e-07 0.02982731501219571 8.14324978676274e-07 0.02925002048968134 \
8.143251924268523e-07 0.02872465224286764 8.14325398273815e-07 0.02822791768061097 8.143257906108381e-07 0.02730524204782691 8.143259790028487e-07 0.02687312495148303 \
8.143263546143072e-07 0.02603163971789 8.143265290810819e-07 0.02564950258131362 8.143269530155409e-07 0.02474274850847508 8.14327073769958e-07 0.02449086781212801 \
8.143275440207214e-07 0.02353384026002922 8.143276932357865e-07 0.02323677291035493 8.143280868679981e-07 0.02246740853134286 8.143282578943424e-07 0.02213909006726131 \
8.143287451732745e-07 0.02121869533024997 8.143288872209831e-07 0.02095326544309953 8.143294202372519e-07 0.01997576278857772 8.143295424012889e-07 0.01975737097014436 \
8.143300645590335e-07 0.01885981776906158 8.143302351373363e-07 0.01857989792133653 8.143307224503993e-07 0.01781360777737795 8.143308939733227e-07 0.01755501440977742 \
8.143315137600803e-07 0.01666567753024489 8.14331684684406e-07 0.0164316648397145 8.143323902353963e-07 0.01551160061118263 8.14332552852409e-07 0.01530799450170666 \
8.143333097458993e-07 0.01439879525764199 8.143334506625442e-07 0.01423641007536438 8.143343506613841e-07 0.01324361033368418 8.143344380106346e-07 0.01315122959105692 \
8.14335342363989e-07 0.01223321097894121 8.143354795559379e-07 0.01209984223734439 8.14336450212214e-07 0.01118944790767422 8.14336578130092e-07 0.01107451071402888 \
8.143377285400387e-07 0.01011008206277823 8.143378223420746e-07 0.01003687265682024 8.143390783878875e-07 0.009120584045805383 8.143392159292007e-07 0.009026502753623255 \
8.143407746836019e-07 0.008029670037698805 8.143408584862873e-07 0.007977066150721189 8.143424638651058e-07 0.00699828665725172 8.143425747634501e-07 0.006935886594503895 \
8.143445070098237e-07 0.005959177461785255 8.143446867147595e-07 0.005876661013304485 8.14346798505876e-07 0.004981749118765498 8.143471412910116e-07 0.004848482978762325 \
8.143496544570453e-07 0.003966891390423618 8.143501241787149e-07 0.003819799497680527 8.143537644949897e-07 0.002847564273158896 8.143542802321751e-07 0.002731633924241866 \
8.143596220620139e-07 0.001773027297371861 8.143599073822989e-07 0.001729522787584184 8.143651360301289e-07 0.0007540451492352357 8.143653101766958e-07 0.0007162692714263865 \
8.170136987690021e-07 -0.0001123232525192561 8.170138717942903e-07 -0.0002901710972538241 8.170144915460445e-07 -0.001202022686018724 8.170145801152216e-07 -0.001365806793032466 \
8.170149410863549e-07 -0.002110727959526865 8.1701506578065e-07 -0.002395793696299351 8.170154296225313e-07 -0.003299857180474864 8.170156008981996e-07 -0.003758114451912169 \
8.170158948960376e-07 -0.004576312838821549 8.170160051044431e-07 -0.004886880824040592 8.170162833584409e-07 -0.005643955697619643 8.170164046322499e-07 -0.00594200199557267 \
8.170174982543479e-07 -0.00517389603226481 8.170176213582281e-07 -0.004409713243767066 8.170177448263028e-07 -0.003462788751204457 8.170178649920999e-07 -0.002366010162083454 \
8.170179628537676e-07 -0.001346276287748183 8.170180695561039e-07 -0.0001076498664581183 8.170181813974884e-07 0.001328007358939307 8.170183173718548e-07 0.003256083960376262 \
8.170184394010113e-07 0.00514709866632534 8.170186278172891e-07 0.008343062029134115 8.17018768805819e-07 0.01093380316938193 8.170189215775226e-07 0.01391176330477175 \
8.170190642801505e-07 0.01683596409946878 8.170192186323876e-07 0.02013443377634912 8.170193744260431e-07 0.02358734537610087 8.170195304833402e-07 0.02715365164079262 \
8.170196778877403e-07 0.03060642997674319 8.170198265044852e-07 0.03415780069914553 8.170199819257017e-07 0.03793559522944389 8.170201403115321e-07 0.04184227512730877 \
8.170203052511541e-07 0.04596085539464361 8.170204795004229e-07 0.05035714787605008 8.170206584435392e-07 0.05491177248689325 8.17020847583032e-07 0.0597604232635115 \
8.170210503636104e-07 0.06498910043066243 8.170212697356368e-07 0.07067233091134768 8.170215005721333e-07 0.07667464705993039 8.170217473839692e-07 0.0831083675499642 \
8.170220175160799e-07 0.09016243555275107 8.17022310704188e-07 0.0978236474935409 8.170226343596258e-07 0.1062798466079799 8.17022997926912e-07 0.1157689210849182 \
8.170233902204302e-07 0.1259925151671456 8.170238386999148e-07 0.1376538644086695 8.170243603994004e-07 0.1511757390224034 8.170249727720439e-07 0.1669844191341421 \
8.170256494173591e-07 0.1843663871188266 8.170264363276495e-07 0.2044554566749352 8.170273175487439e-07 0.2267919980918504 8.170281372923844e-07 0.2474048556006221 \
8.170288657453285e-07 0.2655829647002126 8.17029507221317e-07 0.2814688958417333 8.170300831444853e-07 0.2956305456066151 8.170306204013018e-07 0.3087428400511723 \
8.170311242925969e-07 0.3209487846516751 8.170316018961449e-07 0.3324328152479784 8.170320800193788e-07 0.343838772307344 8.170325321182285e-07 0.3545331600964184 \
8.170330038845194e-07 0.365596737404158 8.170334475813599e-07 0.3759140547845509 8.170339695498976e-07 0.3879344734281669 8.170344970878305e-07 0.399956933836353 \
8.170348766025743e-07 0.4085271910771138 8.170354055641745e-07 0.4203606102508351 8.170358748832553e-07 0.4307444005277802 8.170363100387911e-07 0.4402814026247405 \
8.170367575161174e-07 0.4500002273945978 8.170371975395924e-07 0.4594737646471725 8.170376008413354e-07 0.4680814138276727 8.170379192411012e-07 0.4748254127722248 \
8.170382892190148e-07 0.4826007100982719 8.170385254720969e-07 0.4875314737878706 8.170387605434931e-07 0.4924129045770672 8.170390118828311e-07 0.4975994385012801 \
8.170393182698654e-07 0.5038799449729535 8.170395752283189e-07 0.5091120301871851 8.170397837026154e-07 0.5133309170973237 8.170399840849047e-07 0.5173683849445317 \
8.170401264786059e-07 0.5202244049244739 8.170402754030717e-07 0.5231993726577677 8.170404869493287e-07 0.5274019882470222 8.170407130069516e-07 0.5318780389403845 \
8.170409075493335e-07 0.5357103559602913 8.170410966812289e-07 0.539423417888626 8.170413261282767e-07 0.5439012399750046 8.170415086340828e-07 0.5474563135343053 \
8.170417459969518e-07 0.5520623276458133 8.170420149912601e-07 0.5572695987004129 8.170422639017101e-07 0.5620706638085723 8.170425079185313e-07 0.5667633705755619 \
8.170427802737437e-07 0.5719926523718327 8.170430416698736e-07 0.5769928369418796 8.170432993012793e-07 0.5819084237686675 8.17043546144628e-07 0.586601202059797 \
8.170437918903539e-07 0.5912552023551558 8.170440184678743e-07 0.5955288021520931 8.170442496200641e-07 0.5998646534936181 8.170444559004441e-07 0.6037202012184053 \
8.170446840212041e-07 0.6079592993751251 8.170449064011853e-07 0.6120725203834017 8.17045133377667e-07 0.6162454422471376 8.170453484306168e-07 0.6201823359462864 \
8.170455778001902e-07 0.6243500782103125 8.170458468230649e-07 0.6292041961704016 8.170460698367118e-07 0.6331993632081415 8.170462820912891e-07 0.6369772451758789 \
8.170464934888789e-07 0.6407176358819484 8.17046693558109e-07 0.644236566349866 8.170469231519586e-07 0.6482486956559365 8.170471639888862e-07 0.6524328529570182 \
8.170473457382733e-07 0.6555667906748446 8.170475342864999e-07 0.6588018260593631 8.170476873661394e-07 0.6614154033769962 8.170478593744212e-07 0.6643352515471471 \
8.170480095472396e-07 0.6668697017322168 8.170481460645293e-07 0.6691578850264722 8.170482956937163e-07 0.6716547631652277 8.170484234340851e-07 0.673777752640997 \
8.170485630202225e-07 0.6760856948620949 8.170486872589102e-07 0.6781310478824312 8.170488184087495e-07 0.6802827752320969 8.170489428500931e-07 0.6823179209931315 \
8.170490800809157e-07 0.6845542421253382 8.170492003290863e-07 0.6865048414796368 8.170493416605294e-07 0.6887891282595083 8.170494419916407e-07 0.6904033553735033 \
8.170495631093427e-07 0.6923460943304175 8.170496538868777e-07 0.6937948943079848 8.170497511453436e-07 0.6953408241330762 8.170498473532237e-07 0.6968660703265798 \
8.170499359670681e-07 0.6982647859968389 8.170500332550912e-07 0.6997938110311075 8.170501657237293e-07 0.7018622871835729 8.170503209139279e-07 0.7042674555997347 \
8.170504587918793e-07 0.7063866855441746 8.170506036461533e-07 0.7085960165693863 8.170507307079098e-07 0.7105202221428537 8.170508553934701e-07 0.7123960184768648 \
8.170509680988463e-07 0.7140814553427599 8.170510798891907e-07 0.7157437310299281 8.170511806678399e-07 0.7172341607972841 8.170513179462953e-07 0.7192525454101454 \
8.170514376303672e-07 0.7210013704967912 8.170515570598379e-07 0.7227365757678518 8.170516839430602e-07 0.7245692610776365 8.17051808360712e-07 0.7263556789600311 \
8.170519320935366e-07 0.728121726658988 8.170520586890633e-07 0.7299181396522603 8.17052189074464e-07 0.7317573312219798 8.170523118842844e-07 0.7334798522758219 \
8.170524473200596e-07 0.7353678990088863 8.170525486098379e-07 0.7367723836293941 8.170526562323338e-07 0.7382576460517265 8.170527457604157e-07 0.7394878879617913 \
8.170528603087849e-07 0.7410528648863303 8.170529483370413e-07 0.7422487366778059 8.170530554151068e-07 0.7436953530868765 8.170531854801004e-07 0.7454403311053276 \
8.170532967597954e-07 0.7469230742113165 8.170534013783548e-07 0.7483084058091373 8.170535254613402e-07 0.7499400420429273 8.170536737621685e-07 0.7518749696944975 \
8.170537951620327e-07 0.7534462209622173 8.170539096027802e-07 0.7549170836379747 8.170540499400977e-07 0.7567069362027918 8.170541917029811e-07 0.7584995177563068 \
8.170543095039188e-07 0.759977341175643 8.170544374807853e-07 0.761570846386187 8.170545791832092e-07 0.7633205808366864 8.170546966945227e-07 0.7647599110190483 \
8.170548422997917e-07 0.7665289162262866 8.170549639940993e-07 0.7679951561698679 8.170550827247088e-07 0.7694149786178283 8.170552050113037e-07 0.7708662727382939 \
8.170553320558196e-07 0.77236234268503 8.170554416997921e-07 0.7736439866494906 8.170555673867047e-07 0.7751025186690397 8.170556734018051e-07 0.776323977486031 \
8.170558089877718e-07 0.7778743028704433 8.170559339507685e-07 0.7792913979962601 8.170560598569209e-07 0.7807070123991936 8.170561751241669e-07 0.7819915514687489 \
8.170562814286401e-07 0.7831664991275713 8.17056419833432e-07 0.7846822315516878 8.170565691298821e-07 0.7862997378875561 8.170567146373276e-07 0.7878588534534761 \
8.170568340418389e-07 0.7891257303126159 8.170569691346634e-07 0.7905455128963393 8.170570903878263e-07 0.7918076974797237 8.170572333811047e-07 0.7932816011184505 \
8.170573775854105e-07 0.7947523458802197 8.17057503122239e-07 0.7960199014141693 8.170576221686117e-07 0.7972110037065316 8.170577341044954e-07 0.7983213107123885 \
8.170578389760474e-07 0.7993531099923881 8.170579342264591e-07 0.8002831901653534 8.170580705697046e-07 0.8016020813281191 8.170581873938354e-07 0.8027203407102198 \
8.170583067984452e-07 0.803852171037294 8.170584289052493e-07 0.8049980820693966 8.170585518602504e-07 0.8061401395390313 8.170586788289509e-07 0.8073073595000361 \
8.170588040685604e-07 0.8084467645495962 8.17058934640955e-07 0.8096220968518901 8.170590606314732e-07 0.8107441738369082 8.170591888173857e-07 0.8118738099374113 \
8.170592943471138e-07 0.8127947795787664 8.170593972188868e-07 0.8136847278655364 8.17059490214057e-07 0.8144826950388273 8.170596140106596e-07 0.8155354283166244 \
8.170597019789174e-07 0.8162769513478326 8.170598007099885e-07 0.8171027376706747 8.170599439751417e-07 0.8182889948057973 8.170600792538271e-07 0.8193962136425846 \
8.170601883684495e-07 0.8202800249700468 8.170603364517579e-07 0.8214657808291811 8.170604862226849e-07 0.8226492530953341 8.170606114572855e-07 0.8236267526687548 \
8.170607554487031e-07 0.8247372275730155 8.170608795047738e-07 0.8256825756473101 8.170610299680322e-07 0.8268152483647575 8.17061165678884e-07 0.8278240064655301 \
8.17061290697392e-07 0.828742521381556 8.170614084523219e-07 0.8295983347934622 8.170615544291349e-07 0.8306466023667578 8.170617209384522e-07 0.8318251482734692 \
8.170618518610281e-07 0.8327390940956469 8.170620252884657e-07 0.8339327615268647 8.170621934353481e-07 0.8350717495747054 8.170623632702772e-07 0.8362042975620877 \
8.170625441950478e-07 0.8373912937861997 8.170626872933069e-07 0.8383160748488641 8.170628013791983e-07 0.8390446117604563 8.170629315531841e-07 0.8398665237782376 \
8.170630333942663e-07 0.8405024977857931 8.170631502136154e-07 0.8412243379523001 8.170632870780449e-07 0.8420597162999857 8.170634848766686e-07 0.8432475311273343 \
8.170636764807397e-07 0.8443767279905872 8.170638859212215e-07 0.8455874169714939 8.170640678468519e-07 0.8466193100105236 8.170642649799575e-07 0.8477171434207121 \
8.170644383298479e-07 0.8486653666163242 8.170646213292318e-07 0.8496493024239481 8.17064792495495e-07 0.8505537352954988 8.170649671272818e-07 0.8514606693963016 \
8.170651423896692e-07 0.8523550102558151 8.170653185417845e-07 0.8532381479010797 8.170655088128237e-07 0.8541746551565574 8.170656994147744e-07 0.85509499218684 \
8.170659000624008e-07 0.8560449689899254 8.170660926729659e-07 0.8569390259424264 8.170663033306522e-07 0.8578972157030333 8.170665314560508e-07 0.8589122247267402 \
8.170667972133685e-07 0.8600655879592763 8.170670958378129e-07 0.8613244245924475 8.170673721693317e-07 0.862454900702886 8.170676564023905e-07 0.8635842083919951 \
