1.002758896945878e-06 0.2072766958045763 1.00275979625821e-06 0.2300508264895909 1.002760696698323e-06 0.2526618731709107 1.002761498589855e-06 0.2726215666318766 \
1.002762194096996e-06 0.2897857674353052 1.002762826931282e-06 0.3052728323588638 1.002763422339774e-06 0.3197161646377594 1.002763969382815e-06 0.3328722959176427 \
1.002764503143162e-06 0.3455929446372428 1.002765022382586e-06 0.3578476146335662 1.002765529774049e-06 0.3697097539883151 1.002766033395218e-06 0.3813674725871593 \
1.002766545138114e-06 0.3930934709428262 1.002767052299123e-06 0.404595334768291 1.002767582595137e-06 0.4164962117964878 1.002768068708626e-06 0.4272847049163567 \
1.002768546816947e-06 0.437781779057129 1.002768986249071e-06 0.4473362978389137 1.002769109408535e-06 0.4500002106608159 1.002769355727463e-06 0.4553046876287923 \
1.002769698999458e-06 0.4626558934952216 1.002770010436459e-06 0.4692815017887791 1.002770261147724e-06 0.4745855323881177 1.002770531976868e-06 0.480281321066213 \
1.002770868458777e-06 0.4873122872019196 1.002771224467388e-06 0.4946959640027882 1.002771541737556e-06 0.5012322602315481 1.002771780618105e-06 0.506122906570856 \
1.002772021646287e-06 0.5110269393752048 1.002772273577991e-06 0.5161276795544476 1.002772513731835e-06 0.5209621749612534 1.002772736483296e-06 0.5254248476203834 \
1.002772925040944e-06 0.5291850880529715 1.002773139790987e-06 0.5334523706207774 1.002773354339378e-06 0.5376948565446859 1.00277361310367e-06 0.5427871977552768 \
1.002773863931242e-06 0.5477009885064807 1.002774119350104e-06 0.5526782776843104 1.00277447039263e-06 0.5594898819265107 1.002774735000954e-06 0.5645984056527484 \
1.00277500141751e-06 0.569709962982798 1.00277526193182e-06 0.5746801970751495 1.002775529021882e-06 0.5797469183389945 1.002775772159963e-06 0.5843213438768613 \
1.002776027852189e-06 0.5890994944692448 1.002776255671159e-06 0.5933243819692556 1.002776493215979e-06 0.5976999800355528 1.002776704606465e-06 0.6015679915939678 \
1.002776916747225e-06 0.6054277082074113 1.002777105936602e-06 0.6088479815213901 1.00277723709492e-06 0.6112112531841202 1.002777369391478e-06 0.6135871094428261 \
1.002777554614204e-06 0.6169015645304802 1.002777716636591e-06 0.6197943209800671 1.002777875055755e-06 0.6226100751126036 1.002778009167621e-06 0.6249846001944386 \
1.002778181488729e-06 0.6280247049765127 1.002778310427531e-06 0.6302937061188456 1.002778430805044e-06 0.6324061607157294 1.002778571333915e-06 0.634864734791624 \
1.002778764419407e-06 0.6382321981637986 1.002778914230185e-06 0.6408363654380513 1.00277908153778e-06 0.6437327988167145 1.002779262592003e-06 0.6468572757970242 \
1.002779465918433e-06 0.6503523798695617 1.002779648771588e-06 0.6534819287355287 1.002779819395834e-06 0.6563879501053153 1.002779996860074e-06 0.6594029650344411 \
1.002780162839025e-06 0.6622113135173925 1.002780320075814e-06 0.6648594636266301 1.002780460561866e-06 0.6672075432495704 1.002780604291994e-06 0.6695987751186935 \
1.002780737338985e-06 0.6718055529208897 1.002780879311128e-06 0.6741523780906628 1.002780999371661e-06 0.6761293215200647 1.002781144309748e-06 0.6785098354674278 \
1.002781260306798e-06 0.6804095298668216 1.002781379886685e-06 0.6823647593763783 1.00278147884666e-06 0.68397755359623 1.002781597355079e-06 0.6859039329668146 \
1.00278168439936e-06 0.6873150904607619 1.00278180641018e-06 0.6892866586554622 1.002781905332791e-06 0.6908817703737582 1.002781997228166e-06 0.6923536807698466 \
1.002782097196705e-06 0.6939486118486815 1.002782195442366e-06 0.6955126686751646 1.002782287156128e-06 0.6969676095571918 1.00278239128907e-06 0.698613189139943 \
1.002782527015812e-06 0.7007470979739818 1.002782681624274e-06 0.7031613517373301 1.002782816731986e-06 0.7052558942641604 1.002782963068532e-06 0.7075085519458914 \
1.002783091536074e-06 0.7094732734147607 1.002783215720207e-06 0.7113609898537658 1.002783325624507e-06 0.7130225953369277 1.002783442207576e-06 0.7147759898693785 \
1.002783542385407e-06 0.7162749667021007 1.002783679474216e-06 0.7183149847558421 1.002783799463242e-06 0.7200901405411056 1.00278391857669e-06 0.7218426783097279 \
1.002784045072077e-06 0.723693513465353 1.002784170939449e-06 0.7255245570057045 1.002784293560468e-06 0.7272980597885179 1.002784421177991e-06 0.7291334326655684 \
1.002784551426783e-06 0.7309957624152177 1.002784673019733e-06 0.73272442801297 1.002784811788425e-06 0.7346853525547948 1.002784912196869e-06 0.7360963845229137 \
1.002785015584257e-06 0.7375412410987998 1.0027851092447e-06 0.7388443755773992 1.002785220866297e-06 0.7403895158541485 1.0027853073349e-06 0.7415798421827293 \
1.00278540819801e-06 0.7429609798983192 1.002785540294732e-06 0.7447573558536402 1.002785649496034e-06 0.7462323422761349 1.002785754027664e-06 0.747635567415085 \
1.002785877674144e-06 0.7492836897664436 1.00278602637058e-06 0.7512497161812216 1.002786148251239e-06 0.7528480713857697 1.002786261855803e-06 0.7543274008692354 \
1.002786402375488e-06 0.7561429069656862 1.00278654356493e-06 0.7579511824827749 1.002786661311106e-06 0.7594470562859095 1.002786790000766e-06 0.7610693809796742 \
1.002786932555413e-06 0.7628512182523866 1.002787048411964e-06 0.7642872416835913 1.00278719417523e-06 0.7660789429779771 1.002787316007677e-06 0.7675637574673733 \
1.002787434476374e-06 0.7689965471136999 1.002787557264006e-06 0.7704700089613156 1.002787683416889e-06 0.7719718272910862 1.002787793785939e-06 0.7732757954107932 \
1.002787919217035e-06 0.7747465774777432 1.002788024698746e-06 0.775974259539018 1.002788157865176e-06 0.7775122819577122 1.002788280546631e-06 0.7789173428708996 \
1.002788415309674e-06 0.7804473432620218 1.002788525980963e-06 0.7816923373676121 1.002788635302591e-06 0.7829118427552927 1.002788770435026e-06 0.7844048889494442 \
1.00278892121405e-06 0.7860523747618094 1.002789061582958e-06 0.7875692293014268 1.002789181294483e-06 0.7888502570533434 1.002789319548823e-06 0.7903153082715967 \
1.002789442919159e-06 0.7916096503654788 1.002789588017784e-06 0.7931164937536124 1.002789727758044e-06 0.7945521172774316 1.002789854939467e-06 0.7958455533278409 \
1.00278997397922e-06 0.7970449251022731 1.002790086337411e-06 0.7981670522831598 1.002790190566191e-06 0.79919939674296 1.002790285905002e-06 0.8001364844871954 \
1.002790422193112e-06 0.8014634245741865 1.002790539085656e-06 0.8025894467082511 1.002790658725145e-06 0.8037305025474466 1.002790780606717e-06 0.8048811831579785 \
1.002790902985054e-06 0.8060245537852575 1.002791031013733e-06 0.8072081965553952 1.002791155658532e-06 0.8083483262222385 1.00279128615728e-06 0.8095291977395493 \
1.002791412617707e-06 0.8106611567088965 1.002791539743675e-06 0.8117869190804841 1.002791644861151e-06 0.8127087429624065 1.00279175011134e-06 0.8136235164943317 \
1.00279184125159e-06 0.8144090748259969 1.002791964669625e-06 0.8154632009865571 1.002792051748274e-06 0.8162003374872545 1.002792151070959e-06 0.8170344894488412 \
1.002792295992703e-06 0.8182390501293432 1.002792432261206e-06 0.8193582434421302 1.002792541723485e-06 0.8202477434185359 1.002792687843586e-06 0.8214214001843773 \
1.002792839202198e-06 0.8226208465286928 1.00279296500612e-06 0.8236052915965452 1.002793109416779e-06 0.824721541823094 1.00279323401773e-06 0.8256729463037898 \
1.002793384729791e-06 0.8268094083523665 1.00279352010105e-06 0.8278169867326588 1.002793645303979e-06 0.8287379047458127 1.002793762973362e-06 0.829593908450195 \
1.002793908801339e-06 0.8306418458276996 1.00279407529732e-06 0.8318207857986918 1.002794206154408e-06 0.8327345044534114 1.002794379603849e-06 0.833928356718921 \
1.002794547722322e-06 0.8350667646575466 1.002794717596125e-06 0.8361988603660855 1.002794898450754e-06 0.8373843006762304 1.002795041633135e-06 0.8383085120571983 \
1.002795155746479e-06 0.8390361588138326 1.00279528581247e-06 0.8398559950134801 1.002795387687706e-06 0.8404909448220066 1.002795504566998e-06 0.8412116130393378 \
1.002795641678929e-06 0.8420465258793415 1.002795839559572e-06 0.843231707656198 1.002796031345765e-06 0.8443585547012582 1.002796240708829e-06 0.8455646258450146 \
1.002796422822406e-06 0.846593677725298 1.002796619917178e-06 0.8476867969181797 1.002796793185875e-06 0.8486305714188691 1.002796976264561e-06 0.8496104335327738 \
1.002797147401587e-06 0.8505103231661706 1.002797322080438e-06 0.8514128411730317 1.002797497318728e-06 0.8523022053693007 1.002797673458368e-06 0.8531802340241421 \
1.002797863809624e-06 0.8541115036082744 1.00279805438677e-06 0.855025905954957 1.002798254818193e-06 0.8559685891497206 1.002798447410669e-06 0.8568563992305701 \
1.002798658273806e-06 0.8578086227668252 1.002798886187182e-06 0.8588150784816577 1.002799152217719e-06 0.8599606428795262 1.002799450738801e-06 0.8612090806949765 \
1.002799726692482e-06 0.8623286542354505 1.002800010954596e-06 0.8634483918036945 1.002800285103046e-06 0.8644969441068078 1.002800557392313e-06 0.8655088801415273 \
1.002800827558089e-06 0.8664846790737442 1.002801084736186e-06 0.8673881555543895 1.002801357299353e-06 0.868319368003445 1.002801633304697e-06 0.8692355072818493 \
1.002801903418629e-06 0.870106770567397 1.002802203245002e-06 0.8710447971670072 1.002802574222291e-06 0.8721640818024149 1.002802869154012e-06 0.8730224021943973 \
1.002803123432376e-06 0.873740732376842 1.002803421677207e-06 0.8745584461000401 1.002803695285219e-06 0.8752856917963749 1.002803931415444e-06 0.8758961959341748 \
1.002804171760979e-06 0.8765017794770257 1.002804394097168e-06 0.8770481951318053 1.00280458810245e-06 0.8775144010549708 1.002804917823794e-06 0.8782846129827527 \
1.002805072996819e-06 0.8786376896881318 1.002805390752408e-06 0.8793424631377607 1.002805569616983e-06 0.8797286397841958 1.002805912078462e-06 0.8804474051285093 \
1.002806096217817e-06 0.880822800830328 1.002806571118475e-06 0.881756283451624 1.002806738513154e-06 0.8820737784441692 1.0028072043462e-06 0.8829272622221894 \
1.002807385170493e-06 0.8832470363605239 1.002807879204793e-06 0.8840891816604841 1.002808020548669e-06 0.8843218944112644 1.002808626940586e-06 0.8852805359894154 \
1.002808779011766e-06 0.8855111592597558 1.002809425691436e-06 0.8864506941541785 1.002809553987642e-06 0.8866295550025313 1.002810202164815e-06 0.8874976172723908 \
1.002810331923676e-06 0.8876644392549727 1.002811100144497e-06 0.8886037370453904 1.002811229881009e-06 0.8887539063021698 1.002812083306654e-06 0.8896836309705964 \
1.002812226565088e-06 0.8898301468060963 1.002813212785821e-06 0.890764641901611 1.002813434267227e-06 0.8909571971396437 1.002814577308628e-06 0.8918770673440963 \
1.002814707298117e-06 0.8919774876506176 1.002816058923388e-06 0.8929731820841386 1.00281620928357e-06 0.89307657739048 1.002817689916169e-06 0.8939986636922405 \
1.002817928817934e-06 0.8941315911431026 1.002819693311633e-06 0.894999985510941 1.002820000994978e-06 0.8951330875684044 1.002822522266181e-06 0.8960612226716312 \
1.002822959317422e-06 0.8961978289811912 1.002826862729643e-06 0.8971619289239613 1.00282710951145e-06 0.8972094058147089 1.002834686001285e-06 0.8981998139535015 \
1.002834801913031e-06 0.8982099955090975 1.002853900445735e-06 0.8992062631372056 1.002854297888509e-06 0.8992194728667773 1.00300471332359e-06 0.9002121614362558 \
1.003004979381947e-06 0.9002436812458944 1.003010247532015e-06 0.8993470931706574 1.003010453902932e-06 0.899191170936528 1.003011932015742e-06 0.8982046351054961 \
1.003012112466398e-06 0.8981003355419954 1.003014334948061e-06 0.8971299612768925 1.003014541040576e-06 0.897079983173831 1.003024949306681e-06 0.8980580240048047 \
1.003025087164257e-06 0.8980839755683444 1.003031884513298e-06 0.8990685088718567 1.003032070084766e-06 0.8990874390200084 1.003528299258968e-06 0.9000706848616691 \
1.003528359054814e-06 0.9000975977971888 1.003529612605432e-06 0.9010828413531861 1.003529718298035e-06 0.9012097231395001 1.003530376428752e-06 0.9021613947651476 \
1.003530513611021e-06 0.9023918767045529 1.003531036637641e-06 0.9033649777562528 1.003531099501233e-06 0.9034908765919824 1.003531572096782e-06 0.904476514442582 \
1.003531623410595e-06 0.9045863669199017 1.003532089373931e-06 0.9055619780118375 1.003532121578392e-06 0.9056252631670594 1.003532838677129e-06 0.9066212416280413 \
1.003532923113402e-06 0.9066528951765993 1.003533523179781e-06 0.9059679814895146 1.003533643037393e-06 0.9055903401525059 1.003533774200172e-06 0.9050640446667092 \
1.003533909019925e-06 0.9043926011431642 1.003534057154984e-06 0.9034897747335404 1.003534194714335e-06 0.902493211317788 1.003534334926095e-06 0.9013135799985507 \
1.003534433588205e-06 0.9003872218501816 1.003534519272014e-06 0.8995148096066522 1.003534601836213e-06 0.8986166894493001 1.003534716618842e-06 0.8972773101170661 \
1.003534797717086e-06 0.8962642459447687 1.003534877134364e-06 0.8952218112132616 1.003534982588892e-06 0.8937633947192651 1.003535105230195e-06 0.8919606744930825 \
1.003535204954274e-06 0.890414036797163 1.003535375148685e-06 0.8876203405523397 1.003535521333777e-06 0.8850727273800474 1.003535689551925e-06 0.8819879035815887 \
1.003535861713021e-06 0.8786780617039783 1.003536046099114e-06 0.8749807502679057 1.003536230665458e-06 0.8711418063496947 1.003536414912944e-06 0.8671917613865908 \
1.003536600248607e-06 0.8631174608718694 1.003536774636335e-06 0.8592060069639053 1.003536957340272e-06 0.8550405244181323 1.003537132687366e-06 0.8509893565349284 \
1.003537315016877e-06 0.8467313026054767 1.003537505330306e-06 0.8422468264612591 1.003537675660435e-06 0.838204894125699 1.003537842184074e-06 0.8342320488410089 \
1.003538004754937e-06 0.830337741667393 1.00353815461616e-06 0.8267359097041467 1.003538305792179e-06 0.8230937075736249 1.003538494937653e-06 0.8185270080344306 \
1.003538640655707e-06 0.8150026134285653 1.003538815646674e-06 0.8107652770601156 1.003538964118218e-06 0.807166938184282 1.003539136005683e-06 0.8029987283123258 \
1.003539305073922e-06 0.7988973224349885 1.003539469252632e-06 0.7949140139776875 1.003539628580169e-06 0.7910485911592836 1.003539789029776e-06 0.7871568543472617 \
1.003539990849157e-06 0.7822630953020117 1.003540139296892e-06 0.7786646206504594 1.003540293464276e-06 0.77492821376164 1.003540430547636e-06 0.7716074476660475 \
1.003540539933082e-06 0.7689587163513494 1.003540645866538e-06 0.7663946531324515 1.003540772880885e-06 0.7633217481666642 1.003540887243854e-06 0.7605561828888391 \
1.003540990091676e-06 0.7580702160470256 1.003541111681993e-06 0.7551325442760125 1.003541222459267e-06 0.7524575925939972 1.003541339308092e-06 0.7496376180588871 \
1.003541450092818e-06 0.7469652567786068 1.003541568458919e-06 0.7441116745915923 1.003541693286014e-06 0.7411038668912771 1.00354184584781e-06 0.7374292753756717 \
1.003541979744798e-06 0.7342062928952946 1.003542100776237e-06 0.7312947572377408 1.003542264973752e-06 0.7273475399259534 1.003542442334699e-06 0.7230877912371642 \
1.003542624545107e-06 0.7187161681757385 1.003542805542373e-06 0.7143786395952922 1.003542986206316e-06 0.7100537072471783 1.003543176357883e-06 0.7055071781827296 \
1.003543364117777e-06 0.7010230964996226 1.003543564650882e-06 0.696237807975249 1.003543773336343e-06 0.6912646166759551 1.003543980979908e-06 0.6863227581165517 \
1.003544208547776e-06 0.6809140411171237 1.00354440082261e-06 0.6763521085712711 1.003544638087858e-06 0.6707310800019505 1.003544831366122e-06 0.6661595641347996 \
1.003545064098869e-06 0.6606646229758047 1.003545269656336e-06 0.6558174602470968 1.003545502009758e-06 0.6503484594495911 1.003545697011727e-06 0.6457674053103037 \
1.003545900240336e-06 0.6410004262200759 1.003546080092881e-06 0.6367906205544323 1.003546259199312e-06 0.6326052789263827 1.003546422576526e-06 0.628795088826817 \
1.00354659462593e-06 0.6247880828503264 1.003546758118769e-06 0.6209892715878097 1.003546933908588e-06 0.6169100951581823 1.003547115847573e-06 0.6126978430086294 \
1.003547304331305e-06 0.6083422542008314 1.003547510763727e-06 0.6035858951323969 1.00354769007839e-06 0.5994633272559844 1.003547887257257e-06 0.5949432360761027 \
1.003548096345397e-06 0.5901646611556908 1.00354830209466e-06 0.5854760387944159 1.003548542605348e-06 0.5800160304866983 1.00354871573345e-06 0.5760958285528379 \
1.003548880627452e-06 0.5723746772837877 1.003549061488027e-06 0.5683014035092815 1.003549218774123e-06 0.5647722902613652 1.003549387756918e-06 0.5609879409349005 \
1.003549567863379e-06 0.5569709657351898 1.003549720846506e-06 0.5535669615732179 1.003549852560951e-06 0.5506462283231492 1.003549999948651e-06 0.5473865746199473 \
1.003550087374242e-06 0.5454560063082221 1.003550172245481e-06 0.5435860258811447 1.003550270874694e-06 0.5414171943998213 1.003550342966855e-06 0.5398340751058975 \
1.003550440057874e-06 0.5377039800781129 1.003550525648258e-06 0.5358302678688993 1.003550590729134e-06 0.5344081412607664 1.003550714329502e-06 0.5317121235594142 \
1.003550808753772e-06 0.52965475734789 1.003550906276994e-06 0.5275349985745696 1.003551079137645e-06 0.5237893654184622 1.003551214133166e-06 0.5208709659121862 \
1.003551368316628e-06 0.5175498113398643 1.003551542781984e-06 0.5138002600288881 1.00355169458797e-06 0.510550000123414 1.003551840818953e-06 0.5074290310664136 \
1.003551984717826e-06 0.5043644611166801 1.00355212773967e-06 0.5013276181140283 1.003552223349517e-06 0.499301733014788 1.003552317793473e-06 0.4973032961550828 \
1.003552438849414e-06 0.4947494705229025 1.00355253372771e-06 0.4927525559781179 1.003552649558553e-06 0.4903172469328811 1.003552736822402e-06 0.4884854516151125 \
1.003552819252848e-06 0.4867593351188191 1.003552914660802e-06 0.484765406725184 1.003553015371081e-06 0.4826639978995959 1.003553112231473e-06 0.4806459052877932 \
1.003553250961224e-06 0.4777646955734051 1.003553386666086e-06 0.4749532752442271 1.003553587150809e-06 0.4708139964547478 1.003553802464962e-06 0.4663911383470885 \
1.003553984040267e-06 0.462674698484628 1.003554183012236e-06 0.4586189944293299 1.003554353577757e-06 0.455154096457448 1.003554527931445e-06 0.4516251957269069 \
1.003554696864699e-06 0.4482170126441485 1.00355486946186e-06 0.4447467276163349 1.00355505206819e-06 0.4410867902598327 1.003555240617056e-06 0.4373240875354826 \
1.003555434084593e-06 0.4334777823509549 1.003555642405232e-06 0.4293535036700135 1.003555856750462e-06 0.4251286740881063 1.003556082455792e-06 0.4207018662297695 \
1.00355630899916e-06 0.4162771402745992 1.003556571175911e-06 0.4111844468197049 1.003556820209735e-06 0.4063709766754009 1.003557121308433e-06 0.4005865607947761 \
1.00355741072925e-06 0.3950673729298416 1.003557718243529e-06 0.3892455819062323 1.003558040439924e-06 0.3831936848847286 1.003558368170407e-06 0.3770882112794804 \
1.003558700600163e-06 0.3709500980558715 1.003559030329171e-06 0.3649083177186754 1.003559351558758e-06 0.3590729273462687 1.003559682375082e-06 0.3531219177045733 \
1.003560024730645e-06 0.3470224718704957 1.003560324371677e-06 0.3417374346434491 1.003560654159242e-06 0.3359723367088904 1.003560981053185e-06 0.3303128110141857 \
1.003561319032532e-06 0.3245206193888226 1.003561628003696e-06 0.3192755432624759 1.003561952801668e-06 0.31382336954194 1.003562268431866e-06 0.3085864885517507 \
1.003562573419032e-06 0.3035810258414895 1.003562828757678e-06 0.2994330834535801 1.003563093620834e-06 0.295170851203172 1.003563380703519e-06 0.2905978071194348 \
1.003563603673297e-06 0.2870801635277143 1.003563803212567e-06 0.2839591363066187 1.00356401286858e-06 0.2807045410859125 1.003564193125121e-06 0.2779290029372279 \
1.003564355469842e-06 0.2754463208250681 1.003564505904816e-06 0.2731629026725527 1.003564656910124e-06 0.2708866524077067 1.003564853800715e-06 0.2679392949564011 \
1.003564984945479e-06 0.2659970646012914 1.003565109682017e-06 0.2641561221543183 1.00356526127406e-06 0.2619266655689588 1.003565357242231e-06 0.2605306204207966 \
1.0035654537936e-06 0.2591282589302421 1.003565578413389e-06 0.2573209601776467 1.003565720989923e-06 0.255257422470362 1.003565879923458e-06 0.25296979123958 \
1.003566012589525e-06 0.251062957019046 1.003566196158294e-06 0.2484301322588876 1.00356637739346e-06 0.2458327969660818 1.003566588907565e-06 0.2428051031600066 \
1.003566791497399e-06 0.2399069804317323 1.003566958053847e-06 0.2375282895552967 1.003567168273059e-06 0.2345337828133105 1.003567341690945e-06 0.2320692345528927 \
1.003567570533673e-06 0.2288260787734411 1.003567791168424e-06 0.2257162440502939 1.003567966830138e-06 0.2232503232699662 1.003568147290643e-06 0.2207258962977968 \
1.003568318047021e-06 0.2183528725291195 1.003568498243287e-06 0.2158619697278009 1.003568664973905e-06 0.2135675266585953 1.003568814095326e-06 0.2115251542210239 \
1.003568969905344e-06 0.2094125291275523 1.003569105085769e-06 0.2075875692769576 1.003569255167197e-06 0.2055694209972212 1.003569387612823e-06 0.2037957203154137 \
1.003569528157359e-06 0.2019220745191926 1.003569645226124e-06 0.2003748851744883 1.00356977493373e-06 0.1986681706274326 1.003569896991199e-06 0.1970700654731777 \
1.003570019534635e-06 0.1954731161836187 1.003570137553958e-06 0.1939418157697267 1.003570272576731e-06 0.1921981789937757 1.003570417201182e-06 0.1903420634523806 \
1.003570545551681e-06 0.1887049708672087 1.003570669186156e-06 0.1871351133418249 1.003570766736279e-06 0.1859021016257166 1.003570881809208e-06 0.1844539912642748 \
1.003570975507888e-06 0.1832809848801438 1.003571074292012e-06 0.1820493959460708 1.003571197226553e-06 0.1805230483556907 1.003571292980556e-06 0.1793400249325384 \
1.003571422068107e-06 0.177753298391591 1.003571524533477e-06 0.1764993061988986 1.003571622786974e-06 0.1753029542432101 1.003571742874186e-06 0.1738483570896001 \
1.003571845423405e-06 0.1726127298531683 1.003571955881064e-06 0.1712877101305652 1.003572084370928e-06 0.1697552709290656 1.003572175855769e-06 0.1686698090598139 \
1.003572280340358e-06 0.1674358120019214 1.003572355277094e-06 0.1665544493622226 1.003572444845591e-06 0.1655049734124585 1.0035724954106e-06 0.164914347906921 \
1.003572545388976e-06 0.1643318187475747 1.003572610358061e-06 0.163576534137217 1.003572645872029e-06 0.1631646263336159 1.003572718071202e-06 0.162329174921529 \
1.003572785200298e-06 0.1615546732967998 1.003572844430032e-06 0.160873195114598 1.003572888175631e-06 0.1603710314414745 1.003572935822459e-06 0.1598254649913795 \
1.003573006202993e-06 0.1590230739426561 1.003573088541159e-06 0.1580883269013631 1.003573166712759e-06 0.1572048664554128 1.003573248765708e-06 0.1562816770844126 \
1.003573341469331e-06 0.1552436243401225 1.003573464249495e-06 0.153877370231325 1.003573563395588e-06 0.1527810927807017 1.003573664895936e-06 0.1516651170047695 \
1.003573766171126e-06 0.1505582666538253 1.003573862662911e-06 0.1495093242781697 1.003573962080945e-06 0.1484346886615803 1.003574046381569e-06 0.1475281828465028 \
1.003574139320259e-06 0.1465342051547719 1.0035742219212e-06 0.1456551508734999 1.003574330687285e-06 0.1445034822456445 1.003574436330265e-06 0.1433917535370727 \
1.003574517989854e-06 0.1425365900703354 1.003574611735024e-06 0.1415598856352903 1.003574705302971e-06 0.1405903867550886 1.003574788187462e-06 0.139735765814107 \
1.003574876346636e-06 0.1388313836440244 1.003574956132722e-06 0.1380170907865772 1.003575049728122e-06 0.1370669869522621 1.003575139660646e-06 0.1361590166429519 \
1.003575210211042e-06 0.1354501541392388 1.003575279971219e-06 0.1347521119166949 1.003575394120126e-06 0.1336164586193709 1.00357547609874e-06 0.1328058651355588 \
1.003575563704043e-06 0.1319440719770354 1.003575663205239e-06 0.1309710196939938 1.003575772385241e-06 0.1299110174488692 1.003575874550573e-06 0.1289256009328031 \
1.003575982010779e-06 0.1278959836800649 1.003576102045057e-06 0.1267549558890445 1.003576196253091e-06 0.1258657925752028 1.003576327232195e-06 0.1246390638240933 \
1.003576426659897e-06 0.1237164070883829 1.003576535781582e-06 0.1227104370444639 1.00357664463475e-06 0.1217138859540913 1.003576736944154e-06 0.120874257454373 \
1.003576849784484e-06 0.1198547128626846 1.003576946796524e-06 0.118986084968971 1.003577051062872e-06 0.1180628196869088 1.003577160029803e-06 0.1171053395831002 \
1.003577259569368e-06 0.1162371554254778 1.003577376562078e-06 0.1152245300989246 1.003577463662869e-06 0.1144761644999183 1.00357757295452e-06 0.1135478691973115 \
1.003577654479583e-06 0.1128618460838699 1.003577754254576e-06 0.1120273350449922 1.003577871679726e-06 0.1110526766231405 1.003577973464844e-06 0.1102143708571793 \
1.003578061203792e-06 0.1094962336869811 1.0035781420033e-06 0.1088432886892514 1.003578228954319e-06 0.1081456845520918 1.003578309740945e-06 0.1075007757815706 \
1.003578399947511e-06 0.1067842832273628 1.003578490898266e-06 0.1060655611559195 1.00357857956879e-06 0.1053685613006139 1.003578678583611e-06 0.1045946508745568 \
1.003578772289787e-06 0.1038723470842792 1.003578866149063e-06 0.1031520741219857 1.003578966976511e-06 0.1023817709659086 1.003579071607409e-06 0.1015861061604995 \
1.003579195570165e-06 0.1006484085638475 1.003579292969478e-06 0.09991551135558702 1.003579413227425e-06 0.09901872452754552 1.0035795240953e-06 0.09819831936474602 \
1.003579628568336e-06 0.09742874659471555 1.003579745805045e-06 0.09656937225591002 1.003579847599366e-06 0.09582695326576983 1.003579945574917e-06 0.09511577589263259 \
1.003580086079406e-06 0.09410164141823299 1.003580191157203e-06 0.09334832721827611 1.003580289770019e-06 0.09264549593674179 1.003580382484827e-06 0.09198739948435641 \
1.003580468683212e-06 0.09137785861853052 1.003580562596188e-06 0.09071637432184691 1.003580659696934e-06 0.09003559055802626 1.003580769117988e-06 0.08927317549644689 \
1.003580870101537e-06 0.08857281843916648 1.003580963759483e-06 0.08792605868920525 1.003581037934155e-06 0.08741581771673042 1.003581175834007e-06 0.08647193599618339 \
1.003581248191011e-06 0.08597917321277694 1.003581383512214e-06 0.08506274029062395 1.00358146942382e-06 0.08448410751389913 1.003581614152054e-06 0.08351486081643937 \
1.003581710382619e-06 0.0828744112740944 1.003581798218398e-06 0.08229260392026354 1.003581914017306e-06 0.08152964121883956 1.003582029145758e-06 0.08077575264951149 \
1.00358214291219e-06 0.08003553900012179 1.003582283169683e-06 0.0791300282244784 1.003582424545716e-06 0.07822490276368012 1.003582574181758e-06 0.07727536491519127 \
1.003582718670613e-06 0.07636690312463701 1.003582869844724e-06 0.07542565384097814 1.003583019215544e-06 0.07450459906593411 1.003583168562251e-06 0.0735926433331697 \
1.003583328517767e-06 0.07262574717347114 1.003583484664678e-06 0.07169171823582712 1.003583659153112e-06 0.07065947636250877 1.003583828862219e-06 0.0696671357044583 \
1.003584014041303e-06 0.0685979885997255 1.00358421076238e-06 0.06747763456279594 1.0035844212802e-06 0.06629631776014881 1.003584643312255e-06 0.06507007089066431 \
1.003584873524276e-06 0.0638195278444372 1.003585116035382e-06 0.06252626147401 1.003585376689467e-06 0.06116236403900636 1.003585656588531e-06 0.05972739422233359 \
1.003585950172255e-06 0.05825544847408989 1.003586265108239e-06 0.05671370145268265 1.003586607914164e-06 0.05507846134953124 1.003586957380758e-06 0.0534565727116736 \
1.003587366284915e-06 0.05161746230842366 1.003587712949942e-06 0.05010669351290297 1.003588100364995e-06 0.04846839895323611 1.003588444582788e-06 0.04705645202362623 \
1.003588768009047e-06 0.04576625679949029 1.003589073054809e-06 0.04458093278443617 1.003589365916806e-06 0.04347099288378908 1.003589650057723e-06 0.04242242262004604 \
1.003589926078015e-06 0.04142902112907627 1.003590192930566e-06 0.04049015932812138 1.003590461822789e-06 0.03956531631184226 1.003590737883211e-06 0.03863769040165695 \
1.003591025478782e-06 0.03769451689421055 1.003591265044408e-06 0.03692662498323904 1.003591554211835e-06 0.03602084344675294 1.003591770003438e-06 0.03535960341037672 \
1.003591957720476e-06 0.03479599077274986 1.003592155849583e-06 0.03421285035004928 1.003592518724446e-06 0.03317032497347058 1.003592776866276e-06 0.03244834222605905 \
1.00359308657919e-06 0.0316030971185694 1.003593352049328e-06 0.03089664771451467 1.003593620168408e-06 0.03019941363307669 1.003593899042439e-06 0.02949128999862272 \
1.003594145228876e-06 0.02888043298519722 1.003594375860285e-06 0.02832033800396738 1.003594614150204e-06 0.02775711540944564 1.003594849157569e-06 0.02721270742060762 \
1.003595076940031e-06 0.02669509678424227 1.003595485552303e-06 0.02579039168486155 1.003595661854632e-06 0.02540904040268441 1.003596016332316e-06 0.02465798827491217 \
1.003596200203288e-06 0.02427641469830137 1.00359653515201e-06 0.02359448510613503 1.003596699060727e-06 0.02326678168937357 1.003597091331304e-06 0.02249905491676728 \
1.003597247322069e-06 0.02220010404946675 1.003597678925426e-06 0.02138321689778962 1.003597816314806e-06 0.0211255367654138 1.003598333123589e-06 0.02017559010600388 \
1.003598458659483e-06 0.01995091418019728 1.003598915901008e-06 0.01915998482559782 1.003599075046989e-06 0.01889493739859509 1.003599682285467e-06 0.01793263500095189 \
1.003599816822955e-06 0.01772934138481063 1.003600480086948e-06 0.01678091027541291 1.003600673410379e-06 0.01651856846389665 1.00360134106704e-06 0.01565087920017967 \
1.003601502655887e-06 0.01544858341705342 1.00360225789114e-06 0.01454101846553843 1.003602407452107e-06 0.01436800730673201 1.003603297789931e-06 0.01338293844200974 \
1.003603396447817e-06 0.01327873262558703 1.003604353121314e-06 0.01230993787860994 1.003604474231022e-06 0.01219243157195396 1.00360546572373e-06 0.01126376273051215 \
1.00360562925246e-06 0.01111855113153209 1.003606759174535e-06 0.01018247077230436 1.003606871621774e-06 0.01009565848301377 1.003608249445262e-06 0.009103273453806031 \
1.003608388390533e-06 0.009009747578659758 1.003609942788868e-06 0.008018073335410726 1.00361005485534e-06 0.00794673960805117 1.00361169983817e-06 0.006958154532207958 \
1.003611807090664e-06 0.006899512253112593 1.003613751584152e-06 0.005937533026687714 1.00361395848211e-06 0.005843834961138424 1.003616297369853e-06 0.00487227039639981 \
1.003616721356264e-06 0.004712306502041247 1.00361949358946e-06 0.003780857497341114 1.003619941898552e-06 0.003647790772321777 1.003623582397237e-06 0.00272553831825111 \
1.003624079053071e-06 0.002619503085887757 1.003629830173496e-06 0.001650572925599863 1.003630116955382e-06 0.001609446887446839 1.003635471944067e-06 0.0006353228983793809 \
1.003635677300692e-06 0.0005920420449145349 1.006282712074507e-06 -0.0002718533828215428 1.006282867950111e-06 -0.0004579010352009555 1.006283416265203e-06 -0.001326296959495401 \
1.006283529048879e-06 -0.001543805653187533 1.006283963541019e-06 -0.002491429791030493 1.006284039366175e-06 -0.002673591589873599 1.006284396016773e-06 -0.003590195133438418 \
1.006284523065853e-06 -0.003936807634339821 1.006284801566247e-06 -0.004716444651655622 1.006284909650731e-06 -0.005020876868076652 1.006285253249855e-06 -0.00592430224391268 \
1.00628536024372e-06 -0.006162325733041658 1.006286259614116e-06 -0.005653094509861465 1.006286438047546e-06 -0.004687598829536962 1.00628654377096e-06 -0.003940993102967527 \
1.006286668833738e-06 -0.002883597584075996 1.006286762417834e-06 -0.001971418478057775 1.006286840257396e-06 -0.001132968824455395 1.006286920329394e-06 -0.0001977429743171 \
1.006287042702205e-06 0.001370578777960296 1.006287160958077e-06 0.003041212838230153 1.006287279607187e-06 0.004860750887681821 1.006287393089626e-06 0.006730904986417607 \
1.006287496532764e-06 0.008536402178002854 1.006287611192018e-06 0.01064190690353853 1.006287801775811e-06 0.0143607330143792 1.006287935565949e-06 0.01711819191720031 \
1.006288085819515e-06 0.02033933849841947 1.006288240988762e-06 0.02378599874269359 1.006288396380811e-06 0.0273434151175349 1.006288544088042e-06 0.03080849965087477 \
1.006288693077668e-06 0.03437359286003162 1.006288848068751e-06 0.03814545786868043 1.006289007439365e-06 0.04208062121327779 1.006289172372776e-06 0.04620305710844342 \
1.006289347319105e-06 0.0506208066052034 1.006289526449176e-06 0.05518387280380205 1.006289716238431e-06 0.06005265756871143 1.0062899199354e-06 0.06530840376289772 \
1.006290139745932e-06 0.07100650943730057 1.006290371497376e-06 0.07703584544314998 1.006290619322674e-06 0.08349927754587044 1.006290890643603e-06 0.09058756662233436 \
1.006291185356381e-06 0.09829181712822582 1.006291510614029e-06 0.106792896697727 1.006291876859735e-06 0.1163551101154179 1.006292270156448e-06 0.1266079356677421 \
1.006292722809343e-06 0.1383809089651769 1.006293248524511e-06 0.1520098384503803 1.006293867738049e-06 0.1679979965193872 1.006294548482365e-06 0.1854865650013753 \
1.00629534215732e-06 0.2057488551561759 1.006296230922953e-06 0.2282732214494322 1.006297044312215e-06 0.2487218262351868 1.006297766061792e-06 0.2667261628598245 \
1.006298401725801e-06 0.282460740414376 1.006298973442562e-06 0.2965101025186013 1.006299508996846e-06 0.3095696210007924 1.006300012355259e-06 0.3217495654069301 \
1.006300488682701e-06 0.3331878525640654 1.006300962606306e-06 0.3444754071334732 1.006301420078025e-06 0.3552759747331513 1.006301886058294e-06 0.3661792384270033 \
1.006302335046104e-06 0.376592601923634 1.006302831152646e-06 0.3879857357798637 1.006303350914508e-06 0.3998002499051578 1.006303730319152e-06 0.4083447473225827 \
1.006304170327876e-06 0.4181679450526055 1.006304640096814e-06 0.4285466970600206 1.006305125617752e-06 0.4391589006481625 1.006305565065858e-06 0.4486701556983262 \
1.006305626818807e-06 0.4500002248264944 1.006305750324704e-06 0.4526540461147197 1.006305997336498e-06 0.4579447795386873 1.006306249931409e-06 0.463325462421476 \
1.006306447502524e-06 0.467511453725808 1.006306673074271e-06 0.4722681264242033 1.006306994642268e-06 0.4790073975813253 1.006307263421496e-06 0.4846013351959894 \
1.00630748207297e-06 0.4891262574467725 1.006307692176936e-06 0.4934547887280634 1.006307918582461e-06 0.4980921872304203 1.006308127687652e-06 0.5023516957637455 \
1.006308317089911e-06 0.5061927337048852 1.006308441251129e-06 0.5086969563931187 1.006308568006226e-06 0.5112441466129884 1.006308728004704e-06 0.5144514110933732 \
1.006308975647656e-06 0.5193914248715521 1.006309154234115e-06 0.5229351592435862 1.006309325187692e-06 0.5263079149198099 1.006309586537288e-06 0.5314455197962068 \
1.00630981260887e-06 0.5358634945234868 1.006310015740537e-06 0.5398188128751134 1.006310180971267e-06 0.5430252218652345 1.006310337758288e-06 0.5460612552756139 \
1.006310526914905e-06 0.5497137532216215 1.006310728782658e-06 0.5535976061995346 1.006310952933981e-06 0.5578986282275192 1.006311191316346e-06 0.5624617013850463 \
1.006311426077985e-06 0.566941985223824 1.00631165634869e-06 0.5713275351537204 1.006311862141324e-06 0.5752375533958141 1.006312067125538e-06 0.5791255875933676 \
1.00631230994078e-06 0.5837094709690289 1.006312564698362e-06 0.588493349632063 1.006312792926793e-06 0.5927514274590796 1.006313030765665e-06 0.5971656109489694 \
1.006313243043101e-06 0.6010807441713891 1.006313454836505e-06 0.6049674646600495 1.006313708720774e-06 0.6095919957414236 1.006313913314301e-06 0.6132953190650409 \
1.006314165037654e-06 0.6178178328453598 1.006314352827174e-06 0.6211736970442716 1.006314605700251e-06 0.6256587164710262 1.006314804109613e-06 0.6291560967673944 \
1.006314983842284e-06 0.6323071487074056 1.006315254113091e-06 0.6370161336915187 1.006315471396857e-06 0.6407803561788556 1.006315651923236e-06 0.6438916924996977 \
1.006315853084131e-06 0.6473460740030906 1.006316021667513e-06 0.650231451944099 1.00631622602572e-06 0.6537144072723954 1.006316371688778e-06 0.6561873372238678 \
1.006316536247377e-06 0.6589728476742622 1.006316705716593e-06 0.6618316558839334 1.006316859256675e-06 0.664412775690417 1.006317000490202e-06 0.6667750288922751 \
1.006317144066013e-06 0.6691685747430841 1.006317277296139e-06 0.6713840140331436 1.006317419196459e-06 0.6737368819239464 1.006317539430086e-06 0.6757233098298149 \
1.006317684081138e-06 0.6781085120392751 1.006317800299844e-06 0.6800197521569988 1.006317919382163e-06 0.6819757159594566 1.006318017960477e-06 0.6835903813535821 \
1.006318135558183e-06 0.6855122399681081 1.006318222994146e-06 0.6869376986921233 1.006318347740232e-06 0.6889650632873403 1.006318447547296e-06 0.6905825000046129 \
1.006318540037093e-06 0.6920753042469043 1.006318641321177e-06 0.6937043390836264 1.006318739114283e-06 0.695273833970533 1.006318830385075e-06 0.6967333967490603 \
1.006318932842905e-06 0.6983656370917724 1.006319065752136e-06 0.7004728611232253 1.006319220767541e-06 0.7029137789397926 1.006319355649227e-06 0.7050222373350452 \
1.006319501145018e-06 0.7072806469370021 1.006319628999685e-06 0.709252249158637 1.006319753457981e-06 0.7111597484283609 1.006319864783685e-06 0.7128563623504806 \
1.006319978813713e-06 0.7145852226468989 1.00632007932493e-06 0.7161013069709498 1.006320216526077e-06 0.7181590832501857 1.006320336471979e-06 0.7199473375636642 \
1.006320455641778e-06 0.7217141075019444 1.006320582586792e-06 0.7235855504531626 1.006320707354209e-06 0.7254141264975077 1.006320830849597e-06 0.7272133847865295 \
1.00632095763087e-06 0.7290498056238117 1.006321088220355e-06 0.730930225429108 1.006321210432258e-06 0.7326797786847141 1.006321347490272e-06 0.7346298644824388 \
1.006321448705626e-06 0.7360619656663578 1.006321553674562e-06 0.7375401619041119 1.006321645165995e-06 0.7388229997694907 1.006321758241356e-06 0.7404001534680551 \
1.00632184554224e-06 0.7416107338190071 1.006321950005571e-06 0.7430512000342341 1.006322080768703e-06 0.7448411286358657 1.0063221906822e-06 0.7463352048609909 \
1.006322295341959e-06 0.7477488743938407 1.00632241917362e-06 0.7494094725133206 1.006322567926971e-06 0.751387874302702 1.006322689842132e-06 0.7529958494242643 \
1.006322803696392e-06 0.7544867042370438 1.00632294419585e-06 0.7563117925204224 1.006323085519364e-06 0.7581313010100689 1.006323203298972e-06 0.7596352654099263 \
1.006323331697459e-06 0.7612620174900669 1.006323474021161e-06 0.7630496612437514 1.006323590410316e-06 0.7644991888858087 1.006323736133977e-06 0.7662987831554334 \
1.006323857913867e-06 0.7677897310961733 1.006323976478797e-06 0.7692300520321635 1.006324099092246e-06 0.7707078417740018 1.006324225543629e-06 0.77221964326554 \
1.006324335666584e-06 0.7735261258099556 1.006324461188726e-06 0.7750039859681491 1.006324566849672e-06 0.7762386743660952 1.006324702026829e-06 0.7778058706872942 \
1.006324825637346e-06 0.7792267957652825 1.006324955634725e-06 0.7807078764205345 1.006325068606223e-06 0.7819831642610904 1.006325176500111e-06 0.7831908181350914 \
1.006325313030793e-06 0.7847046126527283 1.006325463151702e-06 0.7863508260127218 1.006325605416006e-06 0.7878933964149381 1.006325724997519e-06 0.7891771019825847 \
1.006325861808649e-06 0.7906313890246753 1.006325984312413e-06 0.7919206245676671 1.006326128984341e-06 0.7934276941869095 1.006326269769414e-06 0.794878360380241 \
1.006326396585209e-06 0.796171745508174 1.006326515632602e-06 0.7973744708066829 1.006326627895563e-06 0.7984986270115709 1.006326732283333e-06 0.7995352562746869 \
1.006326827560395e-06 0.8004739840425704 1.006326963902891e-06 0.8018044219089175 1.00632708076796e-06 0.8029326473252685 1.006327200364489e-06 0.8040757482679398 \
1.006327322250299e-06 0.8052288531124292 1.006327444838559e-06 0.8063765489401953 1.006327572579618e-06 0.8075599074701925 1.006327697362526e-06 0.8087035441861687 \
1.006327827862901e-06 0.8098867241643505 1.006327954229597e-06 0.8110199871086299 1.006328081578389e-06 0.8121498004723215 1.006328186791179e-06 0.8130740322933268 \
1.006328291495184e-06 0.8139855427426806 1.00632838302539e-06 0.8147757515715357 1.00632850639836e-06 0.8158311616195392 1.006328593352408e-06 0.8165684017534872 \
1.006328692208245e-06 0.8173999442793862 1.006328836710884e-06 0.8186029267949408 1.006328973036573e-06 0.8197243345631372 1.006329082445008e-06 0.8206145128367788 \
1.006329228461948e-06 0.821788834531623 1.006329380203007e-06 0.8229927727264784 1.006329506119585e-06 0.8239792970156907 1.006329650568649e-06 0.8250971468990039 \
1.006329775264817e-06 0.8260503472050121 1.006329925878834e-06 0.8271873005969326 1.006330061249302e-06 0.8281959289694237 1.006330186472937e-06 0.8291179217777711 \
1.006330304128897e-06 0.8299746468143927 1.00633044991051e-06 0.8310230722388168 1.00633061639426e-06 0.8322027532553667 1.006330747215024e-06 0.8331167337813133 \
1.006330920675045e-06 0.834311196379941 1.006331088787841e-06 0.8354501125721271 1.006331258668969e-06 0.8365827385393307 1.006331439512628e-06 0.8377685497174457 \
1.006331582704692e-06 0.8386931238161603 1.006331696822189e-06 0.8394210074154138 1.006331826873799e-06 0.8402408682651782 1.006331928753516e-06 0.8408758513273116 \
1.006332045641139e-06 0.841596551294542 1.006332182786859e-06 0.8424315815669623 1.006332380696072e-06 0.8436167827761205 1.006332572515411e-06 0.8447436440637145 \
1.006332781866157e-06 0.8459494874145237 1.006332964017768e-06 0.8469786287449077 1.006333161103991e-06 0.8480715276019779 1.006333334356719e-06 0.8490148531186206 \
1.006333517450963e-06 0.8499943787178993 1.00633368858243e-06 0.8508936588199895 1.006333863270272e-06 0.8517955326875627 1.006334038504287e-06 0.8526841769874772 \
1.006334214641154e-06 0.8535614892404448 1.006334405008494e-06 0.8544920815553035 1.006334595580845e-06 0.8554057038167108 1.006334795976838e-06 0.8563474066245403 \
1.006334988566464e-06 0.8572344253714166 1.006335199466375e-06 0.858185963363946 1.006335427341862e-06 0.8591913103610016 1.006335693424718e-06 0.8603357477151101 \
1.006335991926854e-06 0.8615822374427254 1.006336267816323e-06 0.8627000332972231 1.006336552083493e-06 0.8638181192989086 1.006336826221443e-06 0.8648650323418529 \
1.006337098522366e-06 0.8658754039994767 1.006337368678562e-06 0.8668495780678541 1.006337625862699e-06 0.8677515347235455 1.006337898421613e-06 0.8686810999091764 \
1.006338174469332e-06 0.8695957110915412 1.006338444589598e-06 0.8704649939918846 1.006338744449489e-06 0.8714007440816277 1.006339115430114e-06 0.8725171209518352 \
1.006339410352536e-06 0.8733732402027278 1.006339664628271e-06 0.8740897163373675 1.006339962841735e-06 0.8749052413925265 1.006340236411347e-06 0.8756305047096297 \
1.006340472534748e-06 0.8762394088953867 1.006340712859886e-06 0.8768433401198644 1.006340935193821e-06 0.8773882060838187 1.006341129200254e-06 0.8778530214284207 \
1.006341458909681e-06 0.8786208714695904 1.00634161408109e-06 0.87897283049042 1.006341931723491e-06 0.8796750328643211 1.006342110604035e-06 0.8800599154915705 \
1.006342453064798e-06 0.8807759898408113 1.00634263726721e-06 0.8811501695110489 1.006343112296513e-06 0.8820806183873429 1.006343279683462e-06 0.8823969901232691 \
1.006343745459843e-06 0.8832471741583867 1.006343926299187e-06 0.8835657112976044 1.006344420308805e-06 0.8844044135654346 1.006344561623711e-06 0.8846360992458032 \
1.006345167867327e-06 0.8855901496945974 1.006345319942526e-06 0.8858196526512701 1.006345966662599e-06 0.8867549368993356 1.006346094949267e-06 0.8869330782847171 \
1.006346743158686e-06 0.8877977435561634 1.006346872882985e-06 0.8879638504720397 1.006347641302053e-06 0.8888993076310558 1.006347771073903e-06 0.8890488273083775 \
1.006348624736509e-06 0.8899738047157748 1.006348767761561e-06 0.8901192131187072 1.006349754067048e-06 0.8910487927319016 1.0063499755536e-06 0.8912403904783051 \
1.006351118378139e-06 0.8921548233216382 1.006351248258076e-06 0.8922544308366913 1.006352600758498e-06 0.8932425879319322 1.006352751041431e-06 0.8933452769452155 \
1.006354231575698e-06 0.8942627870546499 1.006354470485492e-06 0.8943950258099049 1.006356252518433e-06 0.8952625983306248 1.00635663826586e-06 0.895426813549116 \
1.006359040424079e-06 0.8963023915260389 1.006359515360049e-06 0.8964490046842035 1.006363433287165e-06 0.8974035634625627 1.006363903247409e-06 0.8974927205890085 \
1.006372272035387e-06 0.8984807567386782 1.006372492545714e-06 0.8984960697096243 1.006417072074293e-06 0.8994905034760702 1.006418273460192e-06 0.8995076493514624 \
1.006554083268694e-06 0.9004821828323031 1.006554262245419e-06 0.9005421539807538 1.006557707120337e-06 0.8996085030263692 1.006557879904192e-06 0.8994755022453073 \
1.006559206223899e-06 0.8985168769831137 1.006559392989208e-06 0.8983970610744239 1.006561177194233e-06 0.8974304740967198 1.006561389324515e-06 0.8973403978332656 \
1.006574730020299e-06 0.8983331062395279 1.006574843308145e-06 0.8983517458922662 1.006583546661241e-06 0.8993273409280406 1.00658409447182e-06 0.8993637478389299 \
1.007076621843715e-06 0.9003542216796759 1.007076717582567e-06 0.9004233209197793 1.007077660131942e-06 0.9014023545001312 1.007077822585254e-06 0.9016297223302431 \
1.0070783892915e-06 0.9025464066367429 1.007078496462212e-06 0.9027401250447874 1.007078889770564e-06 0.9035002370985188 1.007079022567928e-06 0.9037710185404622 \
1.007079402169034e-06 0.9045728679206633 1.00707953238378e-06 0.9048512534150681 1.007079993790073e-06 0.9057878278182891 1.007080113037131e-06 0.9060008176934132 \
1.007081542646165e-06 0.9050557440230738 1.007081626316293e-06 0.9046580283931719 1.007081751622122e-06 0.9039622140338933 1.007081859436291e-06 0.9032622438705011 \
1.007081978430637e-06 0.9023800387125585 1.007082093802854e-06 0.9014106868475621 1.007082183899751e-06 0.900578017289966 1.007082295347455e-06 0.8994526603282017 \
1.007082381426603e-06 0.8985125975436928 1.007082487392251e-06 0.8972736935213672 1.007082587160617e-06 0.8960214106762436 1.007082668156228e-06 0.8949470092681954 \
1.007082777804195e-06 0.8934133399212493 1.007082863391606e-06 0.8921520042367302 1.007082955514215e-06 0.8907345325087322 1.007083043733598e-06 0.8893220116766375 \
1.007083152508351e-06 0.8875100775672261 1.007083235401386e-06 0.8860780350921965 1.007083343975057e-06 0.8841400608632336 1.007083436201252e-06 0.8824412727986957 \
1.00708352082175e-06 0.8808423775446282 1.00708360666218e-06 0.8791839877465467 1.00708368587706e-06 0.8776224824828824 1.00708376196503e-06 0.8760960492665846 \
1.007083854301399e-06 0.874210837196514 1.007083914177735e-06 0.8729702140710593 1.007083971566019e-06 0.8717685933706794 1.007084033561192e-06 0.8704574090763495 \
1.007084096840043e-06 0.8691057216070059 1.007084146911381e-06 0.8680269866686803 1.007084196353533e-06 0.8669542389500936 1.00708426002324e-06 0.8655623656543436 \
1.007084335970659e-06 0.8638877358586781 1.007084384801671e-06 0.8628032002737418 1.007084433325624e-06 0.8617197496806845 1.007084509037347e-06 0.8600184098866027 \
1.007084576246125e-06 0.8584975010852487 1.007084618952631e-06 0.8575263577286506 1.007084662855204e-06 0.8565244243916033 1.007084750660351e-06 0.8545103166059256 \
1.00708481351352e-06 0.8530605771626394 1.007084872183177e-06 0.8517018597088126 1.007084908361779e-06 0.8508614974547222 1.007084943180258e-06 0.8500510151036469 \
1.007084978206243e-06 0.8492340038666518 1.007085048258213e-06 0.8475953578585981 1.007085096728698e-06 0.8464581214772323 1.007085140673499e-06 0.8454248116355969 \
1.007085186191255e-06 0.8443523575543517 1.007085250092166e-06 0.8428433081697474 1.00708531621854e-06 0.8412777165526386 1.007085421348608e-06 0.8387809254526315 \
1.007085509283283e-06 0.8366857089760468 1.007085588228565e-06 0.834800137446173 1.007085676393602e-06 0.8326899670047023 1.007085763209599e-06 0.8306078985741704 \
1.007085851101283e-06 0.8284959280419055 1.007085942350373e-06 0.8262996967350639 1.007086045112241e-06 0.8238226494465998 1.007086143615716e-06 0.8214450402687625 \
1.007086255948631e-06 0.8187302447322098 1.007086368922768e-06 0.8159967029774419 1.007086490210663e-06 0.8130591602364435 1.007086620717817e-06 0.8098958628758253 \
1.00708674976372e-06 0.8067658935936169 1.00708690323932e-06 0.8030416153605923 1.00708706852354e-06 0.799029304640783 1.007087236264745e-06 0.7949567682299736 \
1.007087432788334e-06 0.7901857478752816 1.007087637550659e-06 0.7852160332972318 1.007087850227715e-06 0.7800563994093253 1.007088050847662e-06 0.7751902022758907 \
1.007088251706389e-06 0.7703212856706637 1.007088401728407e-06 0.766686939713112 1.007088532263574e-06 0.7635264252913375 1.007088666681014e-06 0.7602735436595947 \
1.007088772876545e-06 0.7577048602246427 1.007088906182877e-06 0.754482067181252 1.007089013215803e-06 0.7518959494812111 1.007089156291704e-06 0.7484409822837247 \
1.007089320797846e-06 0.7444713482725677 1.007089441615092e-06 0.74155777711076 1.007089612721756e-06 0.7374334100931738 1.007089773612309e-06 0.733558046396253 \
1.00708999020493e-06 0.7283457217000903 1.007090183460631e-06 0.7236999380850822 1.007090362395765e-06 0.7194029726762079 1.007090529212387e-06 0.7154015770462002 \
1.007090715418352e-06 0.7109395231330657 1.007090903351593e-06 0.7064416825495208 1.007091069273699e-06 0.7024749886985119 1.007091261631787e-06 0.6978803202016938 \
1.007091402988682e-06 0.6945068232011449 1.007091559996444e-06 0.6907636199298515 1.007091755976089e-06 0.6860965106368763 1.007091918410194e-06 0.6822325558671515 \
1.007092079586376e-06 0.6784034260021697 1.007092271894574e-06 0.6738409413562468 1.007092489556454e-06 0.6686845685784016 1.007092737577756e-06 0.6628199086538362 \
1.007092915635219e-06 0.6586162961343578 1.007093164179028e-06 0.6527567611811057 1.007093366786271e-06 0.6479896840619462 1.007093536596938e-06 0.6440011601507294 \
1.007093695213124e-06 0.6402799599229552 1.007093833743559e-06 0.637035894415233 1.007093969951321e-06 0.6338503464729111 1.007094096262698e-06 0.6309003762865483 \
1.007094225721933e-06 0.6278810604265532 1.007094354053672e-06 0.6248911458464299 1.007094485383603e-06 0.6218374290191309 1.007094617410215e-06 0.6187713222160208 \
1.007094761570095e-06 0.6154276788919771 1.007094905778687e-06 0.6120888358645944 1.007095053433791e-06 0.6086753592300279 1.007095200490149e-06 0.6052842859263143 \
1.007095358304176e-06 0.6016504852589418 1.007095490909828e-06 0.5986039825107707 1.007095622374795e-06 0.5955897059985247 1.007095741804593e-06 0.5928552647156846 \
1.007095877873286e-06 0.5897484304797134 1.007095992801548e-06 0.5871283594046445 1.007096143912269e-06 0.5836892419704927 1.007096258561337e-06 0.5810871834776226 \
1.007096376499006e-06 0.5784138884735546 1.007096466280294e-06 0.576381560286313 1.007096556599689e-06 0.5743415774978985 1.007096623290559e-06 0.5728373329037385 \
1.007096688852372e-06 0.5713590910263378 1.007096739894496e-06 0.5702089751121119 1.007096801596215e-06 0.5688198806440578 1.007096864686071e-06 0.5674025889664359 \
1.007096929044425e-06 0.5659586381304559 1.007096982438224e-06 0.5647616504486359 1.007097075080806e-06 0.5626864159088959 1.007097151688079e-06 0.5609719030357503 \
1.007097207513141e-06 0.5597256439368602 1.007097276567267e-06 0.5581857825097393 1.007097383455393e-06 0.5558054549196561 1.007097461199018e-06 0.5540764009223496 \
1.007097562049117e-06 0.5518382286767042 1.007097687729972e-06 0.5490568313009737 1.007097787971657e-06 0.5468419758621708 1.00709789988934e-06 0.5443739014182352 \
1.007098003155247e-06 0.5421024366463116 1.007098122904589e-06 0.5394737463112931 1.007098224637469e-06 0.5372436950013484 1.007098340157213e-06 0.5347185748314579 \
1.007098455192299e-06 0.5322102907975605 1.007098581673211e-06 0.529456475824718 1.007098707047009e-06 0.5267350629320526 1.007098853862932e-06 0.5235577714138258 \
1.007098989426381e-06 0.5206304261698983 1.007099147124634e-06 0.5172373565578411 1.007099309443689e-06 0.5137528589513558 1.007099490267585e-06 0.5098871206809381 \
1.007099682715905e-06 0.5057874350093188 1.007099895621209e-06 0.5012700264709963 1.007100127802608e-06 0.4963634062180514 1.007100385093187e-06 0.4909555076455908 \
1.00710062471901e-06 0.4859407514401474 1.007100926434446e-06 0.479662588092526 1.0071012143538e-06 0.4737079198104491 1.007101527242619e-06 0.4672821326282255 \
1.007101846980824e-06 0.4607585360408045 1.007102186575985e-06 0.4538766993710576 1.007102513478483e-06 0.4472977926730654 1.007102849036864e-06 0.4405887635920606 \
1.007103166132787e-06 0.4342949501181722 1.007103500370541e-06 0.4277061431972559 1.007103851801663e-06 0.4208322784122511 1.007104166327818e-06 0.4147233751108969 \
1.007104489505308e-06 0.4084912998479469 1.007104930620066e-06 0.400057814108821 1.007105272736104e-06 0.3935812134363078 1.007105572680633e-06 0.3879522399691127 \
1.007105947811639e-06 0.3809760137481454 1.007106277555878e-06 0.3749002425561211 1.007106560798803e-06 0.3697269896098562 1.007106860945059e-06 0.3642865787664632 \
1.007107140547253e-06 0.3592589179584539 1.007107364323365e-06 0.3552676761685443 1.007107576103695e-06 0.3515151294490645 1.007107778537159e-06 0.3479514629380864 \
1.007107979628427e-06 0.3444362246481504 1.007108185342845e-06 0.3408632458568372 1.007108452965717e-06 0.3362478643926977 1.007108691897011e-06 0.3321601360780691 \
1.007108925403074e-06 0.3281974319442653 1.007109138868474e-06 0.3246000376975314 1.007109360246046e-06 0.3208952602338652 1.007109560209693e-06 0.3175728982722026 \
1.007109764482006e-06 0.3142073831356898 1.007109961828878e-06 0.3109812293225088 1.007110147201405e-06 0.3079732989686547 1.007110343307796e-06 0.3048147723336881 \
1.007110545584936e-06 0.3015820927993307 1.007110721243233e-06 0.2988007390096292 1.00711090711339e-06 0.295878328903569 1.007111114092782e-06 0.2926488196724605 \
1.007111299414374e-06 0.2897857719971084 1.007111494641182e-06 0.2867989994419413 1.007111650415531e-06 0.28443329608414 1.007111829172313e-06 0.2817356906084737 \
1.007112010203233e-06 0.2790344478478936 1.007112160100347e-06 0.2768142575519123 1.007112361143774e-06 0.273859574769726 1.007112510258904e-06 0.2716833853889438 \
1.007112648798333e-06 0.2696726034832688 1.007112800673409e-06 0.2674956304896134 1.007112915147537e-06 0.2658586287383957 1.007113046677468e-06 0.2639823142040156 \
1.007113172435956e-06 0.2622048582339201 1.007113276776362e-06 0.2607341604582348 1.007113389755722e-06 0.2591418073851619 1.007113506084246e-06 0.2575033437579446 \
1.007113649011667e-06 0.2554974228347739 1.007113762273172e-06 0.2539102348881249 1.007113896429905e-06 0.2520298733123076 1.00711400690271e-06 0.2504818583075984 \
1.007114162335285e-06 0.2483006006477398 1.007114303220384e-06 0.2463217957442577 1.007114454612954e-06 0.2441928603691365 1.007114609775035e-06 0.2420086586735095 \
1.007114739184283e-06 0.2401849910837116 1.007114873896377e-06 0.2382868210192302 1.007115011594201e-06 0.2363478190565156 1.007115129346217e-06 0.2346905900295477 \
1.00711528867041e-06 0.2324499447852502 1.007115425932636e-06 0.2305210708572645 1.007115566678993e-06 0.2285488733964877 1.007115672470167e-06 0.2270688194984586 \
1.007115802411565e-06 0.2252532503786337 1.007115902948028e-06 0.2238506847401111 1.007116005281736e-06 0.2224250970611539 1.007116079010317e-06 0.2214012665004395 \
1.00711615824426e-06 0.2203047212273054 1.007116229215507e-06 0.2193236206014474 1.007116280678535e-06 0.218612902325451 1.007116333626988e-06 0.2178825126218075 \
1.007116412781991e-06 0.2167921001391954 1.007116455054626e-06 0.2162104926182252 1.007116494899171e-06 0.2156628374086678 1.00711653812282e-06 0.2150692779925967 \
1.007116579029823e-06 0.2145080585354088 1.007116649152284e-06 0.2135474129702876 1.007116682837256e-06 0.2130867492099046 1.007116727666638e-06 0.212477723463 \
1.0071167865238e-06 0.2116792343136102 1.007116851309261e-06 0.2108017053965978 1.007116908790024e-06 0.2100241135398916 1.007116969219033e-06 0.209207737948094 \
1.007117066255463e-06 0.2078991976528634 1.007117150945123e-06 0.2067595417901527 1.007117259855885e-06 0.2052972881712416 1.007117356256692e-06 0.2040065614180294 \
1.007117451273329e-06 0.2027428333585779 1.007117554705127e-06 0.2013717100485363 1.007117649634473e-06 0.2001158751783069 1.007117752654899e-06 0.198757993281026 \
1.007117857737332e-06 0.1973779917312911 1.007117967046146e-06 0.1959482000350934 1.007118077489628e-06 0.1945091075764383 1.007118193779904e-06 0.1929996650696684 \
1.007118303709896e-06 0.1915811184357085 1.00711841337232e-06 0.1901717999899754 1.007118515088965e-06 0.1888694322720079 1.007118608043679e-06 0.1876837490531375 \
1.007118700772569e-06 0.1865049219968967 1.007118774458125e-06 0.1855719169757668 1.00711885729934e-06 0.1845269810791141 1.007118931885336e-06 0.1835895008849975 \
1.007119001608678e-06 0.1827150226754214 1.007119068327085e-06 0.1818808699270075 1.007119164170411e-06 0.1806871657728035 1.007119246877184e-06 0.1796611249561687 \
1.007119340441008e-06 0.1785035608809835 1.007119435337095e-06 0.1773351434884491 1.007119546707405e-06 0.1759704596301353 1.007119688349759e-06 0.1742450478777388 \
1.007119803596612e-06 0.1728486436789435 1.007119948144251e-06 0.1711076225712051 1.007120059739928e-06 0.1697708811114609 1.007120200958902e-06 0.1680898955975501 \
1.007120316696175e-06 0.1667201145354908 1.007120422656861e-06 0.1654722325850081 1.007120521416477e-06 0.164314417410061 1.00712061775965e-06 0.1631901152369615 \
1.007120706417402e-06 0.1621596955203892 1.007120831751673e-06 0.1607099933926625 1.007120926277088e-06 0.1596224416957933 1.00712102401604e-06 0.1585042187118262 \
1.007121132110917e-06 0.1572745454417887 1.007121226778605e-06 0.1562036643369483 1.007121334226451e-06 0.1549951394274829 1.007121425315495e-06 0.1539767092330788 \
1.007121532087207e-06 0.1527896463435911 1.007121635480473e-06 0.1516469620792683 1.007121746560958e-06 0.1504267727114754 1.00712183578694e-06 0.1494522115900035 \
1.007121921266868e-06 0.1485231035185812 1.007122005192055e-06 0.1476157397758405 1.007122074898619e-06 0.1468658175993407 1.007122153536697e-06 0.1460232248551682 \
1.007122231847954e-06 0.1451880611912267 1.007122302483827e-06 0.1444378248611795 1.007122387974695e-06 0.1435337156153706 1.007122475363672e-06 0.1426139614481139 \
1.007122556951186e-06 0.1417594571206545 1.007122654270137e-06 0.1407454482154784 1.007122734959659e-06 0.139910090776864 1.007122825744691e-06 0.1389752404035735 \
1.007122947088963e-06 0.1377336220260025 1.007123036138604e-06 0.13682812281983 1.007123134655454e-06 0.1358318692385875 1.007123221741723e-06 0.1349560640726983 \
1.007123332152611e-06 0.1338550874529322 1.007123420611433e-06 0.1329791517134813 1.007123521340026e-06 0.1319874611681985 1.00712362612958e-06 0.1309622419763913 \
1.007123720519813e-06 0.1300442429014473 1.007123817024605e-06 0.1291112112475518 1.007123916511258e-06 0.1281591654439075 1.007124002912429e-06 0.1273384721630967 \
1.00712409789256e-06 0.1264411177628728 1.007124202081388e-06 0.1254629331099751 1.007124311200138e-06 0.124445178694 1.007124405550594e-06 0.1235704029653004 \
1.007124517846343e-06 0.1225411084520107 1.007124613309697e-06 0.1216733466577494 1.007124717520587e-06 0.1207311846737792 1.007124806865944e-06 0.1199276649878674 \
1.007124877253218e-06 0.1192980345746366 1.007124952639251e-06 0.1186268760051257 1.007125028771421e-06 0.1179522201461119 1.007125097748918e-06 0.1173458504859956 \
1.007125180268091e-06 0.1166263596898966 1.007125252211578e-06 0.1160015972854393 1.007125334290304e-06 0.1152916772467617 1.00712541862478e-06 0.1145654108773922 \
1.007125496418619e-06 0.113898375935255 1.007125589183521e-06 0.1131065723182637 1.007125704787342e-06 0.1121254933399327 1.007125810692911e-06 0.1112341778178403 \
1.007125888349831e-06 0.1105854195321705 1.007125976646302e-06 0.1098504899494786 1.007126056703354e-06 0.1091866403929743 1.007126153629479e-06 0.1083861389179563 \
1.007126248864964e-06 0.1076031391441806 1.007126337436159e-06 0.1068780200140514 1.00712643874426e-06 0.1060523297458165 1.007126544289947e-06 0.1051963702337609 \
1.007126653484312e-06 0.1043160928234657 1.007126761601933e-06 0.1034503663302994 1.007126881519694e-06 0.1024949450012773 1.007126982881521e-06 0.1016914181115986 \
1.007127088891151e-06 0.100855068690839 1.00712721468278e-06 0.09986840123414902 1.007127344240086e-06 0.09885896724496235 1.00712747991544e-06 0.09780904711780367 \
1.007127655987304e-06 0.09645781830037269 1.007127819787824e-06 0.09521257997344186 1.007127982612565e-06 0.09398642071914091 1.0071280677512e-06 0.09334985726464029 \
1.007128137589223e-06 0.09282999162688726 1.007128207084828e-06 0.09231474740697931 1.007128281043488e-06 0.09176875214326782 1.007128377198376e-06 0.09106241641841166 \
1.007128451613741e-06 0.09051841344162129 1.007128529603309e-06 0.08995079828656057 1.00712860605214e-06 0.08939693755534793 1.007128693546224e-06 0.08876614459792892 \
1.007128795722934e-06 0.08803382885421264 1.007128884287322e-06 0.08740269463919083 1.00712899395281e-06 0.08662585268124241 1.007129110009217e-06 0.08580942306245626 \
1.007129251558034e-06 0.0848216759818637 1.007129384427018e-06 0.08390253510334872 1.007129525187328e-06 0.08293727564630923 1.007129674896948e-06 0.08192024575105315 \
1.007129810608835e-06 0.08100683753927941 1.007129952125717e-06 0.08006309454860433 1.007130087247591e-06 0.07917070961097784 1.007130228520028e-06 0.07824718349428782 \
1.00713037561292e-06 0.07729532867436953 1.007130527122786e-06 0.07632524417621221 1.0071306924985e-06 0.07527819040792309 1.00713085625969e-06 0.07425356708383206 \
1.007131032389632e-06 0.07316505371836476 1.00713122152861e-06 0.07201151367936541 1.007131432202234e-06 0.07074528708793332 1.007131651768856e-06 0.06944624562626683 \
1.007131886535262e-06 0.06808094281860989 1.0071321449277e-06 0.06660616301228137 1.007132439592361e-06 0.06496103773121734 1.007132743671683e-06 0.06330286177969326 \
1.007133104582163e-06 0.06138472526627536 1.007133440499035e-06 0.05964719353945821 1.007133880676406e-06 0.05743991201668189 1.007134259043809e-06 0.05560437501227136 \
1.007134701502771e-06 0.05352996728430704 1.007135055522916e-06 0.05192508193542229 1.007135442039672e-06 0.05022502935509546 1.007135786643729e-06 0.04875485597254389 \
1.007136108618665e-06 0.04741934964807833 1.007136412152492e-06 0.04619304551845941 1.007136707073488e-06 0.04503122626702559 1.007136989555767e-06 0.04394770877170886 \
1.007137266636177e-06 0.04291147062934708 1.007137532363668e-06 0.04194013461971725 1.007137803594355e-06 0.0409708748276704 1.007138079853372e-06 0.04000619535229137 \
1.007138369752594e-06 0.03901828782233653 1.007138598128988e-06 0.03825741181922668 1.007138903013054e-06 0.03726495139513845 1.00713911968491e-06 0.03657573971894532 \
1.007139311041637e-06 0.03597943984071691 1.007139509636156e-06 0.03537298232318693 1.007139839551497e-06 0.03438820140908775 1.00714008149717e-06 0.03368375433354889 \
1.007140396809222e-06 0.03278771666975258 1.007140666929207e-06 0.03203957074185158 1.007140923300881e-06 0.03134567005659093 1.007141203312881e-06 0.03060515313352298 \
1.007141448968657e-06 0.02997014710356035 1.007141681704302e-06 0.02938120249260199 1.007141924434299e-06 0.02878348292867495 1.007142161161563e-06 0.02821317433052753 \
1.007142389807974e-06 0.0276732289298247 1.007142807093634e-06 0.02671456010533928 1.007143002274328e-06 0.02627749693639509 1.007143383441411e-06 0.02544369227895442 \
1.007143560694233e-06 0.02506446942885681 1.007143903145688e-06 0.02434654114125227 1.00714405641412e-06 0.02403127656358269 1.007144431432584e-06 0.02327616399748992 \
1.007144569066725e-06 0.02300530455388665 1.007145053333359e-06 0.02207084195640928 1.00714517295276e-06 0.02184403312078184 1.007145589991564e-06 0.02106026682208277 \
1.007145733393791e-06 0.02079332360769017 1.007146254605173e-06 0.01984598817089831 1.007146382379043e-06 0.0196205814374062 1.007146966791417e-06 0.01863359713481367 \
1.007147139226823e-06 0.01835589372257288 1.007147743323573e-06 0.01743644241612937 1.007147904755214e-06 0.01720262545858322 1.007148544701434e-06 0.01631831686205014 \
1.0071487230176e-06 0.016083210242981 1.007149371001649e-06 0.01526127675881721 1.00714953625524e-06 0.01505930898173208 1.007150272557175e-06 0.01419381259610907 \
1.007150406833225e-06 0.01404154276213586 1.007151203932743e-06 0.01317592498067951 1.007151344530354e-06 0.01302934089458718 1.007152309873577e-06 0.0120661300044765 \
1.007152474212383e-06 0.01190857475316222 1.007153474943512e-06 0.01099048917119646 1.007153612213369e-06 0.01087009009405628 1.007154750907886e-06 0.009949273443646761 \
1.007154865085787e-06 0.009863136028526375 1.007156245730622e-06 0.008889755784408603 1.007156400087833e-06 0.00878832203975914 1.007157946582061e-06 0.00781340401000951 \
1.007158030943764e-06 0.007760176032106158 1.007159716371082e-06 0.006770348169342283 1.007159839899572e-06 0.00670487246831437 1.007161889714139e-06 0.005720970231232756 \
1.007162086114296e-06 0.005634691917282852 1.007164404793654e-06 0.004698942116576918 1.007164865407988e-06 0.004530544077955615 1.00716760550353e-06 0.003639937533647344 \
1.007168123648567e-06 0.00349159181499799 1.007172274289875e-06 0.002502201117031859 1.007172812139883e-06 0.002396807933581942 1.00717889437533e-06 0.001421603691354927 \
1.00717915335574e-06 0.001378272220758726 1.00718447611909e-06 0.0003814093765652445 1.007184589276134e-06 0.0003711807182531981 1.00983070639237e-06 -0.0004615907568095335 \
1.009830868831338e-06 -0.0006852153244161934 1.009831369832807e-06 -0.001554404032531494 1.00983145401537e-06 -0.001725199767551738 1.009831855538194e-06 -0.002626792336557519 \
1.009831944873161e-06 -0.002845673237760077 1.00983223146497e-06 -0.0035898660494722 1.009832359033499e-06 -0.003937855927128601 1.009832677745161e-06 -0.004830400105952924 \
1.009832791946313e-06 -0.00515011308870196 1.009833074346638e-06 -0.005887653497963378 1.009833204572857e-06 -0.006177415671381139 1.009834182925754e-06 -0.005220113099403402 \
1.009834370233287e-06 -0.004004368716724641 1.009834501677689e-06 -0.002901539130564616 1.009834607105242e-06 -0.001869327786897239 1.009834692822726e-06 -0.0009323217369615201 \
1.009834774749213e-06 4.151965372454519e-05 1.009834895786036e-06 0.001618129410352471 1.009834994714683e-06 0.003024565667809575 1.009835153111357e-06 0.005482561958548801 \
1.009835370558587e-06 0.00923691162542661 1.00983555178081e-06 0.0126653356758144 1.009835763874906e-06 0.01697021734206094 1.009835926898563e-06 0.02046388365739064 \
1.009836087520978e-06 0.02403759527126768 1.009836241061221e-06 0.02755862871109176 1.009836389117902e-06 0.031036270750196 1.009836538198811e-06 0.03460722192241437 \
1.009836692728723e-06 0.03837091703902212 1.009836853379538e-06 0.04234026030123839 1.009837018034219e-06 0.04645786783841532 1.009837194575117e-06 0.05091770581196236 \
1.009837373537969e-06 0.05547793877747508 1.009837564281134e-06 0.0603721650098247 1.009837769062163e-06 0.06565647483694508 1.009837989534449e-06 0.07137203566208646 \
1.009838222394174e-06 0.0774299331224613 1.00983847158165e-06 0.08392829098722057 1.009838744423778e-06 0.09105513637423955 1.009839041127578e-06 0.09880974921055499 \
1.009839368453968e-06 0.1073623706929605 1.009839738105355e-06 0.11701033799881 1.009840132977169e-06 0.1273002725707723 1.00984059081541e-06 0.1392030195235975 \
1.00984112262225e-06 0.1529832553757746 1.009841747860046e-06 0.1691182447448397 1.009842433607517e-06 0.1867241161332086 1.009843236003391e-06 0.2071957342970069 \
1.009844134802183e-06 0.2299563735557614 1.009844940415632e-06 0.2501946571168963 1.009845654166966e-06 0.2679877251922811 1.009846283728848e-06 0.2835633151515627 \
1.009846854092298e-06 0.2975737963344939 1.00984738504768e-06 0.3105173405876944 1.009847886835131e-06 0.3226580892822354 1.009848366129684e-06 0.3341673054699896 \
1.009848831685103e-06 0.3452566901045974 1.009849295481511e-06 0.3562094254686541 1.009849751229541e-06 0.3668794056881832 1.009850211449675e-06 0.3775613305945491 \
1.009850749733646e-06 0.3899285626759094 1.00985125058418e-06 0.4013172511919189 1.009851650806863e-06 0.4103337945930838 1.009852157667644e-06 0.421642452039157 \
1.009852643633856e-06 0.4323669409017459 1.009853043148568e-06 0.4410997362599856 1.009853453760627e-06 0.4500002277813482 1.00985388268706e-06 0.4592207708982954 \
1.009854284201442e-06 0.4677760623951868 1.009854591591889e-06 0.4742753916877908 1.009854941833647e-06 0.4816249679276425 1.00985529507385e-06 0.4889795533930016 \
1.00985554824443e-06 0.4942125642332652 1.00985578118832e-06 0.4989990073547648 1.009856022831611e-06 0.5039392821429431 1.00985624782223e-06 0.5085102868389438 \
1.009856439858337e-06 0.5123881070394828 1.009856624670034e-06 0.5161059569497825 1.00985684696035e-06 0.5205538992744256 1.009857013671757e-06 0.5238726938135662 \
1.009857230888352e-06 0.5281726418673847 1.009857433967244e-06 0.5321820613122353 1.009857611378699e-06 0.5356681922482178 1.009857799451086e-06 0.5393528234657015 \
1.009858035483266e-06 0.5439555888699217 1.00985830136529e-06 0.5491186112539347 1.009858523127178e-06 0.5534070305875756 1.009858803185033e-06 0.5588091140818973 \
1.009859046184818e-06 0.5634839438879177 1.009859321538161e-06 0.5687575845994758 1.009859566533502e-06 0.5734440561015828 1.009859806827721e-06 0.5780305526007354 \
1.009860047867023e-06 0.5826153106864888 1.009860305457841e-06 0.5874946531182738 1.009860540824618e-06 0.5919209497705462 1.009860772126727e-06 0.5962518282209535 \
1.009860994653448e-06 0.6003950532231523 1.009861203013056e-06 0.6042587207462122 1.00986144085487e-06 0.6086392006348278 1.009861651715085e-06 0.612499186772883 \
1.009861907322267e-06 0.617151767543529 1.009862106050033e-06 0.620751700070918 1.009862381682677e-06 0.6257066023742009 1.009862604438798e-06 0.6296824120643636 \
1.009862897809922e-06 0.6348814180513288 1.009863130579923e-06 0.6389753720667986 1.009863350781309e-06 0.6428252659334456 1.009863552051921e-06 0.6463216644290061 \
1.009863769340794e-06 0.6500784077528632 1.009863944056703e-06 0.6530842133917786 1.009864130321333e-06 0.6562672470877895 1.009864309060386e-06 0.6593113758161715 \
1.009864471764399e-06 0.6620700940033843 1.00986463703341e-06 0.6648583661366954 1.009864780301224e-06 0.6672607123132118 1.009864919531648e-06 0.669583864918244 \
1.009865059332215e-06 0.6719085596965743 1.009865194107422e-06 0.6741424479378803 1.009865321601663e-06 0.6762463034350935 1.009865454555775e-06 0.6784344250006583 \
1.009865576160125e-06 0.680430207161383 1.009865704573366e-06 0.6825336955632141 1.009865820340421e-06 0.6844241240890321 1.009865918381594e-06 0.686020684362688 \
1.0098660190777e-06 0.687656981754083 1.009866128831463e-06 0.689434454762776 1.009866245599418e-06 0.6913211166705923 1.009866336826192e-06 0.6927889453402305 \
1.009866446031605e-06 0.6945396927028351 1.009866547140326e-06 0.6961566646470493 1.009866642540618e-06 0.6976767415743361 1.009866752022643e-06 0.6994136821864276 \
1.009866886474277e-06 0.7015344809028976 1.009867035493214e-06 0.7038694457768003 1.009867164423232e-06 0.7058755144243859 1.009867311083691e-06 0.7081418729260142 \
1.009867437868072e-06 0.7100885084081828 1.009867562465961e-06 0.7119899232102255 1.009867674319728e-06 0.7136874821928206 1.009867787275692e-06 0.7153928249203609 \
1.009867887829089e-06 0.716903336497302 1.009868025110592e-06 0.7189542886859326 1.009868144979452e-06 0.7207346491296758 1.009868264162204e-06 0.7224952472954583 \
1.009868391164313e-06 0.7243608783177121 1.009868515712665e-06 0.726179956024653 1.009868639383676e-06 0.7279757435764195 1.009868765971953e-06 0.7298035010246171 \
1.009868896541188e-06 0.7316777339938921 1.009869019056222e-06 0.7334262671520465 1.009869155299713e-06 0.7353588786631546 1.009869256742486e-06 0.7367901064855561 \
1.009869362765969e-06 0.7382789144707947 1.009869453297152e-06 0.7395446819117977 1.009869567123378e-06 0.7411267287627761 1.00986965478496e-06 0.742338113895605 \
1.009869760680238e-06 0.7437932991468792 1.009869891033533e-06 0.7455718205320391 1.00987000160114e-06 0.7470699275523445 1.009870106271612e-06 0.7484790865773925 \
1.009870230233143e-06 0.7501360792234356 1.009870378790597e-06 0.752105598322839 1.009870500473193e-06 0.7537054667443914 1.009870614584882e-06 0.7551949470168074 \
1.009870755005483e-06 0.7570132059451244 1.009870896533544e-06 0.7588296197226846 1.009871014322813e-06 0.7603289862386273 1.009871142522635e-06 0.7619481626911874 \
1.009871284590468e-06 0.7637269294216019 1.009871401465576e-06 0.7651780119234867 1.009871547139362e-06 0.7669714049983392 1.009871668877809e-06 0.7684572223066155 \
1.009871787518301e-06 0.7698939375992205 1.009871909984595e-06 0.7713653733660819 1.009872036701684e-06 0.7728756341192486 1.009872146603679e-06 0.7741754302862822 \
1.009872272219022e-06 0.7756497674172792 1.009872378029431e-06 0.7768823528242577 1.009872514199553e-06 0.7784559787239111 1.009872638546601e-06 0.7798807766277074 \
1.009872765971877e-06 0.7813271999647126 1.009872880527956e-06 0.7826155184370988 1.009872987208226e-06 0.7838050786084815 1.009873125150823e-06 0.785328674235108 \
1.009873274600319e-06 0.7869612315653352 1.009873419452536e-06 0.7885256944569791 1.009873538888287e-06 0.7898026796320731 1.00987367431316e-06 0.7912364721526877 \
1.009873795807481e-06 0.7925100718437531 1.009873939166556e-06 0.7939977458315933 1.009874082600237e-06 0.7954699260458764 1.009874208411247e-06 0.7967479640295563 \
1.009874327457928e-06 0.7979459892863545 1.009874439471573e-06 0.7990632136113104 1.009874544263454e-06 0.8000996927221937 1.009874639456303e-06 0.8010335634530776 \
1.009874775866828e-06 0.8023587211299719 1.009874892679005e-06 0.8034813603122919 1.009875012140248e-06 0.8046180202255495 1.0098751341806e-06 0.8057672874017472 \
1.009875257080697e-06 0.8069126780167393 1.009875384200053e-06 0.8080849010520604 1.009875509341915e-06 0.8092265787736463 1.009875639893142e-06 0.8104047139317369 \
1.009875765969389e-06 0.811530109085512 1.009875893966049e-06 0.8126603425876329 1.009875999427297e-06 0.8135823118114501 1.009876102696598e-06 0.814477091043954 \
1.009876195349946e-06 0.8152732203909091 1.009876319044181e-06 0.8163262937528154 1.009876406664095e-06 0.8170655553659417 1.009876505330151e-06 0.8178914289762149 \
1.009876648877154e-06 0.819080619224994 1.009876784463307e-06 0.8201904093102529 1.009876893653288e-06 0.8210742465492874 1.009877041102747e-06 0.8222539401850584 \
1.009877191506449e-06 0.8234410273756358 1.009877316975412e-06 0.8244188977545531 1.009877461141395e-06 0.8255287290252299 1.00987758542996e-06 0.8264738611628292 \
1.009877735900256e-06 0.8276038147969816 1.009877871506614e-06 0.8286089145501508 1.009877996601616e-06 0.8295251220930787 1.009878114317453e-06 0.8303776282987162 \
1.009878260203052e-06 0.8314210189912619 1.009878426696148e-06 0.8325942517713072 1.009878557562851e-06 0.833503494447128 1.009878731007462e-06 0.8346911703335461 \
1.009878899140202e-06 0.8358239212093587 1.009879068993949e-06 0.8369500705213252 1.009879249886955e-06 0.838129582835239 1.009879393021216e-06 0.8390486258646698 \
1.009879507119162e-06 0.8397723391454259 1.009879637246322e-06 0.8405879656882547 1.009879739102179e-06 0.8412191375388212 1.009879855947599e-06 0.8419354178465567 \
1.009879992919396e-06 0.84276453896487 1.009880190759142e-06 0.843942473808897 1.00988038244463e-06 0.8450620046306492 1.009880591850993e-06 0.8462610422160779 \
1.009880773861877e-06 0.8472832413425977 1.009880970977333e-06 0.8483697584184032 1.009881144290447e-06 0.8493077402131245 1.009881327325656e-06 0.8502809338042043 \
1.009881498478783e-06 0.8511747489972419 1.009881673131736e-06 0.8520708361396651 1.009881848382891e-06 0.8529540285731302 1.009882024530391e-06 0.8538259128238825 \
1.009882214836779e-06 0.8547503816925358 1.009882405427748e-06 0.8556583881771193 1.009882605979791e-06 0.8565949481971697 1.009882798582589e-06 0.8574764650234362 \
1.009883009331288e-06 0.8584213553684483 1.009883237362186e-06 0.8594210644592908 1.009883503241952e-06 0.8605573106989262 1.009883801820094e-06 0.8617960322792503 \
1.009884077983729e-06 0.8629075153790151 1.009884362230229e-06 0.8640180616030438 1.009884636414231e-06 0.8650581816846495 1.00988490866944e-06 0.8660616517296992 \
1.009885178858915e-06 0.8670295451208139 1.009885436023238e-06 0.8679256252637404 1.009885708596972e-06 0.8688492356117473 1.009885984602435e-06 0.8697577927663542 \
1.009886254710518e-06 0.8706213441784563 1.009886554568938e-06 0.8715508809746347 1.009886925582816e-06 0.8726599440782473 1.009887220515529e-06 0.873510245983525 \
1.009887474800895e-06 0.8742218447789023 1.009887773044171e-06 0.8750318897722944 1.009888046640929e-06 0.8757523113099853 1.009888282767907e-06 0.8763571312809064 \
1.009888523107205e-06 0.876957042728428 1.009888745440861e-06 0.8774982514557473 1.009888939446794e-06 0.8779599514934209 1.009889269165229e-06 0.8787226653583874 \
1.009889424338019e-06 0.8790722725343518 1.009889742071409e-06 0.8797700114458387 1.00988992093906e-06 0.880152324917399 1.009890263400534e-06 0.8808637455080008 \
1.009890447552368e-06 0.8812353200296749 1.009890922478418e-06 0.8821594045029107 1.009891089871654e-06 0.8824737723885729 1.00989155569296e-06 0.8833186808430151 \
1.009891736520447e-06 0.883635209600208 1.009892230549786e-06 0.8844687288968743 1.009892371887773e-06 0.8846990198924604 1.009892978249103e-06 0.8856473543416146 \
1.009893130320955e-06 0.8858754372639542 1.009893777008948e-06 0.8868048391838264 1.009893905303109e-06 0.8869818633102416 1.009894553496582e-06 0.8878410756373726 \
1.009894683245133e-06 0.8880061989117775 1.009895451498601e-06 0.8889361126992519 1.009895581240625e-06 0.8890847997417872 1.009896434697558e-06 0.8900046759307325 \
1.009896577924673e-06 0.8901495209380393 1.009897564158077e-06 0.8910738355210844 1.009897785636141e-06 0.8912643084423501 1.009898928653689e-06 0.8921737958641509 \
1.009899058631989e-06 0.8922730011388891 1.009900410338988e-06 0.8932565980587214 1.009900560692342e-06 0.8933589605607284 1.009902041315768e-06 0.8942730372387374 \
1.00990228021907e-06 0.8944047337041336 1.009904061344228e-06 0.8952702388217941 1.009904447325595e-06 0.8954343910560414 1.009906848871635e-06 0.896309305076933 \
1.00990732380842e-06 0.8964562995603377 1.009911141970139e-06 0.8973944547681553 1.009911624459337e-06 0.897487269196476 1.009919510474849e-06 0.898471373493449 \
1.00992012663754e-06 0.8985180228791175 1.010015282612379e-06 0.899508178894561 1.010016773214557e-06 0.8995204306067698 1.010128061288741e-06 0.9005118233983579 \
1.010128237625743e-06 0.9005706457326812 1.010131860757067e-06 0.8996048713171836 1.010132041955094e-06 0.8994654179496379 1.01013335307657e-06 0.8985275682722235 \
1.010133534953976e-06 0.8984123497545736 1.01013535794417e-06 0.8974436520388238 1.010135517857424e-06 0.8973766233009967 1.010148668688723e-06 0.8983720910457982 \
1.010148779670277e-06 0.8983905835035384 1.010157601254383e-06 0.8993863063850064 1.010158148023847e-06 0.8994226481040219 1.01065071997668e-06 0.9003987622903815 \
1.010650789769166e-06 0.9004496773542636 1.010651622421929e-06 0.9012853800543292 1.010651748468094e-06 0.9014513953152168 1.010652328988958e-06 0.9023435091985418 \
1.010652469953212e-06 0.9025895326188698 1.010652869091291e-06 0.9033428289365844 1.010653019240832e-06 0.9036449200440446 1.010653462322153e-06 0.9045762589490434 \
1.010653619494256e-06 0.9049121924877023 1.010654065120987e-06 0.9058152254958243 1.010654163577326e-06 0.9059929146639856 1.01065558025872e-06 0.9052304871087643 \
1.010655711415865e-06 0.904616184869324 1.010655880423041e-06 0.9036290332250884 1.010656045714917e-06 0.9024406226812831 1.010656151980698e-06 0.9015554774641358 \
1.010656255417528e-06 0.9006052096506509 1.010656341184247e-06 0.8997486040545581 1.010656430678233e-06 0.8987887485205278 1.010656554922632e-06 0.8973492764100613 \
1.01065667300358e-06 0.8958624931586439 1.010656760219672e-06 0.8946938835082598 1.010656884526716e-06 0.8929289312882503 1.010656991510644e-06 0.8913158670103165 \
1.010657091342348e-06 0.8897378501708729 1.010657217633174e-06 0.8876466417139378 1.010657385821785e-06 0.884705368138502 1.010657541521538e-06 0.8818365157686672 \
1.010657738126367e-06 0.8780362649814708 1.010657921747617e-06 0.8743271923380105 1.01065813325501e-06 0.8698916163736473 1.010658314064811e-06 0.8659808238081558 \
1.010658498645858e-06 0.8618945354625286 1.010658671649854e-06 0.8579913311618118 1.010658857050504e-06 0.8537436868396935 1.010659036133651e-06 0.8495884889292737 \
1.010659219722713e-06 0.8452850234109005 1.010659386484418e-06 0.8413449312544377 1.010659554574996e-06 0.8373487193315756 1.010659717684167e-06 0.8334514816705533 \
1.010659872870403e-06 0.829729402178684 1.010660045969282e-06 0.8255639501984255 1.010660231959738e-06 0.8210763864673301 1.010660396580222e-06 0.8170961425007568 \
1.010660561450132e-06 0.8131038678717658 1.010660736782164e-06 0.8088537582860886 1.010660901208668e-06 0.8048648186953292 1.010661069844279e-06 0.8007719922541914 \
1.010661260647645e-06 0.7961398815555145 1.010661446171818e-06 0.7916360074082958 1.010661655100628e-06 0.7865651471012967 1.010661879917618e-06 0.7811107659751856 \
1.010662069732705e-06 0.77650678233121 1.010662271590188e-06 0.7716133355283564 1.010662415860827e-06 0.76811790639139 1.010662557504393e-06 0.7646880872338248 \
1.010662685202102e-06 0.7615975116975136 1.010662796247944e-06 0.7589113686396982 1.010662924810579e-06 0.7558028559024855 1.010663057376087e-06 0.7525995467138866 \
1.010663170697783e-06 0.7498629233610832 1.010663307032409e-06 0.7465723252212872 1.010663413431661e-06 0.7440058350410135 1.010663572650447e-06 0.7401674766516904 \
1.010663745028142e-06 0.7360137588823189 1.010663907275386e-06 0.7321074183421575 1.010664079624344e-06 0.7279612819449855 1.010664239010527e-06 0.7241302920521341 \
1.010664446815714e-06 0.7191408067115369 1.010664607355379e-06 0.7152908836069264 1.010664799844715e-06 0.7106793324906435 1.010664985361064e-06 0.7062404417184839 \
1.010665155237109e-06 0.7021802791355866 1.010665347106947e-06 0.6975984806629684 1.010665493330962e-06 0.6941099299715526 1.010665653617309e-06 0.6902897983225644 \
1.010665856006145e-06 0.6854719661536142 1.010666037294609e-06 0.681161582477689 1.010666206116036e-06 0.6771536053116509 1.010666391961911e-06 0.6727470762459599 \
1.010666597892751e-06 0.6678715161770782 1.010666765819558e-06 0.6639016226084196 1.010666926081261e-06 0.6601182542089066 1.010667164933735e-06 0.65448589698252 \
1.010667332694849e-06 0.6505369020837752 1.010667513768288e-06 0.6462813620835641 1.010667674923199e-06 0.642499550819208 1.01066782119046e-06 0.6390715923276049 \
1.010667959878569e-06 0.6358268652274862 1.010668089235615e-06 0.6328040340451749 1.01066821862017e-06 0.6297855584526113 1.01066834694149e-06 0.6267952385336898 \
1.010668477143629e-06 0.6237652412672913 1.010668606160074e-06 0.6207683673242944 1.010668744735633e-06 0.6175525629501428 1.01066889281122e-06 0.6141227553162802 \
1.010669079138505e-06 0.60981438109949 1.010669226822204e-06 0.6064079319686639 1.01066946198641e-06 0.600995965122186 1.010669654434141e-06 0.5965821560879089 \
1.010669895003955e-06 0.5910808370261941 1.010670064051325e-06 0.587228367631822 1.01067020171775e-06 0.5840969866928536 1.010670329822726e-06 0.581191110277254 \
1.010670443409422e-06 0.5786182870235701 1.010670534774226e-06 0.5765512826027382 1.010670624196113e-06 0.5745328691003393 1.010670691457846e-06 0.573016830490748 \
1.010670757478049e-06 0.5715297341779608 1.010670809531724e-06 0.5703577032508095 1.010670873770593e-06 0.5689124506700958 1.010670935307116e-06 0.5675311492520995 \
1.01067099958866e-06 0.5660899724818867 1.010671052779755e-06 0.5648985048860162 1.01067114512554e-06 0.5628316153148989 1.010671221701441e-06 0.5611191615154557 \
1.010671277545091e-06 0.5598732849310241 1.0106713468882e-06 0.5583285932816697 1.010671452739476e-06 0.5559733466166974 1.01067153043128e-06 0.5542469170533902 \
1.010671631029867e-06 0.5520159549745236 1.010671759063078e-06 0.5491849411292137 1.01067185856046e-06 0.5469885705929382 1.010671971125811e-06 0.544508366501287 \
1.010672074170131e-06 0.5422442603473754 1.010672194219017e-06 0.5396115972585003 1.010672295833426e-06 0.5373863339265779 1.010672411457693e-06 0.5348611538529422 \
1.010672526573874e-06 0.5323536236546169 1.010672653010918e-06 0.529604142030661 1.010672778525186e-06 0.5268822104345234 1.010672925204862e-06 0.5237112381511962 \
1.01067306087557e-06 0.5207845659358002 1.010673218641409e-06 0.5173942078023266 1.010673381063349e-06 0.5139116507621072 1.010673561971818e-06 0.5100482739823553 \
1.010673754563972e-06 0.5059503908118104 1.010673967555743e-06 0.5014368974673542 1.01067419998846e-06 0.4965308659362653 1.010674457509373e-06 0.49112491222925 \
1.010674697473551e-06 0.4861095397820235 1.010674998677906e-06 0.4798501326413723 1.010675286975534e-06 0.4738957353990632 1.010675600061861e-06 0.4674739717793394 \
1.010675919588141e-06 0.4609631488871989 1.010676259085406e-06 0.4540919149088484 1.010676585275518e-06 0.4475353831519197 1.01067692175678e-06 0.4408159131180407 \
1.010677238467587e-06 0.4345373385230166 1.01067757255266e-06 0.4279587671099637 1.010677924261529e-06 0.4210864038135054 1.010678238746378e-06 0.4149846225409808 \
1.010678562192836e-06 0.4087533091618546 1.010679003120949e-06 0.400331870031168 1.010679344916025e-06 0.3938679283557566 1.010679644350069e-06 0.3882534014213259 \
1.010680018872672e-06 0.3812944595528024 1.010680348250389e-06 0.375233915169682 1.010680631354694e-06 0.3700684563936956 1.010680931099705e-06 0.3646408765157301 \
1.010681210595549e-06 0.3596219010422631 1.010681434267487e-06 0.3556377385586224 1.010681645979195e-06 0.3518907610576284 1.010681848481927e-06 0.3483292724130969 \
1.010682049543475e-06 0.3448190020587957 1.010682255221384e-06 0.3412518188287665 1.01068247359686e-06 0.3374887625241871 1.010682717359257e-06 0.3333167726275162 \
1.010682944115829e-06 0.3294678078423895 1.010683164026801e-06 0.3257615367192951 1.010683382451408e-06 0.3221060038181086 1.010683586476418e-06 0.318715141566024 \
1.010683788334208e-06 0.3153870758963987 1.010683988657595e-06 0.3121102802474151 1.010684175271502e-06 0.309079115007194 1.010684372573109e-06 0.3058982938882217 \
1.010684581156335e-06 0.3025606704206737 1.010684786791057e-06 0.2992974534031506 1.010685011523137e-06 0.2957609785165763 1.010685228418979e-06 0.2923771984023277 \
1.010685436098331e-06 0.2891642611511841 1.010685667149178e-06 0.2856239464683982 1.010685841949429e-06 0.2829684481899911 1.010686021147604e-06 0.2802647299798244 \
1.01068619002212e-06 0.2777348429135014 1.010686418345393e-06 0.274348458173166 1.010686595082661e-06 0.2717528218126659 1.010686763365392e-06 0.2693020894036587 \
1.010686935832162e-06 0.2668230333489093 1.010687069934441e-06 0.264903804409765 1.010687215894446e-06 0.2628277003548514 1.010687354589946e-06 0.2608803500812688 \
1.010687476871551e-06 0.2591684246570544 1.010687610990381e-06 0.2572942758553639 1.010687740091486e-06 0.2554978336754472 1.01068785952522e-06 0.2538430842138498 \
1.010687986360419e-06 0.2520939183506197 1.010688106001441e-06 0.2504447954274527 1.010688255617635e-06 0.2483797066042054 1.010688390481146e-06 0.2465170278296022 \
1.01068852003856e-06 0.2447289494531232 1.010688677103379e-06 0.2425624627506451 1.010688801099014e-06 0.2408491463446025 1.010688941247149e-06 0.2389135279283614 \
1.01068907114005e-06 0.2371200701944942 1.010689191757671e-06 0.2354534357320198 1.010689354230601e-06 0.2332087289724075 1.0106895002847e-06 0.2311905595759856 \
1.010689638605484e-06 0.2292825126447264 1.010689746532702e-06 0.2277949627009887 1.010689877317609e-06 0.225993474229161 1.010689975823625e-06 0.22463752857886 \
1.010690079906972e-06 0.2232056532573264 1.010690152783836e-06 0.2222046546567725 1.010690234937313e-06 0.2210804129356655 1.010690302346398e-06 0.2201585377209549 \
1.010690349050661e-06 0.2195201149856669 1.01069039846802e-06 0.2188449488487562 1.010690489422163e-06 0.2176035744446363 1.010690555816576e-06 0.2166983392055156 \
1.010690602779869e-06 0.2160586379972232 1.010690653091075e-06 0.2153737902794619 1.010690712240425e-06 0.2145693142997165 1.010690755086328e-06 0.2139870779821451 \
1.010690798893629e-06 0.2133941263688522 1.010690868423894e-06 0.2124566309962414 1.010690955340708e-06 0.2112864027023158 1.010691036529563e-06 0.2101949018929156 \
1.010691122429026e-06 0.2090416531541652 1.010691216575207e-06 0.2077796428137634 1.010691308329081e-06 0.2065517647617813 1.010691403625517e-06 0.2052788208685862 \
1.010691500104208e-06 0.2039945431316728 1.01069160092949e-06 0.2026602783061639 1.010691696885502e-06 0.2013924147365721 1.010691799571213e-06 0.2000377255165624 \
1.010691902607567e-06 0.1986831378210229 1.010692012697906e-06 0.1972405340748948 1.010692121449794e-06 0.1958206085628783 1.010692241171749e-06 0.1942631948714586 \
1.010692351614651e-06 0.1928328887741874 1.010692459617459e-06 0.1914411844406488 1.010692584973803e-06 0.1898318066870429 1.010692677907979e-06 0.1886434908940876 \
1.010692756278755e-06 0.1876443873000938 1.010692832918829e-06 0.1866698667869858 1.010692915430143e-06 0.1856249297118943 1.010692984939759e-06 0.1847473639743596 \
1.010693050895387e-06 0.1839166514106665 1.010693115162722e-06 0.1831089953192083 1.010693227146207e-06 0.1817072258029639 1.010693321200174e-06 0.1805353135896268 \
1.010693428841935e-06 0.1791985758407087 1.010693535314993e-06 0.1778827552324552 1.01069365530692e-06 0.1764073736674057 1.010693793359546e-06 0.174720142305475 \
1.0106939095201e-06 0.1733081217455876 1.010694071616903e-06 0.1713503924599185 1.01069418670542e-06 0.1699688234017716 1.010694326691019e-06 0.1682987764548305 \
1.010694443897095e-06 0.1669083002780509 1.010694554816447e-06 0.1655990025649634 1.010694652444933e-06 0.1644521190704843 1.010694747295481e-06 0.1633427224865242 \
1.010694863349893e-06 0.161991523106341 1.010694954898444e-06 0.1609305136382055 1.01069505100742e-06 0.1598214181625073 1.010695145225553e-06 0.1587403933520305 \
1.010695238726156e-06 0.1576732160104884 1.010695332323478e-06 0.1566104070550305 1.010695428005016e-06 0.1555300824433628 1.010695518592921e-06 0.1545132165873678 \
1.010695609606078e-06 0.1534969984004868 1.010695705154555e-06 0.1524358767948732 1.010695795820268e-06 0.1514342506187442 1.010695898892631e-06 0.1503020548964867 \
1.01069597134408e-06 0.1495100717445464 1.010696050444872e-06 0.148649146151682 1.010696124993092e-06 0.1478424742503694 1.010696196024501e-06 0.1470770917224498 \
1.010696268788981e-06 0.1462962409077327 1.010696343406157e-06 0.1454990959398698 1.010696413389118e-06 0.1447543557055888 1.010696487550038e-06 0.143968261688537 \
1.010696541295377e-06 0.1434005634796054 1.010696594578932e-06 0.1428396203849428 1.01069665977469e-06 0.1421555039833398 1.010696731080731e-06 0.141411576573238 \
1.010696795450793e-06 0.1407432786314442 1.010696868802754e-06 0.1399847409254479 1.010696929420321e-06 0.1393607073002494 1.010697015453804e-06 0.1384787080092832 \
1.010697091404821e-06 0.1377037134581418 1.010697181372726e-06 0.1367902106004182 1.010697263099684e-06 0.1359645165492482 1.010697345789661e-06 0.1351360437760365 \
1.010697428345969e-06 0.1343145513298757 1.010697533908125e-06 0.1332698421778018 1.010697615775408e-06 0.1324642397250402 1.010697713142868e-06 0.1315110876582503 \
1.010697803143728e-06 0.130634908321232 1.010697891113988e-06 0.1297829978838479 1.010697974043843e-06 0.1289892226181523 1.010698048280934e-06 0.1282822873521282 \
1.010698147931993e-06 0.1273377645104763 1.010698243687052e-06 0.1264350619688987 1.010698330534457e-06 0.1256206895242312 1.010698420535994e-06 0.1247808744623497 \
1.010698500868674e-06 0.1240346855852102 1.010698587562703e-06 0.1232365419604467 1.010698686393032e-06 0.1223331159004786 1.01069877647517e-06 0.1215131568528167 \
1.010698886718427e-06 0.1205141992263624 1.010698973949866e-06 0.1197275966302077 1.010699042523e-06 0.1191120727131645 1.010699127185392e-06 0.1183553887582162 \
1.010699193692874e-06 0.1177634990399222 1.010699265148799e-06 0.1171309945267847 1.010699334822604e-06 0.1165184920865242 1.010699412159692e-06 0.1158409171037389 \
1.010699507902975e-06 0.1150054407698888 1.010699579157887e-06 0.1143861389207103 1.01069964652742e-06 0.1138025718558601 1.010699714964191e-06 0.113211685696446 \
1.010699790554542e-06 0.1125613765304429 1.010699881296388e-06 0.1117840233035959 1.010699964000116e-06 0.1110788257213999 1.010700077599187e-06 0.1101151050704521 \
1.010700187474899e-06 0.1091895325357105 1.010700279674213e-06 0.1084169374841771 1.010700403623544e-06 0.1073835127717347 1.010700491987867e-06 0.1066505015902263 \
1.010700631446837e-06 0.1055001025916527 1.010700730743538e-06 0.1046863788921388 1.01070082339359e-06 0.1039306459201802 1.010700933598102e-06 0.1030359883605075 \
1.010701018892542e-06 0.1023467905686673 1.010701103793345e-06 0.101663637589173 1.010701186744309e-06 0.1009989740617136 1.01070130925421e-06 0.1000225794851696 \
1.010701431196063e-06 0.09905761200121259 1.010701557818349e-06 0.09806258992746317 1.010701670630472e-06 0.09718220909187772 1.010701815205956e-06 0.09606278874246346 \
1.010701952919884e-06 0.09500564015228773 1.010702069610674e-06 0.09411672853020667 1.010702197354242e-06 0.0931507147971556 1.010702297018758e-06 0.09240236948627445 \
1.010702376452638e-06 0.09180921593916676 1.010702475187935e-06 0.09107599640376031 1.010702553063239e-06 0.09050081472416407 1.010702634529155e-06 0.08990210528957472 \
1.010702709246463e-06 0.0893557072655629 1.010702789776201e-06 0.08876971652456604 1.010702908608526e-06 0.08791061481419053 1.010702998269062e-06 0.08726673116015753 \
1.010703103183109e-06 0.08651800316437093 1.010703234657667e-06 0.08558693768262025 1.010703395765802e-06 0.08445695903909305 1.010703535947497e-06 0.08348350561263763 \
1.010703684450103e-06 0.08246223579158835 1.010703821170292e-06 0.08153124812726546 1.010703961182002e-06 0.08058696725890066 1.010704098179202e-06 0.07967195061625794 \
1.010704236789813e-06 0.07875532825288725 1.0107043812627e-06 0.07780967510081127 1.010704528808937e-06 0.07685421131041187 1.010704686312648e-06 0.07584560580436887 \
1.010704850707884e-06 0.07480523464991846 1.010705018799982e-06 0.07375451744755303 1.010705199799341e-06 0.07263751640721161 1.010705398512623e-06 0.07142823309373261 \
1.010705611921415e-06 0.07014922396308329 1.0107058380853e-06 0.06881630383186611 1.010706078645623e-06 0.06742468841361035 1.010706356206536e-06 0.06585179211508728 \
1.010706653410938e-06 0.06420523370201831 1.010706971711662e-06 0.06248365192299224 1.010707361695962e-06 0.06043183534616462 1.010707760522748e-06 0.05839861031494715 \
1.010708202994687e-06 0.05621846258761681 1.01070858797559e-06 0.05438828987170503 1.010709000022182e-06 0.05249218901100536 1.010709351759698e-06 0.05092353490091287 \
1.01070968726435e-06 0.04946969867921969 1.010709997763245e-06 0.04816021644386199 1.010710291700064e-06 0.04695194805701195 1.010710584430997e-06 0.04577883625507727 \
1.010710859274204e-06 0.04470700909733757 1.010711133117927e-06 0.04366353526031765 1.010711398807688e-06 0.04267398813878486 1.010711674116703e-06 0.04167180388267511 \
1.010711958673621e-06 0.04066026046469497 1.010712254971736e-06 0.03963283340811159 1.010712513847122e-06 0.03875659098599576 1.010712741803528e-06 0.03800131046948733 \
1.010712960528722e-06 0.03729095380188759 1.010713180383449e-06 0.03659437723507575 1.010713521249514e-06 0.03554043311314246 1.010713797290394e-06 0.03470953269536187 \
1.010714090721169e-06 0.03384790442147732 1.010714373289092e-06 0.03303898052111545 1.010714628198529e-06 0.03232625790162248 1.010714908882988e-06 0.03155947796597136 \
1.010715154716382e-06 0.03090318379665042 1.01071538687767e-06 0.03029616297556957 1.010715627215008e-06 0.02968398395812225 1.010715862851843e-06 0.02909722707395018 \
1.010716091063021e-06 0.0285403787496557 1.010716507835749e-06 0.02755138287878544 1.010716702361127e-06 0.02710176794309662 1.010717088601532e-06 0.02623051698020805 \
1.010717267770925e-06 0.0258356865503758 1.010717618998109e-06 0.02507792837274256 1.010717786904156e-06 0.0247229612172224 1.010718171166812e-06 0.02392944198669211 \
1.010718286448541e-06 0.02369675911063252 1.010718728496378e-06 0.02282172072611499 1.010718950311652e-06 0.02239223679446916 1.010719473931311e-06 0.02139838041889957 \
1.010719629293819e-06 0.02110714647916685 1.010720146999888e-06 0.02015295207761772 1.010720272033152e-06 0.01992792118872039 1.010720796234659e-06 0.01901759738223179 \
1.010720932454034e-06 0.01879045572456909 1.01072153873049e-06 0.01783210191617334 1.010721705739623e-06 0.01758082406519646 1.010722348947266e-06 0.01666064795441237 \
1.010722528091535e-06 0.0164167113061686 1.010723218250269e-06 0.01551958953683085 1.010723381870153e-06 0.01531511209162885 1.01072414235084e-06 0.01440332854054019 \
1.010724289392963e-06 0.01423371673427115 1.010725107264621e-06 0.01333087949608782 1.010725226813134e-06 0.01320411419549955 1.010726142674655e-06 0.01227329163592313 \
1.010726284027572e-06 0.01213544173166964 1.010727232503148e-06 0.01124488043697059 1.010727391142586e-06 0.01110230805801717 1.01072857354363e-06 0.01011356759191894 \
1.01072867164402e-06 0.01003725601038859 1.01072993325548e-06 0.009120360285939955 1.01073006766933e-06 0.009028655389366201 1.010731608240655e-06 0.008043892937307966 \
1.010731689273999e-06 0.007992925041580451 1.010733277867931e-06 0.007023242357651564 1.010733410759078e-06 0.006948518507451114 1.01073538746242e-06 0.005952856104192286 \
1.010735569200568e-06 0.005869662958407677 1.010737671554228e-06 0.004980929874643355 1.010738112345997e-06 0.004810448874467742 1.010740767560855e-06 0.003892108290451164 \
1.010741244140394e-06 0.003745909362026665 1.010744882222615e-06 0.00279447349697209 1.01074540774606e-06 0.002678838783887205 1.010751013810845e-06 0.001700248310874221 \
1.010751324898547e-06 0.001653333728976835 1.010756459226246e-06 0.0006858192122199529 1.010756653206019e-06 0.0006440832883579712 1.013404576914862e-06 -0.0002037173203380238 \
1.013404741115283e-06 -0.0003889174928863678 1.013405314458091e-06 -0.001270938904608877 1.013405389392278e-06 -0.001411855863724778 1.013405849976055e-06 -0.002393592696522268 \
1.013405961916807e-06 -0.002660411672198376 1.013406215188795e-06 -0.003300974950034667 1.013406381572099e-06 -0.003745951779090856 1.01340667656787e-06 -0.004566571567208835 \
1.013406788055443e-06 -0.00488071790655901 1.013407067428216e-06 -0.005641221413069743 1.013407188386555e-06 -0.005938820066262044 1.013408282339388e-06 -0.005180465225493313 \
1.013408406471631e-06 -0.004410796826645887 1.013408530879049e-06 -0.003456122327429311 1.013408650435428e-06 -0.002364170815481491 1.013408748579805e-06 -0.001341064316055312 \
1.013408855004127e-06 -0.0001052154991983786 1.013408967239972e-06 0.001336046702817826 1.013409102195821e-06 0.003249882807978809 1.013409224782331e-06 0.005149402351921401 \
1.013409413644246e-06 0.008353592055059769 1.013409554826578e-06 0.01094873860302964 1.013409708187922e-06 0.01393943619118621 1.013409851561427e-06 0.01687898420971235 \
1.013410005752867e-06 0.02017576688295359 1.013410161892825e-06 0.02363796584892512 1.013410317618878e-06 0.02719811802828209 1.013410465112557e-06 0.03065407560139007 \
1.013410613784323e-06 0.03420778369279751 1.013410769114408e-06 0.03798436241030867 1.013410927740287e-06 0.04189786275883118 1.013411092673448e-06 0.0460171220807938 \
1.013411267096336e-06 0.05041857973200652 1.013411446085736e-06 0.05497510627343041 1.013411635385597e-06 0.05982852266675163 1.013411838393603e-06 0.06506368941101938 \
1.013412057870669e-06 0.07075025585284363 1.01341228893533e-06 0.07675903373893865 1.013412535995649e-06 0.08319974270080552 1.013412806420637e-06 0.0902619122132732 \
1.013413099984324e-06 0.09793335781011638 1.013413424033306e-06 0.1064001814721126 1.013413788254856e-06 0.1159066558703892 1.013414180806326e-06 0.1261372395632307 \
1.013414630304251e-06 0.1378252442462487 1.013415153096484e-06 0.1513754922073403 1.013415766694219e-06 0.1672157090591849 1.013416444455093e-06 0.184625848284817 \
1.013417232720212e-06 0.2047487967247964 1.013418115553072e-06 0.22712469896725 1.013418933839029e-06 0.2476994923478653 1.013419661268608e-06 0.2658503723959502 \
1.013420301381636e-06 0.2817009601644404 1.01342087568535e-06 0.2958213763442377 1.013421413251317e-06 0.3089396094373287 1.013421917248776e-06 0.3211464104224903 \
1.01342239337143e-06 0.3325930942309646 1.013422871259445e-06 0.3439912352478621 1.013423324592551e-06 0.3547121966731367 1.013423795885259e-06 0.3657614311162562 \
1.013424238561085e-06 0.3760518588326446 1.013424757059872e-06 0.3879885572071845 1.013425284221992e-06 0.3999987293386327 1.013425663131623e-06 0.4085537955782026 \
1.013426193047166e-06 0.4204060347738258 1.013426622963746e-06 0.429919877745455 1.013427076664521e-06 0.4398653393542544 1.013427543378037e-06 0.4500002271552926 \
1.013427981059267e-06 0.4594210430579985 1.013428389021531e-06 0.468120704286539 1.013428708454565e-06 0.4748816926501604 1.013429080589837e-06 0.4826992142337162 \
1.013429315571977e-06 0.4876010339127531 1.013429549178225e-06 0.4924491904621348 1.013429797190648e-06 0.4975647713404599 1.013430095592078e-06 0.5036796627825791 \
1.01343035194848e-06 0.5088948470128004 1.01343056424179e-06 0.5131878547336713 1.013430758259862e-06 0.5170959594548015 1.013430905246394e-06 0.5200432695146362 \
1.013431059224404e-06 0.523118600542271 1.013431277106154e-06 0.5274469616807909 1.01343153021048e-06 0.5324525256580425 1.013431740049324e-06 0.5365797337241586 \
1.013431951502633e-06 0.5407247601751553 1.013432233709534e-06 0.5462280430697679 1.013432463254817e-06 0.5506821559930507 1.013432679151024e-06 0.5548604062613707 \
1.013432961372541e-06 0.560308769190463 1.013433212680268e-06 0.5651538146135803 1.01343351034116e-06 0.5708625224168123 1.013433760568061e-06 0.5756519166658941 \
1.013434016931556e-06 0.5805516059354519 1.01343425734157e-06 0.585116682128892 1.013434515521386e-06 0.5900038400537884 1.013434739113592e-06 0.5942175703762435 \
1.013434977623163e-06 0.5986919452581434 1.013435185207861e-06 0.6025689278491061 1.013435401730487e-06 0.6065904171332736 1.013435651033092e-06 0.6111939272561876 \
1.013435856106535e-06 0.6149609706257601 1.013436107378861e-06 0.6195555361399968 1.013436310600886e-06 0.6232455818254186 1.013436507472791e-06 0.6267987644955494 \
1.013436700764307e-06 0.630267737067843 1.013436955542762e-06 0.6348113783570861 1.013437185753374e-06 0.638887973644319 1.013437403107185e-06 0.6427143472883045 \
1.013437701512908e-06 0.6479268061885751 1.013437916915757e-06 0.6516657345437264 1.013438118139476e-06 0.6551344108237934 1.013438293060983e-06 0.6581323437428509 \
1.013438458126254e-06 0.6609495238976936 1.013438627594775e-06 0.6638251431769452 1.013438779731612e-06 0.666392827642013 1.013438917642298e-06 0.6687037209181631 \
1.013439066478412e-06 0.6711867545200138 1.013439194593014e-06 0.6733159837320549 1.013439337815828e-06 0.6756849429836936 1.013439459090078e-06 0.6776819274526149 \
1.013439596688762e-06 0.6799401191146522 1.013439716069216e-06 0.6818929034138137 1.013439863176962e-06 0.6842914131385206 1.013439980378628e-06 0.6861933934268433 \
1.013440073884205e-06 0.6877071857403232 1.013440164873897e-06 0.6891752279197846 1.013440267615961e-06 0.6908280855439021 1.013440369133525e-06 0.6924555900607121 \
1.013440487516631e-06 0.6943444167618776 1.013440599637217e-06 0.6961264383846065 1.013440717192718e-06 0.6979868779962457 1.013440902343005e-06 0.7008959348649784 \
1.013441033535213e-06 0.7029413755586562 1.013441169703753e-06 0.7050491462541959 1.013441291222456e-06 0.7069171228306749 1.013441431145468e-06 0.7090538254196674 \
1.013441535088117e-06 0.7106315721465845 1.013441646249101e-06 0.712309798010818 1.013441750508965e-06 0.7138759052437967 1.013441880147056e-06 0.7158124745844324 \
1.013441977077769e-06 0.7172526339884565 1.013442116000004e-06 0.7193052800722975 1.013442235549293e-06 0.7210612846995991 1.013442355121865e-06 0.7228080613301419 \
1.013442480897243e-06 0.7246353354365959 1.013442607615586e-06 0.7264656873164689 1.013442729655437e-06 0.728218443613998 1.01344285780388e-06 0.7300486655261287 \
1.013442987872205e-06 0.7318956587421809 1.013443108863227e-06 0.7336041830685722 1.013443249633811e-06 0.7355801168346318 1.01344335060338e-06 0.7369898206659778 \
1.013443452204237e-06 0.7384020079314992 1.013443548224548e-06 0.7397310783624924 1.013443659137403e-06 0.7412570822736337 1.01344374678503e-06 0.7424563811251772 \
1.013443846639401e-06 0.7438154404043728 1.013443981404538e-06 0.7456370856934184 1.013444097699018e-06 0.747198032089633 1.013444201190815e-06 0.7485782798032956 \
1.013444325446263e-06 0.7502239458264747 1.013444470359203e-06 0.7521280942578691 1.013444588339771e-06 0.753666143975803 1.013444707270879e-06 0.7552056331692281 \
1.013444846850418e-06 0.7569980918234445 1.013444991202808e-06 0.7588357421297242 1.013445109263616e-06 0.7603265096672839 1.013445234085335e-06 0.7618908200857619 \
1.013445373916531e-06 0.7636286950759973 1.013445498679428e-06 0.7651662633748356 1.013445642192899e-06 0.7669199865864609 1.013445762878376e-06 0.7683824344671055 \
1.013445883722124e-06 0.7698356273746885 1.013446003367048e-06 0.7712633747646481 1.013446133074687e-06 0.7727989859455529 1.01344624181849e-06 0.7740766298596218 \
1.013446364466227e-06 0.7755070372682662 1.013446474242911e-06 0.7767778749889983 1.013446603267025e-06 0.7782599816788072 1.013446735043344e-06 0.7797610257751375 \
1.01344684835592e-06 0.7810403609326458 1.013446969441862e-06 0.7823954393038701 1.013447073314495e-06 0.7835479431998941 1.013447215597517e-06 0.785111775748914 \
1.013447363800666e-06 0.7867227488076519 1.013447522694201e-06 0.7884297907063792 1.013447642887223e-06 0.7897074707829422 1.01344779245393e-06 0.7912811323018302 \
1.013447916569147e-06 0.7925734175081853 1.013448042273444e-06 0.7938699048627912 1.013448145219011e-06 0.7949224966762399 1.013448259590165e-06 0.7960823495211882 \
1.013448372064409e-06 0.7972131756542409 1.013448462336983e-06 0.7981137961420948 1.013448551677879e-06 0.7989989930139054 1.013448676903817e-06 0.800229513878344 \
1.01344878467518e-06 0.8012785338618679 1.013448914342979e-06 0.8025281307685926 1.013449035722257e-06 0.8036855380110038 1.013449152278057e-06 0.8047859282369955 \
1.013449273083453e-06 0.80591497746663 1.013449405708758e-06 0.8071413435168892 1.013449527502378e-06 0.8082555056211007 1.013449654106103e-06 0.8094015704683005 \
1.013449779719621e-06 0.8105266036187198 1.013449899211046e-06 0.8115857443778658 1.013450037409299e-06 0.8127973981963581 1.013450146908547e-06 0.8137473213416323 \
1.013450231056663e-06 0.8144713378799666 1.01345035186072e-06 0.8155017394983226 1.013450447369557e-06 0.8163089346032877 1.01345058366036e-06 0.8174496006492775 \
1.013450726424414e-06 0.8186303638797883 1.013450860857535e-06 0.8197292014569521 1.013450970729519e-06 0.8206175763825388 1.013451114629137e-06 0.8217677661037901 \
1.01345126795672e-06 0.8229768690765377 1.013451395805574e-06 0.8239722812379519 1.013451536202905e-06 0.8250521595273246 1.013451662107844e-06 0.8260088941474263 \
1.01345181672401e-06 0.8271688948348412 1.013451949079339e-06 0.8281489842609937 1.013452075346168e-06 0.8290730392392056 1.013452193006695e-06 0.8299245984162376 \
1.013452341409092e-06 0.8309852945996649 1.01345250860326e-06 0.8321626230293395 1.013452641380572e-06 0.8330844501529713 1.013452814281769e-06 0.8342675727345584 \
1.013452982699063e-06 0.8354015168591284 1.013453152193536e-06 0.8365246342267009 1.013453333630418e-06 0.8377070668209077 1.013453476186559e-06 0.8386219603417975 \
1.01345359009745e-06 0.8393441765511721 1.013453720973659e-06 0.8401643924869071 1.013453822596633e-06 0.8407940582489307 1.013453939036871e-06 0.8415078269750864 \
1.013454074330058e-06 0.8423269142909066 1.013454271595159e-06 0.8435017451489455 1.013454462114483e-06 0.844614933042255 1.013454672039296e-06 0.8458175693076773 \
1.013454852817827e-06 0.8468334846981137 1.013455050185846e-06 0.8479221976595614 1.01345522404434e-06 0.8488638701886076 1.013455406558583e-06 0.8498353939890455 \
1.013455577902694e-06 0.8507314120859523 1.013455752248258e-06 0.8516272398309612 1.013455927651258e-06 0.8525125793730954 1.013456103896448e-06 0.8533864315694911 \
1.013456293665326e-06 0.8543099749208749 1.013456484423344e-06 0.8552205033559714 1.01345668621255e-06 0.8561646193034282 1.013456878916116e-06 0.8570482883232282 \
1.013457088356793e-06 0.8579892478796384 1.013457318098559e-06 0.8589986827500428 1.013457583567511e-06 0.8601360945383778 1.013457882213856e-06 0.8613786760148464 \
1.013458160601222e-06 0.8625023989005415 1.013458444791177e-06 0.8636161469557806 1.013458719285784e-06 0.8646608622318305 1.01345899137728e-06 0.8656672252055042 \
1.013459261593727e-06 0.8666387059277968 1.013459518761915e-06 0.8675381145236246 1.013459791320979e-06 0.8684653318325959 1.01346006734232e-06 0.8693777905953765 \
1.013460337484171e-06 0.8702455402709716 1.013460637231955e-06 0.8711796653984102 1.013461008105812e-06 0.872294745819888 1.013461303028797e-06 0.8731503023941 \
1.013461557284845e-06 0.8738665406311316 1.013461855515577e-06 0.8746822274488602 1.013462129133902e-06 0.8754080260278182 1.013462365269549e-06 0.8760175227551726 \
1.013462605621406e-06 0.876622281264788 1.013462827963785e-06 0.8771680781109068 1.013463021968129e-06 0.8776338860468618 1.013463351691208e-06 0.8784037109613512 \
1.01346350686397e-06 0.8787567114621292 1.013463824616497e-06 0.879461652496718 1.013464003481858e-06 0.8798480920375044 1.013464345943324e-06 0.8805675499479563 \
1.013464530084847e-06 0.8809434933546246 1.013465004990284e-06 0.8818790560183651 1.013465172384703e-06 0.8821975058309585 1.013465638216128e-06 0.8830540251881659 \
1.013465819040967e-06 0.8833751042472839 1.013466313074347e-06 0.8842212008576973 1.013466454417056e-06 0.884455124402366 1.013467060806836e-06 0.8854193259359495 \
1.013467212878983e-06 0.8856514227360587 1.01346785955747e-06 0.8865980751852495 1.013467987853825e-06 0.8867785329419297 1.013468635979926e-06 0.8876550049536978 \
1.013468765772447e-06 0.8878236738033012 1.013469544034095e-06 0.8887860366092379 1.013469659025973e-06 0.8889208282599539 1.013470514758392e-06 0.8898661633196656 \
1.013470660021537e-06 0.8900169066926564 1.013471645777722e-06 0.8909664261264102 1.013471866882863e-06 0.8911622482549515 1.013473011997307e-06 0.8921020388386462 \
1.013473143207264e-06 0.8922053928944147 1.013474330865799e-06 0.8931033243919096 1.013474484486092e-06 0.8932130731307282 1.013475894522803e-06 0.8941348173026452 \
1.013476117329622e-06 0.8942660193790342 1.01347779802033e-06 0.8951452796684343 1.01347812564151e-06 0.8952966652167414 1.013480355582631e-06 0.8961896554712738 \
1.013480908496592e-06 0.8963788593752812 1.013484476711123e-06 0.8973573335043913 1.013484800223538e-06 0.8974284307984646 1.013491156631826e-06 0.8984120886469452 \
1.013491705534673e-06 0.8984686671268907 1.013544207609024e-06 0.8994658645395698 1.013544850637887e-06 0.8994692460188505 1.013736989308519e-06 0.9004073346715066 \
1.013737190722491e-06 0.9004708280105613 1.013741150500432e-06 0.8995366825576255 1.01374133452723e-06 0.8993953949813248 1.013742651124504e-06 0.8984641879157507 \
1.013742823168359e-06 0.8983566564859006 1.013744719544654e-06 0.8973720929359315 1.013744893250842e-06 0.897304621671452 1.013757467177875e-06 0.8982933655523699 \
1.013757552368112e-06 0.8983081509245614 1.013765819241151e-06 0.8993078551592517 1.013766293960572e-06 0.8993433667976791 1.014259794870011e-06 0.9002974142054325 \
1.014259914349735e-06 0.9003767372269074 1.014260807172786e-06 0.9012336455299185 1.014260953429423e-06 0.901423267690772 1.014261548322101e-06 0.9023325668564308 \
1.014261683292918e-06 0.9025673929107925 1.014262187968707e-06 0.9035294259428087 1.014262320579608e-06 0.9038000271808221 1.014262721206972e-06 0.9046475051114249 \
1.014262865572371e-06 0.9049556543240072 1.01426328869358e-06 0.9058123566484279 1.014263384150638e-06 0.9059850892484415 1.014264808709455e-06 0.9052205906349737 \
1.014264933747309e-06 0.9046352442223391 1.014265060157898e-06 0.9039223775493039 1.014265162806642e-06 0.9032486771507763 1.014265290021932e-06 0.9022944222362175 \
1.014265408867758e-06 0.9012801950564071 1.014265506520237e-06 0.9003603330664713 1.014265588522258e-06 0.8995243596151602 1.014265668185821e-06 0.8986589236008835 \
1.014265778963989e-06 0.8973708307079206 1.014265880140004e-06 0.8961049472956977 1.014265963084475e-06 0.8950067229086057 1.014266071529892e-06 0.8934921260891034 \
1.01426617999385e-06 0.8918872687155874 1.014266275049989e-06 0.8904106867557802 1.014266395922642e-06 0.8884444419111864 1.014266516699262e-06 0.8863849482818795 \
1.014266629744433e-06 0.8843763393508186 1.014266732915182e-06 0.8824794505619851 1.014266818515338e-06 0.8808620855018965 1.014266892989399e-06 0.8794251273161163 \
1.014266987312942e-06 0.8775673968166831 1.014267075773858e-06 0.8757888800524039 1.01426715484687e-06 0.8741711975775893 1.014267248834225e-06 0.872216793437976 \
1.014267330179529e-06 0.8704993514258973 1.014267425093555e-06 0.8684673705816817 1.014267518136275e-06 0.8664480751909672 1.014267614922069e-06 0.8643215060814092 \
1.014267738217441e-06 0.8615778533848952 1.014267851664452e-06 0.859022019682563 1.014267977516491e-06 0.8561558571929792 1.014268100844636e-06 0.8533196845306243 \
1.014268230022927e-06 0.850323637950593 1.014268370619783e-06 0.8470370034914 1.014268479399504e-06 0.8444782910716596 1.014268614459257e-06 0.8412850455921466 \
1.014268724119566e-06 0.8386804253780991 1.014268853299345e-06 0.8356002443501571 1.014268979483175e-06 0.8325812421138936 1.01426910657353e-06 0.8295317031556502 \
1.014269235595804e-06 0.826427745883674 1.014269344676045e-06 0.8237985689995477 1.014269484526701e-06 0.8204223029647078 1.014269623954893e-06 0.8170507778356514 \
1.014269756708524e-06 0.8138366863616762 1.014269886777199e-06 0.8106848159989707 1.014270010472646e-06 0.8076853837479523 1.014270147427036e-06 0.8043627031572629 \
1.014270261138882e-06 0.8016030849198694 1.014270388615922e-06 0.7985086235398901 1.014270499416994e-06 0.7958187897651571 1.014270618603452e-06 0.7929254985494992 \
1.014270731982508e-06 0.7901733724735396 1.014270866292901e-06 0.7869138859547327 1.014270973387169e-06 0.7843152933129034 1.014271089404312e-06 0.7815009627552112 \
1.014271218595275e-06 0.778367508739124 1.014271316207711e-06 0.7760002683782802 1.014271421787151e-06 0.773440790716327 1.01427153046932e-06 0.7708069008430674 \
1.014271632885583e-06 0.7683258101021144 1.014271726279241e-06 0.7660641808432364 1.014271845835017e-06 0.7631702213567544 1.014271938307379e-06 0.7609327305817616 \
1.014272030945494e-06 0.7586922094322426 1.01427212937031e-06 0.7563124992069843 1.014272237347962e-06 0.7537030947613649 1.014272333616474e-06 0.7513778334636231 \
1.014272419872877e-06 0.7492952979736797 1.014272522736666e-06 0.7468128004450286 1.014272601580994e-06 0.744910856519283 1.014272702387036e-06 0.7424801602439853 \
1.014272836915276e-06 0.7392377693660663 1.014272974140136e-06 0.7359316755186537 1.014273117619987e-06 0.7324773442723981 1.014273266044177e-06 0.7289066083419234 \
1.014273409305472e-06 0.7254625447335662 1.014273549382451e-06 0.7220977259655398 1.014273705808317e-06 0.7183435968963056 1.014273830210067e-06 0.715360858370426 \
1.014273951271848e-06 0.7124600029613375 1.01427410478411e-06 0.7087850045121084 1.014274239566055e-06 0.7055614325718365 1.014274365665088e-06 0.7025479112911024 \
1.014274508839371e-06 0.6991289103945657 1.014274628921163e-06 0.6962626602560111 1.014274758155491e-06 0.6931807499479741 1.014274864640539e-06 0.6906432840523983 \
1.014274976916361e-06 0.6879696524977363 1.014275073251648e-06 0.6856773754336868 1.01427517606134e-06 0.683232326200841 1.014275270865193e-06 0.6809792012818872 \
1.014275376187123e-06 0.6784784437814733 1.014275484625777e-06 0.6759058899658261 1.014275583635057e-06 0.673558569590366 1.01427570039165e-06 0.6707929011939652 \
1.014275808476928e-06 0.6682347329991606 1.014275918483137e-06 0.6656332609774134 1.014276004570979e-06 0.6635992664604092 1.014276134166118e-06 0.6605400273835189 \
1.014276226767366e-06 0.6583552307294462 1.014276322555092e-06 0.6560965362104854 1.014276407507078e-06 0.6540950852804182 1.014276526801602e-06 0.6512869789851043 \
1.01427661407154e-06 0.6492343850333612 1.014276704778561e-06 0.6471030993779646 1.014276805943536e-06 0.6447280068361273 1.014276885774359e-06 0.6428551652550211 \
1.014276974560194e-06 0.6407732405330839 1.01427705225042e-06 0.6389536101386547 1.014277114019368e-06 0.6375081226244841 1.014277177784013e-06 0.6360167668935747 \
1.014277241018233e-06 0.634538653569437 1.014277280258806e-06 0.6336218002627473 1.014277320897828e-06 0.6326726453797233 1.014277400982362e-06 0.6308039353694699 \
1.014277470886543e-06 0.6291742390428672 1.014277521523257e-06 0.6279942052995945 1.014277560272899e-06 0.6270914175114127 1.014277599267879e-06 0.6261832343283663 \
1.014277643882627e-06 0.6251445623164014 1.014277686739083e-06 0.6241478292286105 1.014277737053687e-06 0.6229782634938205 1.014277788990864e-06 0.6217719122409077 \
1.014277874058449e-06 0.6197972300178722 1.014277934038866e-06 0.6184052992407258 1.014278023826075e-06 0.61632338076978 1.014278100290156e-06 0.6145529519516876 \
1.014278179854447e-06 0.6127119801362371 1.014278260891059e-06 0.6108383709630588 1.014278350105382e-06 0.6087775861620425 1.014278440965394e-06 0.6066826282541496 \
1.014278528184102e-06 0.6046739453334793 1.014278621957293e-06 0.6025158549334848 1.014278723642757e-06 0.6001788642681311 1.014278823240848e-06 0.5978941858483342 \
1.014278935095889e-06 0.5953317151711254 1.014279051129026e-06 0.5926772450523136 1.014279172750132e-06 0.5899020947998995 1.014279277133946e-06 0.5875236635596754 \
1.014279421924166e-06 0.5842296531729801 1.014279534584127e-06 0.5816734289694181 1.014279643596094e-06 0.5792035939892568 1.014279736075537e-06 0.5771100174076607 \
1.014279829526177e-06 0.5749994714793375 1.01427992185204e-06 0.5729181236728181 1.014279994438741e-06 0.571283073141143 1.014280050392967e-06 0.5700232888304386 \
1.014280111461249e-06 0.5686498830286455 1.014280209950764e-06 0.5664400707212188 1.014280273162208e-06 0.5650238531380825 1.014280333588177e-06 0.5636708824310654 \
1.01428041053656e-06 0.5619492451093103 1.014280473695101e-06 0.5605380106414651 1.01428056200871e-06 0.558569506627369 1.014280633210033e-06 0.5569845302974165 \
1.014280719745787e-06 0.555060151797141 1.01428084109856e-06 0.5523665438352664 1.014280969027808e-06 0.5495364947125975 1.014281067158439e-06 0.5473694328713704 \
1.014281180282435e-06 0.5448752016832871 1.014281282350254e-06 0.5426314425864434 1.014281401299125e-06 0.5400217272291628 1.014281504386832e-06 0.5377630705755105 \
1.014281618593987e-06 0.5352670017334624 1.014281732009658e-06 0.532794946211756 1.014281859080713e-06 0.5300302694710822 1.014281982900802e-06 0.5273426867079006 \
1.014282127689607e-06 0.5242103332418484 1.01428226351311e-06 0.5212782585303676 1.014282418567968e-06 0.5179428401013338 1.014282579419853e-06 0.5144913885072363 \
1.0142827581493e-06 0.5106699876709851 1.01428294832834e-06 0.5066200804011861 1.014283158230362e-06 0.5021665212646098 1.014283386936347e-06 0.4973332357952056 \
1.014283640864285e-06 0.4919960258408594 1.014283881797751e-06 0.4869529241725989 1.014284177960236e-06 0.4807889695952298 1.014284467957623e-06 0.4747910561470179 \
1.014284774200956e-06 0.4684976697011882 1.014285094876887e-06 0.4619520863481486 1.014285422744054e-06 0.4553041925245184 1.014285762989109e-06 0.4484521981997251 \
1.014286088414655e-06 0.4419418052309769 1.014286410321802e-06 0.4355465312739703 1.014286740535907e-06 0.4290298934287748 1.0142870965285e-06 0.4220583188787752 \
1.014287415406929e-06 0.4158579595363656 1.014287752858691e-06 0.4093433989943853 1.014288180725408e-06 0.4011531841887147 1.014288529437355e-06 0.3945419525178304 \
1.014288837073319e-06 0.388759214407489 1.014289216899811e-06 0.3816861832573664 1.014289548089372e-06 0.3755780492082042 1.014289831697452e-06 0.370391509977049 \
1.014290142516397e-06 0.3647512908748707 1.014290421833004e-06 0.3597258263082204 1.014290648329152e-06 0.3556836811642302 1.014290864011538e-06 0.3518598964090484 \
1.014291061295543e-06 0.3483842179544538 1.014291266280002e-06 0.3447988491770444 1.014291478501966e-06 0.3411119200457455 1.014291733807154e-06 0.33670771290924 \
1.014291975329403e-06 0.3325734463267218 1.014292206706731e-06 0.3286464933807047 1.014292421559231e-06 0.3250253651850565 1.014292642118388e-06 0.3213332986541765 \
1.014292843544355e-06 0.3179852906236645 1.014293046612606e-06 0.3146379646143546 1.014293244508216e-06 0.3114011111455273 1.014293431469302e-06 0.3083651674074345 \
1.014293625269522e-06 0.3052406640298299 1.014293829186134e-06 0.3019773030815858 1.014294008255468e-06 0.2991336297844484 1.014294243846324e-06 0.2954229173226265 \
1.014294444650423e-06 0.2922868215109002 1.014294645829315e-06 0.2891696385850206 1.014294869639057e-06 0.2857334090862961 1.014295034201803e-06 0.2832271910241367 \
1.014295211129189e-06 0.2805503385691353 1.014295396922194e-06 0.2777610713150803 1.01429557873767e-06 0.2750538970423583 1.014295757762463e-06 0.2724132377985424 \
1.014295925107616e-06 0.2699606650006489 1.014296085536534e-06 0.2676371805838822 1.014296208110285e-06 0.2658719571410424 1.014296357874814e-06 0.2637236906090554 \
1.01429648557194e-06 0.2619099339733745 1.014296592880312e-06 0.2603957336038235 1.014296708880974e-06 0.2587625259947361 1.01429681918957e-06 0.2572125806747212 \
1.014296945068767e-06 0.2554509781935611 1.014297060550618e-06 0.2538402638894013 1.014297195131521e-06 0.2519757335310172 1.014297307194775e-06 0.2504255755821768 \
1.014297457534134e-06 0.2483447107137444 1.014297597159989e-06 0.2464124269747185 1.01429774305181e-06 0.2444035064209518 1.014297876012447e-06 0.2425734862730615 \
1.014297999574161e-06 0.2408709992523319 1.014298146783853e-06 0.2388417729476062 1.014298263370682e-06 0.2372355665500016 1.014298402825832e-06 0.23532008003217 \
1.014298537000301e-06 0.2334768281602104 1.014298662976758e-06 0.2317465561243653 1.014298782376161e-06 0.2301094434087779 1.014298877230585e-06 0.2288105340759602 \
1.014298990368184e-06 0.2272617792622066 1.014299070684642e-06 0.2261626001158484 1.014299158249699e-06 0.2249657246820506 1.014299283786836e-06 0.2232507767215072 \
1.014299389480543e-06 0.2218101326756785 1.014299479135054e-06 0.2205921574607158 1.014299549986253e-06 0.2196300825522397 1.014299593014783e-06 0.2190460135436258 \
1.014299635305326e-06 0.2184724035808872 1.014299677647042e-06 0.2178984240735344 1.014299749842462e-06 0.2169203674089526 1.014299792235817e-06 0.2163464205126744 \
1.014299827490656e-06 0.2158693585303403 1.01429987168224e-06 0.2152716287340076 1.014299941290467e-06 0.2143309212991285 1.014299975633796e-06 0.2138672544767182 \
1.014300020093325e-06 0.2132698436071631 1.014300087771806e-06 0.2123628126304402 1.014300174199065e-06 0.2112058698236149 1.014300248835667e-06 0.2102078598594563 \
1.014300330137676e-06 0.2091219706754807 1.014300427015059e-06 0.2078300362310651 1.014300552998548e-06 0.2061528795789772 1.014300655533384e-06 0.2047906894256944 \
1.014300757016901e-06 0.2034500128132261 1.014300858082597e-06 0.202119416354989 1.014300954696817e-06 0.2008491615811921 1.01430105666124e-06 0.1995112314821507 \
1.014301163383484e-06 0.1981153840927639 1.014301271788624e-06 0.1967018790395962 1.01430138378278e-06 0.1952465002768531 1.014301496249907e-06 0.1937897263683151 \
1.014301608323246e-06 0.1923454332378671 1.01430171621572e-06 0.1909603537828802 1.014301817598649e-06 0.1896629368444172 1.014301909236098e-06 0.1884941330679491 \
1.014302003211707e-06 0.1872990757663449 1.014302074478072e-06 0.1863957871745983 1.01430215115336e-06 0.1854271890400033 1.014302254812475e-06 0.184122202819407 \
1.014302328479596e-06 0.1831974022686171 1.014302401825496e-06 0.1822796569444652 1.014302515215845e-06 0.1808667181969195 1.014302603074485e-06 0.1797760932362061 \
1.014302686923162e-06 0.1787387947787487 1.01430281588559e-06 0.1771515524267008 1.014302917772084e-06 0.1759040172436072 1.014303023472791e-06 0.1746156056808686 \
1.014303125120866e-06 0.1733818993219825 1.014303255982584e-06 0.1718019019596718 1.014303363179221e-06 0.1705140034701537 1.014303492508118e-06 0.168969083715685 \
1.01430360420461e-06 0.167642098072289 1.014303704535189e-06 0.1664555496840579 1.014303800335743e-06 0.1653276075899142 1.014303911148015e-06 0.1640289617085985 \
1.014303998548296e-06 0.1630090521997956 1.014304109869413e-06 0.1617156184952586 1.014304202821272e-06 0.1606409001560029 1.01430429039415e-06 0.1596330843918451 \
1.014304392025023e-06 0.1584700928658864 1.014304476479078e-06 0.1575086241734052 1.014304551583458e-06 0.1566573095634876 1.0143046294057e-06 0.1557789554714152 \
1.014304709763569e-06 0.1548759612316424 1.014304810818399e-06 0.1537464547857493 1.014304893251962e-06 0.1528311848879565 1.014304985556514e-06 0.1518114053368895 \
1.014305062490987e-06 0.150965812476358 1.014305145413558e-06 0.1500585909391909 1.014305216944298e-06 0.1492793026301012 1.014305313327797e-06 0.1482344968214558 \
1.014305383556283e-06 0.1474766665551334 1.014305466536561e-06 0.1465853655470201 1.014305527978825e-06 0.1459298106834085 1.014305599661209e-06 0.1451677491870439 \
1.014305668289752e-06 0.1444408762699853 1.014305718558261e-06 0.1439102090153988 1.014305766138067e-06 0.143409423336876 1.014305820187418e-06 0.1428423132663369 \
1.014305879529516e-06 0.1422216078256897 1.014305947564923e-06 0.1415124633834424 1.014306023828345e-06 0.1407207186008814 1.014306092108145e-06 0.1400161356079559 \
1.014306186894323e-06 0.1390460813732662 1.014306276448135e-06 0.1381341561933974 1.014306348133609e-06 0.1374075731330657 1.014306432085018e-06 0.1365606113096345 \
1.014306497397473e-06 0.1359045398875483 1.014306558840598e-06 0.1352895588344758 1.014306633117097e-06 0.1345490408254265 1.014306695327357e-06 0.1339328028964004 \
1.014306763298366e-06 0.133265236037424 1.014306822505405e-06 0.1326856657519672 1.014306895177879e-06 0.1319767402814105 1.014306970197988e-06 0.1312477270463112 \
1.014307055651411e-06 0.1304208267333309 1.01430714175175e-06 0.1295914604616623 1.014307241877205e-06 0.1286317929389105 1.014307323166875e-06 0.127857435971709 \
1.014307424934223e-06 0.1268981149578782 1.014307509182182e-06 0.1261072369695883 1.014307607998911e-06 0.1251836587365037 1.014307680839456e-06 0.1245055382686853 \
1.014307760865543e-06 0.1237631876254407 1.014307831351338e-06 0.1231117958237987 1.014307903881761e-06 0.1224439308288319 1.014307981350756e-06 0.1217331219782777 \
1.014308088702104e-06 0.1207554316575004 1.01430818934012e-06 0.1198442997624752 1.014308261927674e-06 0.1191899427853172 1.014308330759514e-06 0.1185715582611356 \
1.014308396546334e-06 0.1179824683205609 1.014308466175132e-06 0.1173610347366148 1.014308536558877e-06 0.1167350538439435 1.01430861173725e-06 0.1160688810594495 \
1.014308715991485e-06 0.1151493019715505 1.014308791126139e-06 0.114489769343061 1.014308860041223e-06 0.1138870655592168 1.014308923246094e-06 0.1133369146236164 \
1.01430899278746e-06 0.1127339156958381 1.014309050088964e-06 0.1122385190692166 1.014309121730019e-06 0.1116210355509516 1.014309179565092e-06 0.1111240709857579 \
1.014309251686527e-06 0.1105063809580559 1.01430931410261e-06 0.1099736279351742 1.014309398424132e-06 0.1092565349771765 1.0143094660201e-06 0.1086842173446869 \
1.014309574816032e-06 0.1077671916889585 1.014309679126564e-06 0.1068924975608609 1.014309758614772e-06 0.1062289053282379 1.014309846183182e-06 0.1055008617114655 \
1.014309909639535e-06 0.1049752776433979 1.014309971350652e-06 0.10446579874651 1.014310075190416e-06 0.103612238268202 1.014310157871118e-06 0.1029362225408096 \
1.014310256339144e-06 0.1021348761715451 1.014310340785582e-06 0.101450818648051 1.014310457263062e-06 0.1005121841703865 1.014310591996508e-06 0.09943411943161744 \
1.014310728066044e-06 0.0983541971400249 1.014310842385451e-06 0.09745369041838402 1.014310927852596e-06 0.09678457778867394 1.014311038134269e-06 0.09592640631053104 \
1.014311118922622e-06 0.09530159220710262 1.014311218473493e-06 0.09453592511176086 1.014311308421543e-06 0.09384821103094763 1.014311380924943e-06 0.09329669945188329 \
1.014311462667009e-06 0.09267796846073476 1.014311590787245e-06 0.09171467366828615 1.014311672199308e-06 0.09110674702409056 1.014311746631215e-06 0.09055373306570065 \
1.014311821605099e-06 0.08999936228352182 1.014311901024074e-06 0.08941505746347288 1.014312009684932e-06 0.08862052380504259 1.014312104044903e-06 0.08793517800096999 \
1.014312193440026e-06 0.08728987318634121 1.014312300205743e-06 0.086524181682867 1.014312418708183e-06 0.08568073755029131 1.014312560233253e-06 0.08468224831562859 \
1.014312693371676e-06 0.08375174214918565 1.014312834217007e-06 0.08277682112810406 1.014312983268988e-06 0.08175525972387458 1.014313119066718e-06 0.08083369778093191 \
1.014313260523232e-06 0.0798830809748103 1.014313395783147e-06 0.07898330517332906 1.014313537164988e-06 0.07805242629322809 1.014313684232761e-06 0.07709434677344783 \
1.014313835960902e-06 0.07611680364043326 1.014314001309203e-06 0.07506403321855706 1.014314165176721e-06 0.07403332863189842 1.014314341490649e-06 0.07293832728335037 \
1.014314530925751e-06 0.07177777688466977 1.014314741692455e-06 0.07050569389938771 1.014314961464952e-06 0.06920150027616521 1.014315196433104e-06 0.06783224552442871 \
1.014315455333654e-06 0.06635227408830123 1.014315750264117e-06 0.06470266364809808 1.014316054610178e-06 0.06304001691994518 1.014316416556457e-06 0.06111393619706453 \
1.014316732684212e-06 0.05947639552636011 1.014317174006677e-06 0.0572596911373907 1.01431748757272e-06 0.05573556853365672 1.014317911072189e-06 0.0537382660685313 \
1.014318255024043e-06 0.05216649213267931 1.01431859526531e-06 0.05065508790922631 1.0143189061029e-06 0.04931137323461653 1.014319200574802e-06 0.04807062469528345 \
1.014319494274299e-06 0.04686392507224969 1.014319769145536e-06 0.04576537019482012 1.014320044685701e-06 0.04468949010490332 1.01432030977623e-06 0.04367785045825667 \
1.014320586533311e-06 0.04264571401740119 1.014320869801436e-06 0.04161414314527601 1.014321167794735e-06 0.04055545327485047 1.014321427280131e-06 0.03965542606183669 \
1.014321657303569e-06 0.03887446236327848 1.014321876995156e-06 0.03814321686473518 1.014322101935296e-06 0.0374128399305801 1.01432242218897e-06 0.0363978329183388 \
1.01432270998682e-06 0.03550963653148703 1.014322986382154e-06 0.03467738358988744 1.014323270201283e-06 0.03384352473043348 1.014323508310587e-06 0.03315996078327022 \
1.014323792621371e-06 0.03236211345273886 1.014324034533221e-06 0.03169864947531036 1.014324269673394e-06 0.03106710921041438 1.014324511380923e-06 0.03043352335444016 \
1.014324748333857e-06 0.02982731501219571 1.014324978676274e-06 0.02925002048968134 1.014325192426852e-06 0.02872465224286764 1.014325398273815e-06 0.02822791768061097 \
1.014325790610838e-06 0.02730524204782691 1.014325979002849e-06 0.02687312495148303 1.014326354614307e-06 0.02603163971789 1.014326529081082e-06 0.02564950258131362 \
1.014326953015541e-06 0.02474274850847508 1.014327073769958e-06 0.02449086781212801 1.014327544020722e-06 0.02353384026002922 1.014327693235786e-06 0.02323677291035493 \
1.014328086867998e-06 0.02246740853134286 1.014328257894342e-06 0.02213909006726131 1.014328745173275e-06 0.02121869533024997 1.014328887220983e-06 0.02095326544309953 \
1.014329420237252e-06 0.01997576278857772 1.014329542401289e-06 0.01975737097014436 1.014330064559033e-06 0.01885981776906158 1.014330235137336e-06 0.01857989792133653 \
1.014330722450399e-06 0.01781360777737795 1.014330893973323e-06 0.01755501440977742 1.01433151376008e-06 0.01666567753024489 1.014331684684406e-06 0.0164316648397145 \
1.014332390235396e-06 0.01551160061118263 1.014332552852409e-06 0.01530799450170666 1.014333309745899e-06 0.01439879525764199 1.014333450662544e-06 0.01423641007536438 \
1.014334350661384e-06 0.01324361033368418 1.014334438010634e-06 0.01315122959105692 1.014335342363989e-06 0.01223321097894121 1.014335479555938e-06 0.01209984223734439 \
1.014336450212214e-06 0.01118944790767422 1.014336578130092e-06 0.01107451071402888 1.014337728540039e-06 0.01011008206277823 1.014337822342075e-06 0.01003687265682024 \
1.014339078387887e-06 0.009120584045805383 1.014339215929201e-06 0.009026502753623255 1.014340774683602e-06 0.008029670037698805 1.014340858486287e-06 0.007977066150721189 \
1.014342463865106e-06 0.00699828665725172 1.01434257476345e-06 0.006935886594503895 1.014344507009824e-06 0.005959177461785255 1.01434468671476e-06 0.005876661013304485 \
1.014346798505876e-06 0.004981749118765498 1.014347141291011e-06 0.004848482978762325 1.014349654457045e-06 0.003966891390423618 1.014350124178715e-06 0.003819799497680527 \
1.01435376449499e-06 0.002847564273158896 1.014354280232175e-06 0.002731633924241866 1.014359622062014e-06 0.001773027297371861 1.014359907382299e-06 0.001729522787584184 \
1.014365136030129e-06 0.0007540451492352357 1.014365310176696e-06 0.0007162692714263865 1.017013698769002e-06 -0.0001123232525192561 1.01701387179429e-06 -0.0002901710972538241 \
1.017014491546044e-06 -0.001202022686018724 1.017014580115222e-06 -0.001365806793032466 1.017014941086355e-06 -0.002110727959526865 1.01701506578065e-06 -0.002395793696299351 \
1.017015429622531e-06 -0.003299857180474864 1.017015600898199e-06 -0.003758114451912169 1.017015894896038e-06 -0.004576312838821549 1.017016005104443e-06 -0.004886880824040592 \
1.017016283358441e-06 -0.005643955697619643 1.01701640463225e-06 -0.00594200199557267 1.017017498254348e-06 -0.00517389603226481 1.017017621358228e-06 -0.004409713243767066 \
1.017017744826303e-06 -0.003462788751204457 1.0170178649921e-06 -0.002366010162083454 1.017017962853768e-06 -0.001346276287748183 1.017018069556104e-06 -0.0001076498664581183 \
1.017018181397488e-06 0.001328007358939307 1.017018317371855e-06 0.003256083960376262 1.017018439401011e-06 0.00514709866632534 1.017018627817289e-06 0.008343062029134115 \
1.017018768805819e-06 0.01093380316938193 1.017018921577523e-06 0.01391176330477175 1.017019064280151e-06 0.01683596409946878 1.017019218632388e-06 0.02013443377634912 \
1.017019374426043e-06 0.02358734537610087 1.01701953048334e-06 0.02715365164079262 1.01701967788774e-06 0.03060642997674319 1.017019826504485e-06 0.03415780069914553 \
1.017019981925702e-06 0.03793559522944389 1.017020140311532e-06 0.04184227512730877 1.017020305251154e-06 0.04596085539464361 1.017020479500423e-06 0.05035714787605008 \
1.017020658443539e-06 0.05491177248689325 1.017020847583032e-06 0.0597604232635115 1.01702105036361e-06 0.06498910043066243 1.017021269735637e-06 0.07067233091134768 \
1.017021500572133e-06 0.07667464705993039 1.017021747383969e-06 0.0831083675499642 1.01702201751608e-06 0.09016243555275107 1.017022310704188e-06 0.0978236474935409 \
1.017022634359626e-06 0.1062798466079799 1.017022997926912e-06 0.1157689210849182 1.01702339022043e-06 0.1259925151671456 1.017023838699915e-06 0.1376538644086695 \
1.0170243603994e-06 0.1511757390224034 1.017024972772044e-06 0.1669844191341421 1.017025649417359e-06 0.1843663871188266 1.01702643632765e-06 0.2044554566749352 \
1.017027317548744e-06 0.2267919980918504 1.017028137292384e-06 0.2474048556006221 1.017028865745328e-06 0.2655829647002126 1.017029507221317e-06 0.2814688958417333 \
1.017030083144485e-06 0.2956305456066151 1.017030620401302e-06 0.3087428400511723 1.017031124292597e-06 0.3209487846516751 1.017031601896145e-06 0.3324328152479784 \
1.017032080019379e-06 0.343838772307344 1.017032532118228e-06 0.3545331600964184 1.017033003884519e-06 0.365596737404158 1.01703344758136e-06 0.3759140547845509 \
1.017033969549898e-06 0.3879344734281669 1.01703449708783e-06 0.399956933836353 1.017034876602574e-06 0.4085271910771138 1.017035405564175e-06 0.4203606102508351 \
1.017035874883255e-06 0.4307444005277802 1.017036310038791e-06 0.4402814026247405 1.017036757516117e-06 0.4500002273945978 1.017037197539592e-06 0.4594737646471725 \
1.017037600841335e-06 0.4680814138276727 1.017037919241101e-06 0.4748254127722248 1.017038289219015e-06 0.4826007100982719 1.017038525472097e-06 0.4875314737878706 \
1.017038760543493e-06 0.4924129045770672 1.017039011882831e-06 0.4975994385012801 1.017039318269865e-06 0.5038799449729535 1.017039575228319e-06 0.5091120301871851 \
1.017039783702615e-06 0.5133309170973237 1.017039984084905e-06 0.5173683849445317 1.017040126478606e-06 0.5202244049244739 1.017040275403072e-06 0.5231993726577677 \
1.017040486949329e-06 0.5274019882470222 1.017040713006952e-06 0.5318780389403845 1.017040907549333e-06 0.5357103559602913 1.017041096681229e-06 0.539423417888626 \
1.017041326128277e-06 0.5439012399750046 1.017041508634083e-06 0.5474563135343053 1.017041745996952e-06 0.5520623276458133 1.01704201499126e-06 0.5572695987004129 \
1.01704226390171e-06 0.5620706638085723 1.017042507918531e-06 0.5667633705755619 1.017042780273744e-06 0.5719926523718327 1.017043041669874e-06 0.5769928369418796 \
1.017043299301279e-06 0.5819084237686675 1.017043546144628e-06 0.586601202059797 1.017043791890354e-06 0.5912552023551558 1.017044018467874e-06 0.5955288021520931 \
1.017044249620064e-06 0.5998646534936181 1.017044455900444e-06 0.6037202012184053 1.017044684021204e-06 0.6079592993751251 1.017044906401185e-06 0.6120725203834017 \
1.017045133377667e-06 0.6162454422471376 1.017045348430617e-06 0.6201823359462864 1.01704557780019e-06 0.6243500782103125 1.017045846823065e-06 0.6292041961704016 \
1.017046069836712e-06 0.6331993632081415 1.017046282091289e-06 0.6369772451758789 1.017046493488879e-06 0.6407176358819484 1.017046693558109e-06 0.644236566349866 \
1.017046923151959e-06 0.6482486956559365 1.017047163988886e-06 0.6524328529570182 1.017047345738273e-06 0.6555667906748446 1.0170475342865e-06 0.6588018260593631 \
1.017047687366139e-06 0.6614154033769962 1.017047859374421e-06 0.6643352515471471 1.01704800954724e-06 0.6668697017322168 1.017048146064529e-06 0.6691578850264722 \
1.017048295693716e-06 0.6716547631652277 1.017048423434085e-06 0.673777752640997 1.017048563020223e-06 0.6760856948620949 1.01704868725891e-06 0.6781310478824312 \
1.01704881840875e-06 0.6802827752320969 1.017048942850093e-06 0.6823179209931315 1.017049080080916e-06 0.6845542421253382 1.017049200329086e-06 0.6865048414796368 \
1.01704934166053e-06 0.6887891282595083 1.017049441991641e-06 0.6904033553735033 1.017049563109343e-06 0.6923460943304175 1.017049653886878e-06 0.6937948943079848 \
1.017049751145344e-06 0.6953408241330762 1.017049847353224e-06 0.6968660703265798 1.017049935967068e-06 0.6982647859968389 1.017050033255091e-06 0.6997938110311075 \
1.017050165723729e-06 0.7018622871835729 1.017050320913928e-06 0.7042674555997347 1.017050458791879e-06 0.7063866855441746 1.017050603646153e-06 0.7085960165693863 \
1.01705073070791e-06 0.7105202221428537 1.01705085539347e-06 0.7123960184768648 1.017050968098846e-06 0.7140814553427599 1.017051079889191e-06 0.7157437310299281 \
1.01705118066784e-06 0.7172341607972841 1.017051317946295e-06 0.7192525454101454 1.017051437630367e-06 0.7210013704967912 1.017051557059838e-06 0.7227365757678518 \
1.01705168394306e-06 0.7245692610776365 1.017051808360712e-06 0.7263556789600311 1.017051932093537e-06 0.728121726658988 1.017052058689063e-06 0.7299181396522603 \
1.017052189074464e-06 0.7317573312219798 1.017052311884284e-06 0.7334798522758219 1.01705244732006e-06 0.7353678990088863 1.017052548609838e-06 0.7367723836293941 \
1.017052656232334e-06 0.7382576460517265 1.017052745760416e-06 0.7394878879617913 1.017052860308785e-06 0.7410528648863303 1.017052948337041e-06 0.7422487366778059 \
1.017053055415107e-06 0.7436953530868765 1.0170531854801e-06 0.7454403311053276 1.017053296759795e-06 0.7469230742113165 1.017053401378355e-06 0.7483084058091373 \
1.01705352546134e-06 0.7499400420429273 1.017053673762168e-06 0.7518749696944975 1.017053795162033e-06 0.7534462209622173 1.01705390960278e-06 0.7549170836379747 \
1.017054049940098e-06 0.7567069362027918 1.017054191702981e-06 0.7584995177563068 1.017054309503919e-06 0.759977341175643 1.017054437480785e-06 0.761570846386187 \
1.017054579183209e-06 0.7633205808366864 1.017054696694523e-06 0.7647599110190483 1.017054842299792e-06 0.7665289162262866 1.017054963994099e-06 0.7679951561698679 \
1.017055082724709e-06 0.7694149786178283 1.017055205011304e-06 0.7708662727382939 1.01705533205582e-06 0.77236234268503 1.017055441699792e-06 0.7736439866494906 \
1.017055567386705e-06 0.7751025186690397 1.017055673401805e-06 0.776323977486031 1.017055808987772e-06 0.7778743028704433 1.017055933950769e-06 0.7792913979962601 \
1.017056059856921e-06 0.7807070123991936 1.017056175124167e-06 0.7819915514687489 1.01705628142864e-06 0.7831664991275713 1.017056419833432e-06 0.7846822315516878 \
1.017056569129882e-06 0.7862997378875561 1.017056714637328e-06 0.7878588534534761 1.017056834041839e-06 0.7891257303126159 1.017056969134663e-06 0.7905455128963393 \
1.017057090387826e-06 0.7918076974797237 1.017057233381105e-06 0.7932816011184505 1.017057377585411e-06 0.7947523458802197 1.017057503122239e-06 0.7960199014141693 \
1.017057622168612e-06 0.7972110037065316 1.017057734104495e-06 0.7983213107123885 1.017057838976047e-06 0.7993531099923881 1.017057934226459e-06 0.8002831901653534 \
1.017058070569705e-06 0.8016020813281191 1.017058187393835e-06 0.8027203407102198 1.017058306798445e-06 0.803852171037294 1.017058428905249e-06 0.8049980820693966 \
1.017058551860251e-06 0.8061401395390313 1.017058678828951e-06 0.8073073595000361 1.01705880406856e-06 0.8084467645495962 1.017058934640955e-06 0.8096220968518901 \
1.017059060631473e-06 0.8107441738369082 1.017059188817386e-06 0.8118738099374113 1.017059294347114e-06 0.8127947795787664 1.017059397218887e-06 0.8136847278655364 \
1.017059490214057e-06 0.8144826950388273 1.017059614010659e-06 0.8155354283166244 1.017059701978917e-06 0.8162769513478326 1.017059800709988e-06 0.8171027376706747 \
1.017059943975142e-06 0.8182889948057973 1.017060079253827e-06 0.8193962136425846 1.01706018836845e-06 0.8202800249700468 1.017060336451758e-06 0.8214657808291811 \
1.017060486222685e-06 0.8226492530953341 1.017060611457285e-06 0.8236267526687548 1.017060755448703e-06 0.8247372275730155 1.017060879504774e-06 0.8256825756473101 \
1.017061029968032e-06 0.8268152483647575 1.017061165678884e-06 0.8278240064655301 1.017061290697392e-06 0.828742521381556 1.017061408452322e-06 0.8295983347934622 \
1.017061554429135e-06 0.8306466023667578 1.017061720938452e-06 0.8318251482734692 1.017061851861028e-06 0.8327390940956469 1.017062025288466e-06 0.8339327615268647 \
1.017062193435348e-06 0.8350717495747054 1.017062363270277e-06 0.8362042975620877 1.017062544195048e-06 0.8373912937861997 1.017062687293307e-06 0.8383160748488641 \
1.017062801379198e-06 0.8390446117604563 1.017062931553184e-06 0.8398665237782376 1.017063033394266e-06 0.8405024977857931 1.017063150213615e-06 0.8412243379523001 \
1.017063287078045e-06 0.8420597162999857 1.017063484876669e-06 0.8432475311273343 1.01706367648074e-06 0.8443767279905872 1.017063885921222e-06 0.8455874169714939 \
1.017064067846852e-06 0.8466193100105236 1.017064264979958e-06 0.8477171434207121 1.017064438329848e-06 0.8486653666163242 1.017064621329232e-06 0.8496493024239481 \
1.017064792495495e-06 0.8505537352954988 1.017064967127282e-06 0.8514606693963016 1.017065142389669e-06 0.8523550102558151 1.017065318541784e-06 0.8532381479010797 \
1.017065508812824e-06 0.8541746551565574 1.017065699414774e-06 0.85509499218684 1.017065900062401e-06 0.8560449689899254 1.017066092672966e-06 0.8569390259424264 \
1.017066303330652e-06 0.8578972157030333 1.017066531456051e-06 0.8589122247267402 1.017066797213369e-06 0.8600655879592763 1.017067095837813e-06 0.8613244245924475 \
1.017067372169332e-06 0.862454900702886 1.01706765640239e-06 0.8635842083919951 1.017067930614306e-06 0.8646423892283146 1.017068202842372e-06 0.8656634505877856 \
1.017068473051191e-06 0.8666487272755322 1.017068730204067e-06 0.8675609437488442 1.017069002786335e-06 0.868501515423508 1.017069278771335e-06 0.8694269133137555 \
1.017069548872912e-06 0.8703069289141475 1.017069848734863e-06 0.8712546000783432 1.017070219768993e-06 0.8723856543073821 1.017070514706754e-06 0.8732530157608677 \
1.017070768997536e-06 0.8739790309043101 1.017071067254951e-06 0.8748056771600844 1.017071340863485e-06 0.8755409825400007 1.017071576991549e-06 0.8761583495732972 \
1.01707181733693e-06 0.876770807053994 1.017072039670212e-06 0.8773233906735478 1.01707223367596e-06 0.8777948466981503 1.017072563398506e-06 0.8785737911727464 \
1.017072718571944e-06 0.8789308835864816 1.017073036347473e-06 0.8796437246174529 1.01707321520917e-06 0.8800342982281311 1.017073557671047e-06 0.8807611334253193 \
1.017073741799519e-06 0.8811407335605206 1.017074216677856e-06 0.8820849466541889 1.017074384074053e-06 0.8824061830950772 1.017074849915456e-06 0.8832696475595492 \
1.017075030737665e-06 0.8835931319180218 1.017075524775914e-06 0.8844450822729043 1.017075666124327e-06 0.8846804878101884 1.017076272457385e-06 0.8856498028150036 \
1.017076424526725e-06 0.8858829444029697 1.0170770712152e-06 0.8868329272509302 1.017077199509723e-06 0.8870138524519416 1.017077847626928e-06 0.8878919388991984 \
1.017077977425792e-06 0.8880607713689423 1.017078755627481e-06 0.8890227771434612 1.017078870684414e-06 0.8891574578072456 1.017079726342848e-06 0.8901003239091128 \
1.017079871707616e-06 0.8902505899439886 1.01708085746403e-06 0.8911948786459364 1.01708107856904e-06 0.8913892999646706 1.017082223696019e-06 0.8923206810037944 \
1.017082354912619e-06 0.892422953350996 1.017083696124267e-06 0.8934189515818408 1.017083847523211e-06 0.8935240845833778 1.017085328961459e-06 0.8944568913393511 \
1.017085567840892e-06 0.8945912088657246 1.017087337161074e-06 0.8954685138428928 1.01708772631084e-06 0.895637400736999 1.017090119976628e-06 0.896526474291006 \
1.01709059568945e-06 0.8966764365754722 1.017094011699057e-06 0.8975478548673914 1.017094658849072e-06 0.8976786076740833 1.017102137013678e-06 0.8986646932675814 \
1.017102809590796e-06 0.8987192862546014 1.017195253995367e-06 0.8997188196574962 1.017195917228051e-06 0.8997241906476866 1.017385126389945e-06 0.900686595210158 \
1.017385288462789e-06 0.9007292695325627 1.017387933983676e-06 0.8998161167154269 1.017388102533154e-06 0.8996881690130656 1.017389379285545e-06 0.8987393243250013 \
1.017389581451881e-06 0.8986030018074492 1.017391189561267e-06 0.8976721249252815 1.017391381667193e-06 0.8975774045828077 1.017406495049839e-06 0.8985726115129884 \
1.017406683108756e-06 0.8986004060702872 1.017417988037768e-06 0.8995874924221801 1.017418361423516e-06 0.8996034751727418 1.017907373786698e-06 0.9005892719715856 \
1.017907484554897e-06 0.9006868984798269 1.017908237227259e-06 0.9015617873136611 1.017908339021945e-06 0.9017086238768567 1.01790887442049e-06 0.9025814930725723 \
1.017908976929663e-06 0.9027670217776843 1.017909369148482e-06 0.9035254014384071 1.017909509991429e-06 0.9038129158713877 1.017909951028881e-06 0.9047472953155866 \
1.017910136514484e-06 0.9051402477015744 1.017910652827601e-06 0.9061269394579334 1.017910737502694e-06 0.9062564181617988 1.017911972174744e-06 0.9053011091537977 \
1.017912129388156e-06 0.9045688862145235 1.017912321204818e-06 0.9034162411061901 1.017912488045348e-06 0.9021712267446264 1.017912635003746e-06 0.9008824031243315 \
1.017912749119942e-06 0.8997575350477262 1.017912878992032e-06 0.8983446880789033 1.01791299010955e-06 0.8970273815442567 1.017913082914029e-06 0.8958483937359277 \
1.017913171236719e-06 0.8946639786015808 1.017913274417478e-06 0.8932058048613533 1.017913366625413e-06 0.8918333298588224 1.01791345419561e-06 0.8904732289418564 \
1.017913568189077e-06 0.8886245408236838 1.0179137299935e-06 0.8858564722885236 1.017913914992118e-06 0.8825005184224666 1.017914107151785e-06 0.8788219124347386 \
1.017914308599139e-06 0.874780227084481 1.017914515009728e-06 0.8704697801294994 1.017914700181681e-06 0.8664790122147591 1.017914884689405e-06 0.862405115500708 \
1.017915057841296e-06 0.8585071391690239 1.017915242887321e-06 0.8542751393552932 1.017915420261524e-06 0.8501657390392787 1.017915597007955e-06 0.8460284987362284 \
1.017915763166606e-06 0.8421077870518131 1.017915925211044e-06 0.8382599993991456 1.017916091783925e-06 0.8342839555277276 1.017916250437662e-06 0.8304816347052207 \
1.017916441313687e-06 0.8258903812682129 1.017916616297259e-06 0.8216694867670907 1.017916786243393e-06 0.8175615830390965 1.017916951419568e-06 0.8135626411663678 \
1.017917124611674e-06 0.8093650119631921 1.017917295673877e-06 0.8052155696745213 1.017917463774914e-06 0.801136095357175 1.017917654109863e-06 0.7965156511928794 \
1.017917837691807e-06 0.7920591698039 1.017918045682732e-06 0.7870113041480956 1.017918268259242e-06 0.7816114142545842 1.017918457674258e-06 0.7770174196885687 \
1.017918650984654e-06 0.7723312127316435 1.01791879443024e-06 0.7688556734481145 1.017918943853591e-06 0.7652374066097742 1.017919063006063e-06 0.7623536300085233 \
1.017919175722545e-06 0.7596269484184472 1.017919284997451e-06 0.7569846861296079 1.017919421027209e-06 0.753697254849378 1.017919533823024e-06 0.750972995067179 \
1.01791965602098e-06 0.7480232093637929 1.017919767605752e-06 0.7453311011793381 1.017919892312215e-06 0.7423241425761796 1.017920046694167e-06 0.7386034578119585 \
1.017920213478233e-06 0.7345862494782525 1.017920430642921e-06 0.7293605768817599 1.01792062520351e-06 0.7246835946359503 1.017920785534396e-06 0.7208333202545074 \
1.017920960959998e-06 0.7166251500492028 1.017921150723573e-06 0.7120779400724765 1.017921339451897e-06 0.7075610435995559 1.017921521273264e-06 0.7032145396962334 \
1.017921705870676e-06 0.6988062725207448 1.017921842953811e-06 0.6955348514212173 1.017921996242049e-06 0.6918805091472418 1.017922191613795e-06 0.6872279990818534 \
1.017922347770547e-06 0.6835136309588888 1.017922505722766e-06 0.6797605476340507 1.01792270397403e-06 0.6750570282453686 1.017922897319928e-06 0.6704763548785364 \
1.017923133825274e-06 0.6648822204491218 1.017923320030378e-06 0.6604858901039825 1.017923557652698e-06 0.6548824851665868 1.017923744451452e-06 0.6504854738275335 \
1.017923925009212e-06 0.6462424706993735 1.017924088085156e-06 0.6424159959781919 1.017924232696721e-06 0.6390271817202816 1.017924373299071e-06 0.6357379642635244 \
1.017924500108657e-06 0.632774906490579 1.017924632245193e-06 0.6296924762754078 1.017924758489145e-06 0.6267508340255646 1.017924889752774e-06 0.6236963630311418 \
1.017925018850514e-06 0.6206978048938425 1.017925158276179e-06 0.6174624210713571 1.017925306646171e-06 0.6140261568477932 1.01792550120306e-06 0.6095278574984737 \
1.017925644648937e-06 0.6062198040692683 1.017925879109183e-06 0.6008245134060309 1.017926051007495e-06 0.5968818013610552 1.017926263928033e-06 0.5920102583789468 \
1.017926436394651e-06 0.5880775912131976 1.017926566719198e-06 0.5851108450968721 1.017926698275517e-06 0.5821241897920357 1.017926808505599e-06 0.5796262478458715 \
1.017926904159847e-06 0.5774603558442819 1.017927003393806e-06 0.5752182923213994 1.017927086311907e-06 0.5733484809858778 1.017927165227534e-06 0.5715706040143225 \
1.017927228156309e-06 0.5701535626562365 1.017927293664786e-06 0.5686800671140783 1.017927374150839e-06 0.5668736364148982 1.017927424016846e-06 0.5657560592102344 \
1.017927473205615e-06 0.5646541775062763 1.017927534675401e-06 0.5632780399140616 1.017927582596929e-06 0.5622058085646952 1.017927633441648e-06 0.5610687758404553 \
1.017927692541903e-06 0.5597501790023616 1.01792775115623e-06 0.5584442118409422 1.017927826782323e-06 0.5567607189607793 1.017927897341035e-06 0.5551915720267918 \
1.017927986471042e-06 0.5532116467156011 1.01792807569462e-06 0.5512351177508077 1.017928160998231e-06 0.5493490637975145 1.017928248625197e-06 0.5474138635528197 \
1.01792834562712e-06 0.545274424894262 1.017928449972891e-06 0.5429792414815097 1.017928566264315e-06 0.5404269323775457 1.017928672601932e-06 0.5380963700835184 \
1.017928784310815e-06 0.5356536306660374 1.017928896605295e-06 0.5332047801427824 1.017929023802854e-06 0.5304364255197962 1.017929146572528e-06 0.5277698476303582 \
1.017929288796925e-06 0.5246912237717902 1.017929425160057e-06 0.5217463069543907 1.017929577381123e-06 0.5184691491721333 1.017929737017329e-06 0.5150420887864461 \
1.017929912992522e-06 0.5112761258030903 1.017930101501109e-06 0.5072591542828934 1.01793030856769e-06 0.5028616940969075 1.017930533509662e-06 0.4981043078903621 \
1.017930784905619e-06 0.4928144328841237 1.017931021331185e-06 0.4878598554762091 1.017931318494919e-06 0.4816683149127979 1.017931609172211e-06 0.4756487143466775 \
1.017931917027196e-06 0.469313240945046 1.017932230852953e-06 0.4628991126846517 1.017932559994313e-06 0.4562163541974347 1.01793289337242e-06 0.4494927613461197 \
1.017933224999028e-06 0.4428490490857003 1.017933546548425e-06 0.4364504708187015 1.017933874224238e-06 0.4299742838549845 1.01793422184386e-06 0.4231546934710667 \
1.017934555065174e-06 0.4166645133789623 1.017934900974402e-06 0.4099771621835854 1.017935346388222e-06 0.4014400148089548 1.017935704178092e-06 0.3946500490499754 \
1.017936018334912e-06 0.3887397205534429 1.017936402745391e-06 0.3815756289527631 1.017936732720037e-06 0.3754830843203271 1.017937017930125e-06 0.3702633801070484 \
1.017937326220382e-06 0.3646649204592909 1.017937606017443e-06 0.3596257204303125 1.017937832011793e-06 0.3555880084110294 1.017938046849747e-06 0.3517755993421203 \
1.01793824528482e-06 0.3482769933469286 1.017938449224337e-06 0.3447071465415313 1.017938659760396e-06 0.3410461989361561 1.017938916734522e-06 0.3366091000429626 \
1.017939157995129e-06 0.3324763702393667 1.017939389568845e-06 0.3285420159269506 1.017939604222291e-06 0.3249208057821749 1.017939825046275e-06 0.3212218866489027 \
1.017940026292867e-06 0.3178749657716667 1.01794022938212e-06 0.3145250552959265 1.017940427226992e-06 0.3112865758726304 1.017940614079937e-06 0.3082497660855442 \
1.017940808016663e-06 0.3051208532403978 1.017941011761317e-06 0.30185834615803 1.017941190488583e-06 0.2990186060348319 1.017941428134378e-06 0.2952727068736475 \
1.017941627896611e-06 0.2921508861588616 1.017941829525427e-06 0.2890253490052915 1.017942054991886e-06 0.285561995332 1.017942221086285e-06 0.2830312764183137 \
1.017942399705387e-06 0.2803277612349699 1.017942581409589e-06 0.2775983111934518 1.017942770043305e-06 0.2747882307029562 1.017942947466508e-06 0.2721695222189568 \
1.017943124659646e-06 0.2695724116247911 1.01794328473156e-06 0.2672552081803913 1.017943405132239e-06 0.2655193337608355 1.017943552958303e-06 0.2633957862580221 \
1.017943681588075e-06 0.2615692882062232 1.017943783793658e-06 0.2601227034409412 1.017943902028939e-06 0.2584516051170885 1.0179440224823e-06 0.2567534139348401 \
1.017944146190618e-06 0.2550183706610066 1.017944264442643e-06 0.2533694204037282 1.017944392295773e-06 0.2515887492000971 1.017944512581604e-06 0.249915736161692 \
1.01794466526121e-06 0.2477917697339537 1.017944800173988e-06 0.2459264316518071 1.01794492881341e-06 0.2441493177932957 1.017945086528788e-06 0.2419705448111171 \
1.017945213210091e-06 0.2402201997919771 1.017945348536159e-06 0.2383592392624043 1.017945487448727e-06 0.2364550510890953 1.017945605221031e-06 0.2348405558720491 \
1.01794576449185e-06 0.2326580599570062 1.017945901013704e-06 0.2307878375452989 1.01794604224565e-06 0.2288626996658652 1.017946148058693e-06 0.2274220928889542 \
1.01794627840164e-06 0.2256484734765637 1.017946378112453e-06 0.2242944442559471 1.017946480933888e-06 0.2228991027388591 1.017946554349542e-06 0.2219046249368765 \
1.017946634181104e-06 0.2208265149641777 1.017946704228335e-06 0.2198809561195558 1.017946754631426e-06 0.2192009305305119 1.017946806883225e-06 0.2184966408607167 \
1.017946886120743e-06 0.2174292050927151 1.017946927964696e-06 0.2168658036437602 1.017946967304648e-06 0.216336351877609 1.017947010340058e-06 0.2157575332679269 \
1.017947054507484e-06 0.2151638767852215 1.017947128273223e-06 0.2141731338947761 1.017947163785221e-06 0.2136967174286463 1.017947211500021e-06 0.2130606706933813 \
1.017947272229561e-06 0.2122518321687151 1.017947340486787e-06 0.2113438957752176 1.017947413008566e-06 0.2103801801047663 1.017947485683193e-06 0.2094152724966429 \
1.017947593999181e-06 0.2079788886429202 1.017947691670323e-06 0.20668564243436 1.017947803221819e-06 0.2052110974836689 1.017947901757253e-06 0.2039136008387587 \
1.017948005250393e-06 0.2025572972554956 1.017948101152128e-06 0.2013021587886929 1.017948203780057e-06 0.1999606878451601 1.01794830660317e-06 0.1986207062101238 \
1.017948416722797e-06 0.1971897063011611 1.017948525418353e-06 0.1957815523781236 1.017948645095582e-06 0.1942360962608612 1.01794875537326e-06 0.192818053470401 \
1.017948863436481e-06 0.1914343471929882 1.017948988535148e-06 0.1898375077741012 1.017949078504982e-06 0.1886931806549971 1.017949157191935e-06 0.1876950225942949 \
1.017949234476806e-06 0.1867173468865102 1.017949320985382e-06 0.1856271834369256 1.017949419934593e-06 0.1843848109964498 1.017949490443458e-06 0.1835017733581451 \
1.017949561894511e-06 0.1826096997732476 1.017949667039846e-06 0.1813018727451555 1.017949746279475e-06 0.1803200401832796 1.01794982736337e-06 0.1793174195483187 \
1.01794992085531e-06 0.1781663090788374 1.017950021631285e-06 0.1769308188703378 1.017950171343388e-06 0.175105380089017 1.017950287132704e-06 0.1737009932372819 \
1.017950438138081e-06 0.1718807311127691 1.0179505492465e-06 0.1705485445502526 1.017950691372958e-06 0.168854666407182 1.017950809031379e-06 0.167460358327668 \
1.017950913935975e-06 0.1662230887079887 1.017951008998573e-06 0.1651069099307241 1.017951102429828e-06 0.1640147999883682 1.01795120347649e-06 0.1628388413495604 \
1.017951299823398e-06 0.1617223204899406 1.017951396975644e-06 0.1606011553546776 1.017951480024216e-06 0.1596469772300165 1.01795159006187e-06 0.1583897228513109 \
1.017951672364432e-06 0.1574542248873526 1.017951777364141e-06 0.156267858580057 1.01795185506021e-06 0.1553950893374849 1.017951937879689e-06 0.1544690878994293 \
1.017952019541594e-06 0.1535604570452941 1.017952108890884e-06 0.152571060794856 1.01795218460332e-06 0.1517364980793458 1.017952267165934e-06 0.1508307726525361 \
1.017952343747367e-06 0.1499942554682341 1.017952412035254e-06 0.1492531084507001 1.017952505402265e-06 0.1482449401818621 1.017952574555677e-06 0.1475015570698688 \
1.017952650180008e-06 0.1466917482325688 1.017952711729129e-06 0.1460354497178591 1.017952778977892e-06 0.1453208357145237 1.017952850039892e-06 0.1445684785944268 \
1.01795292553732e-06 0.143772322008306 1.01795298444886e-06 0.1431546944759192 1.01795306112247e-06 0.1423563022825049 1.017953141443211e-06 0.1415233898163201 \
1.017953214594519e-06 0.1407682091691316 1.017953308750941e-06 0.139800669784813 1.017953380355125e-06 0.1390684367429364 1.017953453815901e-06 0.1383201464810226 \
1.017953537327652e-06 0.1374732033664194 1.017953626806795e-06 0.1365744208092838 1.0179536918717e-06 0.1359252211013016 1.017953803997723e-06 0.1348115665849295 \
1.017953869183863e-06 0.1341670699454539 1.017953939222108e-06 0.1334770515823289 1.017953999527163e-06 0.1328849371768329 1.017954054537987e-06 0.1323464455745446 \
1.017954142654965e-06 0.1314871014507438 1.017954183441259e-06 0.131090685705856 1.017954287144011e-06 0.1300923774523848 1.01795433045658e-06 0.1296773144713907 \
1.017954391675178e-06 0.1290920262082728 1.017954436511897e-06 0.1286643765206081 1.017954524107923e-06 0.127831527987147 1.017954565661879e-06 0.1274377589706847 \
1.017954625523389e-06 0.1268718307679372 1.017954697367115e-06 0.1261946708524367 1.017954753579841e-06 0.1256664967939027 1.01795481606734e-06 0.125081039250218 \
1.017954890295323e-06 0.1243877959456236 1.017954964976328e-06 0.1236954937854857 1.017955052159541e-06 0.1228905551604285 1.017955120558092e-06 0.1222610287411191 \
1.017955201128775e-06 0.1215216597888775 1.017955282424256e-06 0.120778012781285 1.017955349340781e-06 0.1201677797529914 1.017955432157726e-06 0.1194156054679852 \
1.017955491346448e-06 0.1188799972037829 1.017955557267448e-06 0.1182853617472536 1.017955637141492e-06 0.1175675408705869 1.01795571363729e-06 0.1168828806096336 \
1.0179557950994e-06 0.1161574242846086 1.017955893570281e-06 0.1152852106851665 1.01795596868063e-06 0.114622623867465 1.01795607166842e-06 0.1137180076826871 \
1.017956145852371e-06 0.1130691786503039 1.017956243471825e-06 0.1122190343868764 1.01795633928278e-06 0.1113890351962442 1.017956435131205e-06 0.110562946039519 \
1.017956516069412e-06 0.1098685209805978 1.017956604452683e-06 0.1091134439098378 1.017956703052662e-06 0.108274944429282 1.017956775836866e-06 0.1076586405352824 \
1.017956865109775e-06 0.1069058608836731 1.017956927091788e-06 0.1063852406583179 1.017956989684956e-06 0.1058613310701875 1.017957074907104e-06 0.105150777260444 \
1.017957180369478e-06 0.1042758147594986 1.017957260199961e-06 0.1036167065755082 1.017957340914214e-06 0.1029530974056021 1.017957423527949e-06 0.1022768941101355 \
1.017957493972562e-06 0.1017026162492672 1.017957597231928e-06 0.1008648142128753 1.017957670072054e-06 0.1002767039768694 1.017957755712335e-06 0.09958839426015198 \
1.017957874514073e-06 0.09863954321822334 1.017957942151898e-06 0.09810250133474645 1.01795801190202e-06 0.09755100310752296 1.017958089237e-06 0.09694230106952094 \
1.017958181657254e-06 0.09621870517595056 1.017958253354782e-06 0.09566033062548993 1.017958339171942e-06 0.09499542738017568 1.017958441597192e-06 0.09420660575030523 \
1.017958534892083e-06 0.09349264652734962 1.017958631208556e-06 0.09276005482712441 1.017958708110817e-06 0.09217843893134048 1.017958801590805e-06 0.09147541043939374 \
1.017958880833232e-06 0.09088281005358793 1.017958995455426e-06 0.0900310686188453 1.017959125063686e-06 0.08907580221142102 1.017959258320876e-06 0.08810234090122065 \
1.017959402350766e-06 0.08705990691030199 1.01795955951891e-06 0.08593388720602639 1.017959709295387e-06 0.08487214151476249 1.017959871762979e-06 0.08373303262435308 \
1.017960014942984e-06 0.08273971668837025 1.017960167622107e-06 0.0816913199659166 1.017960301891878e-06 0.08077856892457436 1.017960443644155e-06 0.07982444400446118 \
1.017960578643816e-06 0.07892500874648442 1.017960720601213e-06 0.07798882638923543 1.017960867448644e-06 0.07703088995320664 1.017961019894053e-06 0.07604750978240994 \
1.017961185112776e-06 0.07499422991502351 1.017961349250621e-06 0.07396067809208305 1.017961526112024e-06 0.07286119333145537 1.01796171645358e-06 0.07169407515132428 \
1.017961927410093e-06 0.07042030845332216 1.017962147819231e-06 0.0691121699798517 1.017962383344393e-06 0.06773900533435212 1.017962643793767e-06 0.0662496528900723 \
1.017962939459177e-06 0.06459579389282195 1.017963244581463e-06 0.06292902455725519 1.017963609576024e-06 0.06098725515092194 1.017964004456839e-06 0.05894944116461652 \
1.017964410847493e-06 0.05692211719668253 1.017964826573035e-06 0.05491854459141238 1.017965189379358e-06 0.0532251207245777 1.017965533980648e-06 0.05166301626031383 \
1.01796584916051e-06 0.05027284652491828 1.017966144689875e-06 0.04900240867073854 1.017966442670382e-06 0.04775344010203557 1.017966718469172e-06 0.04662857640242725 \
1.017966997243768e-06 0.04551884372531381 1.017967261178638e-06 0.04449205559535935 1.017967537201376e-06 0.04344260531795661 1.01796781615763e-06 0.04240676967887352 \
1.017968129850963e-06 0.04127097799875453 1.01796836585125e-06 0.04043636567030678 1.017968621645987e-06 0.03955075129286261 1.017968881769487e-06 0.03867033103466553 \
1.017969151904759e-06 0.03778142289416799 1.017969431124747e-06 0.03688501536902895 1.017969712963396e-06 0.03600226561751176 1.017969989839066e-06 0.03515600409566183 \
1.017970268932665e-06 0.03432349610146775 1.017970501810272e-06 0.03364444121149882 1.017970785646989e-06 0.03283527291840588 1.017971025751923e-06 0.03216626441466421 \
1.017971265550746e-06 0.0315119836023277 1.01797150482792e-06 0.03087436846876356 1.017971740084942e-06 0.03026290129608995 1.017971971011964e-06 0.02967475842909434 \
1.017972186001007e-06 0.02913788335257221 1.017972588155459e-06 0.02816043724496065 1.017972786878278e-06 0.02768988489927659 1.017973160561295e-06 0.0268265706552881 \
1.017973347359617e-06 0.02640514011949098 1.017973694919304e-06 0.02563810810034544 1.017973816848767e-06 0.0253740445387235 1.017974199320207e-06 0.02456430406701914 \
1.017974370028237e-06 0.02421180751242828 1.017974827125621e-06 0.02328894863848502 1.017975012758007e-06 0.0229225623309489 1.01797537621526e-06 0.02221803970155307 \
1.017975596582612e-06 0.02179832126591805 1.01797605430897e-06 0.02093867417890744 1.017976189728599e-06 0.02068687731869814 1.017976719624047e-06 0.01972418011126781 \
1.017976838945017e-06 0.01951377505543128 1.017977404730696e-06 0.01856069823426573 1.017977569110437e-06 0.0182962226476828 1.017978187655734e-06 0.01735107502432094 \
1.017978357709933e-06 0.01710418363667701 1.017978889842166e-06 0.01636278834442301 1.017979086926142e-06 0.01610013864443424 1.017979810045215e-06 0.01517806887136661 \
1.017979974675381e-06 0.01497647803580381 1.017980723800768e-06 0.01409711804523418 1.01798085710012e-06 0.01394643716836554 1.017981717353759e-06 0.01301449210748497 \
1.017981852457379e-06 0.01287422877142914 1.01798279503482e-06 0.01193816285908547 1.017982958630574e-06 0.01178202925388569 1.017983959987201e-06 0.0108653384673985 \
1.017984097529988e-06 0.01074500730514941 1.017985319636371e-06 0.009765086624518643 1.017985426589084e-06 0.00968516078425012 1.017986830780577e-06 0.008707372520026449 \
1.017986935611284e-06 0.008639312158696611 1.017988470448246e-06 0.00767719340797631 1.017988565731548e-06 0.007617466071856052 1.017990174528868e-06 0.006680264535635283 \
1.017990308605608e-06 0.006609506832171614 1.017992405618559e-06 0.005610918814474722 1.017992636163191e-06 0.005510783990371394 1.017994959158435e-06 0.004586584533412417 \
1.017995440488638e-06 0.004413562233393853 1.017998278050269e-06 0.003511943147855551 1.017998822969955e-06 0.003360532104877318 1.018002947178352e-06 0.002408309874554541 \
1.018003490902011e-06 0.002305347543005144 1.018009362191237e-06 0.001333291345955189 1.018009605056421e-06 0.001286469439319215 1.018023932948772e-06 0.0002880570268237783 \
1.018024077507414e-06 0.0002853642807229123 1.020661356428513e-06 -0.0006859155495331031 1.02066149598365e-06 -0.000901903561740745 1.020662005077583e-06 -0.001859438188174024 \
1.020662094565085e-06 -0.002052812934985279 1.020662457959945e-06 -0.00291126965001638 1.020662548982015e-06 -0.003143482006111167 1.020662914420052e-06 -0.004127275145644371 \
1.02066302468062e-06 -0.004436819103926468 1.020663336727774e-06 -0.005309594399865315 1.020663439442621e-06 -0.005584800160857357 1.020663803290477e-06 -0.006384516484886619 \
1.020663968081209e-06 -0.006586298968823262 1.020664547677408e-06 -0.005791490933239759 1.020664722787551e-06 -0.004914057272375438 1.020664839479485e-06 -0.004132845175365214 \
1.020664966064091e-06 -0.003100877896798674 1.020665067873013e-06 -0.002132773363901063 1.020665188361723e-06 -0.0008283127610571584 1.020665278808799e-06 0.0002599396317828252 \
1.020665376698931e-06 0.001541559978017447 1.020665475763239e-06 0.002943971508909197 1.020665646570516e-06 0.005594911825788154 1.020665868338539e-06 0.00944046646559993 \
1.020666064242384e-06 0.01317281463966807 1.020666223123766e-06 0.01639870563256729 1.020666387552263e-06 0.01989779506365397 1.020666541918294e-06 0.02331070396473752 \
1.020666700690818e-06 0.02693200463312963 1.020666847428777e-06 0.03036422445567413 1.020666996052748e-06 0.0339113704936035 1.020667151667245e-06 0.03768995713197771 \
1.020667308909259e-06 0.04156499463828727 1.020667473802058e-06 0.04567927910670353 1.020667647221578e-06 0.05005184210758699 1.020667825915293e-06 0.05459761989277153 \
1.020668014531131e-06 0.05943075613080645 1.020668215431274e-06 0.06460909294799391 1.020668434888065e-06 0.0702927970720964 1.020668664434351e-06 0.07626037976612585 \
1.020668910133291e-06 0.08266408948881369 1.02066917869823e-06 0.08967663153997742 1.020669470040145e-06 0.09728936802005522 1.020669791708172e-06 0.1056939239977524 \
1.020670152022263e-06 0.1150987971742611 1.020670543001701e-06 0.1252892839303718 1.020670986416517e-06 0.1368209045172546 1.020671502729605e-06 0.1502062239570841 \
1.020672108934821e-06 0.16586000516691 1.020672780191848e-06 0.1831102247110778 1.020673559691505e-06 0.20301830483439 1.020674432001389e-06 0.2251413938832897 \
1.020675262336714e-06 0.2460320778586349 1.020675993667063e-06 0.264292249712138 1.020676641612843e-06 0.280346965484095 1.020677224923317e-06 0.29469740877147 \
1.020677760655584e-06 0.3077798509628869 1.020678263914169e-06 0.3199778888071559 1.02067874911767e-06 0.3316516836183861 1.020679228040376e-06 0.3430829066939081 \
1.020679674471008e-06 0.3536501814456421 1.020680148800718e-06 0.3647819492304352 1.020680597991712e-06 0.3752331958288908 1.02068108846397e-06 0.3865396207984229 \
1.020681617036723e-06 0.3985997842463301 1.020681988181063e-06 0.4069920784971888 1.020682515935418e-06 0.4188173133762567 1.020682978292178e-06 0.4290642331729484 \
1.020683450624318e-06 0.4394285229343968 1.020683932409041e-06 0.4498981261869666 1.020683965448159e-06 0.4506126593745911 1.020684003207152e-06 0.45142837879914 \
1.020684078725137e-06 0.4530572051633331 1.020684229761107e-06 0.4563088938659436 1.020684437280373e-06 0.460764549126051 1.020684625319184e-06 0.4647825567212808 \
1.020684844328398e-06 0.469441659996985 1.020685087159409e-06 0.4745824626509371 1.020685386935038e-06 0.4808894567257585 1.020685624728187e-06 0.4858624696070272 \
1.020685887949588e-06 0.4913374535260851 1.020686148847133e-06 0.4967277906005185 1.02068637840122e-06 0.5014431429135263 1.020686601461414e-06 0.506003872007333 \
1.020686803037404e-06 0.5100983586086808 1.020686951867463e-06 0.51310967141356 1.020687196178516e-06 0.5180317772556589 1.020687328783749e-06 0.5206893064287169 \
1.020687468140331e-06 0.5234717264876519 1.020687679105724e-06 0.5276623644271943 1.020687853979606e-06 0.5311266030493931 1.020688122027852e-06 0.5364094032095129 \
1.02068831705351e-06 0.5402319029111832 1.020688496615017e-06 0.5437361368949839 1.020688747571146e-06 0.5486228351952749 1.020689024979257e-06 0.5540035987981641 \
1.020689308928559e-06 0.5594901708581531 1.02068956456585e-06 0.5644152233389156 1.02068985554807e-06 0.570006772487656 1.020690115853754e-06 0.5749917787111524 \
1.020690384297874e-06 0.5801232573974072 1.020690627063004e-06 0.5847450403362237 1.020690883594205e-06 0.5896146675871002 1.020691109757648e-06 0.59388771440121 \
1.020691347099143e-06 0.5983512154742827 1.02069155648786e-06 0.6022720321566808 1.020691770260628e-06 0.6062574570422776 1.020692023713469e-06 0.6109557890491497 \
1.020692226567816e-06 0.6146943332140289 1.020692419372338e-06 0.6182333111593361 1.020692609677365e-06 0.6217090173923294 1.020692800335854e-06 0.6251694921350958 \
1.02069300291378e-06 0.6288260100903066 1.020693265662542e-06 0.6335359534764116 1.020693494630232e-06 0.6376100987349322 1.020693714577867e-06 0.6414991146358265 \
1.02069394026254e-06 0.6454625140719233 1.020694149149966e-06 0.6491091855837361 1.020694370803585e-06 0.652957810138281 1.020694555693011e-06 0.6561429680377227 \
1.020694745707564e-06 0.6594017273991298 1.020694895862686e-06 0.6619630641908443 1.020695070740593e-06 0.6649292185271485 1.020695216461309e-06 0.6673855496832628 \
1.020695352493842e-06 0.6696641287411549 1.020695500856121e-06 0.672138295335571 1.020695630303834e-06 0.6742883907026684 1.020695764169531e-06 0.6764996355878535 \
1.02069589251393e-06 0.6786115243545502 1.020696017902058e-06 0.6806677490053815 1.020696147367755e-06 0.6827843190971332 1.02069627834897e-06 0.6849171426143115 \
1.020696426722072e-06 0.6873221141612875 1.020696534784827e-06 0.6890667486235877 1.020696663316499e-06 0.6911333958680312 1.020696798756284e-06 0.6933004139195943 \
1.020696923690607e-06 0.6952876996714908 1.020697049447875e-06 0.6972799977491608 1.020697155963766e-06 0.6989584331773744 1.020697273081655e-06 0.7007929859467624 \
1.020697391621401e-06 0.7026383448210159 1.020697514924797e-06 0.704545102273978 1.020697618097696e-06 0.7061304255463237 1.020697769068859e-06 0.7084341141567283 \
1.020697885323065e-06 0.7101955266062138 1.020698015883454e-06 0.7121605601685687 1.020698134445982e-06 0.7139335830373704 1.020698240519852e-06 0.7155108922888329 \
1.020698340544792e-06 0.716990346352101 1.020698477870007e-06 0.719009255813789 1.020698596531362e-06 0.7207429633399333 1.020698718230586e-06 0.7225107522614664 \
1.020698843413152e-06 0.7243181860083944 1.020698965432965e-06 0.7260693242762759 1.020699093464719e-06 0.7278954552757622 1.020699217946458e-06 0.7296603419865877 \
1.020699346245781e-06 0.7314685590147565 1.020699473339584e-06 0.7332489547570846 1.020699599364423e-06 0.7350034830462163 1.02069970210311e-06 0.7364262918236342 \
1.020699816775856e-06 0.7380063527755659 1.020699898181918e-06 0.7391232259175492 1.020700017381438e-06 0.7407496908814458 1.020700110023778e-06 0.7420059782745783 \
1.020700248182835e-06 0.7438668850244906 1.020700379238334e-06 0.7456179978167152 1.020700509370502e-06 0.7473439783685625 1.020700614344577e-06 0.7487266533969134 \
1.020700753484419e-06 0.7505456565005918 1.020700907428719e-06 0.7525407731682957 1.020701029372999e-06 0.7541080835708853 1.020701176919359e-06 0.7559892974429111 \
1.020701298924537e-06 0.7575320275232224 1.020701447624467e-06 0.7593968175435225 1.020701581671092e-06 0.7610632318338031 1.020701703924347e-06 0.7625711443351471 \
1.020701816790257e-06 0.763953046884334 1.020701959641225e-06 0.7656882893306027 1.020702086364119e-06 0.7672149413549471 1.020702202168994e-06 0.7685995877768005 \
1.020702331910823e-06 0.7701390587657672 1.020702447649211e-06 0.7715019052061673 1.020702570601637e-06 0.7729391548276606 1.020702688317297e-06 0.7743051053122872 \
1.020702794287273e-06 0.7755262985206828 1.020702910698467e-06 0.7768586864857919 1.0207030173164e-06 0.7780703956921795 1.020703129515121e-06 0.7793369495935717 \
1.02070321618369e-06 0.7803089322889447 1.020703319569181e-06 0.7814603789665585 1.020703432733432e-06 0.7827108149434853 1.020703538380716e-06 0.783868819044773 \
1.020703647720273e-06 0.7850578567336689 1.020703754897288e-06 0.786214126597127 1.020703884303365e-06 0.7875981444497275 1.020703996720751e-06 0.7887899291890393 \
1.02070412010849e-06 0.7900869036018625 1.020704237558825e-06 0.7913106402786101 1.020704381085744e-06 0.7927918312347375 1.020704496005322e-06 0.7939667362870242 \
1.020704634727735e-06 0.7953719780830618 1.020704772759876e-06 0.7967562205547866 1.020704882253029e-06 0.7978444364842524 1.020704983271459e-06 0.7988406866985471 \
1.02070508435942e-06 0.7998302780396641 1.020705216746616e-06 0.8011146558616069 1.020705335472037e-06 0.8022550163876687 1.020705457256542e-06 0.8034134048507504 \
1.020705576346336e-06 0.8045351524060473 1.020705697550853e-06 0.8056657048884367 1.020705829194664e-06 0.8068811249615274 1.020705952212703e-06 0.8080052413861453 \
1.020706079823023e-06 0.8091594649786741 1.020706210891683e-06 0.8103325925767672 1.020706334212046e-06 0.8114249716726942 1.020706442136311e-06 0.8123719892944993 \
1.020706549931703e-06 0.8133095350680949 1.020706631652631e-06 0.8140147772069938 1.020706748520247e-06 0.815015186305849 1.020706839581256e-06 0.8157880755829442 \
1.020706973749888e-06 0.8169164295805346 1.02070711832076e-06 0.8181184617099191 1.020707251823126e-06 0.8192158725965917 1.020707361789038e-06 0.8201107352847025 \
1.020707505654697e-06 0.8212684563313245 1.020707658960262e-06 0.8224861772268215 1.020707786698555e-06 0.8234883060891934 1.020707927340891e-06 0.8245786478120171 \
1.020708053124456e-06 0.8255423809867173 1.020708207742427e-06 0.8267124309768116 1.020708340154194e-06 0.8277017767197102 1.020708466433798e-06 0.8286345641820314 \
1.020708584064113e-06 0.8294941055817234 1.020708732230976e-06 0.8305638349826423 1.020708899375221e-06 0.8317531470681401 1.020709031993881e-06 0.832683775428688 \
1.020709204938569e-06 0.8338803479528284 1.020709373325224e-06 0.8350269493631071 1.020709542859754e-06 0.8361634673386688 1.020709724228909e-06 0.8373596561587384 \
1.020709866861491e-06 0.8382862741713709 1.02070998079734e-06 0.8390176620397163 1.020710111571134e-06 0.8398476357987267 1.020710213225074e-06 0.8404856735008092 \
1.020710329718803e-06 0.8412091703399448 1.020710465236349e-06 0.8420405885319162 1.020710662580143e-06 0.8432318270427018 1.020710853245141e-06 0.8443612543037786 \
1.02071106310198e-06 0.8455804035625291 1.020711244039104e-06 0.8466117334714958 1.020711441374591e-06 0.8477160230260256 1.020711615161427e-06 0.8486711109012058 \
1.020711797742881e-06 0.8496572451898022 1.020711969062461e-06 0.850566499179887 1.020712143447508e-06 0.8514760798656241 1.020712318831052e-06 0.8523748177975867 \
1.020712495063209e-06 0.8532619682996843 1.020712684901452e-06 0.8542000584728613 1.020712875637665e-06 0.8551245802328369 1.020713077434399e-06 0.856083442102113 \
1.020713270127775e-06 0.8569809170305027 1.020713479756077e-06 0.857937542729613 1.02071370919384e-06 0.8589615588718806 1.02071397499048e-06 0.8601183337444025 \
1.020714273565707e-06 0.8613802063570262 1.020714551467221e-06 0.8625196921548358 1.020714835677695e-06 0.8636511027355716 1.020715110089482e-06 0.8647118800460076 \
1.020715382252364e-06 0.8657341977214618 1.020715652421455e-06 0.8667205537246333 1.020715909616139e-06 0.8676338760342862 1.020716182155811e-06 0.868575115807136 \
1.020716458190291e-06 0.8695013130444248 1.020716728342986e-06 0.8703818891200001 1.020717028049788e-06 0.8713292845176382 1.020717398867258e-06 0.8724597217497643 \
1.020717693785921e-06 0.8733269024855727 1.020717948030199e-06 0.8740525764960509 1.020718246254199e-06 0.8748787854419284 1.020718519878969e-06 0.8756137195941651 \
1.020718756017958e-06 0.8762307200963571 1.020718996373686e-06 0.8768427579093606 1.020719218719338e-06 0.8773949085683344 1.020719412723072e-06 0.877865919014753 \
1.020719742447196e-06 0.878644045115768 1.020719897619855e-06 0.8790007149587372 1.020720215373248e-06 0.879712598742095 1.020720394238605e-06 0.8801026384247937 \
1.020720736700094e-06 0.8808283583858193 1.020720920841293e-06 0.8812073588304842 1.020721395746114e-06 0.8821499412898334 1.020721563140601e-06 0.8824705695712217 \
1.020722028971889e-06 0.8833323038036038 1.020722209796771e-06 0.8836551183393088 1.020722703830028e-06 0.8845051821644966 1.020722845172603e-06 0.8847400410050358 \
1.020723451563118e-06 0.8857071861637142 1.020723603635685e-06 0.8859397703602404 1.020724250313758e-06 0.8868873789663725 1.020724378610247e-06 0.8870678433440622 \
1.020725026723245e-06 0.8879435266410994 1.020725156528523e-06 0.8881118897635528 1.020725934785608e-06 0.8890711781604964 1.020726049780423e-06 0.8892053868933587 \
1.020726905511062e-06 0.8901454611437621 1.020727050777629e-06 0.8902951528450479 1.020728036533732e-06 0.8912364417375994 1.020728257640946e-06 0.8914302300078862 \
1.020729402752027e-06 0.892358484239638 1.020729533960174e-06 0.8924604119362172 1.02073087526337e-06 0.8934531785430913 1.020731026651031e-06 0.8935579568409697 \
1.020732508109867e-06 0.8944876667405802 1.020732746990229e-06 0.894621531696939 1.020734516461986e-06 0.8954958910368339 1.020734905568823e-06 0.8956641700186337 \
1.020737299334232e-06 0.8965498195158238 1.020737774894223e-06 0.8966991754584082 1.020741837950387e-06 0.8976977719002629 1.020742329424408e-06 0.8977905759376156 \
1.020750645951487e-06 0.8987839664765119 1.020751565805377e-06 0.8988472044554419 1.020877770945903e-06 0.8998441026240215 1.020878784754255e-06 0.8998514601858095 \
1.021070497347411e-06 0.8990059056521554 1.021070727348974e-06 0.8988405173838494 1.021072342221535e-06 0.8978439928078279 1.021072519935389e-06 0.8977495532019018 \
1.021089285710429e-06 0.8987316330193963 1.021089421698825e-06 0.8987497732072308 1.021104884427938e-06 0.8997471920221268 1.02110515229253e-06 0.8997526389354535 \
1.021588977619798e-06 0.9006560548284696 1.021589098408998e-06 0.9007687033315858 1.021589886180037e-06 0.9017381658104292 1.021590020318756e-06 0.901943163319478 \
1.021590513933531e-06 0.9027850367016239 1.021590658833145e-06 0.9030569221572713 1.02159105464053e-06 0.9038490360455199 1.021591174436184e-06 0.9041001886668685 \
1.021591558609718e-06 0.9049189780371781 1.021591670731365e-06 0.9051556495331843 1.021592178052336e-06 0.9061253139956988 1.021592272051192e-06 0.90626859229291 \
1.021593430700898e-06 0.9055667778886739 1.021593533663832e-06 0.9051589876696525 1.021593617506701e-06 0.9047707260375384 1.021593751246752e-06 0.9040404158978201 \
1.021593851964133e-06 0.9033957423200318 1.021593959579919e-06 0.9026166239542108 1.021594077153173e-06 0.9016533104038295 1.021594165418223e-06 0.90085556431878 \
1.021594285051691e-06 0.8996698288011099 1.021594382373389e-06 0.8986166602050341 1.021594493390828e-06 0.8973222354192386 1.021594595500415e-06 0.8960407982554908 \
1.021594678931815e-06 0.8949326975987755 1.021594783112883e-06 0.8934749428758865 1.021594874199646e-06 0.8921321265381427 1.021594966740432e-06 0.8907058396397178 \
1.02159506189443e-06 0.8891776325191247 1.021595176449407e-06 0.88725933118288 1.021595265292509e-06 0.8857137884271823 1.021595363531691e-06 0.8839502506198179 \
1.021595448901865e-06 0.8823735982707064 1.021595529802107e-06 0.8808434949738935 1.0215956027634e-06 0.8794355441897157 1.021595669782045e-06 0.8781198554636557 \
1.021595738393124e-06 0.8767515715160701 1.021595821888036e-06 0.8750591081124355 1.021595884015366e-06 0.8737811510706814 1.021595946997964e-06 0.8724704924326797 \
1.021596042153715e-06 0.8704632161180945 1.021596142764354e-06 0.8683077530860182 1.021596222643544e-06 0.8665738309361769 1.021596306905814e-06 0.8647250601592834 \
1.021596386016074e-06 0.8629723295901451 1.021596448831519e-06 0.8615696597604833 1.021596536288554e-06 0.8596016864744445 1.021596602182084e-06 0.8581079708060287 \
1.021596670243626e-06 0.856556281928966 1.021596719556134e-06 0.8554267461646872 1.021596774792924e-06 0.85415654045335 1.021596815532529e-06 0.8532164928603474 \
1.021596861834283e-06 0.8521450198670055 1.021596892048343e-06 0.8514441160591502 1.021596921089625e-06 0.8507691938976955 1.02159695172822e-06 0.8500558939662993 \
1.02159701300541e-06 0.8486254874746039 1.021597066077972e-06 0.8473828229799116 1.021597119733165e-06 0.8461232012188223 1.021597182390447e-06 0.8446482873934593 \
1.021597245673395e-06 0.8431545995644786 1.021597336171269e-06 0.8410121009440262 1.02159743316905e-06 0.8387078554355326 1.02159751614655e-06 0.8367307351423475 \
1.021597598150905e-06 0.8347721678896715 1.021597687219307e-06 0.8326403548070889 1.021597771732643e-06 0.8306135893189693 1.021597862591523e-06 0.8284303722590877 \
1.021597954526378e-06 0.8262176456275642 1.021598056957308e-06 0.8237486178045141 1.02159815707534e-06 0.8213320995840899 1.021598271896223e-06 0.8185572053828121 \
1.02159838410276e-06 0.8158423448209959 1.021598509096305e-06 0.8128151787794674 1.021598640356713e-06 0.8096337870015397 1.021598785627755e-06 0.8061104108175116 \
1.021598940135368e-06 0.8023613213197434 1.021599111575989e-06 0.7981999722344618 1.021599275625781e-06 0.794217661721315 1.021599460041203e-06 0.7897413884478564 \
1.021599666533577e-06 0.7847307375046715 1.02159985602742e-06 0.7801344622909899 1.021600049421183e-06 0.775444374634302 1.021600249988038e-06 0.7705834242206392 \
1.021600397552439e-06 0.7670092004965298 1.02160052756389e-06 0.7638619034739171 1.021600662428303e-06 0.7605987503374771 1.021600768918754e-06 0.7580234999254772 \
1.021600900608547e-06 0.7548403390839162 1.021601007032976e-06 0.7522693550468039 1.021601150211605e-06 0.7488125398635642 1.021601311338716e-06 0.7449250928176189 \
1.021601429565533e-06 0.7420746008290786 1.021601599798354e-06 0.7379721584775248 1.021601765724623e-06 0.7339761998059781 1.021601985266954e-06 0.7286940862104242 \
1.021602178454078e-06 0.724050920820232 1.021602353368041e-06 0.719851304223293 1.021602520315139e-06 0.7158476177432674 1.0216027078061e-06 0.711355754450834 \
1.021602895234537e-06 0.7068709122373377 1.021603063571096e-06 0.7028473835914892 1.02160325640163e-06 0.6982428782038785 1.021603396451377e-06 0.694901318858167 \
1.021603552708666e-06 0.6911769338170629 1.021603746878113e-06 0.6865540563080536 1.021603905984601e-06 0.6827702245679255 1.021604064344632e-06 0.679008548037742 \
1.02160425966174e-06 0.6743756772263459 1.021604470090519e-06 0.6693917663527935 1.021604722792665e-06 0.6634173774538097 1.021604902460616e-06 0.6591769455535931 \
1.021605154037489e-06 0.6532475027332399 1.021605354410306e-06 0.6485340174553987 1.021605526064158e-06 0.6445032789616798 1.021605684756275e-06 0.6407814961122935 \
1.021605823964202e-06 0.637522316374186 1.021605960288252e-06 0.6343349641335875 1.021606087501276e-06 0.6313646237382058 1.021606216993833e-06 0.6283457899522861 \
1.021606344985121e-06 0.6253646753452949 1.02160647605963e-06 0.6223174651643489 1.021606606771705e-06 0.6192830747181834 1.021606749379758e-06 0.6159760732208495 \
1.021606892103236e-06 0.612672916206165 1.021607044651037e-06 0.6091471600588 1.021607189155024e-06 0.6058158037532523 1.021607353173272e-06 0.6020406322262999 \
1.021607490637933e-06 0.5988837056407329 1.021607625454949e-06 0.5957940466067043 1.021607746953592e-06 0.5930134750293682 1.021607885803897e-06 0.5898448108574432 \
1.021607999450713e-06 0.5872554148224447 1.021608150860885e-06 0.5838116422847746 1.02160826457956e-06 0.5812320812748947 1.021608383992651e-06 0.5785269636915771 \
1.021608472673178e-06 0.5765205397309219 1.021608563818269e-06 0.5744630259469776 1.021608629157145e-06 0.5729901393713442 1.021608693626847e-06 0.5715377831648228 \
1.021608744447459e-06 0.5703933076453638 1.021608803422398e-06 0.569066051987989 1.021608870867106e-06 0.5675516747474645 1.021608937959298e-06 0.5660472084764079 \
1.021608990879742e-06 0.5648615894615425 1.021609086527225e-06 0.5627204246953637 1.021609143708361e-06 0.5614413394337 1.021609197510977e-06 0.5602399192081799 \
1.021609259253083e-06 0.5588634520375642 1.021609345086214e-06 0.5569525037715509 1.021609427781862e-06 0.5551133137453282 1.021609553910589e-06 0.552313430559463 \
1.021609689009665e-06 0.5493247407981657 1.021609787329828e-06 0.5471534914294828 1.02160989990789e-06 0.5446716589975775 1.021610002452305e-06 0.5424173856211837 \
1.021610122561131e-06 0.5397821662853191 1.021610224248782e-06 0.5375541863492928 1.021610339752745e-06 0.5350300289250629 1.021610454643861e-06 0.5325260225312031 \
1.021610581121134e-06 0.5297740207092871 1.02161070633833e-06 0.5270565158317848 1.021610853184312e-06 0.5238798967507053 1.021610988642446e-06 0.5209557060405445 \
1.021611146203055e-06 0.5175672114705414 1.021611308357229e-06 0.5140875588169389 1.021611489068307e-06 0.5102248342695275 1.02161168131606e-06 0.5061308236654174 \
1.021611894038323e-06 0.5016182665703952 1.021612125943484e-06 0.4967183500883584 1.021612383137188e-06 0.4913135654247419 1.021612622690498e-06 0.4863004534671564 \
1.021612924620373e-06 0.4800178499336004 1.021613212386814e-06 0.4740665530855001 1.021613525189057e-06 0.4676409412178996 1.021613845020806e-06 0.4611139840073785 \
1.021614184657409e-06 0.4542292677834274 1.021614511873228e-06 0.4476411633207955 1.021614847034797e-06 0.4409363684817221 1.021615164291458e-06 0.4346351592989786 \
1.021615498111436e-06 0.4280489847791872 1.02161584979678e-06 0.4211625252737479 1.021616163864498e-06 0.4150547397555842 1.021616486893702e-06 0.4088175946446666 \
1.021616927873099e-06 0.4003732788922496 1.021617270275942e-06 0.3938810608698495 1.02161757072383e-06 0.3882325136127223 1.021617946053402e-06 0.3812375944419973 \
1.02161827612863e-06 0.3751439175705365 1.021618559406411e-06 0.3699597784791666 1.021618859913773e-06 0.3645020109013299 1.021619139561233e-06 0.3594637112692664 \
1.021619363423524e-06 0.3554634414471464 1.021619575274513e-06 0.35170280677964 1.021619777623113e-06 0.3481338771034005 1.021619978758139e-06 0.3446120049995081 \
1.021620184535656e-06 0.3410324794262659 1.021620445514371e-06 0.3365252478245505 1.021620685004553e-06 0.3324209773202946 1.021620917679624e-06 0.3284665339262754 \
1.021621131761216e-06 0.3248537323113044 1.021621352906983e-06 0.3211475567840967 1.021621553789873e-06 0.3178053707831449 1.021621757181075e-06 0.3144500223650613 \
1.021621954849488e-06 0.3112139453100684 1.021622141093175e-06 0.3081862077816076 1.021622336074257e-06 0.3050391973134606 1.021622539536502e-06 0.3017803754370622 \
1.021622717477408e-06 0.2989521325826759 1.021622953201112e-06 0.2952356640875101 1.021623151333966e-06 0.2921385263640672 1.021623352678033e-06 0.2890160050544278 \
1.02162357696723e-06 0.2855690750291008 1.021623741897129e-06 0.2830551950838826 1.021623919525814e-06 0.2803657404651576 1.021624103924961e-06 0.2775946687427531 \
1.021624287746306e-06 0.2748547260732712 1.021624466202979e-06 0.2722194282383935 1.021624638103246e-06 0.2696976713509589 1.021624798643653e-06 0.2673699088296289 \
1.021624920125712e-06 0.265617282026588 1.021625073047239e-06 0.2634201198254058 1.021625200480934e-06 0.2616085083773952 1.021625304654605e-06 0.2601317890528609 \
1.021625421559082e-06 0.2584775571399547 1.021625536570573e-06 0.2568557450124987 1.021625660932803e-06 0.2551103168403305 1.021625776507087e-06 0.2534925198640895 \
1.021625910614607e-06 0.2516172680784447 1.021626025601848e-06 0.2500177396912131 1.021626179351445e-06 0.2478798443778067 1.021626316154646e-06 0.2459790966208961 \
1.021626450740453e-06 0.2441094379339017 1.021626606604589e-06 0.2419575875351012 1.021626731253411e-06 0.2402378086535915 1.021626870468935e-06 0.2383186229544463 \
1.02162700069296e-06 0.236525770455347 1.021627121045801e-06 0.2348769158236033 1.021627256439084e-06 0.233027137746051 1.021627407644063e-06 0.2309620730808924 \
1.021627542400533e-06 0.2291249940296414 1.02162764708672e-06 0.2277003186426776 1.021627769622861e-06 0.2260366668203369 1.02162790456742e-06 0.2242086518061946 \
1.021627999683167e-06 0.2229209267876512 1.021628114943222e-06 0.2213657311907907 1.021628197476202e-06 0.2202562617028589 1.021628268681533e-06 0.2192992955643472 \
1.021628317389017e-06 0.2186449771734718 1.021628364583973e-06 0.2180112263680214 1.021628411132791e-06 0.2173864029843717 1.021628464521355e-06 0.2166701476649976 \
1.021628501898025e-06 0.2161690444847812 1.021628539283138e-06 0.2156680710113931 1.021628579604508e-06 0.2151283464800275 1.021628650854647e-06 0.2141753141901174 \
1.021628685068904e-06 0.2137180869447317 1.021628731463535e-06 0.2131018213873352 1.021628791907201e-06 0.2122998083652294 1.02162886091012e-06 0.2113853596849882 \
1.021628926205072e-06 0.210520730631805 1.021628994183195e-06 0.2096212333552783 1.021629110629525e-06 0.2080823984153433 1.021629200551714e-06 0.2068957989735914 \
1.02162930821762e-06 0.2054771097790837 1.021629404278935e-06 0.2042146625011118 1.021629507657509e-06 0.2028641889872041 1.021629604342544e-06 0.2016026287683381 \
1.021629707152397e-06 0.2002625524503448 1.021629807912368e-06 0.1989526210414513 1.021629919058035e-06 0.1975116692735505 1.021630026097529e-06 0.1961279675313261 \
1.021630144004064e-06 0.1946083430154048 1.021630252114387e-06 0.1932197128021231 1.021630361412988e-06 0.1918224631760269 1.021630482044739e-06 0.1902849927564414 \
1.021630576945331e-06 0.1890796997295432 1.02163070550625e-06 0.18745262875399 1.021630798541038e-06 0.1862801166370808 1.021630900937594e-06 0.1849947785893032 \
1.021630988904886e-06 0.1838942174288659 1.021631087175557e-06 0.182668828510528 1.021631183776179e-06 0.1814691026470878 1.021631270414692e-06 0.1803971466393716 \
1.021631356823705e-06 0.1793305247657973 1.021631452660814e-06 0.1781527189679156 1.021631557387688e-06 0.1768710765218302 1.021631703199975e-06 0.1750963017969037 \
1.021631819167907e-06 0.1736923427161618 1.021631975631711e-06 0.1718092975148396 1.02163208681163e-06 0.1704786474822015 1.021632227061631e-06 0.1688098560703619 \
1.021632350073035e-06 0.1673544160765056 1.021632456564033e-06 0.1661007559767333 1.021632552889492e-06 0.1649724583647661 1.021632650322959e-06 0.1638357962207703 \
1.021632754176237e-06 0.1626293386330815 1.02163284597681e-06 0.1615673458739011 1.021632944364525e-06 0.1604337426303964 1.02163302728317e-06 0.1594828374885931 \
1.021633122651503e-06 0.1583950132920943 1.021633205213852e-06 0.1574587876231885 1.021633307798537e-06 0.1563016192679324 1.021633384076854e-06 0.1554454316211293 \
1.021633472662479e-06 0.1544557264474612 1.021633544831984e-06 0.1536532700165102 1.021633626541473e-06 0.1527486200895024 1.021633700220281e-06 0.1519363404455653 \
1.02163378044041e-06 0.1510573496788611 1.021633852168484e-06 0.1502755532525617 1.021633920425463e-06 0.149534520573691 1.021634018141422e-06 0.1484788062294206 \
1.021634087591606e-06 0.147731872792437 1.021634170343085e-06 0.1468455801890639 1.021634230379995e-06 0.1462052652532956 1.021634300618658e-06 0.1454587420502366 \
1.021634372046193e-06 0.1447037411390827 1.021634452559695e-06 0.1438588888651768 1.021634515822599e-06 0.1431977449412327 1.021634593496578e-06 0.1423892845091393 \
1.021634682806343e-06 0.141463758692191 1.021634752169929e-06 0.1407479403162204 1.021634850118149e-06 0.1397418416088305 1.021634940462669e-06 0.1388188591118084 \
1.021635026242994e-06 0.1379520826379384 1.021635093896779e-06 0.1372719511642241 1.021635160204629e-06 0.1366075914250998 1.021635238824321e-06 0.1358227655030745 \
1.02163531951923e-06 0.135020537018139 1.021635377921894e-06 0.1344419857224206 1.021635438674417e-06 0.1338420332148588 1.021635532580729e-06 0.1329184183639811 \
1.021635574978232e-06 0.1325029080242558 1.021635654222426e-06 0.1317336600863391 1.021635694592584e-06 0.1313430593815061 1.021635784293463e-06 0.130477658168832 \
1.02163582324155e-06 0.1301029732927899 1.021635918857236e-06 0.1291862249441596 1.021635957741065e-06 0.1288146335111444 1.021636050975841e-06 0.1279263274670414 \
1.02163611931843e-06 0.1272775968534341 1.021636171639285e-06 0.1267823325594629 1.021636253739999e-06 0.1260075984242486 1.021636324903378e-06 0.1253406747583812 \
1.021636402856366e-06 0.1246136378429537 1.021636481976102e-06 0.1238779526756392 1.021636560619333e-06 0.1231489004754178 1.021636640654241e-06 0.122409328367501 \
1.021636702388658e-06 0.1218405706457005 1.02163677598364e-06 0.1211645344030958 1.021636859363458e-06 0.120401093559758 1.021636923460189e-06 0.1198161795466899 \
1.021636992898777e-06 0.119184869057559 1.021637065921716e-06 0.1185234239195788 1.021637150796627e-06 0.1177582144838446 1.021637230159478e-06 0.117046673033812 \
1.021637314893136e-06 0.1162898833629492 1.021637405604425e-06 0.1154830714735263 1.021637481187504e-06 0.1148135241260771 1.021637546915428e-06 0.1142333070693714 \
1.021637606975201e-06 0.1137047561823949 1.021637676580917e-06 0.1130943456353956 1.021637742999969e-06 0.1125141752866663 1.021637822411232e-06 0.1118230150855203 \
1.021637912674161e-06 0.1110406875128299 1.021637981718461e-06 0.1104447270551955 1.02163805627358e-06 0.1098035355921305 1.021638144757501e-06 0.1090456469739195 \
1.021638223865648e-06 0.1083709350695736 1.021638293734029e-06 0.1077773127978274 1.021638374743399e-06 0.1070920034756896 1.021638430948213e-06 0.106618206733547 \
1.021638493607492e-06 0.1060916009495399 1.021638558754098e-06 0.105545887371837 1.021638630089726e-06 0.1049504956797945 1.021638750386101e-06 0.1039516085561449 \
1.021638801939674e-06 0.103525508500865 1.021638857088742e-06 0.1030709598036589 1.021638947785926e-06 0.1023262935955709 1.021639030175778e-06 0.1016530765296615 \
1.021639125755586e-06 0.1008759670630478 1.021639232965152e-06 0.1000092507657299 1.021639336624559e-06 0.09917656019160864 1.021639422832161e-06 0.09848810438956324 \
1.021639509074386e-06 0.09780303991321163 1.02163958861546e-06 0.09717448010577609 1.021639668628333e-06 0.09654538840876434 1.021639759916661e-06 0.09583163072761708 \
1.02163984166208e-06 0.09519620281310773 1.021639930588917e-06 0.09450872319168514 1.021640020366224e-06 0.09381864801001834 1.021640097328872e-06 0.09323024625953365 \
1.021640187653689e-06 0.0925435244861572 1.021640251462415e-06 0.09206084550525626 1.021640323925983e-06 0.09151514907748673 1.021640388054635e-06 0.09103438864950099 \
1.021640466302011e-06 0.09045054736970405 1.021640566003292e-06 0.08971110930136832 1.021640640056444e-06 0.08916512281998501 1.021640726664979e-06 0.08852997392441805 \
1.021640872964685e-06 0.08746544055362569 1.021640983676948e-06 0.08666684197409438 1.021641093986626e-06 0.08587717033461532 1.021641236182269e-06 0.08486839672072237 \
1.02164137623472e-06 0.08388450488753585 1.021641518880534e-06 0.08289222299161547 1.021641667651249e-06 0.08186778387581196 1.021641804363935e-06 0.08093569403044946 \
1.021641946484565e-06 0.07997640434545976 1.021642081061545e-06 0.07907728405019222 1.021642221281423e-06 0.07814997945867638 1.021642369028229e-06 0.07718353387841098 \
1.021642518982415e-06 0.07621348085094087 1.021642683698247e-06 0.07516037195605636 1.021642847284363e-06 0.07412732798506308 1.021643021932716e-06 0.07303837372665309 \
1.021643208986408e-06 0.07188781219077654 1.021643418972926e-06 0.0706159374129187 1.021643637046174e-06 0.06931715807027321 1.021643870366328e-06 0.06795188046253516 \
1.021644124845882e-06 0.0664909822812602 1.02164441780254e-06 0.06484528303377844 1.021644719953089e-06 0.06318745987130532 1.021645057674792e-06 0.06138078634948794 \
1.021645452783393e-06 0.05932807220464856 1.021645820234636e-06 0.05747953410674719 1.021646237842402e-06 0.05544691527644593 1.021646582838376e-06 0.0538196438399016 \
1.021646933380665e-06 0.05221302159193914 1.021647248341029e-06 0.0508087490907442 1.021647547582396e-06 0.049508488261462 1.021647846948248e-06 0.04824029756235761 \
1.021648122190958e-06 0.04710512226277328 1.021648405654525e-06 0.04596497870754415 1.021648667254946e-06 0.04493681260994405 1.021648944707071e-06 0.04387103439794762 \
1.021649220766506e-06 0.04283531238677037 1.021649529036243e-06 0.04170718945545093 1.021649751468863e-06 0.0409114719535993 1.021650039009947e-06 0.03990505631995635 \
1.02165027524288e-06 0.0390969788355163 1.021650593704555e-06 0.03803800466874574 1.021650844115589e-06 0.03722710566490722 1.021651167100391e-06 0.03620720400565681 \
1.021651425436406e-06 0.03541203096995557 1.021651715410285e-06 0.03454066075983582 1.021651945205102e-06 0.0338658635512188 1.021652230100444e-06 0.03304787219836024 \
1.021652469846563e-06 0.03237513696606491 1.021652710481132e-06 0.03171392889024889 1.021652949599619e-06 0.03107212555077287 1.02165318553853e-06 0.03045460689686571 \
1.021653416367391e-06 0.02986254663395104 1.021653631393919e-06 0.02932175456294728 1.02165403355976e-06 0.0283374222946415 1.02165423211788e-06 0.02786401170979088 \
1.021654605819066e-06 0.02699470773596776 1.021654792632261e-06 0.02657042318767052 1.021655138633508e-06 0.02580176906824739 1.021655260576947e-06 0.02553595448027303 \
1.021655643429963e-06 0.02472011952872977 1.021655803864149e-06 0.02438657631284594 1.021656246865303e-06 0.02348572425118655 1.021656417479344e-06 0.02314627247835563 \
1.02165673805594e-06 0.02251902970747987 1.021656938340868e-06 0.0221336684630111 1.021657385278801e-06 0.02128811173678137 1.021657513222916e-06 0.02104854104185888 \
1.021658001100276e-06 0.02014826272243131 1.021658136077553e-06 0.01990454278080647 1.021658618329071e-06 0.0190640092473091 1.021658780655186e-06 0.01879235028057063 \
1.021659267049527e-06 0.01801148170254873 1.021659430077186e-06 0.01776103207540622 1.021660110298877e-06 0.01676849304257711 1.021660249382615e-06 0.01657541006259178 \
1.021660981877148e-06 0.01560782569993242 1.02166114077078e-06 0.01540693214221847 1.021661923851867e-06 0.01445869962397344 1.021662069644422e-06 0.01428952172302696 \
1.021662920425781e-06 0.01334248985256295 1.021663031529053e-06 0.01322388191882306 1.021663964823417e-06 0.0122699293983148 1.021664098661466e-06 0.01213902814618388 \
1.021665057199482e-06 0.01123495036716388 1.021665178316551e-06 0.01112486091825863 1.021666300400348e-06 0.01017270671243764 1.021666405901602e-06 0.01008921053061839 \
1.021667734976014e-06 0.009112307258623473 1.021667855180288e-06 0.009029744095492466 1.021669403542048e-06 0.008036808760534916 1.021669484329818e-06 0.007986285493236449 \
1.021671055209352e-06 0.007024564730313319 1.021671122625551e-06 0.006986095570813155 1.021673043392229e-06 0.006001386377072119 1.021673230194113e-06 0.005914747648762168 \
1.021675545608061e-06 0.0049318160947762 1.021675945134908e-06 0.004777795182599986 1.021678508944408e-06 0.003889929704329555 1.021679007815328e-06 0.003736330440833864 \
1.021682637539317e-06 0.002784984367379526 1.021683188233292e-06 0.002663729254427667 1.021688586673671e-06 0.001711392372544448 1.021688899941243e-06 0.001662511220227468 \
1.021693892233791e-06 0.0006970413096974805 1.021694076252826e-06 0.0006571176749162138 1.024342555395609e-06 -0.0002691198397987355 1.024342711454572e-06 -0.0004551674219448388 \
1.024343259438427e-06 -0.001322174727784445 1.02434337237642e-06 -0.001539785040943742 1.02434380163135e-06 -0.002474302920374066 1.024343907888515e-06 -0.002730173903076456 \
1.024344190690667e-06 -0.003454402452283872 1.02434430428521e-06 -0.003760966378165151 1.024344642839789e-06 -0.004705104513819927 1.02434475526375e-06 -0.005021586953003071 \
1.024345083541651e-06 -0.005887841248467669 1.024345191080172e-06 -0.006130875888161453 1.024346071006203e-06 -0.005789627805322099 1.02434624621225e-06 -0.004910736584223327 \
1.024346363043013e-06 -0.004127745010746014 1.024346489910138e-06 -0.00309221842859156 1.024346591442863e-06 -0.002125750314016509 1.024346712864133e-06 -0.0008095618968406578 \
1.024346803029046e-06 0.0002767910803854594 1.024346900212696e-06 0.001550247908954045 1.02434699828696e-06 0.002938803805678211 1.024347165508045e-06 0.005530627736217106 \
1.024347387813323e-06 0.009378371294171852 1.024347573551714e-06 0.01290572951649239 1.024347797633049e-06 0.01747895571448658 1.024347957277782e-06 0.02091945933227325 \
1.024348121767111e-06 0.02459614091902196 1.024348271591569e-06 0.0280452875125503 1.024348420991461e-06 0.03156498790849799 1.024348570522767e-06 0.03515592969144176 \
1.024348724602661e-06 0.03891669635189081 1.024348886786809e-06 0.0429309674228065 1.024349053210035e-06 0.0470989728378523 1.024349229143508e-06 0.05154884981278444 \
1.024349410271779e-06 0.05616867911875007 1.024349602402705e-06 0.06110225049351239 1.024349810098117e-06 0.0664648391313285 1.024350032018198e-06 0.07222051812179281 \
1.02435026721968e-06 0.07834079218654426 1.024350519405989e-06 0.08491829088081257 1.024350795545224e-06 0.09213111703448683 1.024351096666701e-06 0.1000001933597138 \
1.024351428586562e-06 0.1086702418150647 1.02435180590533e-06 0.1185147411083515 1.024352204195387e-06 0.1288888856248832 1.024352673503706e-06 0.1410822143415975 \
1.024353219529231e-06 0.1552200475789812 1.024353854489538e-06 0.1715918832733369 1.024354553890129e-06 0.1895291194622146 1.024355372129055e-06 0.2103807608661494 \
1.024356277823022e-06 0.2332840710921665 1.024357067334088e-06 0.253091928008631 1.024357771092906e-06 0.2706124241987875 1.024358388943719e-06 0.2858796548825839 \
1.024358954567131e-06 0.2997575097153312 1.024359476302405e-06 0.3124620269501652 1.024359974086121e-06 0.3244932238414255 1.024360457724081e-06 0.3360954048923613 \
1.024360914598215e-06 0.3469667650518959 1.024361387439109e-06 0.3581213589834248 1.024361827052466e-06 0.3684065070151987 1.024362314929562e-06 0.379719432411247 \
1.024362845729985e-06 0.3919028193132517 1.024363343625359e-06 0.4032143644097119 1.024363775002613e-06 0.41292177789323 1.024364261889801e-06 0.4237731225600331 \
1.024364761989243e-06 0.4348012155672935 1.024365106609934e-06 0.4423321287141763 1.024365460003778e-06 0.4500000647748709 1.024365887773617e-06 0.4592134948422093 \
1.024366279634688e-06 0.4675816212925634 1.024366579929044e-06 0.4739471552041949 1.024366921860125e-06 0.4811428413521782 1.02436726519457e-06 0.4883132334011818 \
1.024367525955058e-06 0.4937215836208605 1.024367768011587e-06 0.4987106167174703 1.024368034010056e-06 0.5041617362307154 1.02436829349824e-06 0.5094435946950286 \
1.02436848341454e-06 0.5132872703533161 1.024368698649141e-06 0.5176241792560061 1.0243688371999e-06 0.5204025546691405 1.024368982080679e-06 0.5232962183003332 \
1.024369195494746e-06 0.5275364624051522 1.024369397519361e-06 0.5315382148201082 1.024369590248024e-06 0.5353370730264509 1.024369775503404e-06 0.5389735557287745 \
1.024369952500928e-06 0.5424323215059959 1.024370261764263e-06 0.5484573594957171 1.02437052291231e-06 0.5535233414883098 1.024370824731481e-06 0.5593562770234363 \
1.024371080160122e-06 0.5642781701956761 1.024371372515619e-06 0.5698968483756405 1.024371631969813e-06 0.5748654731717864 1.02437190208979e-06 0.5800301911327002 \
1.024372144100348e-06 0.5846380733684551 1.024372401610146e-06 0.5895273573494454 1.024372628054483e-06 0.5938057549890672 1.024372864942966e-06 0.5982619499065401 \
1.024373074987873e-06 0.6021962733001386 1.024373287918585e-06 0.6061670177072124 1.024373541397282e-06 0.6108668889270118 1.024373744692931e-06 0.6146150465592417 \
1.024373936381114e-06 0.6181346807088086 1.024374125007479e-06 0.6215812235468744 1.024374312325417e-06 0.6249823889551316 1.024374517937406e-06 0.6286953279350977 \
1.024374767760625e-06 0.6331759959753138 1.024374971572404e-06 0.6368063379741715 1.024375179211121e-06 0.6404826298163093 1.024375371862737e-06 0.6438748386876914 \
1.02437561647481e-06 0.6481531432733096 1.024375864373314e-06 0.6524620620600715 1.024376044208219e-06 0.6555644139995785 1.024376234982255e-06 0.6588391718544121 \
1.024376388158437e-06 0.6614554104590837 1.024376559827147e-06 0.6643705886591137 1.024376710293968e-06 0.6669108747194671 1.024376846897971e-06 0.6692010654183506 \
1.024376996338373e-06 0.6716954191563786 1.024377124072524e-06 0.6738189269502312 1.02437726394477e-06 0.6761323074508511 1.024377388021905e-06 0.6781756764962316 \
1.02437751938327e-06 0.6803315871556701 1.024377643554731e-06 0.6823627547057004 1.024377781331592e-06 0.6846081866267727 1.024377901575812e-06 0.6865586181592046 \
1.024378043628418e-06 0.6888545186016138 1.024378143856122e-06 0.6904668682779994 1.024378265160113e-06 0.6924123325129877 1.024378356135388e-06 0.6938641504265992 \
1.024378453518671e-06 0.695411869780077 1.024378550601538e-06 0.6969507228893711 1.024378639884158e-06 0.6983595753378042 1.024378737855943e-06 0.699898781449533 \
1.02437886813103e-06 0.7019319515314388 1.024379021543255e-06 0.7043083163565919 1.024379157109067e-06 0.7063909659299702 1.024379301449562e-06 0.708591461371511 \
1.024379427320445e-06 0.710496752775434 1.024379552347831e-06 0.712376488910674 1.024379666630191e-06 0.7140841686551523 1.024379777613336e-06 0.7157331888171029 \
1.024379877308405e-06 0.7172065512867005 1.024380014352623e-06 0.7192196995505324 1.024380133379835e-06 0.7209572005600779 1.024380253677943e-06 0.7227029412191364 \
1.024380380176863e-06 0.7245276185835638 1.024380504108467e-06 0.7263044524160376 1.0243806283948e-06 0.7280754330070212 1.024380754759953e-06 0.7298652243312684 \
1.024380884571695e-06 0.7316925631262517 1.024381008410214e-06 0.7334254795816325 1.024381141191101e-06 0.735272086289578 1.024381242042306e-06 0.7366670415914529 \
1.024381355233975e-06 0.738224777043618 1.024381442019956e-06 0.7394137384482823 1.024381558645253e-06 0.7410021813026957 1.02438164793451e-06 0.7422110784210975 \
1.024381759111394e-06 0.7437075443329063 1.024381888370158e-06 0.7454347509364776 1.024382002229194e-06 0.7469455276109591 1.024382106633406e-06 0.74832188588007 \
1.024382231000437e-06 0.7499498655229884 1.024382378240616e-06 0.7518616907275563 1.024382498520907e-06 0.753411006437983 1.024382614425446e-06 0.7548933175676444 \
1.02438275450129e-06 0.7566706674475765 1.02438289711296e-06 0.7584645678799224 1.024383015067203e-06 0.7599365027959469 1.024383141883712e-06 0.7615071445339606 \
1.024383282766856e-06 0.7632375905494565 1.024383402560354e-06 0.7646969139886852 1.024383547519211e-06 0.7664484133613445 1.024383669077996e-06 0.7679052725436226 \
1.02438378811749e-06 0.7693214142140735 1.024383909748853e-06 0.7707575700077021 1.024384037717832e-06 0.772256936813787 1.024384146933014e-06 0.7735272422640712 \
1.024384271823892e-06 0.774969549136603 1.024384378939953e-06 0.7761978171588899 1.024384512193147e-06 0.7777146071439789 1.024384639296593e-06 0.7791497354387434 \
1.024384761047568e-06 0.7805132846941326 1.024384877632151e-06 0.7818078758210534 1.024384983459753e-06 0.7829735233300771 1.024385122825895e-06 0.7844949153190801 \
1.024385271897694e-06 0.786105286864636 1.024385419626362e-06 0.7876841235632186 1.02438553893224e-06 0.7889471147195867 1.024385672939052e-06 0.7903527806482344 \
1.024385793365227e-06 0.791604423795974 1.024385934910404e-06 0.7930616786923709 1.024386082336417e-06 0.7945638089648995 1.024386206810925e-06 0.7958198087139573 \
1.024386325854918e-06 0.7970105506108808 1.024386437445202e-06 0.7981174590942314 1.02438654267449e-06 0.7991530841216606 1.024386638185594e-06 0.8000862307887144 \
1.024386774247547e-06 0.8014036057482816 1.024386891123682e-06 0.8025237700417888 1.024387010277354e-06 0.8036549841722296 1.024387132589548e-06 0.8048050501807249 \
1.024387255861622e-06 0.8059526272620129 1.024387382358398e-06 0.8071184350969989 1.024387507861062e-06 0.8082633544790385 1.024387638586967e-06 0.8094437311890262 \
1.024387764154939e-06 0.8105658358439867 1.024387893209804e-06 0.8117072367686948 1.024387999065961e-06 0.8126345588578442 1.024388100234837e-06 0.8135133322873783 \
1.024388194854656e-06 0.8143286754242188 1.02438831913574e-06 0.8153900871385379 1.024388408847426e-06 0.816149614585347 1.02438850788495e-06 0.8169816577628611 \
1.024388645662827e-06 0.8181280288377792 1.024388780198677e-06 0.81923501721715 1.024388888604944e-06 0.8201180631035904 1.024389038518447e-06 0.8213254631869725 \
1.024389189097025e-06 0.8225223201378843 1.02438931459218e-06 0.8235077122548546 1.024389458438707e-06 0.8246238332260477 1.024389583021971e-06 0.8255790649890803 \
1.024389731875191e-06 0.8267066458678887 1.024389868023775e-06 0.827725029289517 1.024389993047602e-06 0.8286494160599757 1.024390110754582e-06 0.8295103773055483 \
1.024390256393581e-06 0.8305630309532103 1.024390422774875e-06 0.8317484146982921 1.024390553358565e-06 0.8326660250626342 1.024390726880675e-06 0.8338683097812621 \
1.024390895002578e-06 0.8350147136930499 1.02439106486518e-06 0.8361549927788252 1.024391245766883e-06 0.8373497079260466 1.024391388876165e-06 0.8382806519784776 \
1.024391502965127e-06 0.839013953006387 1.024391633127604e-06 0.8398410866028793 1.024391734972734e-06 0.8404811280669765 1.02439185179894e-06 0.8412075886390841 \
1.02439198869038e-06 0.8420483852080155 1.024392186497604e-06 0.843243620449199 1.024392378122751e-06 0.8443797466267589 1.024392587554618e-06 0.8455974227529048 \
1.0243927695013e-06 0.8466352798309468 1.024392966630154e-06 0.8477391449715804 1.024393139971014e-06 0.8486924050423899 1.024393322979321e-06 0.8496814535024207 \
1.024393494142356e-06 0.8505903669473519 1.024393668779451e-06 0.851501688465695 1.024393844039281e-06 0.8524001683007644 1.02439402018973e-06 0.8532872510191711 \
1.024394210470029e-06 0.8542278331088334 1.02439440106916e-06 0.8551519386507073 1.024394601692395e-06 0.8561055033533737 1.02439479430095e-06 0.8570028516027762 \
1.024395004981641e-06 0.8579644845832216 1.024395233083109e-06 0.8589827023971403 1.024395498871092e-06 0.860139640227508 1.024395797483852e-06 0.8614018215255795 \
1.024396073772491e-06 0.8625348754565382 1.02439635800901e-06 0.8636666213345715 1.02439663221378e-06 0.8647267940813509 1.024396904448638e-06 0.8657495569722869 \
1.02439717465278e-06 0.8667361702337206 1.02439743180839e-06 0.867649441901348 1.024397704388604e-06 0.8685908808535525 1.02439798037489e-06 0.8695169452638583 \
1.024398250477721e-06 0.870397355937691 1.024398550334798e-06 0.8713451925332844 1.024398921362456e-06 0.8724761722512941 1.024399216299767e-06 0.8733433185969293 \
1.024399470589207e-06 0.8740690226522811 1.024399768845991e-06 0.874895168896023 1.024400042455427e-06 0.8756299040683481 1.024400278583914e-06 0.8762466977562872 \
1.024400518929827e-06 0.8768585021646264 1.024400741263492e-06 0.8774104263690854 1.024400935269169e-06 0.8778812671168952 1.024401264991886e-06 0.8786590883967833 \
1.024401420165319e-06 0.8790156160651978 1.024401737941389e-06 0.8797272612331356 1.024401916803032e-06 0.8801171459162566 1.024402259264861e-06 0.8808425821290963 \
1.024402443393021e-06 0.881221400612852 1.024402918270754e-06 0.8821634994206867 1.024403085666965e-06 0.8824839765989225 1.024403551508906e-06 0.8833452998114757 \
1.024403732330958e-06 0.8836679564577563 1.024404226369383e-06 0.8845176198113115 1.024404367718007e-06 0.8847523712107549 1.024404974052073e-06 0.8857188576377059 \
1.024405126121396e-06 0.8859512996759633 1.024405772809558e-06 0.8868983431897121 1.02440590110417e-06 0.8870786909355212 1.024406549221232e-06 0.8879538337624689 \
1.024406679020295e-06 0.8881220828502663 1.024407457223772e-06 0.8890807033877333 1.024407572278734e-06 0.8892148977954012 1.024408427940206e-06 0.8901543051721961 \
1.024408573301076e-06 0.8903040038307473 1.024409559057127e-06 0.8912446482480114 1.024409780162496e-06 0.8914382978987679 1.024410925289423e-06 0.8923659558950503 \
1.024411056506439e-06 0.8924678262926897 1.024412397715013e-06 0.8934599079028542 1.024412549114272e-06 0.8935646301988298 1.024414030551995e-06 0.8944937559627255 \
1.024414269431373e-06 0.8946275407274444 1.024416038746979e-06 0.8955013787854181 1.024416427898191e-06 0.8956696032899972 1.024418821561142e-06 0.8965547188539188 \
1.02441929727014e-06 0.8967039926079825 1.02442336043021e-06 0.8977020505850396 1.024423851854269e-06 0.8977948037134476 1.024432168453822e-06 0.898787348739254 \
1.02443308835295e-06 0.8988506593152591 1.02457657358348e-06 0.8998476076348748 1.024577692016456e-06 0.8998537475785264 1.024782783635956e-06 0.898985773748599 \
1.024783010725457e-06 0.8988224379910277 1.024784620332255e-06 0.8978282360369357 1.024784797740799e-06 0.8977338482811539 1.0248017048891e-06 0.8987315468430059 \
1.024801814328198e-06 0.8987460089186867 1.024817595049444e-06 0.8997418097871094 1.024817891375339e-06 0.8997476966799167 1.025301325027745e-06 0.9007060148833608 \
1.025301454078085e-06 0.9008313386292994 1.025302104227931e-06 0.9016292186224167 1.025302293723661e-06 0.9019133038041363 1.02530279694564e-06 0.9027675859898705 \
1.0253029324183e-06 0.9030208676018907 1.025303332877016e-06 0.9038195223753869 1.025303464814953e-06 0.9040958310886574 1.025303866030017e-06 0.9049509627747726 \
1.025303964290194e-06 0.9051582028152527 1.025304430164004e-06 0.9060587574877488 1.025304591662727e-06 0.9063060456044927 1.025305735675251e-06 0.9055153668657776 \
1.025305880654596e-06 0.9049059606760256 1.025306059207353e-06 0.9039396653125833 1.025306239402631e-06 0.9027054491383806 1.025306382093561e-06 0.9015369228101149 \
1.025306499253165e-06 0.9004524619440171 1.025306588234526e-06 0.8995505656965809 1.025306679878178e-06 0.8985529714258781 1.02530681299011e-06 0.8969831049011855 \
1.025306906711193e-06 0.8957895978311226 1.025306997850002e-06 0.8945634483845346 1.025307111142313e-06 0.8929516940777753 1.025307214251226e-06 0.8913998138690341 \
1.025307310518406e-06 0.8898830246517148 1.025307429655523e-06 0.8879200664089764 1.025307598240772e-06 0.8849885378698126 1.025307760012273e-06 0.8820195265790133 \
1.025307953231332e-06 0.8782956415026882 1.025308138794443e-06 0.8745571577041361 1.025308349060748e-06 0.8701566079887386 1.025308531309789e-06 0.8662213066841463 \
1.025308716173183e-06 0.8621339172744639 1.02530888885833e-06 0.8582419637438897 1.025309074966403e-06 0.8539816046497358 1.025309252782491e-06 0.849858603441091 \
1.025309433499072e-06 0.8456251963850057 1.025309598637331e-06 0.8417258760277182 1.025309763911433e-06 0.837798995916667 1.025309927159096e-06 0.8339004324287677 \
1.02531008574937e-06 0.8300982805770993 1.025310262673771e-06 0.8258418712800655 1.025310459187584e-06 0.8211009660847696 1.025310626744125e-06 0.8170498602679914 \
1.025310793484544e-06 0.8130123908857781 1.025310967908061e-06 0.8087844286215062 1.025311137277684e-06 0.8046757316210446 1.025311305476779e-06 0.8005936994537799 \
1.025311494325046e-06 0.7960093488074458 1.025311685140882e-06 0.7913773844868103 1.025311893523092e-06 0.7863203192056716 1.025312119942597e-06 0.7808277108969495 \
1.025312309142794e-06 0.7762391340290878 1.025312519289483e-06 0.7711455503222944 1.025312668057987e-06 0.7675418410361046 1.025312799050976e-06 0.7643705172588006 \
1.025312936616212e-06 0.7610417440783073 1.025313042367441e-06 0.7584842184275663 1.025313177141075e-06 0.7552262509102785 1.0253132889738e-06 0.7525244432456109 \
1.025313418408964e-06 0.7493992292091655 1.025313573597688e-06 0.7456545577979357 1.025313685233441e-06 0.7429626190147979 1.025313844808055e-06 0.7391166470929011 \
1.025314020129688e-06 0.7348935218456193 1.025314232505151e-06 0.7297828120356423 1.025314425387679e-06 0.7251458607116523 1.025314582088971e-06 0.7213823872711312 \
1.025314768763662e-06 0.716903961299824 1.025314957650011e-06 0.7123775767926828 1.025315148534203e-06 0.70780884692282 1.025315335282138e-06 0.7033444557767304 \
1.025315518366954e-06 0.698972331957095 1.025315655685935e-06 0.6956951921588121 1.025315808928892e-06 0.6920418367118417 1.025316004057543e-06 0.6873949992893974 \
1.025316161351872e-06 0.6836535194673684 1.025316320746467e-06 0.6798660670227984 1.02531651649026e-06 0.6752219404489795 1.025316708689394e-06 0.6706682621108646 \
1.025316943641022e-06 0.6651105611269369 1.02531713111727e-06 0.6606839627962382 1.025317368354404e-06 0.6550894036851447 1.025317557534366e-06 0.6506361170423679 \
1.025317738150178e-06 0.6463915264929231 1.025317901844741e-06 0.6425504277539856 1.02531804639615e-06 0.6391628119244788 1.02531818686792e-06 0.6358764726647652 \
1.025318313968708e-06 0.6329064225879303 1.025318446276184e-06 0.6298198307262635 1.02531857286323e-06 0.626870110582017 1.025318703443497e-06 0.62383130535404 \
1.025318832712897e-06 0.6208285625908692 1.025318971819793e-06 0.6176004736356133 1.025319120330103e-06 0.6141606483517721 1.025319309878658e-06 0.6097777958748198 \
1.025319455581915e-06 0.6064170107178907 1.025319690632478e-06 0.601007464699683 1.025319873631749e-06 0.5968099615921 1.025320097973423e-06 0.5916778694808832 \
1.025320269146672e-06 0.5877753019413697 1.025320401480491e-06 0.5847634284691802 1.02532053327703e-06 0.5817721407249107 1.025320639820933e-06 0.5793579518205488 \
1.025320735711292e-06 0.5771868999037388 1.025320828211542e-06 0.5750974572268882 1.025320920638905e-06 0.5730134868920421 1.025320993067212e-06 0.5713818265150021 \
1.025321048796317e-06 0.5701269325864891 1.025321109905405e-06 0.5687522410723198 1.02532120667008e-06 0.5665806864277688 1.025321268161595e-06 0.5652027770813386 \
1.025321327214216e-06 0.5638802801505602 1.025321402840882e-06 0.5621878686488651 1.02532146986366e-06 0.5606896577364279 1.02532154346077e-06 0.5590483558003441 \
1.025321611066772e-06 0.5575429304381756 1.025321727135829e-06 0.5549610936632026 1.025321827342234e-06 0.5527359403974305 1.025321939349424e-06 0.5502565947066531 \
1.025322033841475e-06 0.5481686943853854 1.025322154996173e-06 0.5454955387196141 1.025322255183939e-06 0.5432910220514219 1.025322371174451e-06 0.5407443765731218 \
1.025322478878288e-06 0.5383833065966291 1.025322588456977e-06 0.5359861028148916 1.025322700578421e-06 0.5335400310751951 1.025322827515605e-06 0.5307765704644959 \
1.025322949665123e-06 0.5281221248815906 1.025323089426038e-06 0.525095489155881 1.025323226564154e-06 0.522132778766487 1.025323376529244e-06 0.5189020692106626 \
1.025323535302247e-06 0.5154923220538846 1.025323709327904e-06 0.511765695450105 1.025323896158028e-06 0.5077823379664483 1.025324101125994e-06 0.5034264211640872 \
1.025324323834942e-06 0.4987133299464507 1.025324576739139e-06 0.4933874474923696 1.025324811693046e-06 0.4884604410272814 1.025325107961308e-06 0.4822828691822955 \
1.025325397751266e-06 0.4762763831984252 1.025325704087085e-06 0.4699660956099861 1.025326016405612e-06 0.4635767846525711 1.025326354971068e-06 0.4566963260653934 \
1.025326678082485e-06 0.4501741115777416 1.025327016477788e-06 0.4433881855507311 1.025327340309053e-06 0.4369378830387565 1.025327664703474e-06 0.4305204627449936 \
1.02532800763776e-06 0.4237851826852676 1.025328346918578e-06 0.4171698123421442 1.025328686393212e-06 0.4105997181257849 1.025329129505058e-06 0.4020958655332711 \
1.025329491573227e-06 0.3952155038183801 1.025329812124964e-06 0.3891775711374149 1.025330199059534e-06 0.3819561902961204 1.025330526929795e-06 0.3758957719299574 \
1.025330812088852e-06 0.3706704968427373 1.025331130457646e-06 0.3648820026298218 1.025331413288573e-06 0.3597820188690578 1.025331641977337e-06 0.3556924369094372 \
1.025331859870141e-06 0.3518226517641353 1.025332055119486e-06 0.3483769517668343 1.025332262027586e-06 0.344751588202948 1.025332476824342e-06 0.3410137651016431 \
1.025332729050892e-06 0.3366564674340092 1.025332971046205e-06 0.3325077909124976 1.025333201898484e-06 0.3285822460490526 1.025333416746675e-06 0.3249550452085373 \
1.025333637103364e-06 0.3212604562488142 1.025333838674264e-06 0.3179050685021769 1.025334041758211e-06 0.3145531374773136 1.025334239655597e-06 0.3113121771742085 \
1.025334426754836e-06 0.3082694484595072 1.02533462065518e-06 0.3051385396431291 1.025334825703514e-06 0.3018527636900292 1.025335005938266e-06 0.2989872106339772 \
1.025335241836278e-06 0.2952669081535775 1.025335443123827e-06 0.2921198200609627 1.025335644514631e-06 0.2889965001417216 1.025335869163794e-06 0.2855437159941698 \
1.025336034543768e-06 0.2830223598911593 1.025336212348106e-06 0.280330186126118 1.025336396004319e-06 0.277570343839212 1.025336581246076e-06 0.2748090658167894 \
1.025336759391454e-06 0.2721781298892599 1.025336932983517e-06 0.2696316866093095 1.02533709334837e-06 0.267306655456324 1.025337214459552e-06 0.2655585721882695 \
1.02533736765434e-06 0.2633570345323199 1.025337494985789e-06 0.2615475749425888 1.025337598313628e-06 0.2600830587034867 1.025337715638424e-06 0.2584225376281647 \
1.025337833445381e-06 0.2567591557214636 1.025337957409147e-06 0.2550199666844239 1.025338074393314e-06 0.2533821414201824 1.025338205189442e-06 0.2515535495016885 \
1.025338322399552e-06 0.2499173892700276 1.025338475652677e-06 0.2477853623028658 1.025338611183197e-06 0.2459029165157107 1.025338742864406e-06 0.244074199323236 \
1.025338899457317e-06 0.2419017673596028 1.025339024653875e-06 0.2401755227310949 1.025339160371501e-06 0.2383060149301216 1.025339292798663e-06 0.2364844144139329 \
1.025339412772324e-06 0.2348355337769661 1.025339575820161e-06 0.232606585912384 1.025339714627252e-06 0.230713852557009 1.025339853100972e-06 0.2288300961780371 \
1.025339958645721e-06 0.2273962817971701 1.025340087007401e-06 0.2256537837490921 1.025340191135024e-06 0.2242444877898851 1.025340291651026e-06 0.222886569499566 \
1.025340366695402e-06 0.2218745444235658 1.025340444028458e-06 0.2208349692306942 1.025340518791637e-06 0.2198305887827458 1.025340596755314e-06 0.218785487158918 \
1.025340651621824e-06 0.2180503923904892 1.0253407081186e-06 0.2172938400168352 1.025340751572119e-06 0.2167123195211523 1.025340791613165e-06 0.2161767335077376 \
1.025340830852113e-06 0.2156521099473339 1.02534087172635e-06 0.2151058606261434 1.02534092587884e-06 0.2143825797409383 1.025340964295972e-06 0.2138698309421548 \
1.025341003584678e-06 0.2133480458229882 1.025341065121387e-06 0.2125332203444249 1.025341127098915e-06 0.2117131287842428 1.025341183575664e-06 0.2109664019951111 \
1.025341248207254e-06 0.2101124842966758 1.025341343715876e-06 0.2088522205996687 1.025341431031607e-06 0.207701294711168 1.025341527641208e-06 0.2064291756790013 \
1.025341624870762e-06 0.2051510266126755 1.025341725717823e-06 0.2038307158897115 1.025341826317594e-06 0.2025192706911573 1.025341922808891e-06 0.2012627769767186 \
1.025342024991065e-06 0.1999338657614989 1.025342128630722e-06 0.1985898465970496 1.025342238404734e-06 0.1971698847140261 1.025342347579759e-06 0.1957617939809042 \
1.025342467677852e-06 0.1942174441246506 1.025342577697376e-06 0.1928086337505992 1.025342685809285e-06 0.1914295694688549 1.025342808837984e-06 0.1898652723262108 \
1.025342898948554e-06 0.1887234630454603 1.025343006314044e-06 0.1873671680421656 1.025343083125352e-06 0.1864004060894758 1.025343166570621e-06 0.1853535952511875 \
1.025343256102432e-06 0.1842338297700716 1.025343340667898e-06 0.1831790839553313 1.025343420384039e-06 0.1821880912968773 1.025343521709242e-06 0.1809331989518758 \
1.025343630056471e-06 0.1795959386230563 1.025343726532169e-06 0.1784102562612937 1.025343851909986e-06 0.1768766438339704 1.025343984693456e-06 0.1752616821119887 \
1.025344102464279e-06 0.1738362801839788 1.025344248115856e-06 0.1720835746408261 1.025344358713008e-06 0.1707596463148658 1.025344500843447e-06 0.1690680578777541 \
1.02534461655307e-06 0.1676985735146403 1.025344722027083e-06 0.166456424915798 1.025344816543743e-06 0.1653485352650968 1.025344912181115e-06 0.1642320043563913 \
1.025345009252958e-06 0.1631032360400927 1.025345108304212e-06 0.161956192050434 1.025345202227769e-06 0.1608730077890209 1.025345287503444e-06 0.1598934595213354 \
1.025345387883236e-06 0.1587475631033795 1.025345472186073e-06 0.1577906478848196 1.025345574585582e-06 0.1566342854655733 1.025345651979844e-06 0.1557646215197878 \
1.025345744324758e-06 0.154731814591042 1.02534581457623e-06 0.1539498814072817 1.025345910750659e-06 0.1528844393027091 1.025345987575322e-06 0.152038051282755 \
1.025346066345474e-06 0.1511758489440315 1.025346140238394e-06 0.150370438825067 1.025346207936138e-06 0.1496353997608715 1.025346304000026e-06 0.1485973848112393 \
1.025346373572453e-06 0.1478489919002561 1.025346457461625e-06 0.1469503328160803 1.025346518593461e-06 0.146298213254472 1.025346590861543e-06 0.1455309799806117 \
1.025346663300106e-06 0.1447677488542132 1.025346744281147e-06 0.1439178685120187 1.025346810355616e-06 0.1432275520600639 1.025346887756114e-06 0.1424219220725307 \
1.02534697713157e-06 0.1414956876531561 1.025347047992216e-06 0.1407644282175171 1.025347146879283e-06 0.1397487730030469 1.025347224198192e-06 0.1389620820751095 \
1.025347306243418e-06 0.1381330876879582 1.02534739435453e-06 0.1372467208126059 1.025347461981677e-06 0.1365690714953818 1.025347542278859e-06 0.1357674830239305 \
1.025347617062888e-06 0.1350239185327315 1.025347685064065e-06 0.1343502586094245 1.025347731746974e-06 0.1338891847862563 1.025347820998567e-06 0.1330118383700247 \
1.025347859221617e-06 0.1326395291833771 1.025347928213527e-06 0.1319690872918072 1.025347980961596e-06 0.1314578750898332 1.025348063954378e-06 0.1306559489775353 \
1.025348104132829e-06 0.1302688434457458 1.025348196650203e-06 0.1293805059784019 1.02534823536857e-06 0.1290098403727171 1.025348309129285e-06 0.1283055160094505 \
1.025348370757287e-06 0.1277188748199021 1.025348442784976e-06 0.1270353589407805 1.025348510952008e-06 0.1263909833196726 1.025348585574169e-06 0.1256908956540175 \
1.025348667426635e-06 0.1249253613889138 1.025348750880797e-06 0.124147338931438 1.025348823832511e-06 0.1234692772477456 1.025348896559441e-06 0.122795332839617 \
1.025348956549436e-06 0.1222410931008323 1.025349042917447e-06 0.121445549533078 1.025349103886164e-06 0.1208856452315438 1.025349162271955e-06 0.1203507897957366 \
1.02534922790662e-06 0.119751336354628 1.025349287260861e-06 0.1192111367930785 1.025349355292642e-06 0.1185941868697126 1.025349452587012e-06 0.11771710490035 \
1.025349531078992e-06 0.1170124163111649 1.025349621315123e-06 0.1162055395685231 1.025349717161808e-06 0.1153523005684616 1.025349792119505e-06 0.1146878351828532 \
1.025349896478921e-06 0.1137670532163148 1.025349983267518e-06 0.1130053589403202 1.025350092924934e-06 0.1120476726212376 1.025350174478997e-06 0.1113387926087848 \
1.025350270092629e-06 0.1105114393564785 1.025350346804822e-06 0.10985058581598 1.025350441723287e-06 0.1090364400125625 1.025350517546392e-06 0.1083889268999046 \
1.025350595246049e-06 0.1077282965354292 1.0253506775775e-06 0.1070311517075373 1.025350737142764e-06 0.1065286079538068 1.025350800900501e-06 0.1059924133642201 \
1.025350861995109e-06 0.1054803128126646 1.025350957858847e-06 0.1046801683739134 1.025351002721942e-06 0.1043071445723913 1.025351085962687e-06 0.1036173314376927 \
1.025351135082509e-06 0.1032117000904133 1.025351244131271e-06 0.1023149933518279 1.025351288967353e-06 0.1019479364619093 1.025351379228585e-06 0.1012117400678687 \
1.025351420105203e-06 0.1008795969612472 1.025351490563617e-06 0.1003088525914566 1.025351576851038e-06 0.09961307626065434 1.025351668628597e-06 0.09887705578174606 \
1.02535173815669e-06 0.09832225024344161 1.025351816683849e-06 0.09769854072774181 1.025351907412525e-06 0.09698178745350861 1.025351983228664e-06 0.09638605854785212 \
1.025352065241407e-06 0.09574500473888557 1.025352146994443e-06 0.09510943278387665 1.025352237502267e-06 0.09440967388330095 1.025352327061565e-06 0.09372126988887708 \
1.025352412671398e-06 0.09306698857649189 1.025352505450897e-06 0.09236212353634379 1.025352586338857e-06 0.0917510971760913 1.025352687467827e-06 0.09099177263830999 \
1.025352767961353e-06 0.09039108594384238 1.025352852204218e-06 0.08976589684797046 1.025352926049265e-06 0.08922077348043934 1.025353002898743e-06 0.08865632925481931 \
1.025353091039113e-06 0.08801255002475737 1.025353171103482e-06 0.08743108261130086 1.025353264139672e-06 0.08675939571108145 1.025353382140385e-06 0.08591369538214398 \
1.025353524513612e-06 0.08490278100234279 1.025353668761962e-06 0.08388867104764453 1.025353811089671e-06 0.08289807427203813 1.025353960667415e-06 0.08186746790234835 \
1.02535409698116e-06 0.08093761126893445 1.025354239101592e-06 0.0799778356000513 1.02535437365502e-06 0.07907840240745091 1.02535451400773e-06 0.07814980287393705 \
1.025354661689802e-06 0.0771833418413561 1.025354811805299e-06 0.07621180464723754 1.025354976525777e-06 0.07515824360926991 1.025355140155128e-06 0.07412455432658185 \
1.025355314933688e-06 0.07303438636984133 1.025355502186304e-06 0.07188220095900363 1.025355712231308e-06 0.07060976590783831 1.025355930441531e-06 0.06930979572898451 \
1.02535616389862e-06 0.06794333957253913 1.025356418744638e-06 0.06648001693367038 1.025356711839195e-06 0.06483321328442151 1.025357014178957e-06 0.06317411115207273 \
1.025357328765833e-06 0.06148945259513613 1.025357725026527e-06 0.05942677493938087 1.025358058743672e-06 0.05774249301432461 1.025358466054501e-06 0.05574994498853819 \
1.02535879393926e-06 0.05419380357502902 1.025359150629899e-06 0.05254809000207299 1.02535946386806e-06 0.05114243792209583 1.025359766835193e-06 0.04981740498512215 \
1.025360064375719e-06 0.04854875663330436 1.025360343155274e-06 0.04739109061078805 1.025360626155169e-06 0.04624570307560639 1.025360887895477e-06 0.04521055793698023 \
1.02536116713437e-06 0.04413130357485813 1.02536143924029e-06 0.0431040186124033 1.025361746607047e-06 0.04197194005652995 1.025361968409948e-06 0.04117329707315532 \
1.025362274870428e-06 0.04009446155587663 1.025362501059881e-06 0.03931650950691581 1.025362739977206e-06 0.03851359500741255 1.025362964401039e-06 0.03777663690506906 \
1.02536316666332e-06 0.03712468825868943 1.025363367705949e-06 0.03648814235703791 1.025363719479983e-06 0.03540095449820539 1.025363969725821e-06 0.03464776841732944 \
1.025364216044101e-06 0.03392252499723709 1.025364497376965e-06 0.03311308780599518 1.02536474046795e-06 0.03242954897046491 1.025364975941701e-06 0.03178112583711486 \
1.025365217601206e-06 0.03113119522156456 1.025365454483484e-06 0.03050988948014832 1.025365685016041e-06 0.02991733361391674 1.025365898984569e-06 0.02937801894285819 \
1.025366104927116e-06 0.02886851641492237 1.025366497651603e-06 0.02792196059063811 1.025366685729283e-06 0.02747992420741849 1.025367061168249e-06 0.02661861215736662 \
1.025367236042478e-06 0.02622659266649364 1.025367659365492e-06 0.02530049759795254 1.025367780614876e-06 0.02504150687334681 1.025368221176528e-06 0.02412433837770948 \
1.025368363674648e-06 0.02383402682615681 1.025368695728157e-06 0.02316883068419595 1.025368878693682e-06 0.02280879143785283 1.025369267997886e-06 0.02205689891561978 \
1.025369436343594e-06 0.02173705378531499 1.025369908457993e-06 0.02085107653961301 1.025370048202727e-06 0.0205916297664938 1.025370543782805e-06 0.01969297428531048 \
1.025370671008237e-06 0.01946923320191776 1.025371238917342e-06 0.01851512288677271 1.02537140317129e-06 0.0182513999453204 1.025372013043029e-06 0.0173209960017622 \
1.025372172728257e-06 0.01708922829277545 1.025372699639798e-06 0.01635462467776483 1.025372904157091e-06 0.01608193551804103 1.025373627634478e-06 0.01515939662837778 \
1.02537379307661e-06 0.01495683325581705 1.025374539636356e-06 0.01408081084911163 1.025374672939569e-06 0.01393008075245666 1.025375533124155e-06 0.01299799962960837 \
1.02537566920557e-06 0.01285670227674402 1.025376609799459e-06 0.01192267652923807 1.025376773572533e-06 0.01176632439256516 1.025377774751465e-06 0.01084959205883911 \
1.025377912229187e-06 0.01072929995296418 1.025379082926799e-06 0.009787962024485789 1.025379175323166e-06 0.009718668544398181 1.025380593399014e-06 0.008725931027897449 \
1.025380680375162e-06 0.00866912727384293 1.025382221370793e-06 0.00770199130002063 1.025382330686807e-06 0.007633428668288294 1.025383973934629e-06 0.006673746291950173 \
1.025384106791908e-06 0.006603544020797993 1.025386201172206e-06 0.005605323336654431 1.025386409576941e-06 0.00551468736035817 1.025388763913366e-06 0.004577307911602986 \
1.025389237472123e-06 0.004407121484391641 1.02539212290898e-06 0.003492041675788492 1.025392652573327e-06 0.00334538389506189 1.025396860800552e-06 0.00237996320858989 \
1.025397374234803e-06 0.002283557532494709 1.025403133485495e-06 0.001325291758975802 1.025403368066713e-06 0.001279502680325907 1.025418035894088e-06 0.0002809017338477542 \
1.02541814896418e-06 0.0002788534805396912 1.02805516904393e-06 -0.0006849217749926401 1.028055335205606e-06 -0.0009443270389602415 1.028055814074993e-06 -0.001850320037528519 \
1.02805590679462e-06 -0.002050462221988249 1.028056272019697e-06 -0.002913187630468476 1.028056363676814e-06 -0.00314709230904735 1.028056729783165e-06 -0.004133001189868674 \
1.028056839930291e-06 -0.004442309109773816 1.028057150668543e-06 -0.005311341427314526 1.028057252407188e-06 -0.005583925258601597 1.028057616111313e-06 -0.00638370916272213 \
1.028057780957637e-06 -0.006585924750287024 1.028058360754957e-06 -0.005792290386912202 1.028058535589415e-06 -0.004916934050781314 1.028058652279015e-06 -0.00413641027497409 \
1.028058778708708e-06 -0.00310656561120747 1.028058880730911e-06 -0.002137079422087956 1.028059000577393e-06 -0.0008406209844352954 1.028059091214629e-06 0.0002489246187367611 \
1.028059189634679e-06 0.001536790859923857 1.028059289358323e-06 0.002948496343048522 1.028059456842332e-06 0.005545701385567424 1.028059675420934e-06 0.009327395936412004 \
1.028059861491256e-06 0.0128572688386996 1.028060082873864e-06 0.01737012273305725 1.028060243533997e-06 0.02082840415615294 1.028060406999647e-06 0.02447866954313523 \
1.028060557635164e-06 0.02794359528291388 1.028060706690917e-06 0.03145289236167962 1.028060856153671e-06 0.03504014479003619 1.028061010184684e-06 0.03879791952579481 \
1.028061172300943e-06 0.04280891157365373 1.028061338330408e-06 0.04696567134311741 1.028061514283228e-06 0.05141478668696391 1.028061694953866e-06 0.05602187592747932 \
1.028061886774812e-06 0.06094655248807559 1.028062093880316e-06 0.06629309753158302 1.028062315452046e-06 0.07203901748582854 1.028062550186215e-06 0.07814662931008168 \
1.028062801725783e-06 0.08470684589377442 1.028063077167849e-06 0.09190125212984442 1.028063377363668e-06 0.09974607960254324 1.028063708295878e-06 0.108390578238945 \
1.028064083962612e-06 0.1181923833971668 1.02806448154548e-06 0.1285487285136021 1.028064948370082e-06 0.1406786766767902 1.028065491362617e-06 0.1547396794802719 \
1.02806612478764e-06 0.1710742296429572 1.028066820727691e-06 0.1889259607126788 1.028067636284801e-06 0.2097135943149445 1.028068546312904e-06 0.2327316641523666 \
1.028069339569124e-06 0.2526372689279454 1.0280700450442e-06 0.2702038474981599 1.028070663988468e-06 0.2855008995781749 1.028071231094408e-06 0.2994177966724069 \
1.028071754174414e-06 0.3121574438576628 1.028072253153207e-06 0.3242197130846058 1.028072737193214e-06 0.3358335658028451 1.028073192420047e-06 0.3466679577370423 \
1.028073666932009e-06 0.3578644504627745 1.028074106840717e-06 0.368158604789619 1.028074592685345e-06 0.3794271463718566 1.028075124288118e-06 0.3916316501999784 \
1.028075626951417e-06 0.4030538969706937 1.02807605602367e-06 0.4127111343288326 1.028076547040338e-06 0.4236561147984291 1.028077048470419e-06 0.434714731975362 \
1.028077395015009e-06 0.442288187401736 1.028077750424385e-06 0.4500000616404133 1.028078177652114e-06 0.4592019891792938 1.028078569851637e-06 0.4675774400278049 \
1.028078870233395e-06 0.4739448723400065 1.028079212045155e-06 0.4811381049525967 1.028079555484969e-06 0.4883107756756314 1.028079816220095e-06 0.4937186470393492 \
1.028080058250049e-06 0.4987071765458648 1.028080324195291e-06 0.5041573145298286 1.028080581464587e-06 0.509394255416739 1.02808077158369e-06 0.5132422368582924 \
1.028080985109851e-06 0.5175451019736222 1.028081124800157e-06 0.5203466115392713 1.028081271000449e-06 0.5232668091041763 1.02808148498835e-06 0.5275186200231483 \
1.02808169300461e-06 0.5316389396023125 1.028081885465879e-06 0.5354321131715788 1.02808207058211e-06 0.5390651926504321 1.028082244955557e-06 0.5424725330931349 \
1.028082549497633e-06 0.5484058192982523 1.028082810056515e-06 0.5534602958276967 1.028083111487545e-06 0.5592859190791987 1.028083365805138e-06 0.5641865993769294 \
1.028083658661328e-06 0.5698153316805189 1.02808391787448e-06 0.5747800306938655 1.028084188950812e-06 0.579963273174682 1.028084430794571e-06 0.5845680738798381 \
1.028084688299729e-06 0.5894577538325241 1.028084915043605e-06 0.5937419314630586 1.028085152044424e-06 0.5982006324572362 1.028085362230986e-06 0.6021379329905048 \
1.02808557499152e-06 0.6061060319396779 1.028085827870286e-06 0.6107954169450593 1.028086031533555e-06 0.6145509252949414 1.028086222250936e-06 0.6180531102377972 \
1.028086409587374e-06 0.6214768531423983 1.028086598465652e-06 0.6249070011644339 1.028086806665447e-06 0.6286671070650327 1.028087050997562e-06 0.6330499453121026 \
1.028087250564095e-06 0.6366057789565548 1.028087454709836e-06 0.6402215701419991 1.02808763934909e-06 0.643474671963314 1.028087908884781e-06 0.6481901084955864 \
1.028088136591637e-06 0.652149230294136 1.028088324263375e-06 0.6553888277830079 1.02808850516352e-06 0.6584949378977958 1.028088664704602e-06 0.661221510907812 \
1.028088835167002e-06 0.6641177016088209 1.028088986918443e-06 0.6666817235716488 1.028089124561455e-06 0.6689905419339194 1.028089273556319e-06 0.6714784915997724 \
1.028089401298182e-06 0.6736028790357499 1.028089544284695e-06 0.675968899142866 1.028089666067751e-06 0.6779749688503388 1.028089802351161e-06 0.6802121872853304 \
1.028089922180063e-06 0.682172759947357 1.028090068775623e-06 0.6845626218370968 1.028090187248565e-06 0.6864845934661837 1.028090283181927e-06 0.6880368302455475 \
1.028090375701511e-06 0.6895284278106264 1.028090480762023e-06 0.6912169000724893 1.028090578843908e-06 0.6927871490736753 1.028090715959225e-06 0.6949707622226827 \
1.028090835157868e-06 0.6968607547931925 1.028090945097838e-06 0.6985951241089645 1.028091082597082e-06 0.7007503743809057 1.028091214026983e-06 0.7027960765825516 \
1.028091346256499e-06 0.7048392108129343 1.028091459433897e-06 0.7065756917706891 1.028091613866752e-06 0.708927873976708 1.028091744646745e-06 0.7109048231498766 \
1.028091867315455e-06 0.7127465601965561 1.028091973583711e-06 0.7143329262278221 1.028092095963735e-06 0.7161490373358268 1.028092197817232e-06 0.7176517022913665 \
1.028092331955131e-06 0.7196190116794019 1.028092452648172e-06 0.7213783352064487 1.02809257178997e-06 0.7231049829175343 1.028092696807985e-06 0.7249059312823601 \
1.028092826647791e-06 0.7267645120560844 1.028092946459962e-06 0.7284691779696002 1.028093075453213e-06 0.730293808329565 1.028093207560277e-06 0.7321507998840678 \
1.028093325866095e-06 0.7338038328985433 1.028093469126786e-06 0.7357927618453034 1.028093571581473e-06 0.7372070005703254 1.028093667788359e-06 0.7385290937783453 \
1.02809377280598e-06 0.7399656334130889 1.028093883577511e-06 0.7414708009413548 1.028093985256052e-06 0.7428439364018735 1.028094088217507e-06 0.7442258341871242 \
1.028094205143661e-06 0.7457850038572696 1.028094333903936e-06 0.747489965072781 1.028094435062908e-06 0.7488201182152049 1.028094583931952e-06 0.7507626302114226 \
1.028094731611489e-06 0.75267249971878 1.028094850976855e-06 0.7542038164026367 1.0280949974607e-06 0.7560679527984652 1.02809512063619e-06 0.7576223900169708 \
1.028095261439865e-06 0.7593848990234215 1.028095398032531e-06 0.7610800595258669 1.028095520190381e-06 0.7625841275516777 1.028095632846779e-06 0.7639610711610054 \
1.02809577457292e-06 0.7656796138775311 1.02809590073942e-06 0.767196844592689 1.028096016156724e-06 0.768574452686535 1.028096146464904e-06 0.7701179991486644 \
1.028096262177572e-06 0.7714782821591826 1.02809638500186e-06 0.7729116492687436 1.028096502846128e-06 0.7742769236963016 1.028096608476119e-06 0.7754922619072108 \
1.028096723849553e-06 0.7768108638983861 1.028096829112716e-06 0.7780056027231214 1.028096940062529e-06 0.7792565499870431 1.028097026467031e-06 0.7802246528436213 \
1.02809713050085e-06 0.7813823422463088 1.028097244396594e-06 0.7826398494046257 1.028097347430014e-06 0.7837684443710583 1.028097455512714e-06 0.7849432998269023 \
1.02809756376437e-06 0.7861107422109641 1.028097699181616e-06 0.7875582910536544 1.028097811855724e-06 0.7887521292973186 1.028097936279784e-06 0.7900592323105087 \
1.028098054252648e-06 0.7912877959129118 1.028098198720603e-06 0.7927781272271259 1.028098316389742e-06 0.7939806363584788 1.028098452269581e-06 0.7953567374150946 \
1.028098587013954e-06 0.7967081403609936 1.028098698084933e-06 0.7978123285366109 1.028098797974273e-06 0.7987978371087655 1.028098899654231e-06 0.7997937268659365 \
1.028099032867897e-06 0.8010867894381996 1.028099151240716e-06 0.8022243628210853 1.028099272781791e-06 0.8033812848148773 1.028099392145442e-06 0.8045065422543012 \
1.028099513276819e-06 0.80563739819571 1.028099644976236e-06 0.8068544426691319 1.028099767984513e-06 0.8079795872959963 1.02809989582812e-06 0.8091371804586788 \
1.02810002673464e-06 0.8103101881504271 1.028100150327798e-06 0.8114062915203997 1.028100257500303e-06 0.8123479140825919 1.028100364929502e-06 0.8132835730547656 \
1.028100447598621e-06 0.8139979974227743 1.028100565310381e-06 0.8150069815425507 1.028100655915986e-06 0.8157770472204025 1.028100786569431e-06 0.8168774959419571 \
1.028100930959301e-06 0.8180800468042847 1.028101064133715e-06 0.8191766687328477 1.028101174025106e-06 0.8200725423139092 1.028101317623992e-06 0.8212302325252553 \
1.028101471014683e-06 0.8224508494407716 1.028101599092908e-06 0.8234574467428303 1.028101738880276e-06 0.8245431382086058 1.028101865129839e-06 0.8255122018650548 \
1.028102019728392e-06 0.8266841987320058 1.028102151939368e-06 0.8276738265999063 1.028102278166151e-06 0.8286078934539939 1.028102395913874e-06 0.8294698388787296 \
1.028102544986667e-06 0.8305480062617677 1.028102712318221e-06 0.8317406852496945 1.028102845539497e-06 0.8326770812274722 1.02810301832082e-06 0.8338744310092966 \
1.028103186826193e-06 0.8350236380668206 1.028103356205492e-06 0.8361608866600232 1.028103537840761e-06 0.8373606451951652 1.028103680174083e-06 0.8382866867625347 \
1.028103794011069e-06 0.8390185116470331 1.028103925192579e-06 0.8398522525089582 1.028104026724794e-06 0.8404903982372576 1.028104143009054e-06 0.8412135669902132 \
1.028104277643808e-06 0.8420406924792603 1.028104474666644e-06 0.8432316292878405 1.028104664772186e-06 0.8443592803112207 1.028104874895499e-06 0.8455816023960827 \
1.028105055213604e-06 0.8466107566581813 1.028105252676705e-06 0.8477171937062282 1.02810542674582e-06 0.8486750118570332 1.02810560906524e-06 0.8496608982186138 \
1.028105780480376e-06 0.8505716849290491 1.028105954593653e-06 0.8514808063694008 1.028106130324621e-06 0.8523822271368225 1.028106306436321e-06 0.8532696099472232 \
1.028106496054173e-06 0.8542074684498208 1.02810668683567e-06 0.8551330189126392 1.028106888431747e-06 0.8560917259710515 1.028107081166005e-06 0.856990088884472 \
1.028107290037826e-06 0.8579439907476532 1.028107520740263e-06 0.8589743400177088 1.028107785183227e-06 0.8601259267840322 1.028108084005915e-06 0.8613896125360476 \
1.028108363960216e-06 0.8625380186322354 1.028108648086082e-06 0.8636694076724545 1.028108922855057e-06 0.8647317823994775 1.028109194712217e-06 0.8657531067718063 \
1.028109465089334e-06 0.8667403371654003 1.028109722167856e-06 0.8676533221001362 1.028109994792686e-06 0.868594905839151 1.028110270759835e-06 0.8695208838709013 \
1.028110540864093e-06 0.8704012674911344 1.028110840740104e-06 0.8713491368600049 1.028111211801162e-06 0.8724801680184872 1.02811150674079e-06 0.8733472453740196 \
1.028111761036548e-06 0.8740729094291386 1.028112059297474e-06 0.8748989982677786 1.028112332904015e-06 0.8756336613858092 1.028112569029958e-06 0.876250392688866 \
1.028112809374056e-06 0.8768621356511911 1.028113031706182e-06 0.8774140071409635 1.028113225712247e-06 0.8778848105679672 1.028113555434997e-06 0.8786625669521169 \
1.028113710608526e-06 0.8790190643519731 1.028114028387606e-06 0.879730644938159 1.028114207248865e-06 0.8801204696806418 1.028114549710761e-06 0.8808457867651537 \
1.028114733837363e-06 0.8812245477320809 1.028115208711942e-06 0.8821665346129511 1.028115376108352e-06 0.8824869809105039 1.028115841951854e-06 0.883348261932613 \
1.028116022773548e-06 0.8836708855253055 1.028116516812651e-06 0.8845204537290557 1.028116658162059e-06 0.8847551796839913 1.028117264500122e-06 0.8857215808967022 \
1.028117416569336e-06 0.8859539944113424 1.028118063256356e-06 0.8869009218298172 1.028118191551239e-06 0.8870812460539503 1.028118839667745e-06 0.8879562712787433 \
1.028118969467641e-06 0.8881245027440973 1.02811974767834e-06 0.8890830197250962 1.028119862725472e-06 0.8892171882189283 1.028120718396314e-06 0.8901564861234483 \
1.028120863744077e-06 0.8903061494816453 1.028121849499649e-06 0.8912466483555094 1.028122070607711e-06 0.8914402669210102 1.028123215727714e-06 0.892367747196105 \
1.028123346939159e-06 0.8924695935232408 1.028124688211624e-06 0.8934615053489913 1.0281248396029e-06 0.8935661991834861 1.02812632105512e-06 0.8944951400107031 \
1.028126559934816e-06 0.8946288932334222 1.028128329356654e-06 0.895502508848118 1.028128718477945e-06 0.895670668133377 1.028131112210654e-06 0.8965556062201232 \
1.028131587750593e-06 0.8967047758494365 1.028135650819818e-06 0.8977025964496719 1.028136142295653e-06 0.8977953148389237 1.028144458892796e-06 0.8987880790885289 \
1.028145378794248e-06 0.8988514070442593 1.028299242370168e-06 0.8998485708192639 1.028302885496457e-06 0.8998628537402877 1.028529614276672e-06 0.8989664306490068 \
1.028529844616583e-06 0.8988008565867064 1.02853145953688e-06 0.897804750401333 1.028531637269166e-06 0.8977103535805105 1.028548403669272e-06 0.8986978311584225 \
1.028548539768402e-06 0.8987160394686986 1.028563710608672e-06 0.8997133888183054 1.028563987713508e-06 0.899719468756186 1.029048028906422e-06 0.9005852143835333 \
1.029048202241039e-06 0.9007408621809421 1.029048862730638e-06 0.9015135064485434 1.02904902879582e-06 0.9017527716291757 1.029049555130528e-06 0.9026184054967997 \
1.029049746244448e-06 0.9029704910143604 1.0290501104655e-06 0.9036902342402512 1.029050289664922e-06 0.9040628043424317 1.029050651551594e-06 0.9048333795345931 \
1.029050846661164e-06 0.9052442844328937 1.029051379059525e-06 0.9062266394381637 1.029051561413164e-06 0.9064623886473868 1.029052553393556e-06 0.905594670761786 \
1.029052714934123e-06 0.9049318860608667 1.029052882926575e-06 0.9040378649110347 1.029053042758061e-06 0.9029782421366458 1.029053180254799e-06 0.9018984154159868 \
1.029053313162111e-06 0.9007052793196499 1.029053439587579e-06 0.8994328447569792 1.029053546986819e-06 0.8982475863895881 1.029053651483477e-06 0.8970047013543965 \
1.029053765533147e-06 0.8955451342423859 1.029053855502734e-06 0.8943225684615312 1.029053960321373e-06 0.8928208677113324 1.029054049769612e-06 0.891473284704788 \
1.029054132145393e-06 0.8901820884368528 1.029054223238393e-06 0.8887006634027688 1.029054360574471e-06 0.8863657732814155 1.029054459067403e-06 0.8846195012157601 \
1.029054571141153e-06 0.8825649218508906 1.029054702024186e-06 0.880080778639088 1.029054838495216e-06 0.8774018563482072 1.029054991949379e-06 0.8742910281085086 \
1.029055151043747e-06 0.8709679977889497 1.029055315327649e-06 0.867445283300377 1.029055471995751e-06 0.8640104344288071 1.029055624086531e-06 0.860615744772629 \
1.029055777800206e-06 0.857132398554192 1.029055937362381e-06 0.853469801378647 1.029056092451083e-06 0.8498714074018293 1.029056266130402e-06 0.8458039138600054 \
1.029056429161269e-06 0.8419559450883216 1.029056590803684e-06 0.8381170660338335 1.029056753450421e-06 0.8342344554797501 1.029056914868927e-06 0.8303657475978833 \
1.029057083463406e-06 0.8263109424305363 1.029057266356504e-06 0.8219002364007665 1.029057434185218e-06 0.8178440888239877 1.029057602471033e-06 0.8137703061148112 \
1.029057773299085e-06 0.8096302849976138 1.029057945473642e-06 0.8054541271740473 1.029058113235561e-06 0.8013830614994394 1.029058296865018e-06 0.7969255463994016 \
1.029058468271496e-06 0.7927646873948894 1.029058653714802e-06 0.7882638003278283 1.029058820385453e-06 0.7842196820467244 1.029058989271585e-06 0.7801233737411432 \
1.029059173427882e-06 0.7756572567105651 1.02905936803791e-06 0.7709405333854473 1.029059515293241e-06 0.7673736106648734 1.029059641923832e-06 0.7643079795643375 \
1.029059783780644e-06 0.7608754495129878 1.029059888184422e-06 0.7583505812556488 1.029060020577074e-06 0.7551502542766809 1.02906013016127e-06 0.7525028097975122 \
1.029060263325923e-06 0.7492875979647342 1.029060419507685e-06 0.7455190770546114 1.029060532737112e-06 0.7427887939149777 1.029060695258476e-06 0.7388718945951063 \
1.029060867439291e-06 0.7347246296492568 1.029061063444044e-06 0.7300078517193382 1.029061227834023e-06 0.7260553905833119 1.029061380230704e-06 0.7223944885043934 \
1.029061543905858e-06 0.718466402706526 1.029061711831558e-06 0.7144406657912139 1.029061891671936e-06 0.7101336212543717 1.029062067965886e-06 0.7059164985576465 \
1.029062239040521e-06 0.7018286413152719 1.029062407358697e-06 0.6978099102718778 1.029062560624829e-06 0.6941537154717222 1.029062722508398e-06 0.6902960245155986 \
1.029062901459938e-06 0.6860364417190952 1.02906303567149e-06 0.6828448068431195 1.029063139177788e-06 0.6803854168085423 1.029063238462201e-06 0.6780286039046017 \
1.029063339916677e-06 0.6756220912380299 1.029063432373276e-06 0.6734303711245889 1.029063516962075e-06 0.6714267031582685 1.029063610539411e-06 0.6692114082407524 \
1.029063727081631e-06 0.6664546942583044 1.029063836559192e-06 0.6638675763958631 1.029063949672203e-06 0.6611971533414394 1.02906407279097e-06 0.6582923426231613 \
1.029064197017283e-06 0.6553636581362478 1.029064367777427e-06 0.6513432847262797 1.029064526226014e-06 0.6476181700514572 1.029064698513837e-06 0.6435738126612673 \
1.029064844491904e-06 0.6401512360303271 1.02906498628512e-06 0.6368325564797357 1.029065117883574e-06 0.6337564355289309 1.029065248046859e-06 0.630718219665797 \
1.0290653735718e-06 0.6277924818644975 1.029065505354707e-06 0.6247239543970449 1.029065635278202e-06 0.6217046839485236 1.029065771586778e-06 0.6185408917806742 \
1.029065916200345e-06 0.615188962872713 1.029066075692536e-06 0.611499189008522 1.029066249152652e-06 0.6074939486938447 1.029066420159954e-06 0.6035554342946753 \
1.029066651528523e-06 0.5982402936372396 1.029066894990528e-06 0.5926661367297537 1.029067069111016e-06 0.5886942528256315 1.029067215383094e-06 0.5853638081576373 \
1.029067349755312e-06 0.58231230528805 1.029067466850207e-06 0.5796585826255305 1.029067562614553e-06 0.5774900935424465 1.029067661461095e-06 0.5752566196463251 \
1.029067745438414e-06 0.5733628024369305 1.029067823052463e-06 0.571614165956722 1.029067884377937e-06 0.5702331258704825 1.029067949058576e-06 0.5687779664863769 \
1.029068030366711e-06 0.5669528575016536 1.029068080436707e-06 0.5658306078972934 1.029068129757269e-06 0.5647256890740617 1.029068191677069e-06 0.5633393552914843 \
1.029068239508894e-06 0.5622690492396486 1.02906829001368e-06 0.5611395143522533 1.029068350075717e-06 0.559799205480933 1.029068409358512e-06 0.5584782058326896 \
1.029068484415226e-06 0.5568072508052372 1.029068554097883e-06 0.5552574373576753 1.029068639686449e-06 0.5533559356568912 1.029068726753821e-06 0.5514265885063823 \
1.029068810416341e-06 0.5495763264044081 1.029068896561366e-06 0.5476734676082877 1.029068992265987e-06 0.5455621222678217 1.029069096550939e-06 0.5432673229847179 \
1.029069211218113e-06 0.5407497407899529 1.029069319936575e-06 0.5383664115638558 1.029069429508814e-06 0.5359693749054023 1.029069541813574e-06 0.5335193270114367 \
1.029069668589196e-06 0.530759392645703 1.029069790866427e-06 0.5281021910076299 1.029069930952405e-06 0.5250685463469849 1.029070067969762e-06 0.5221084647952599 \
1.029070218271135e-06 0.5188705764247719 1.029070377166376e-06 0.5154582091324615 1.029070551500259e-06 0.5117250894133971 1.029070738517481e-06 0.5077378180012799 \
1.029070943835486e-06 0.5033745272871338 1.029071155677679e-06 0.498891131759938 1.029071408479721e-06 0.4935662239713107 1.02907161056737e-06 0.4893264048484654 \
1.029071845160675e-06 0.4844277613141263 1.029072081275272e-06 0.4795194943790256 1.029072334451769e-06 0.474283574581623 1.029072644981732e-06 0.4679020429045382 \
1.02907286303971e-06 0.4634451779596257 1.029073036485344e-06 0.4599153839204358 1.029073212977781e-06 0.4563351808422506 1.029073492459577e-06 0.4506930409909046 \
1.029073724703484e-06 0.4460279192631412 1.029074011797073e-06 0.44029020239849 1.029074229643181e-06 0.435960758243863 1.029074439695769e-06 0.4318042429497612 \
1.029074640893604e-06 0.4278406951573778 1.029074823313766e-06 0.4242617300271556 1.029074997208751e-06 0.4208637793449936 1.029075162072867e-06 0.4176529694331993 \
1.02907532082684e-06 0.4145718140694327 1.029075487073786e-06 0.4113577680628809 1.029075635718993e-06 0.4084923702366076 1.029075788087249e-06 0.4055658186126443 \
1.029075930150432e-06 0.4028468403491589 1.02907609952631e-06 0.3996150665462138 1.02907621990823e-06 0.3973276483660343 1.029076329881494e-06 0.3952449223617059 \
1.029076444806895e-06 0.3930732253581283 1.029076597048475e-06 0.3902080468194818 1.02907670926954e-06 0.3881039677199808 1.029076816462041e-06 0.386098874836553 \
1.02907696899029e-06 0.383254723448244 1.029077097137419e-06 0.380874963946598 1.029077219985412e-06 0.3786015923730871 1.029077399083788e-06 0.375299968600122 \
1.02907754816842e-06 0.3725653942578417 1.029077715875808e-06 0.3695018296724824 1.029077871273442e-06 0.3666748141177644 1.029077995440288e-06 0.3644243980538668 \
1.029078109332155e-06 0.3623666676050148 1.029078230775526e-06 0.3601804966264144 1.029078410927293e-06 0.3569532670533712 1.029078577415114e-06 0.3539878629329621 \
1.029078767834223e-06 0.3506138544217919 1.029078959590819e-06 0.3472380408565978 1.029079142640212e-06 0.344035729794033 1.029079291612277e-06 0.3414435189591631 \
1.029079411552182e-06 0.3393660536257183 1.029079534213665e-06 0.3372483242714233 1.029079657244151e-06 0.3351324902755385 1.029079802148562e-06 0.3326515017845288 \
1.029079905461337e-06 0.3308907757076019 1.029079999190846e-06 0.3292979229163631 1.029080089851148e-06 0.3277620998585528 1.029080200972602e-06 0.3258853746017661 \
1.029080308145579e-06 0.3240820510456246 1.02908040642023e-06 0.3224338250618513 1.029080518824776e-06 0.3205545940512134 1.029080682764676e-06 0.3178277446588927 \
1.029080844402555e-06 0.3151576097143818 1.029080992189301e-06 0.3127316247504084 1.029081154434516e-06 0.3100832165115083 1.029081314465073e-06 0.3074868334344322 \
1.029081466728372e-06 0.3050304870660137 1.029081620100242e-06 0.3025703731928215 1.029081778808771e-06 0.3000411640344692 1.0290819432579e-06 0.297437246442505 \
1.029082110484976e-06 0.2948063590562646 1.029082263596514e-06 0.292412731930112 1.02908244669444e-06 0.2895700146919417 1.029082637002178e-06 0.2866380344427262 \
1.029082785905237e-06 0.2843603072871506 1.029082959842541e-06 0.2817165165722222 1.02908313671993e-06 0.2790484233348025 1.029083284317149e-06 0.2768363681311815 \
1.029083473948849e-06 0.2740172295061162 1.029083623950767e-06 0.2718052906662373 1.029083761060958e-06 0.2697943906627059 1.029083902591401e-06 0.2677397479842996 \
1.02908401605027e-06 0.2661005451260196 1.029084152340597e-06 0.2641384584581135 1.029084282417217e-06 0.2622807416655737 1.02908440067147e-06 0.2606037730704709 \
1.029084518527066e-06 0.2589348966568543 1.029084649420877e-06 0.2570853888657079 1.029084789659635e-06 0.2551145527343576 1.029084905154221e-06 0.2534976852533538 \
1.029085034005598e-06 0.2516957519945816 1.02908514915158e-06 0.2500885525459272 1.029085302462547e-06 0.2479513765689386 1.029085440316308e-06 0.2460367343642474 \
1.02908557977796e-06 0.2441002375748529 1.029085735245815e-06 0.2419427021952501 1.02908586002843e-06 0.2402176526454788 1.029085999893338e-06 0.2382916534360561 \
1.029086128595514e-06 0.2365220787132559 1.029086249554366e-06 0.234860341242685 1.029086366599666e-06 0.2332541163798121 1.02908649260073e-06 0.2315368940272461 \
1.029086589320323e-06 0.2302195772445239 1.029086681409196e-06 0.2289683907689286 1.029086795826667e-06 0.2274152998827935 1.029086894197314e-06 0.2260807986508055 \
1.029087011344108e-06 0.2244933520241092 1.029087114435226e-06 0.2231010305483718 1.029087219949952e-06 0.2216798666278746 1.029087300868012e-06 0.2205933880575098 \
1.029087374539197e-06 0.2196046443759679 1.029087417268434e-06 0.2190314036349237 1.029087460398579e-06 0.2184540235451489 1.029087511196061e-06 0.217774515685755 \
1.029087548370939e-06 0.217277430841393 1.029087589041954e-06 0.2167338127731004 1.029087631833755e-06 0.2161620985357572 1.029087668244897e-06 0.2156758299561118 \
1.029087710169888e-06 0.2151161507306283 1.029087764712098e-06 0.2143884526296278 1.029087803170856e-06 0.2138756926875936 1.029087842797626e-06 0.2133496230586122 \
1.029087904630127e-06 0.212531488259555 1.029087966356579e-06 0.2117156525305126 1.029088022493854e-06 0.210974237875411 1.029088086149084e-06 0.210134110843225 \
1.029088180240117e-06 0.2088936328424611 1.029088267048376e-06 0.2077505933124353 1.02908836100502e-06 0.2065146061917991 1.029088459047254e-06 0.2052266823513323 \
1.02908856063462e-06 0.2038976009052371 1.029088661543568e-06 0.2025832113009377 1.029088758279377e-06 0.2013244528083448 1.029088860404348e-06 0.1999972806373927 \
1.029088963735906e-06 0.1986583046056677 1.029089073618507e-06 0.1972379690671278 1.029089182560765e-06 0.1958337611883887 1.029089302395885e-06 0.1942937175364915 \
1.029089412679751e-06 0.1928822800638286 1.029089520558496e-06 0.191507108810815 1.029089646621254e-06 0.1899051957406391 1.029089736488961e-06 0.1887671190866151 \
1.0290898469673e-06 0.1873723090993208 1.029089924500249e-06 0.1863971337376019 1.029090008823992e-06 0.1853400660204312 1.02909009641205e-06 0.1842452710069853 \
1.029090184204644e-06 0.18315095174413 1.029090265924515e-06 0.1821357652581398 1.029090363486193e-06 0.1809282658474054 1.029090470197344e-06 0.1796118512064394 \
1.029090570679026e-06 0.178377576484793 1.029090694850238e-06 0.1768595317522179 1.029090828741761e-06 0.1752320886156309 1.029090947653953e-06 0.1737937102924047 \
1.029091098054147e-06 0.1719851742607024 1.02909120888924e-06 0.1706594030660365 1.029091348655982e-06 0.168997130456427 1.02909146718129e-06 0.1675953052211382 \
1.029091572608521e-06 0.1663548750207849 1.02909166731838e-06 0.1652455210322802 1.029091760628154e-06 0.1641568522804657 1.029091861534271e-06 0.1629842804551663 \
1.029091956952102e-06 0.1618800504313296 1.029092054143026e-06 0.1607598891027116 1.029092135704507e-06 0.1598237474547246 1.029092241020952e-06 0.1586229753023833 \
1.029092324500659e-06 0.1576763029943549 1.029092426029949e-06 0.1565306813704828 1.029092503260486e-06 0.1556635090415242 1.029092594132523e-06 0.154647919213242 \
1.029092663483833e-06 0.1538765336840219 1.029092748067885e-06 0.1529397840535594 1.029092822461091e-06 0.1521208717489242 1.029092901831293e-06 0.151251902275755 \
1.029092976418964e-06 0.1504388356812226 1.029093045640521e-06 0.1496871728711989 1.029093140321328e-06 0.1486640077242138 1.029093210087093e-06 0.1479134441579097 \
1.029093294531656e-06 0.147008717574758 1.029093356097002e-06 0.1463518850554192 1.029093430139493e-06 0.1455673550676988 1.029093503525017e-06 0.1447940960774066 \
1.029093584960259e-06 0.1439395015691976 1.029093654409405e-06 0.1432139999234875 1.029093729511102e-06 0.1424323701137583 1.029093819423173e-06 0.1415006120834361 \
1.029093896506793e-06 0.1407052977810757 1.029093995617377e-06 0.1396885207473417 1.02909406515744e-06 0.138983077430453 1.029094146475916e-06 0.1381612812129989 \
1.029094216644325e-06 0.1374549162714094 1.029094295612438e-06 0.1366629455350578 1.029094374590721e-06 0.1358740351737466 1.02909444691251e-06 0.1351544405911459 \
1.029094516277969e-06 0.1344667589602006 1.029094564981977e-06 0.1339854049281765 1.029094655744348e-06 0.1330945614011112 1.029094687765876e-06 0.1327823711724506 \
1.029094775869844e-06 0.131925672678654 1.029094808363886e-06 0.1316105445757083 1.029094907031544e-06 0.1306564447580443 1.029094950687519e-06 0.130235859061297 \
1.029095028669336e-06 0.1294866595045693 1.029095066000294e-06 0.1291289430202982 1.029095168151694e-06 0.128153223240932 1.029095235595654e-06 0.1275115375392494 \
1.029095300748611e-06 0.1268935577290946 1.029095366654626e-06 0.1262729746041904 1.029095437806609e-06 0.1256052797936485 1.02909552074397e-06 0.1248293808775363 \
1.029095606139451e-06 0.1240331657139879 1.029095682226845e-06 0.1233259817834828 1.029095762687521e-06 0.1225806238777534 1.029095820771462e-06 0.1220441728027253 \
1.029095892104936e-06 0.1213870835332726 1.029095976893369e-06 0.1206085709991845 1.029096038048402e-06 0.1200487744399507 1.029096108134853e-06 0.1194096117168642 \
1.029096170640142e-06 0.1188419501154776 1.02909623664509e-06 0.1182453094891599 1.029096305417857e-06 0.1176255789053269 1.029096374874481e-06 0.1170017375875525 \
1.029096458038731e-06 0.1162574953874909 1.029096531156255e-06 0.1156056107435251 1.029096601870241e-06 0.1149774116339468 1.029096661221924e-06 0.1144518657417393 \
1.029096766519136e-06 0.1135239342411639 1.02909681238663e-06 0.1131212254602471 1.029096899340683e-06 0.1123603821649216 1.029096942354464e-06 0.1119852310621949 \
1.029096987221211e-06 0.1115947726395539 1.029097076954706e-06 0.1108164664143028 1.029097147839057e-06 0.110204256460374 1.029097226692571e-06 0.109525796983828 \
1.029097289470346e-06 0.1089876103666232 1.029097349464702e-06 0.1084750215669379 1.029097460462474e-06 0.1075310013968523 1.02909754121676e-06 0.1068475792877216 \
1.029097653680086e-06 0.1059005796323111 1.029097704824629e-06 0.1054717782906781 1.029097787809798e-06 0.1047785948356612 1.029097845974503e-06 0.1042945647727652 \
1.029097960212503e-06 0.1033482075721767 1.02909801011597e-06 0.1029366076865433 1.029098095857569e-06 0.1022320954501846 1.02909814488902e-06 0.1018307629303728 \
1.029098227455441e-06 0.101157455862875 1.029098298387777e-06 0.1005815064560546 1.029098366538127e-06 0.1000302812267231 1.029098444148443e-06 0.0994053199805509 \
1.029098516491814e-06 0.09882546240595018 1.029098594067778e-06 0.09820656846618626 1.029098682738439e-06 0.09750287271560702 1.029098756553227e-06 0.09692010793638871 \
1.029098838144235e-06 0.09627924899616347 1.029098916282703e-06 0.09566870926115327 1.029099002032493e-06 0.09500229249765579 1.029099089729402e-06 0.09432453920671229 \
1.029099183638967e-06 0.09360304191323381 1.029099280098285e-06 0.09286661217778783 1.029099358728946e-06 0.09226977907248698 1.029099461452546e-06 0.09149473120661993 \
1.029099545280196e-06 0.09086620530027881 1.029099666032378e-06 0.08996702094116031 1.029099795302029e-06 0.08901247130467421 1.029099951190493e-06 0.08787237469953549 \
1.029100106290076e-06 0.08675000010972149 1.029100263305882e-06 0.08562614142917294 1.029100443326735e-06 0.08435280068725284 1.029100593847601e-06 0.08330035525696428 \
1.029100742221624e-06 0.08227363395463329 1.029100879838855e-06 0.08133079092382095 1.029101019758505e-06 0.08038162993974078 1.029101156365493e-06 0.07946425488810546 \
1.029101295092791e-06 0.07854214404995859 1.029101440403653e-06 0.07758663187171365 1.029101588151466e-06 0.07662571164688473 1.029101746748333e-06 0.07560598447141591 \
1.029101911000851e-06 0.07456266320243836 1.029102080017927e-06 0.07350246718885647 1.029102261906921e-06 0.07237646636762114 1.029102462529019e-06 0.07115268999588262 \
1.029102676406562e-06 0.0698691158856425 1.029102904040694e-06 0.0685263410462881 1.029103145626235e-06 0.06712722147996912 1.029103427215414e-06 0.06552977831071743 \
1.029103724369535e-06 0.06388229915275011 1.029104047802612e-06 0.06213267023812474 1.029104438962031e-06 0.0600758559534558 1.029104840456333e-06 0.05803293250078725 \
1.029105217397059e-06 0.05617754872181892 1.029105584510791e-06 0.05442503025024555 1.029105934627471e-06 0.05280240270907886 1.029106253933125e-06 0.05136309724710254 \
1.029106558257407e-06 0.05002640192327024 1.029106855163313e-06 0.04875503464657577 1.029107137163638e-06 0.04757867888787161 1.029107417596943e-06 0.04643900623749339 \
1.029107682320567e-06 0.04538777697325767 1.029107958218279e-06 0.04431704973151576 1.029108232683143e-06 0.04327654260273706 1.029108531102423e-06 0.04217254828989973 \
1.02910875761848e-06 0.04135316230013186 1.029109069531318e-06 0.04025053053625379 1.029109289786109e-06 0.03948972371590862 1.029109507050863e-06 0.03875470657060948 \
1.029109716773513e-06 0.03806113111453101 1.0291100269559e-06 0.03705828856757609 1.029110249553778e-06 0.03635538859683734 1.029110496919279e-06 0.03559019656168042 \
1.029110769325656e-06 0.03476651972027592 1.029110989958209e-06 0.03411384091885184 1.02911127423846e-06 0.03329124852897781 1.029111512151752e-06 0.0326183788879464 \
1.029111750241164e-06 0.03195887699386461 1.029111985496492e-06 0.03132132139405813 1.029112214275199e-06 0.03071728735992773 1.029112447005948e-06 0.03011490821398154 \
1.029112666308989e-06 0.02955843195412813 1.02911287025206e-06 0.02905055018162466 1.029113269161796e-06 0.02808303002558106 1.029113456316051e-06 0.02764052191221165 \
1.029113828521772e-06 0.0267814187683372 1.029114015473295e-06 0.02635997027055515 1.029114384827242e-06 0.02554620807076183 1.02911453848041e-06 0.02521471147941385 \
1.029114954694564e-06 0.02434161493068329 1.029115160182381e-06 0.02392065165079968 1.029115499190341e-06 0.02323955384462723 1.029115681885069e-06 0.02287916718068597 \
1.029116138978978e-06 0.02199597290476789 1.029116268719714e-06 0.02174967209293581 1.029116722140138e-06 0.02089828923199067 1.02911686451243e-06 0.0206336680476187 \
1.029117394079191e-06 0.01967289368906444 1.029117520286197e-06 0.01945139161001456 1.029118082520635e-06 0.01850749734048266 1.029118245259022e-06 0.01824627541187189 \
1.029118809439087e-06 0.01738327200207762 1.029118961183154e-06 0.01716165742474803 1.029119662862638e-06 0.01618760396393164 1.029119832951728e-06 0.01596324388168 \
1.029120488009604e-06 0.01513221026437959 1.029120654523916e-06 0.01492874613340729 1.029121387637676e-06 0.01406966818047924 1.029121520900854e-06 0.01391906482409888 \
1.029122372558029e-06 0.01299647369571925 1.029122510500477e-06 0.01285324185793544 1.029123450559967e-06 0.0119198170026788 1.029123614321604e-06 0.01176347583728811 \
1.029124601555038e-06 0.01085909507266535 1.029124736144115e-06 0.0107410715025141 1.029125877583545e-06 0.009819907073012045 1.029125985822443e-06 0.009738548299709823 \
1.029127309069827e-06 0.00880579379490502 1.029127441815525e-06 0.008718202093769473 1.02912896431665e-06 0.007760835273143199 1.029129076858719e-06 0.007690148685505111 \
1.029130769150306e-06 0.00669558715138598 1.029130909416891e-06 0.00662113250846694 1.029132982426194e-06 0.005629132576249021 1.029133174987711e-06 0.005545002188831318 \
1.029135385197559e-06 0.004656096148610405 1.029135791984232e-06 0.004507219767123045 1.029138613724209e-06 0.003590578528330178 1.029139135019959e-06 0.00344214578404881 \
1.029143347121009e-06 0.002447529662748036 1.029143899683877e-06 0.002340875287107731 1.029149782973417e-06 0.001359168649576994 1.029150032246415e-06 0.001311490127959886 \
1.029163182367465e-06 0.0003136950974005476 1.029163299150435e-06 0.0003112730584132499 1.058990000000011e-06 3.042397160644726e-06 1.102746667027013e-06 -0.0009024818035526668 \
1.102746739442629e-06 -0.001022682652537627 1.102747175467347e-06 -0.001858525046639076 1.10274726236173e-06 -0.002046124893065343 1.102747617065043e-06 -0.00288168582347465 \
1.102747716611644e-06 -0.003135075204051477 1.102747976881349e-06 -0.003828199033013717 1.10274811720375e-06 -0.004216406518003108 1.102748344689832e-06 -0.004856871791621592 \
1.102748481897271e-06 -0.005239031028659006 1.10274886679612e-06 -0.006187559915121 1.102748998893307e-06 -0.006423332025500122 1.102749687336335e-06 -0.005917035979538006 \
1.102749844265069e-06 -0.005202654566481615 1.102749971914231e-06 -0.004414133290428114 1.102750099456022e-06 -0.003433350487145549 1.102750217130233e-06 -0.002355902309038119 \
1.10275031626992e-06 -0.001320627313728655 1.10275042165263e-06 -9.507383675133965e-05 1.102750535559933e-06 0.001369964538583592 1.102750666615329e-06 0.003229572948258866 \
1.102750791978547e-06 0.005172303930030842 1.102750983820411e-06 0.008432154569684791 1.102751127490204e-06 0.01107975669588844 1.102751285472017e-06 0.01417105828876112 \
1.102751434071664e-06 0.01723098336859398 1.102751587122593e-06 0.02051714008521248 1.102751746187569e-06 0.02405720796424875 1.102751899257778e-06 0.02756764950178633 \
1.102752047604842e-06 0.03105219347129199 1.102752196711284e-06 0.03462388853332505 1.102752351275713e-06 0.03838854885099419 1.102752511961677e-06 0.04235886888523473 \
1.102752676640863e-06 0.04647718198980624 1.102752853163807e-06 0.05093664320808645 1.102753032175606e-06 0.05549818742091989 1.102753222948448e-06 0.0603932190016783 \
1.1027534277958e-06 0.06567927942044927 1.102753648293053e-06 0.07139554989571946 1.102753881211021e-06 0.07745499876455469 1.102754130458799e-06 0.08395499695136356 \
1.102754403380327e-06 0.09108394918256098 1.102754700173383e-06 0.09884095133633181 1.102755027609896e-06 0.1073964775374675 1.102755397423694e-06 0.1170487607486894 \
1.102755792369976e-06 0.1273407304921971 1.102756250458528e-06 0.1392499850125259 1.102756782558388e-06 0.1530377249371455 1.102757408110397e-06 0.169180864038255 \
1.102758094102463e-06 0.1867931863309214 1.102758896945878e-06 0.2072766958045763 1.10275979625821e-06 0.2300508264895909 1.102760696698323e-06 0.2526618731709107 \
1.102761498589855e-06 0.2726215666318766 1.102762194096996e-06 0.2897857674353052 1.102762826931282e-06 0.3052728323588638 1.102763422339773e-06 0.3197161646377594 \
1.102763969382815e-06 0.3328722959176427 1.102764503143162e-06 0.3455929446372428 1.102765022382586e-06 0.3578476146335662 1.102765529774049e-06 0.3697097539883151 \
1.102766033395218e-06 0.3813674725871593 1.102766545138114e-06 0.3930934709428262 1.102767052299123e-06 0.404595334768291 1.102767582595137e-06 0.4164962117964878 \
1.102768068708626e-06 0.4272847049163567 1.102768546816947e-06 0.437781779057129 1.102768986249071e-06 0.4473362978389137 1.102769109408535e-06 0.4500002106608159 \
1.102769355727463e-06 0.4553046876287923 1.102769698999458e-06 0.4626558934952216 1.102770010436459e-06 0.4692815017887791 1.102770261147724e-06 0.4745855323881177 \
1.102770531976868e-06 0.480281321066213 1.102770868458777e-06 0.4873122872019196 1.102771224467388e-06 0.4946959640027882 1.102771541737556e-06 0.5012322602315481 \
1.102771780618105e-06 0.506122906570856 1.102772021646287e-06 0.5110269393752048 1.102772273577991e-06 0.5161276795544476 1.102772513731835e-06 0.5209621749612534 \
1.102772736483296e-06 0.5254248476203834 1.102772925040943e-06 0.5291850880529715 1.102773139790987e-06 0.5334523706207774 1.102773354339378e-06 0.5376948565446859 \
1.10277361310367e-06 0.5427871977552768 1.102773863931242e-06 0.5477009885064807 1.102774119350104e-06 0.5526782776843104 1.102774470392629e-06 0.5594898819265107 \
1.102774735000954e-06 0.5645984056527484 1.10277500141751e-06 0.569709962982798 1.10277526193182e-06 0.5746801970751495 1.102775529021882e-06 0.5797469183389945 \
1.102775772159962e-06 0.5843213438768613 1.102776027852189e-06 0.5890994944692448 1.102776255671159e-06 0.5933243819692556 1.102776493215979e-06 0.5976999800355528 \
1.102776704606465e-06 0.6015679915939678 1.102776916747224e-06 0.6054277082074113 1.102777105936602e-06 0.6088479815213901 1.10277723709492e-06 0.6112112531841202 \
1.102777369391478e-06 0.6135871094428261 1.102777554614204e-06 0.6169015645304802 1.102777716636591e-06 0.6197943209800671 1.102777875055755e-06 0.6226100751126036 \
1.102778009167621e-06 0.6249846001944386 1.102778181488729e-06 0.6280247049765127 1.102778310427531e-06 0.6302937061188456 1.102778430805044e-06 0.6324061607157294 \
1.102778571333915e-06 0.634864734791624 1.102778764419407e-06 0.6382321981637986 1.102778914230185e-06 0.6408363654380513 1.10277908153778e-06 0.6437327988167145 \
1.102779262592003e-06 0.6468572757970242 1.102779465918433e-06 0.6503523798695617 1.102779648771588e-06 0.6534819287355287 1.102779819395834e-06 0.6563879501053153 \
1.102779996860074e-06 0.6594029650344411 1.102780162839025e-06 0.6622113135173925 1.102780320075814e-06 0.6648594636266301 1.102780460561866e-06 0.6672075432495704 \
1.102780604291994e-06 0.6695987751186935 1.102780737338985e-06 0.6718055529208897 1.102780879311128e-06 0.6741523780906628 1.102780999371661e-06 0.6761293215200647 \
1.102781144309748e-06 0.6785098354674278 1.102781260306798e-06 0.6804095298668216 1.102781379886685e-06 0.6823647593763783 1.10278147884666e-06 0.68397755359623 \
1.102781597355078e-06 0.6859039329668146 1.10278168439936e-06 0.6873150904607619 1.102781806410179e-06 0.6892866586554622 1.102781905332791e-06 0.6908817703737582 \
1.102781997228166e-06 0.6923536807698466 1.102782097196705e-06 0.6939486118486815 1.102782195442366e-06 0.6955126686751646 1.102782287156128e-06 0.6969676095571918 \
1.10278239128907e-06 0.698613189139943 1.102782527015812e-06 0.7007470979739818 1.102782681624274e-06 0.7031613517373301 1.102782816731986e-06 0.7052558942641604 \
1.102782963068532e-06 0.7075085519458914 1.102783091536073e-06 0.7094732734147607 1.102783215720207e-06 0.7113609898537658 1.102783325624507e-06 0.7130225953369277 \
1.102783442207576e-06 0.7147759898693785 1.102783542385407e-06 0.7162749667021007 1.102783679474215e-06 0.7183149847558421 1.102783799463242e-06 0.7200901405411056 \
1.10278391857669e-06 0.7218426783097279 1.102784045072077e-06 0.723693513465353 1.102784170939449e-06 0.7255245570057045 1.102784293560468e-06 0.7272980597885179 \
1.102784421177991e-06 0.7291334326655684 1.102784551426783e-06 0.7309957624152177 1.102784673019733e-06 0.73272442801297 1.102784811788425e-06 0.7346853525547948 \
1.102784912196869e-06 0.7360963845229137 1.102785015584257e-06 0.7375412410987998 1.1027851092447e-06 0.7388443755773992 1.102785220866297e-06 0.7403895158541485 \
1.102785307334899e-06 0.7415798421827293 1.10278540819801e-06 0.7429609798983192 1.102785540294732e-06 0.7447573558536402 1.102785649496034e-06 0.7462323422761349 \
1.102785754027664e-06 0.747635567415085 1.102785877674145e-06 0.7492836897664436 1.10278602637058e-06 0.7512497161812216 1.102786148251239e-06 0.7528480713857697 \
1.102786261855803e-06 0.7543274008692354 1.102786402375488e-06 0.7561429069656862 1.10278654356493e-06 0.7579511824827749 1.102786661311106e-06 0.7594470562859095 \
1.102786790000766e-06 0.7610693809796742 1.102786932555413e-06 0.7628512182523866 1.102787048411964e-06 0.7642872416835913 1.10278719417523e-06 0.7660789429779771 \
1.102787316007677e-06 0.7675637574673733 1.102787434476374e-06 0.7689965471136999 1.102787557264006e-06 0.7704700089613156 1.102787683416889e-06 0.7719718272910862 \
1.102787793785939e-06 0.7732757954107932 1.102787919217035e-06 0.7747465774777432 1.102788024698746e-06 0.775974259539018 1.102788157865176e-06 0.7775122819577122 \
1.102788280546631e-06 0.7789173428708996 1.102788415309674e-06 0.7804473432620218 1.102788525980962e-06 0.7816923373676121 1.102788635302591e-06 0.7829118427552927 \
1.102788770435026e-06 0.7844048889494442 1.10278892121405e-06 0.7860523747618094 1.102789061582958e-06 0.7875692293014268 1.102789181294483e-06 0.7888502570533434 \
1.102789319548824e-06 0.7903153082715967 1.102789442919159e-06 0.7916096503654788 1.102789588017784e-06 0.7931164937536124 1.102789727758043e-06 0.7945521172774316 \
1.102789854939467e-06 0.7958455533278409 1.10278997397922e-06 0.7970449251022731 1.102790086337411e-06 0.7981670522831598 1.102790190566191e-06 0.79919939674296 \
1.102790285905002e-06 0.8001364844871954 1.102790422193112e-06 0.8014634245741865 1.102790539085656e-06 0.8025894467082511 1.102790658725145e-06 0.8037305025474466 \
1.102790780606717e-06 0.8048811831579785 1.102790902985054e-06 0.8060245537852575 1.102791031013733e-06 0.8072081965553952 1.102791155658532e-06 0.8083483262222385 \
1.102791286157279e-06 0.8095291977395493 1.102791412617707e-06 0.8106611567088965 1.102791539743675e-06 0.8117869190804841 1.102791644861151e-06 0.8127087429624065 \
1.102791750111341e-06 0.8136235164943317 1.102791841251591e-06 0.8144090748259969 1.102791964669625e-06 0.8154632009865571 1.102792051748274e-06 0.8162003374872545 \
1.102792151070959e-06 0.8170344894488412 1.102792295992703e-06 0.8182390501293432 1.102792432261206e-06 0.8193582434421302 1.102792541723485e-06 0.8202477434185359 \
1.102792687843586e-06 0.8214214001843773 1.102792839202198e-06 0.8226208465286928 1.10279296500612e-06 0.8236052915965452 1.102793109416779e-06 0.824721541823094 \
1.10279323401773e-06 0.8256729463037898 1.102793384729791e-06 0.8268094083523665 1.10279352010105e-06 0.8278169867326588 1.102793645303979e-06 0.8287379047458127 \
1.102793762973362e-06 0.829593908450195 1.102793908801339e-06 0.8306418458276996 1.10279407529732e-06 0.8318207857986918 1.102794206154408e-06 0.8327345044534114 \
1.102794379603848e-06 0.833928356718921 1.102794547722322e-06 0.8350667646575466 1.102794717596124e-06 0.8361988603660855 1.102794898450754e-06 0.8373843006762304 \
1.102795041633135e-06 0.8383085120571983 1.102795155746479e-06 0.8390361588138326 1.10279528581247e-06 0.8398559950134801 1.102795387687706e-06 0.8404909448220066 \
1.102795504566998e-06 0.8412116130393378 1.102795641678929e-06 0.8420465258793415 1.102795839559572e-06 0.843231707656198 1.102796031345765e-06 0.8443585547012582 \
1.102796240708828e-06 0.8455646258450146 1.102796422822406e-06 0.846593677725298 1.102796619917178e-06 0.8476867969181797 1.102796793185875e-06 0.8486305714188691 \
1.102796976264561e-06 0.8496104335327738 1.102797147401587e-06 0.8505103231661706 1.102797322080438e-06 0.8514128411730317 1.102797497318728e-06 0.8523022053693007 \
1.102797673458367e-06 0.8531802340241421 1.102797863809624e-06 0.8541115036082744 1.10279805438677e-06 0.855025905954957 1.102798254818193e-06 0.8559685891497206 \
1.102798447410669e-06 0.8568563992305701 1.102798658273806e-06 0.8578086227668252 1.102798886187182e-06 0.8588150784816577 1.102799152217719e-06 0.8599606428795262 \
1.102799450738801e-06 0.8612090806949765 1.102799726692482e-06 0.8623286542354505 1.102800010954596e-06 0.8634483918036945 1.102800285103046e-06 0.8644969441068078 \
1.102800557392313e-06 0.8655088801415273 1.102800827558089e-06 0.8664846790737442 1.102801084736186e-06 0.8673881555543895 1.102801357299353e-06 0.868319368003445 \
1.102801633304697e-06 0.8692355072818493 1.102801903418629e-06 0.870106770567397 1.102802203245002e-06 0.8710447971670072 1.102802574222291e-06 0.8721640818024149 \
1.102802869154012e-06 0.8730224021943973 1.102803123432376e-06 0.873740732376842 1.102803421677207e-06 0.8745584461000401 1.102803695285219e-06 0.8752856917963749 \
1.102803931415444e-06 0.8758961959341748 1.102804171760979e-06 0.8765017794770257 1.102804394097168e-06 0.8770481951318053 1.102804588102451e-06 0.8775144010549708 \
1.102804917823794e-06 0.8782846129827527 1.10280507299682e-06 0.8786376896881318 1.102805390752408e-06 0.8793424631377607 1.102805569616983e-06 0.8797286397841958 \
1.102805912078462e-06 0.8804474051285093 1.102806096217817e-06 0.880822800830328 1.102806571118475e-06 0.881756283451624 1.102806738513154e-06 0.8820737784441692 \
1.1028072043462e-06 0.8829272622221894 1.102807385170493e-06 0.8832470363605239 1.102807879204793e-06 0.8840891816604841 1.102808020548669e-06 0.8843218944112644 \
1.102808626940586e-06 0.8852805359894154 1.102808779011766e-06 0.8855111592597558 1.102809425691436e-06 0.8864506941541785 1.102809553987642e-06 0.8866295550025313 \
1.102810202164815e-06 0.8874976172723908 1.102810331923675e-06 0.8876644392549727 1.102811100144497e-06 0.8886037370453904 1.102811229881009e-06 0.8887539063021698 \
1.102812083306654e-06 0.8896836309705964 1.102812226565088e-06 0.8898301468060963 1.102813212785821e-06 0.890764641901611 1.102813434267227e-06 0.8909571971396437 \
1.102814577308628e-06 0.8918770673440963 1.102814707298117e-06 0.8919774876506176 1.102816058923389e-06 0.8929731820841386 1.10281620928357e-06 0.89307657739048 \
1.102817689916169e-06 0.8939986636922405 1.102817928817934e-06 0.8941315911431026 1.102819693311633e-06 0.894999985510941 1.102820000994978e-06 0.8951330875684044 \
1.102822522266181e-06 0.8960612226716312 1.102822959317422e-06 0.8961978289811912 1.102826862729643e-06 0.8971619289239613 1.10282710951145e-06 0.8972094058147089 \
1.102834686001284e-06 0.8981998139535015 1.102834801913031e-06 0.8982099955090975 1.102853900445735e-06 0.8992062631372056 1.102854297888509e-06 0.8992194728667773 \
1.10300471332359e-06 0.9002121614362558 1.103004979381947e-06 0.9002436812458944 1.103010247532015e-06 0.8993470931706574 1.103010453902932e-06 0.899191170936528 \
1.103011932015742e-06 0.8982046351054961 1.103012112466399e-06 0.8981003355419954 1.103014334948061e-06 0.8971299612768925 1.103014541040576e-06 0.897079983173831 \
1.103024949306681e-06 0.8980580240048047 1.103025087164257e-06 0.8980839755683444 1.103031884513298e-06 0.8990685088718567 1.103032070084766e-06 0.8990874390200084 \
1.103528299258968e-06 0.9000706848616691 1.103528359054814e-06 0.9000975977971888 1.103529612605432e-06 0.9010828413531861 1.103529718298035e-06 0.9012097231395001 \
1.103530376428752e-06 0.9021613947651476 1.103530513611021e-06 0.9023918767045529 1.103531036637641e-06 0.9033649777562528 1.103531099501233e-06 0.9034908765919824 \
1.103531572096782e-06 0.904476514442582 1.103531623410596e-06 0.9045863669199017 1.103532089373931e-06 0.9055619780118375 1.103532121578392e-06 0.9056252631670594 \
1.103532838677129e-06 0.9066212416280413 1.103532923113402e-06 0.9066528951765993 1.103533523179781e-06 0.9059679814895146 1.103533643037393e-06 0.9055903401525059 \
1.103533774200172e-06 0.9050640446667092 1.103533909019925e-06 0.9043926011431642 1.103534057154984e-06 0.9034897747335404 1.103534194714335e-06 0.902493211317788 \
1.103534334926095e-06 0.9013135799985507 1.103534433588205e-06 0.9003872218501816 1.103534519272014e-06 0.8995148096066522 1.103534601836213e-06 0.8986166894493001 \
1.103534716618842e-06 0.8972773101170661 1.103534797717086e-06 0.8962642459447687 1.103534877134364e-06 0.8952218112132616 1.103534982588892e-06 0.8937633947192651 \
1.103535105230195e-06 0.8919606744930825 1.103535204954274e-06 0.890414036797163 1.103535375148685e-06 0.8876203405523397 1.103535521333777e-06 0.8850727273800474 \
1.103535689551925e-06 0.8819879035815887 1.103535861713021e-06 0.8786780617039783 1.103536046099114e-06 0.8749807502679057 1.103536230665458e-06 0.8711418063496947 \
1.103536414912944e-06 0.8671917613865908 1.103536600248607e-06 0.8631174608718694 1.103536774636335e-06 0.8592060069639053 1.103536957340272e-06 0.8550405244181323 \
1.103537132687366e-06 0.8509893565349284 1.103537315016877e-06 0.8467313026054767 1.103537505330306e-06 0.8422468264612591 1.103537675660435e-06 0.838204894125699 \
1.103537842184074e-06 0.8342320488410089 1.103538004754937e-06 0.830337741667393 1.10353815461616e-06 0.8267359097041467 1.103538305792179e-06 0.8230937075736249 \
1.103538494937653e-06 0.8185270080344306 1.103538640655707e-06 0.8150026134285653 1.103538815646674e-06 0.8107652770601156 1.103538964118217e-06 0.807166938184282 \
1.103539136005683e-06 0.8029987283123258 1.103539305073922e-06 0.7988973224349885 1.103539469252632e-06 0.7949140139776875 1.103539628580169e-06 0.7910485911592836 \
1.103539789029776e-06 0.7871568543472617 1.103539990849157e-06 0.7822630953020117 1.103540139296892e-06 0.7786646206504594 1.103540293464276e-06 0.77492821376164 \
1.103540430547636e-06 0.7716074476660475 1.103540539933082e-06 0.7689587163513494 1.103540645866538e-06 0.7663946531324515 1.103540772880885e-06 0.7633217481666642 \
1.103540887243854e-06 0.7605561828888391 1.103540990091676e-06 0.7580702160470256 1.103541111681993e-06 0.7551325442760125 1.103541222459267e-06 0.7524575925939972 \
1.103541339308092e-06 0.7496376180588871 1.103541450092818e-06 0.7469652567786068 1.103541568458919e-06 0.7441116745915923 1.103541693286014e-06 0.7411038668912771 \
1.10354184584781e-06 0.7374292753756717 1.103541979744798e-06 0.7342062928952946 1.103542100776237e-06 0.7312947572377408 1.103542264973752e-06 0.7273475399259534 \
1.103542442334699e-06 0.7230877912371642 1.103542624545107e-06 0.7187161681757385 1.103542805542373e-06 0.7143786395952922 1.103542986206316e-06 0.7100537072471783 \
1.103543176357883e-06 0.7055071781827296 1.103543364117777e-06 0.7010230964996226 1.103543564650881e-06 0.696237807975249 1.103543773336343e-06 0.6912646166759551 \
1.103543980979908e-06 0.6863227581165517 1.103544208547776e-06 0.6809140411171237 1.10354440082261e-06 0.6763521085712711 1.103544638087858e-06 0.6707310800019505 \
1.103544831366122e-06 0.6661595641347996 1.103545064098869e-06 0.6606646229758047 1.103545269656336e-06 0.6558174602470968 1.103545502009757e-06 0.6503484594495911 \
1.103545697011728e-06 0.6457674053103037 1.103545900240336e-06 0.6410004262200759 1.103546080092881e-06 0.6367906205544323 1.103546259199312e-06 0.6326052789263827 \
1.103546422576526e-06 0.628795088826817 1.10354659462593e-06 0.6247880828503264 1.103546758118769e-06 0.6209892715878097 1.103546933908587e-06 0.6169100951581823 \
1.103547115847573e-06 0.6126978430086294 1.103547304331305e-06 0.6083422542008314 1.103547510763727e-06 0.6035858951323969 1.10354769007839e-06 0.5994633272559844 \
1.103547887257256e-06 0.5949432360761027 1.103548096345397e-06 0.5901646611556908 1.10354830209466e-06 0.5854760387944159 1.103548542605348e-06 0.5800160304866983 \
1.10354871573345e-06 0.5760958285528379 1.103548880627452e-06 0.5723746772837877 1.103549061488027e-06 0.5683014035092815 1.103549218774123e-06 0.5647722902613652 \
1.103549387756918e-06 0.5609879409349005 1.103549567863379e-06 0.5569709657351898 1.103549720846506e-06 0.5535669615732179 1.103549852560951e-06 0.5506462283231492 \
1.103549999948651e-06 0.5473865746199473 1.103550087374242e-06 0.5454560063082221 1.103550172245482e-06 0.5435860258811447 1.103550270874694e-06 0.5414171943998213 \
1.103550342966855e-06 0.5398340751058975 1.103550440057874e-06 0.5377039800781129 1.103550525648258e-06 0.5358302678688993 1.103550590729134e-06 0.5344081412607664 \
1.103550714329502e-06 0.5317121235594142 1.103550808753772e-06 0.52965475734789 1.103550906276994e-06 0.5275349985745696 1.103551079137645e-06 0.5237893654184622 \
1.103551214133166e-06 0.5208709659121862 1.103551368316628e-06 0.5175498113398643 1.103551542781984e-06 0.5138002600288881 1.10355169458797e-06 0.510550000123414 \
1.103551840818953e-06 0.5074290310664136 1.103551984717826e-06 0.5043644611166801 1.103552127739669e-06 0.5013276181140283 1.103552223349517e-06 0.499301733014788 \
1.103552317793473e-06 0.4973032961550828 1.103552438849414e-06 0.4947494705229025 1.10355253372771e-06 0.4927525559781179 1.103552649558553e-06 0.4903172469328811 \
1.103552736822402e-06 0.4884854516151125 1.103552819252848e-06 0.4867593351188191 1.103552914660802e-06 0.484765406725184 1.103553015371081e-06 0.4826639978995959 \
1.103553112231473e-06 0.4806459052877932 1.103553250961225e-06 0.4777646955734051 1.103553386666086e-06 0.4749532752442271 1.103553587150809e-06 0.4708139964547478 \
1.103553802464962e-06 0.4663911383470885 1.103553984040267e-06 0.462674698484628 1.103554183012236e-06 0.4586189944293299 1.103554353577757e-06 0.455154096457448 \
1.103554527931445e-06 0.4516251957269069 1.103554696864699e-06 0.4482170126441485 1.10355486946186e-06 0.4447467276163349 1.10355505206819e-06 0.4410867902598327 \
1.103555240617055e-06 0.4373240875354826 1.103555434084593e-06 0.4334777823509549 1.103555642405232e-06 0.4293535036700135 1.103555856750462e-06 0.4251286740881063 \
1.103556082455792e-06 0.4207018662297695 1.103556308999161e-06 0.4162771402745992 1.103556571175911e-06 0.4111844468197049 1.103556820209735e-06 0.4063709766754009 \
1.103557121308433e-06 0.4005865607947761 1.10355741072925e-06 0.3950673729298416 1.103557718243529e-06 0.3892455819062323 1.103558040439925e-06 0.3831936848847286 \
1.103558368170407e-06 0.3770882112794804 1.103558700600163e-06 0.3709500980558715 1.10355903032917e-06 0.3649083177186754 1.103559351558758e-06 0.3590729273462687 \
1.103559682375082e-06 0.3531219177045733 1.103560024730645e-06 0.3470224718704957 1.103560324371677e-06 0.3417374346434491 1.103560654159242e-06 0.3359723367088904 \
1.103560981053185e-06 0.3303128110141857 1.103561319032532e-06 0.3245206193888226 1.103561628003696e-06 0.3192755432624759 1.103561952801669e-06 0.31382336954194 \
1.103562268431866e-06 0.3085864885517507 1.103562573419032e-06 0.3035810258414895 1.103562828757677e-06 0.2994330834535801 1.103563093620834e-06 0.295170851203172 \
1.103563380703519e-06 0.2905978071194348 1.103563603673298e-06 0.2870801635277143 1.103563803212567e-06 0.2839591363066187 1.10356401286858e-06 0.2807045410859125 \
1.103564193125121e-06 0.2779290029372279 1.103564355469842e-06 0.2754463208250681 1.103564505904816e-06 0.2731629026725527 1.103564656910124e-06 0.2708866524077067 \
1.103564853800715e-06 0.2679392949564011 1.103564984945479e-06 0.2659970646012914 1.103565109682017e-06 0.2641561221543183 1.10356526127406e-06 0.2619266655689588 \
1.103565357242231e-06 0.2605306204207966 1.1035654537936e-06 0.2591282589302421 1.103565578413389e-06 0.2573209601776467 1.103565720989923e-06 0.255257422470362 \
1.103565879923458e-06 0.25296979123958 1.103566012589525e-06 0.251062957019046 1.103566196158294e-06 0.2484301322588876 1.10356637739346e-06 0.2458327969660818 \
1.103566588907565e-06 0.2428051031600066 1.103566791497399e-06 0.2399069804317323 1.103566958053847e-06 0.2375282895552967 1.103567168273059e-06 0.2345337828133105 \
1.103567341690945e-06 0.2320692345528927 1.103567570533673e-06 0.2288260787734411 1.103567791168424e-06 0.2257162440502939 1.103567966830138e-06 0.2232503232699662 \
1.103568147290643e-06 0.2207258962977968 1.103568318047021e-06 0.2183528725291195 1.103568498243287e-06 0.2158619697278009 1.103568664973905e-06 0.2135675266585953 \
1.103568814095326e-06 0.2115251542210239 1.103568969905344e-06 0.2094125291275523 1.103569105085769e-06 0.2075875692769576 1.103569255167197e-06 0.2055694209972212 \
1.103569387612823e-06 0.2037957203154137 1.10356952815736e-06 0.2019220745191926 1.103569645226124e-06 0.2003748851744883 1.10356977493373e-06 0.1986681706274326 \
1.103569896991199e-06 0.1970700654731777 1.103570019534635e-06 0.1954731161836187 1.103570137553958e-06 0.1939418157697267 1.103570272576731e-06 0.1921981789937757 \
1.103570417201182e-06 0.1903420634523806 1.103570545551681e-06 0.1887049708672087 1.103570669186156e-06 0.1871351133418249 1.103570766736279e-06 0.1859021016257166 \
1.103570881809208e-06 0.1844539912642748 1.103570975507888e-06 0.1832809848801438 1.103571074292012e-06 0.1820493959460708 1.103571197226553e-06 0.1805230483556907 \
1.103571292980556e-06 0.1793400249325384 1.103571422068107e-06 0.177753298391591 1.103571524533477e-06 0.1764993061988986 1.103571622786974e-06 0.1753029542432101 \
1.103571742874187e-06 0.1738483570896001 1.103571845423405e-06 0.1726127298531683 1.103571955881064e-06 0.1712877101305652 1.103572084370928e-06 0.1697552709290656 \
1.103572175855769e-06 0.1686698090598139 1.103572280340358e-06 0.1674358120019214 1.103572355277094e-06 0.1665544493622226 1.103572444845591e-06 0.1655049734124585 \
1.1035724954106e-06 0.164914347906921 1.103572545388976e-06 0.1643318187475747 1.103572610358061e-06 0.163576534137217 1.103572645872029e-06 0.1631646263336159 \
1.103572718071202e-06 0.162329174921529 1.103572785200297e-06 0.1615546732967998 1.103572844430032e-06 0.160873195114598 1.10357288817563e-06 0.1603710314414745 \
1.103572935822458e-06 0.1598254649913795 1.103573006202993e-06 0.1590230739426561 1.103573088541159e-06 0.1580883269013631 1.103573166712759e-06 0.1572048664554128 \
1.103573248765709e-06 0.1562816770844126 1.103573341469331e-06 0.1552436243401225 1.103573464249495e-06 0.153877370231325 1.103573563395588e-06 0.1527810927807017 \
1.103573664895935e-06 0.1516651170047695 1.103573766171127e-06 0.1505582666538253 1.103573862662911e-06 0.1495093242781697 1.103573962080946e-06 0.1484346886615803 \
1.103574046381569e-06 0.1475281828465028 1.103574139320259e-06 0.1465342051547719 1.1035742219212e-06 0.1456551508734999 1.103574330687285e-06 0.1445034822456445 \
1.103574436330265e-06 0.1433917535370727 1.103574517989854e-06 0.1425365900703354 1.103574611735024e-06 0.1415598856352903 1.103574705302971e-06 0.1405903867550886 \
1.103574788187461e-06 0.139735765814107 1.103574876346636e-06 0.1388313836440244 1.103574956132722e-06 0.1380170907865772 1.103575049728122e-06 0.1370669869522621 \
1.103575139660646e-06 0.1361590166429519 1.103575210211042e-06 0.1354501541392388 1.103575279971219e-06 0.1347521119166949 1.103575394120126e-06 0.1336164586193709 \
1.10357547609874e-06 0.1328058651355588 1.103575563704042e-06 0.1319440719770354 1.103575663205238e-06 0.1309710196939938 1.103575772385241e-06 0.1299110174488692 \
1.103575874550573e-06 0.1289256009328031 1.103575982010779e-06 0.1278959836800649 1.103576102045057e-06 0.1267549558890445 1.103576196253091e-06 0.1258657925752028 \
1.103576327232195e-06 0.1246390638240933 1.103576426659896e-06 0.1237164070883829 1.103576535781582e-06 0.1227104370444639 1.10357664463475e-06 0.1217138859540913 \
1.103576736944154e-06 0.120874257454373 1.103576849784484e-06 0.1198547128626846 1.103576946796524e-06 0.118986084968971 1.103577051062872e-06 0.1180628196869088 \
1.103577160029802e-06 0.1171053395831002 1.103577259569368e-06 0.1162371554254778 1.103577376562078e-06 0.1152245300989246 1.103577463662868e-06 0.1144761644999183 \
1.10357757295452e-06 0.1135478691973115 1.103577654479583e-06 0.1128618460838699 1.103577754254576e-06 0.1120273350449922 1.103577871679726e-06 0.1110526766231405 \
1.103577973464844e-06 0.1102143708571793 1.103578061203792e-06 0.1094962336869811 1.1035781420033e-06 0.1088432886892514 1.103578228954319e-06 0.1081456845520918 \
1.103578309740945e-06 0.1075007757815706 1.103578399947511e-06 0.1067842832273628 1.103578490898266e-06 0.1060655611559195 1.10357857956879e-06 0.1053685613006139 \
1.103578678583611e-06 0.1045946508745568 1.103578772289787e-06 0.1038723470842792 1.103578866149063e-06 0.1031520741219857 1.103578966976511e-06 0.1023817709659086 \
1.103579071607409e-06 0.1015861061604995 1.103579195570165e-06 0.1006484085638475 1.103579292969478e-06 0.09991551135558702 1.103579413227425e-06 0.09901872452754552 \
1.1035795240953e-06 0.09819831936474602 1.103579628568336e-06 0.09742874659471555 1.103579745805045e-06 0.09656937225591002 1.103579847599366e-06 0.09582695326576983 \
1.103579945574917e-06 0.09511577589263259 1.103580086079406e-06 0.09410164141823299 1.103580191157202e-06 0.09334832721827611 1.103580289770019e-06 0.09264549593674179 \
1.103580382484827e-06 0.09198739948435641 1.103580468683212e-06 0.09137785861853052 1.103580562596188e-06 0.09071637432184691 1.103580659696934e-06 0.09003559055802626 \
1.103580769117988e-06 0.08927317549644689 1.103580870101537e-06 0.08857281843916648 1.103580963759483e-06 0.08792605868920525 1.103581037934155e-06 0.08741581771673042 \
1.103581175834007e-06 0.08647193599618339 1.103581248191011e-06 0.08597917321277694 1.103581383512214e-06 0.08506274029062395 1.103581469423819e-06 0.08448410751389913 \
1.103581614152054e-06 0.08351486081643937 1.103581710382619e-06 0.0828744112740944 1.103581798218398e-06 0.08229260392026354 1.103581914017306e-06 0.08152964121883956 \
1.103582029145757e-06 0.08077575264951149 1.10358214291219e-06 0.08003553900012179 1.103582283169683e-06 0.0791300282244784 1.103582424545716e-06 0.07822490276368012 \
1.103582574181758e-06 0.07727536491519127 1.103582718670613e-06 0.07636690312463701 1.103582869844724e-06 0.07542565384097814 1.103583019215543e-06 0.07450459906593411 \
1.103583168562251e-06 0.0735926433331697 1.103583328517767e-06 0.07262574717347114 1.103583484664678e-06 0.07169171823582712 1.103583659153112e-06 0.07065947636250877 \
1.103583828862219e-06 0.0696671357044583 1.103584014041303e-06 0.0685979885997255 1.10358421076238e-06 0.06747763456279594 1.1035844212802e-06 0.06629631776014881 \
1.103584643312255e-06 0.06507007089066431 1.103584873524276e-06 0.0638195278444372 1.103585116035382e-06 0.06252626147401 1.103585376689467e-06 0.06116236403900636 \
1.103585656588531e-06 0.05972739422233359 1.103585950172255e-06 0.05825544847408989 1.103586265108239e-06 0.05671370145268265 1.103586607914164e-06 0.05507846134953124 \
1.103586957380758e-06 0.0534565727116736 1.103587366284915e-06 0.05161746230842366 1.103587712949942e-06 0.05010669351290297 1.103588100364996e-06 0.04846839895323611 \
1.103588444582788e-06 0.04705645202362623 1.103588768009047e-06 0.04576625679949029 1.103589073054809e-06 0.04458093278443617 1.103589365916806e-06 0.04347099288378908 \
1.103589650057723e-06 0.04242242262004604 1.103589926078015e-06 0.04142902112907627 1.103590192930566e-06 0.04049015932812138 1.103590461822789e-06 0.03956531631184226 \
1.103590737883211e-06 0.03863769040165695 1.103591025478782e-06 0.03769451689421055 1.103591265044408e-06 0.03692662498323904 1.103591554211835e-06 0.03602084344675294 \
1.103591770003438e-06 0.03535960341037672 1.103591957720476e-06 0.03479599077274986 1.103592155849582e-06 0.03421285035004928 1.103592518724446e-06 0.03317032497347058 \
1.103592776866276e-06 0.03244834222605905 1.10359308657919e-06 0.0316030971185694 1.103593352049329e-06 0.03089664771451467 1.103593620168408e-06 0.03019941363307669 \
1.103593899042439e-06 0.02949128999862272 1.103594145228876e-06 0.02888043298519722 1.103594375860285e-06 0.02832033800396738 1.103594614150204e-06 0.02775711540944564 \
1.103594849157568e-06 0.02721270742060762 1.103595076940031e-06 0.02669509678424227 1.103595485552303e-06 0.02579039168486155 1.103595661854632e-06 0.02540904040268441 \
1.103596016332316e-06 0.02465798827491217 1.103596200203288e-06 0.02427641469830137 1.10359653515201e-06 0.02359448510613503 1.103596699060727e-06 0.02326678168937357 \
1.103597091331304e-06 0.02249905491676728 1.103597247322069e-06 0.02220010404946675 1.103597678925426e-06 0.02138321689778962 1.103597816314806e-06 0.0211255367654138 \
1.103598333123589e-06 0.02017559010600388 1.103598458659483e-06 0.01995091418019728 1.103598915901007e-06 0.01915998482559782 1.103599075046989e-06 0.01889493739859509 \
1.103599682285467e-06 0.01793263500095189 1.103599816822955e-06 0.01772934138481063 1.103600480086948e-06 0.01678091027541291 1.103600673410379e-06 0.01651856846389665 \
1.103601341067039e-06 0.01565087920017967 1.103601502655887e-06 0.01544858341705342 1.10360225789114e-06 0.01454101846553843 1.103602407452107e-06 0.01436800730673201 \
1.103603297789931e-06 0.01338293844200974 1.103603396447817e-06 0.01327873262558703 1.103604353121314e-06 0.01230993787860994 1.103604474231021e-06 0.01219243157195396 \
1.10360546572373e-06 0.01126376273051215 1.10360562925246e-06 0.01111855113153209 1.103606759174536e-06 0.01018247077230436 1.103606871621774e-06 0.01009565848301377 \
1.103608249445262e-06 0.009103273453806031 1.103608388390533e-06 0.009009747578659758 1.103609942788868e-06 0.008018073335410726 1.10361005485534e-06 0.00794673960805117 \
1.10361169983817e-06 0.006958154532207958 1.103611807090664e-06 0.006899512253112593 1.103613751584152e-06 0.005937533026687714 1.10361395848211e-06 0.005843834961138424 \
1.103616297369853e-06 0.00487227039639981 1.103616721356264e-06 0.004712306502041247 1.10361949358946e-06 0.003780857497341114 1.103619941898552e-06 0.003647790772321777 \
1.103623582397237e-06 0.00272553831825111 1.103624079053072e-06 0.002619503085887757 1.103629830173496e-06 0.001650572925599863 1.103630116955383e-06 0.001609446887446839 \
1.103635471944067e-06 0.0006353228983793809 1.103635677300692e-06 0.0005920420449145349 1.106282712074507e-06 -0.0002718533828215428 1.106282867950111e-06 -0.0004579010352009555 \
1.106283416265203e-06 -0.001326296959495401 1.106283529048879e-06 -0.001543805653187533 1.106283963541018e-06 -0.002491429791030493 1.106284039366175e-06 -0.002673591589873599 \
1.106284396016773e-06 -0.003590195133438418 1.106284523065853e-06 -0.003936807634339821 1.106284801566247e-06 -0.004716444651655622 1.10628490965073e-06 -0.005020876868076652 \
1.106285253249855e-06 -0.00592430224391268 1.10628536024372e-06 -0.006162325733041658 1.106286259614116e-06 -0.005653094509861465 1.106286438047545e-06 -0.004687598829536962 \
1.10628654377096e-06 -0.003940993102967527 1.106286668833738e-06 -0.002883597584075996 1.106286762417834e-06 -0.001971418478057775 1.106286840257396e-06 -0.001132968824455395 \
1.106286920329394e-06 -0.0001977429743171 1.106287042702205e-06 0.001370578777960296 1.106287160958077e-06 0.003041212838230153 1.106287279607187e-06 0.004860750887681821 \
1.106287393089626e-06 0.006730904986417607 1.106287496532765e-06 0.008536402178002854 1.106287611192018e-06 0.01064190690353853 1.106287801775811e-06 0.0143607330143792 \
1.106287935565949e-06 0.01711819191720031 1.106288085819515e-06 0.02033933849841947 1.106288240988763e-06 0.02378599874269359 1.106288396380811e-06 0.0273434151175349 \
1.106288544088043e-06 0.03080849965087477 1.106288693077668e-06 0.03437359286003162 1.106288848068751e-06 0.03814545786868043 1.106289007439365e-06 0.04208062121327779 \
1.106289172372776e-06 0.04620305710844342 1.106289347319105e-06 0.0506208066052034 1.106289526449176e-06 0.05518387280380205 1.106289716238432e-06 0.06005265756871143 \
1.1062899199354e-06 0.06530840376289772 1.106290139745932e-06 0.07100650943730057 1.106290371497376e-06 0.07703584544314998 1.106290619322674e-06 0.08349927754587044 \
1.106290890643603e-06 0.09058756662233436 1.106291185356381e-06 0.09829181712822582 1.106291510614029e-06 0.106792896697727 1.106291876859735e-06 0.1163551101154179 \
1.106292270156448e-06 0.1266079356677421 1.106292722809344e-06 0.1383809089651769 1.106293248524511e-06 0.1520098384503803 1.106293867738049e-06 0.1679979965193872 \
1.106294548482366e-06 0.1854865650013753 1.10629534215732e-06 0.2057488551561759 1.106296230922953e-06 0.2282732214494322 1.106297044312215e-06 0.2487218262351868 \
1.106297766061792e-06 0.2667261628598245 1.1062984017258e-06 0.282460740414376 1.106298973442562e-06 0.2965101025186013 1.106299508996846e-06 0.3095696210007924 \
1.106300012355259e-06 0.3217495654069301 1.106300488682702e-06 0.3331878525640654 1.106300962606306e-06 0.3444754071334732 1.106301420078024e-06 0.3552759747331513 \
1.106301886058294e-06 0.3661792384270033 1.106302335046104e-06 0.376592601923634 1.106302831152646e-06 0.3879857357798637 1.106303350914508e-06 0.3998002499051578 \
1.106303730319152e-06 0.4083447473225827 1.106304170327876e-06 0.4181679450526055 1.106304640096814e-06 0.4285466970600206 1.106305125617752e-06 0.4391589006481625 \
1.106305565065858e-06 0.4486701556983262 1.106305626818807e-06 0.4500002248264944 1.106305750324704e-06 0.4526540461147197 1.106305997336498e-06 0.4579447795386873 \
1.106306249931409e-06 0.463325462421476 1.106306447502524e-06 0.467511453725808 1.106306673074272e-06 0.4722681264242033 1.106306994642268e-06 0.4790073975813253 \
1.106307263421497e-06 0.4846013351959894 1.10630748207297e-06 0.4891262574467725 1.106307692176936e-06 0.4934547887280634 1.106307918582462e-06 0.4980921872304203 \
1.106308127687652e-06 0.5023516957637455 1.106308317089911e-06 0.5061927337048852 1.106308441251129e-06 0.5086969563931187 1.106308568006226e-06 0.5112441466129884 \
1.106308728004704e-06 0.5144514110933732 1.106308975647656e-06 0.5193914248715521 1.106309154234115e-06 0.5229351592435862 1.106309325187692e-06 0.5263079149198099 \
1.106309586537288e-06 0.5314455197962068 1.10630981260887e-06 0.5358634945234868 1.106310015740537e-06 0.5398188128751134 1.106310180971267e-06 0.5430252218652345 \
1.106310337758288e-06 0.5460612552756139 1.106310526914905e-06 0.5497137532216215 1.106310728782659e-06 0.5535976061995346 1.106310952933981e-06 0.5578986282275192 \
1.106311191316346e-06 0.5624617013850463 1.106311426077985e-06 0.566941985223824 1.10631165634869e-06 0.5713275351537204 1.106311862141324e-06 0.5752375533958141 \
1.106312067125538e-06 0.5791255875933676 1.10631230994078e-06 0.5837094709690289 1.106312564698362e-06 0.588493349632063 1.106312792926793e-06 0.5927514274590796 \
1.106313030765665e-06 0.5971656109489694 1.106313243043101e-06 0.6010807441713891 1.106313454836505e-06 0.6049674646600495 1.106313708720774e-06 0.6095919957414236 \
1.106313913314301e-06 0.6132953190650409 1.106314165037654e-06 0.6178178328453598 1.106314352827174e-06 0.6211736970442716 1.106314605700251e-06 0.6256587164710262 \
1.106314804109613e-06 0.6291560967673944 1.106314983842284e-06 0.6323071487074056 1.106315254113091e-06 0.6370161336915187 1.106315471396857e-06 0.6407803561788556 \
1.106315651923236e-06 0.6438916924996977 1.106315853084131e-06 0.6473460740030906 1.106316021667513e-06 0.650231451944099 1.10631622602572e-06 0.6537144072723954 \
1.106316371688778e-06 0.6561873372238678 1.106316536247377e-06 0.6589728476742622 1.106316705716594e-06 0.6618316558839334 1.106316859256675e-06 0.664412775690417 \
1.106317000490202e-06 0.6667750288922751 1.106317144066014e-06 0.6691685747430841 1.106317277296139e-06 0.6713840140331436 1.106317419196459e-06 0.6737368819239464 \
1.106317539430086e-06 0.6757233098298149 1.106317684081138e-06 0.6781085120392751 1.106317800299844e-06 0.6800197521569988 1.106317919382163e-06 0.6819757159594566 \
1.106318017960477e-06 0.6835903813535821 1.106318135558183e-06 0.6855122399681081 1.106318222994146e-06 0.6869376986921233 1.106318347740232e-06 0.6889650632873403 \
1.106318447547296e-06 0.6905825000046129 1.106318540037093e-06 0.6920753042469043 1.106318641321177e-06 0.6937043390836264 1.106318739114283e-06 0.695273833970533 \
1.106318830385075e-06 0.6967333967490603 1.106318932842905e-06 0.6983656370917724 1.106319065752136e-06 0.7004728611232253 1.106319220767541e-06 0.7029137789397926 \
1.106319355649227e-06 0.7050222373350452 1.106319501145018e-06 0.7072806469370021 1.106319628999685e-06 0.709252249158637 1.106319753457981e-06 0.7111597484283609 \
1.106319864783685e-06 0.7128563623504806 1.106319978813713e-06 0.7145852226468989 1.106320079324929e-06 0.7161013069709498 1.106320216526077e-06 0.7181590832501857 \
1.106320336471979e-06 0.7199473375636642 1.106320455641778e-06 0.7217141075019444 1.106320582586792e-06 0.7235855504531626 1.106320707354209e-06 0.7254141264975077 \
1.106320830849597e-06 0.7272133847865295 1.10632095763087e-06 0.7290498056238117 1.106321088220355e-06 0.730930225429108 1.106321210432258e-06 0.7326797786847141 \
1.106321347490271e-06 0.7346298644824388 1.106321448705626e-06 0.7360619656663578 1.106321553674562e-06 0.7375401619041119 1.106321645165995e-06 0.7388229997694907 \
1.106321758241356e-06 0.7404001534680551 1.10632184554224e-06 0.7416107338190071 1.106321950005571e-06 0.7430512000342341 1.106322080768703e-06 0.7448411286358657 \
1.1063221906822e-06 0.7463352048609909 1.106322295341958e-06 0.7477488743938407 1.10632241917362e-06 0.7494094725133206 1.106322567926971e-06 0.751387874302702 \
1.106322689842132e-06 0.7529958494242643 1.106322803696393e-06 0.7544867042370438 1.10632294419585e-06 0.7563117925204224 1.106323085519364e-06 0.7581313010100689 \
1.106323203298972e-06 0.7596352654099263 1.106323331697459e-06 0.7612620174900669 1.106323474021161e-06 0.7630496612437514 1.106323590410316e-06 0.7644991888858087 \
1.106323736133978e-06 0.7662987831554334 1.106323857913867e-06 0.7677897310961733 1.106323976478797e-06 0.7692300520321635 1.106324099092246e-06 0.7707078417740018 \
1.106324225543629e-06 0.77221964326554 1.106324335666584e-06 0.7735261258099556 1.106324461188726e-06 0.7750039859681491 1.106324566849672e-06 0.7762386743660952 \
1.106324702026829e-06 0.7778058706872942 1.106324825637346e-06 0.7792267957652825 1.106324955634725e-06 0.7807078764205345 1.106325068606223e-06 0.7819831642610904 \
1.106325176500111e-06 0.7831908181350914 1.106325313030793e-06 0.7847046126527283 1.106325463151702e-06 0.7863508260127218 1.106325605416006e-06 0.7878933964149381 \
1.106325724997519e-06 0.7891771019825847 1.106325861808649e-06 0.7906313890246753 1.106325984312413e-06 0.7919206245676671 1.106326128984341e-06 0.7934276941869095 \
1.106326269769414e-06 0.794878360380241 1.106326396585209e-06 0.796171745508174 1.106326515632602e-06 0.7973744708066829 1.106326627895563e-06 0.7984986270115709 \
1.106326732283333e-06 0.7995352562746869 1.106326827560395e-06 0.8004739840425704 1.106326963902891e-06 0.8018044219089175 1.10632708076796e-06 0.8029326473252685 \
1.106327200364489e-06 0.8040757482679398 1.106327322250299e-06 0.8052288531124292 1.106327444838559e-06 0.8063765489401953 1.106327572579618e-06 0.8075599074701925 \
1.106327697362526e-06 0.8087035441861687 1.106327827862901e-06 0.8098867241643505 1.106327954229597e-06 0.8110199871086299 1.106328081578389e-06 0.8121498004723215 \
1.106328186791179e-06 0.8130740322933268 1.106328291495184e-06 0.8139855427426806 1.10632838302539e-06 0.8147757515715357 1.10632850639836e-06 0.8158311616195392 \
1.106328593352408e-06 0.8165684017534872 1.106328692208245e-06 0.8173999442793862 1.106328836710884e-06 0.8186029267949408 1.106328973036573e-06 0.8197243345631372 \
1.106329082445008e-06 0.8206145128367788 1.106329228461948e-06 0.821788834531623 1.106329380203007e-06 0.8229927727264784 1.106329506119585e-06 0.8239792970156907 \
1.106329650568649e-06 0.8250971468990039 1.106329775264817e-06 0.8260503472050121 1.106329925878834e-06 0.8271873005969326 1.106330061249302e-06 0.8281959289694237 \
1.106330186472937e-06 0.8291179217777711 1.106330304128897e-06 0.8299746468143927 1.10633044991051e-06 0.8310230722388168 1.10633061639426e-06 0.8322027532553667 \
1.106330747215023e-06 0.8331167337813133 1.106330920675045e-06 0.834311196379941 1.106331088787841e-06 0.8354501125721271 1.106331258668969e-06 0.8365827385393307 \
1.106331439512628e-06 0.8377685497174457 1.106331582704692e-06 0.8386931238161603 1.106331696822189e-06 0.8394210074154138 1.1063318268738e-06 0.8402408682651782 \
1.106331928753516e-06 0.8408758513273116 1.106332045641139e-06 0.841596551294542 1.106332182786859e-06 0.8424315815669623 1.106332380696072e-06 0.8436167827761205 \
1.106332572515411e-06 0.8447436440637145 1.106332781866158e-06 0.8459494874145237 1.106332964017768e-06 0.8469786287449077 1.10633316110399e-06 0.8480715276019779 \
1.106333334356719e-06 0.8490148531186206 1.106333517450963e-06 0.8499943787178993 1.10633368858243e-06 0.8508936588199895 1.106333863270272e-06 0.8517955326875627 \
1.106334038504287e-06 0.8526841769874772 1.106334214641154e-06 0.8535614892404448 1.106334405008494e-06 0.8544920815553035 1.106334595580845e-06 0.8554057038167108 \
1.106334795976838e-06 0.8563474066245403 1.106334988566463e-06 0.8572344253714166 1.106335199466375e-06 0.858185963363946 1.106335427341862e-06 0.8591913103610016 \
1.106335693424718e-06 0.8603357477151101 1.106335991926854e-06 0.8615822374427254 1.106336267816323e-06 0.8627000332972231 1.106336552083493e-06 0.8638181192989086 \
1.106336826221443e-06 0.8648650323418529 1.106337098522366e-06 0.8658754039994767 1.106337368678562e-06 0.8668495780678541 1.106337625862699e-06 0.8677515347235455 \
1.106337898421613e-06 0.8686810999091764 1.106338174469332e-06 0.8695957110915412 1.106338444589598e-06 0.8704649939918846 1.106338744449489e-06 0.8714007440816277 \
1.106339115430114e-06 0.8725171209518352 1.106339410352536e-06 0.8733732402027278 1.106339664628271e-06 0.8740897163373675 1.106339962841735e-06 0.8749052413925265 \
1.106340236411346e-06 0.8756305047096297 1.106340472534749e-06 0.8762394088953867 1.106340712859886e-06 0.8768433401198644 1.106340935193821e-06 0.8773882060838187 \
1.106341129200254e-06 0.8778530214284207 1.106341458909681e-06 0.8786208714695904 1.10634161408109e-06 0.87897283049042 1.106341931723491e-06 0.8796750328643211 \
1.106342110604035e-06 0.8800599154915705 1.106342453064798e-06 0.8807759898408113 1.10634263726721e-06 0.8811501695110489 1.106343112296513e-06 0.8820806183873429 \
1.106343279683462e-06 0.8823969901232691 1.106343745459843e-06 0.8832471741583867 1.106343926299187e-06 0.8835657112976044 1.106344420308805e-06 0.8844044135654346 \
1.106344561623711e-06 0.8846360992458032 1.106345167867327e-06 0.8855901496945974 1.106345319942526e-06 0.8858196526512701 1.106345966662599e-06 0.8867549368993356 \
1.106346094949266e-06 0.8869330782847171 1.106346743158686e-06 0.8877977435561634 1.106346872882985e-06 0.8879638504720397 1.106347641302053e-06 0.8888993076310558 \
1.106347771073903e-06 0.8890488273083775 1.106348624736509e-06 0.8899738047157748 1.106348767761561e-06 0.8901192131187072 1.106349754067048e-06 0.8910487927319016 \
1.1063499755536e-06 0.8912403904783051 1.106351118378138e-06 0.8921548233216382 1.106351248258076e-06 0.8922544308366913 1.106352600758498e-06 0.8932425879319322 \
1.106352751041431e-06 0.8933452769452155 1.106354231575698e-06 0.8942627870546499 1.106354470485492e-06 0.8943950258099049 1.106356252518433e-06 0.8952625983306248 \
1.10635663826586e-06 0.895426813549116 1.106359040424079e-06 0.8963023915260389 1.106359515360049e-06 0.8964490046842035 1.106363433287165e-06 0.8974035634625627 \
1.106363903247409e-06 0.8974927205890085 1.106372272035387e-06 0.8984807567386782 1.106372492545714e-06 0.8984960697096243 1.106417072074293e-06 0.8994905034760702 \
1.106418273460192e-06 0.8995076493514624 1.106554083268694e-06 0.9004821828323031 1.106554262245419e-06 0.9005421539807538 1.106557707120337e-06 0.8996085030263692 \
1.106557879904192e-06 0.8994755022453073 1.1065592062239e-06 0.8985168769831137 1.106559392989208e-06 0.8983970610744239 1.106561177194233e-06 0.8974304740967198 \
1.106561389324515e-06 0.8973403978332656 1.106574730020299e-06 0.8983331062395279 1.106574843308144e-06 0.8983517458922662 1.106583546661241e-06 0.8993273409280406 \
1.10658409447182e-06 0.8993637478389299 1.107076621843715e-06 0.9003542216796759 1.107076717582566e-06 0.9004233209197793 1.107077660131942e-06 0.9014023545001312 \
1.107077822585254e-06 0.9016297223302431 1.1070783892915e-06 0.9025464066367429 1.107078496462212e-06 0.9027401250447874 1.107078889770564e-06 0.9035002370985188 \
1.107079022567928e-06 0.9037710185404622 1.107079402169034e-06 0.9045728679206633 1.10707953238378e-06 0.9048512534150681 1.107079993790073e-06 0.9057878278182891 \
1.107080113037131e-06 0.9060008176934132 1.107081542646166e-06 0.9050557440230738 1.107081626316292e-06 0.9046580283931719 1.107081751622122e-06 0.9039622140338933 \
1.10708185943629e-06 0.9032622438705011 1.107081978430637e-06 0.9023800387125585 1.107082093802854e-06 0.9014106868475621 1.107082183899751e-06 0.900578017289966 \
1.107082295347455e-06 0.8994526603282017 1.107082381426603e-06 0.8985125975436928 1.107082487392251e-06 0.8972736935213672 1.107082587160618e-06 0.8960214106762436 \
1.107082668156228e-06 0.8949470092681954 1.107082777804195e-06 0.8934133399212493 1.107082863391606e-06 0.8921520042367302 1.107082955514215e-06 0.8907345325087322 \
1.107083043733598e-06 0.8893220116766375 1.107083152508351e-06 0.8875100775672261 1.107083235401386e-06 0.8860780350921965 1.107083343975057e-06 0.8841400608632336 \
1.107083436201252e-06 0.8824412727986957 1.10708352082175e-06 0.8808423775446282 1.10708360666218e-06 0.8791839877465467 1.10708368587706e-06 0.8776224824828824 \
1.10708376196503e-06 0.8760960492665846 1.107083854301399e-06 0.874210837196514 1.107083914177735e-06 0.8729702140710593 1.107083971566019e-06 0.8717685933706794 \
1.107084033561192e-06 0.8704574090763495 1.107084096840044e-06 0.8691057216070059 1.107084146911381e-06 0.8680269866686803 1.107084196353534e-06 0.8669542389500936 \
1.10708426002324e-06 0.8655623656543436 1.107084335970659e-06 0.8638877358586781 1.107084384801671e-06 0.8628032002737418 1.107084433325624e-06 0.8617197496806845 \
1.107084509037347e-06 0.8600184098866027 1.107084576246125e-06 0.8584975010852487 1.107084618952631e-06 0.8575263577286506 1.107084662855204e-06 0.8565244243916033 \
1.107084750660351e-06 0.8545103166059256 1.107084813513519e-06 0.8530605771626394 1.107084872183177e-06 0.8517018597088126 1.107084908361778e-06 0.8508614974547222 \
1.107084943180258e-06 0.8500510151036469 1.107084978206243e-06 0.8492340038666518 1.107085048258213e-06 0.8475953578585981 1.107085096728698e-06 0.8464581214772323 \
1.107085140673499e-06 0.8454248116355969 1.107085186191255e-06 0.8443523575543517 1.107085250092166e-06 0.8428433081697474 1.10708531621854e-06 0.8412777165526386 \
1.107085421348608e-06 0.8387809254526315 1.107085509283283e-06 0.8366857089760468 1.107085588228565e-06 0.834800137446173 1.107085676393602e-06 0.8326899670047023 \
1.107085763209599e-06 0.8306078985741704 1.107085851101283e-06 0.8284959280419055 1.107085942350373e-06 0.8262996967350639 1.107086045112241e-06 0.8238226494465998 \
1.107086143615716e-06 0.8214450402687625 1.107086255948632e-06 0.8187302447322098 1.107086368922768e-06 0.8159967029774419 1.107086490210663e-06 0.8130591602364435 \
1.107086620717817e-06 0.8098958628758253 1.107086749763719e-06 0.8067658935936169 1.10708690323932e-06 0.8030416153605923 1.107087068523541e-06 0.799029304640783 \
1.107087236264745e-06 0.7949567682299736 1.107087432788334e-06 0.7901857478752816 1.107087637550659e-06 0.7852160332972318 1.107087850227715e-06 0.7800563994093253 \
1.107088050847662e-06 0.7751902022758907 1.107088251706389e-06 0.7703212856706637 1.107088401728407e-06 0.766686939713112 1.107088532263574e-06 0.7635264252913375 \
1.107088666681014e-06 0.7602735436595947 1.107088772876545e-06 0.7577048602246427 1.107088906182877e-06 0.754482067181252 1.107089013215803e-06 0.7518959494812111 \
1.107089156291704e-06 0.7484409822837247 1.107089320797846e-06 0.7444713482725677 1.107089441615093e-06 0.74155777711076 1.107089612721757e-06 0.7374334100931738 \
1.107089773612309e-06 0.733558046396253 1.10708999020493e-06 0.7283457217000903 1.107090183460631e-06 0.7236999380850822 1.107090362395765e-06 0.7194029726762079 \
1.107090529212387e-06 0.7154015770462002 1.107090715418352e-06 0.7109395231330657 1.107090903351594e-06 0.7064416825495208 1.107091069273699e-06 0.7024749886985119 \
1.107091261631787e-06 0.6978803202016938 1.107091402988682e-06 0.6945068232011449 1.107091559996444e-06 0.6907636199298515 1.107091755976089e-06 0.6860965106368763 \
1.107091918410194e-06 0.6822325558671515 1.107092079586376e-06 0.6784034260021697 1.107092271894574e-06 0.6738409413562468 1.107092489556454e-06 0.6686845685784016 \
1.107092737577756e-06 0.6628199086538362 1.107092915635219e-06 0.6586162961343578 1.107093164179028e-06 0.6527567611811057 1.107093366786271e-06 0.6479896840619462 \
1.107093536596938e-06 0.6440011601507294 1.107093695213124e-06 0.6402799599229552 1.107093833743559e-06 0.637035894415233 1.107093969951322e-06 0.6338503464729111 \
1.107094096262698e-06 0.6309003762865483 1.107094225721933e-06 0.6278810604265532 1.107094354053672e-06 0.6248911458464299 1.107094485383603e-06 0.6218374290191309 \
1.107094617410215e-06 0.6187713222160208 1.107094761570095e-06 0.6154276788919771 1.107094905778687e-06 0.6120888358645944 1.107095053433791e-06 0.6086753592300279 \
1.107095200490149e-06 0.6052842859263143 1.107095358304176e-06 0.6016504852589418 1.107095490909828e-06 0.5986039825107707 1.107095622374795e-06 0.5955897059985247 \
1.107095741804593e-06 0.5928552647156846 1.107095877873286e-06 0.5897484304797134 1.107095992801548e-06 0.5871283594046445 1.107096143912269e-06 0.5836892419704927 \
1.107096258561337e-06 0.5810871834776226 1.107096376499006e-06 0.5784138884735546 1.107096466280294e-06 0.576381560286313 1.107096556599689e-06 0.5743415774978985 \
1.107096623290559e-06 0.5728373329037385 1.107096688852372e-06 0.5713590910263378 1.107096739894496e-06 0.5702089751121119 1.107096801596215e-06 0.5688198806440578 \
1.107096864686071e-06 0.5674025889664359 1.107096929044424e-06 0.5659586381304559 1.107096982438224e-06 0.5647616504486359 1.107097075080806e-06 0.5626864159088959 \
1.107097151688078e-06 0.5609719030357503 1.10709720751314e-06 0.5597256439368602 1.107097276567267e-06 0.5581857825097393 1.107097383455393e-06 0.5558054549196561 \
1.107097461199018e-06 0.5540764009223496 1.107097562049117e-06 0.5518382286767042 1.107097687729972e-06 0.5490568313009737 1.107097787971657e-06 0.5468419758621708 \
1.10709789988934e-06 0.5443739014182352 1.107098003155247e-06 0.5421024366463116 1.107098122904589e-06 0.5394737463112931 1.107098224637469e-06 0.5372436950013484 \
1.107098340157213e-06 0.5347185748314579 1.107098455192299e-06 0.5322102907975605 1.107098581673211e-06 0.529456475824718 1.107098707047009e-06 0.5267350629320526 \
1.107098853862932e-06 0.5235577714138258 1.107098989426381e-06 0.5206304261698983 1.107099147124634e-06 0.5172373565578411 1.107099309443688e-06 0.5137528589513558 \
1.107099490267585e-06 0.5098871206809381 1.107099682715905e-06 0.5057874350093188 1.107099895621209e-06 0.5012700264709963 1.107100127802608e-06 0.4963634062180514 \
1.107100385093187e-06 0.4909555076455908 1.10710062471901e-06 0.4859407514401474 1.107100926434446e-06 0.479662588092526 1.1071012143538e-06 0.4737079198104491 \
1.107101527242619e-06 0.4672821326282255 1.107101846980824e-06 0.4607585360408045 1.107102186575985e-06 0.4538766993710576 1.107102513478483e-06 0.4472977926730654 \
1.107102849036864e-06 0.4405887635920606 1.107103166132787e-06 0.4342949501181722 1.107103500370541e-06 0.4277061431972559 1.107103851801663e-06 0.4208322784122511 \
1.107104166327817e-06 0.4147233751108969 1.107104489505308e-06 0.4084912998479469 1.107104930620066e-06 0.400057814108821 1.107105272736103e-06 0.3935812134363078 \
1.107105572680633e-06 0.3879522399691127 1.107105947811638e-06 0.3809760137481454 1.107106277555878e-06 0.3749002425561211 1.107106560798804e-06 0.3697269896098562 \
1.107106860945059e-06 0.3642865787664632 1.107107140547253e-06 0.3592589179584539 1.107107364323365e-06 0.3552676761685443 1.107107576103695e-06 0.3515151294490645 \
1.107107778537159e-06 0.3479514629380864 1.107107979628427e-06 0.3444362246481504 1.107108185342845e-06 0.3408632458568372 1.107108452965717e-06 0.3362478643926977 \
1.107108691897011e-06 0.3321601360780691 1.107108925403074e-06 0.3281974319442653 1.107109138868474e-06 0.3246000376975314 1.107109360246046e-06 0.3208952602338652 \
1.107109560209693e-06 0.3175728982722026 1.107109764482006e-06 0.3142073831356898 1.107109961828878e-06 0.3109812293225088 1.107110147201405e-06 0.3079732989686547 \
1.107110343307796e-06 0.3048147723336881 1.107110545584936e-06 0.3015820927993307 1.107110721243233e-06 0.2988007390096292 1.10711090711339e-06 0.295878328903569 \
1.107111114092783e-06 0.2926488196724605 1.107111299414374e-06 0.2897857719971084 1.107111494641182e-06 0.2867989994419413 1.107111650415531e-06 0.28443329608414 \
1.107111829172313e-06 0.2817356906084737 1.107112010203233e-06 0.2790344478478936 1.107112160100347e-06 0.2768142575519123 1.107112361143774e-06 0.273859574769726 \
1.107112510258904e-06 0.2716833853889438 1.107112648798334e-06 0.2696726034832688 1.107112800673409e-06 0.2674956304896134 1.107112915147538e-06 0.2658586287383957 \
1.107113046677468e-06 0.2639823142040156 1.107113172435956e-06 0.2622048582339201 1.107113276776362e-06 0.2607341604582348 1.107113389755722e-06 0.2591418073851619 \
1.107113506084246e-06 0.2575033437579446 1.107113649011667e-06 0.2554974228347739 1.107113762273172e-06 0.2539102348881249 1.107113896429905e-06 0.2520298733123076 \
1.10711400690271e-06 0.2504818583075984 1.107114162335285e-06 0.2483006006477398 1.107114303220383e-06 0.2463217957442577 1.107114454612954e-06 0.2441928603691365 \
1.107114609775035e-06 0.2420086586735095 1.107114739184283e-06 0.2401849910837116 1.107114873896376e-06 0.2382868210192302 1.107115011594202e-06 0.2363478190565156 \
1.107115129346217e-06 0.2346905900295477 1.10711528867041e-06 0.2324499447852502 1.107115425932636e-06 0.2305210708572645 1.107115566678993e-06 0.2285488733964877 \
1.107115672470167e-06 0.2270688194984586 1.107115802411565e-06 0.2252532503786337 1.107115902948028e-06 0.2238506847401111 1.107116005281736e-06 0.2224250970611539 \
1.107116079010317e-06 0.2214012665004395 1.10711615824426e-06 0.2203047212273054 1.107116229215507e-06 0.2193236206014474 1.107116280678535e-06 0.218612902325451 \
1.107116333626988e-06 0.2178825126218075 1.107116412781991e-06 0.2167921001391954 1.107116455054626e-06 0.2162104926182252 1.107116494899171e-06 0.2156628374086678 \
1.10711653812282e-06 0.2150692779925967 1.107116579029822e-06 0.2145080585354088 1.107116649152284e-06 0.2135474129702876 1.107116682837256e-06 0.2130867492099046 \
1.107116727666638e-06 0.212477723463 1.1071167865238e-06 0.2116792343136102 1.10711685130926e-06 0.2108017053965978 1.107116908790025e-06 0.2100241135398916 \
1.107116969219033e-06 0.209207737948094 1.107117066255463e-06 0.2078991976528634 1.107117150945123e-06 0.2067595417901527 1.107117259855885e-06 0.2052972881712416 \
1.107117356256692e-06 0.2040065614180294 1.107117451273329e-06 0.2027428333585779 1.107117554705128e-06 0.2013717100485363 1.107117649634473e-06 0.2001158751783069 \
1.107117752654899e-06 0.198757993281026 1.107117857737332e-06 0.1973779917312911 1.107117967046146e-06 0.1959482000350934 1.107118077489628e-06 0.1945091075764383 \
1.107118193779904e-06 0.1929996650696684 1.107118303709896e-06 0.1915811184357085 1.10711841337232e-06 0.1901717999899754 1.107118515088965e-06 0.1888694322720079 \
1.107118608043679e-06 0.1876837490531375 1.107118700772569e-06 0.1865049219968967 1.107118774458125e-06 0.1855719169757668 1.10711885729934e-06 0.1845269810791141 \
1.107118931885337e-06 0.1835895008849975 1.107119001608678e-06 0.1827150226754214 1.107119068327085e-06 0.1818808699270075 1.107119164170411e-06 0.1806871657728035 \
1.107119246877184e-06 0.1796611249561687 1.107119340441008e-06 0.1785035608809835 1.107119435337095e-06 0.1773351434884491 1.107119546707405e-06 0.1759704596301353 \
1.107119688349759e-06 0.1742450478777388 1.107119803596612e-06 0.1728486436789435 1.107119948144251e-06 0.1711076225712051 1.107120059739928e-06 0.1697708811114609 \
1.107120200958902e-06 0.1680898955975501 1.107120316696175e-06 0.1667201145354908 1.107120422656861e-06 0.1654722325850081 1.107120521416477e-06 0.164314417410061 \
1.10712061775965e-06 0.1631901152369615 1.107120706417402e-06 0.1621596955203892 1.107120831751673e-06 0.1607099933926625 1.107120926277088e-06 0.1596224416957933 \
1.10712102401604e-06 0.1585042187118262 1.107121132110917e-06 0.1572745454417887 1.107121226778605e-06 0.1562036643369483 1.107121334226451e-06 0.1549951394274829 \
1.107121425315495e-06 0.1539767092330788 1.107121532087207e-06 0.1527896463435911 1.107121635480473e-06 0.1516469620792683 1.107121746560958e-06 0.1504267727114754 \
1.107121835786939e-06 0.1494522115900035 1.107121921266868e-06 0.1485231035185812 1.107122005192055e-06 0.1476157397758405 1.107122074898619e-06 0.1468658175993407 \
1.107122153536697e-06 0.1460232248551682 1.107122231847954e-06 0.1451880611912267 1.107122302483827e-06 0.1444378248611795 1.107122387974695e-06 0.1435337156153706 \
1.107122475363672e-06 0.1426139614481139 1.107122556951186e-06 0.1417594571206545 1.107122654270137e-06 0.1407454482154784 1.10712273495966e-06 0.139910090776864 \
1.10712282574469e-06 0.1389752404035735 1.107122947088963e-06 0.1377336220260025 1.107123036138604e-06 0.13682812281983 1.107123134655454e-06 0.1358318692385875 \
1.107123221741723e-06 0.1349560640726983 1.107123332152611e-06 0.1338550874529322 1.107123420611433e-06 0.1329791517134813 1.107123521340027e-06 0.1319874611681985 \
1.10712362612958e-06 0.1309622419763913 1.107123720519813e-06 0.1300442429014473 1.107123817024605e-06 0.1291112112475518 1.107123916511258e-06 0.1281591654439075 \
1.107124002912429e-06 0.1273384721630967 1.10712409789256e-06 0.1264411177628728 1.107124202081388e-06 0.1254629331099751 1.107124311200139e-06 0.124445178694 \
1.107124405550594e-06 0.1235704029653004 1.107124517846343e-06 0.1225411084520107 1.107124613309697e-06 0.1216733466577494 1.107124717520587e-06 0.1207311846737792 \
1.107124806865944e-06 0.1199276649878674 1.107124877253217e-06 0.1192980345746366 1.107124952639251e-06 0.1186268760051257 1.107125028771421e-06 0.1179522201461119 \
1.107125097748918e-06 0.1173458504859956 1.107125180268091e-06 0.1166263596898966 1.107125252211578e-06 0.1160015972854393 1.107125334290304e-06 0.1152916772467617 \
1.10712541862478e-06 0.1145654108773922 1.107125496418619e-06 0.113898375935255 1.107125589183521e-06 0.1131065723182637 1.107125704787343e-06 0.1121254933399327 \
1.107125810692911e-06 0.1112341778178403 1.107125888349831e-06 0.1105854195321705 1.107125976646302e-06 0.1098504899494786 1.107126056703354e-06 0.1091866403929743 \
1.107126153629479e-06 0.1083861389179563 1.107126248864964e-06 0.1076031391441806 1.107126337436159e-06 0.1068780200140514 1.10712643874426e-06 0.1060523297458165 \
1.107126544289947e-06 0.1051963702337609 1.107126653484312e-06 0.1043160928234657 1.107126761601933e-06 0.1034503663302994 1.107126881519694e-06 0.1024949450012773 \
1.107126982881521e-06 0.1016914181115986 1.107127088891151e-06 0.100855068690839 1.10712721468278e-06 0.09986840123414902 1.107127344240086e-06 0.09885896724496235 \
1.10712747991544e-06 0.09780904711780367 1.107127655987304e-06 0.09645781830037269 1.107127819787824e-06 0.09521257997344186 1.107127982612565e-06 0.09398642071914091 \
1.1071280677512e-06 0.09334985726464029 1.107128137589223e-06 0.09282999162688726 1.107128207084828e-06 0.09231474740697931 1.107128281043488e-06 0.09176875214326782 \
1.107128377198375e-06 0.09106241641841166 1.107128451613741e-06 0.09051841344162129 1.10712852960331e-06 0.08995079828656057 1.107128606052139e-06 0.08939693755534793 \
1.107128693546224e-06 0.08876614459792892 1.107128795722934e-06 0.08803382885421264 1.107128884287322e-06 0.08740269463919083 1.10712899395281e-06 0.08662585268124241 \
1.107129110009218e-06 0.08580942306245626 1.107129251558034e-06 0.0848216759818637 1.107129384427018e-06 0.08390253510334872 1.107129525187328e-06 0.08293727564630923 \
1.107129674896948e-06 0.08192024575105315 1.107129810608835e-06 0.08100683753927941 1.107129952125717e-06 0.08006309454860433 1.107130087247591e-06 0.07917070961097784 \
1.107130228520028e-06 0.07824718349428782 1.10713037561292e-06 0.07729532867436953 1.107130527122786e-06 0.07632524417621221 1.1071306924985e-06 0.07527819040792309 \
1.10713085625969e-06 0.07425356708383206 1.107131032389632e-06 0.07316505371836476 1.10713122152861e-06 0.07201151367936541 1.107131432202234e-06 0.07074528708793332 \
1.107131651768856e-06 0.06944624562626683 1.107131886535262e-06 0.06808094281860989 1.1071321449277e-06 0.06660616301228137 1.10713243959236e-06 0.06496103773121734 \
1.107132743671683e-06 0.06330286177969326 1.107133104582163e-06 0.06138472526627536 1.107133440499035e-06 0.05964719353945821 1.107133880676406e-06 0.05743991201668189 \
1.107134259043809e-06 0.05560437501227136 1.107134701502772e-06 0.05352996728430704 1.107135055522916e-06 0.05192508193542229 1.107135442039672e-06 0.05022502935509546 \
1.107135786643729e-06 0.04875485597254389 1.107136108618665e-06 0.04741934964807833 1.107136412152492e-06 0.04619304551845941 1.107136707073488e-06 0.04503122626702559 \
1.107136989555767e-06 0.04394770877170886 1.107137266636177e-06 0.04291147062934708 1.107137532363668e-06 0.04194013461971725 1.107137803594355e-06 0.0409708748276704 \
1.107138079853372e-06 0.04000619535229137 1.107138369752594e-06 0.03901828782233653 1.107138598128987e-06 0.03825741181922668 1.107138903013054e-06 0.03726495139513845 \
1.107139119684911e-06 0.03657573971894532 1.107139311041637e-06 0.03597943984071691 1.107139509636156e-06 0.03537298232318693 1.107139839551497e-06 0.03438820140908775 \
1.10714008149717e-06 0.03368375433354889 1.107140396809222e-06 0.03278771666975258 1.107140666929207e-06 0.03203957074185158 1.107140923300881e-06 0.03134567005659093 \
1.107141203312881e-06 0.03060515313352298 1.107141448968657e-06 0.02997014710356035 1.107141681704302e-06 0.02938120249260199 1.107141924434299e-06 0.02878348292867495 \
1.107142161161563e-06 0.02821317433052753 1.107142389807974e-06 0.0276732289298247 1.107142807093635e-06 0.02671456010533928 1.107143002274328e-06 0.02627749693639509 \
1.107143383441411e-06 0.02544369227895442 1.107143560694233e-06 0.02506446942885681 1.107143903145688e-06 0.02434654114125227 1.10714405641412e-06 0.02403127656358269 \
1.107144431432584e-06 0.02327616399748992 1.107144569066725e-06 0.02300530455388665 1.107145053333359e-06 0.02207084195640928 1.10714517295276e-06 0.02184403312078184 \
1.107145589991564e-06 0.02106026682208277 1.107145733393791e-06 0.02079332360769017 1.107146254605172e-06 0.01984598817089831 1.107146382379043e-06 0.0196205814374062 \
1.107146966791417e-06 0.01863359713481367 1.107147139226823e-06 0.01835589372257288 1.107147743323573e-06 0.01743644241612937 1.107147904755214e-06 0.01720262545858322 \
1.107148544701434e-06 0.01631831686205014 1.1071487230176e-06 0.016083210242981 1.107149371001649e-06 0.01526127675881721 1.10714953625524e-06 0.01505930898173208 \
1.107150272557175e-06 0.01419381259610907 1.107150406833226e-06 0.01404154276213586 1.107151203932743e-06 0.01317592498067951 1.107151344530355e-06 0.01302934089458718 \
1.107152309873577e-06 0.0120661300044765 1.107152474212383e-06 0.01190857475316222 1.107153474943512e-06 0.01099048917119646 1.107153612213369e-06 0.01087009009405628 \
1.107154750907886e-06 0.009949273443646761 1.107154865085787e-06 0.009863136028526375 1.107156245730622e-06 0.008889755784408603 1.107156400087833e-06 0.00878832203975914 \
1.107157946582061e-06 0.00781340401000951 1.107158030943764e-06 0.007760176032106158 1.107159716371082e-06 0.006770348169342283 1.107159839899572e-06 0.00670487246831437 \
1.107161889714139e-06 0.005720970231232756 1.107162086114296e-06 0.005634691917282852 1.107164404793654e-06 0.004698942116576918 1.107164865407989e-06 0.004530544077955615 \
1.10716760550353e-06 0.003639937533647344 1.107168123648567e-06 0.00349159181499799 1.107172274289875e-06 0.002502201117031859 1.107172812139882e-06 0.002396807933581942 \
1.10717889437533e-06 0.001421603691354927 1.107179153355741e-06 0.001378272220758726 1.10718447611909e-06 0.0003814093765652445 1.107184589276134e-06 0.0003711807182531981 \
1.10983070639237e-06 -0.0004615907568095335 1.109830868831338e-06 -0.0006852153244161934 1.109831369832807e-06 -0.001554404032531494 1.10983145401537e-06 -0.001725199767551738 \
1.109831855538194e-06 -0.002626792336557519 1.109831944873161e-06 -0.002845673237760077 1.10983223146497e-06 -0.0035898660494722 1.109832359033499e-06 -0.003937855927128601 \
1.109832677745161e-06 -0.004830400105952924 1.109832791946313e-06 -0.00515011308870196 1.109833074346638e-06 -0.005887653497963378 1.109833204572857e-06 -0.006177415671381139 \
1.109834182925754e-06 -0.005220113099403402 1.109834370233287e-06 -0.004004368716724641 1.109834501677689e-06 -0.002901539130564616 1.109834607105242e-06 -0.001869327786897239 \
1.109834692822726e-06 -0.0009323217369615201 1.109834774749213e-06 4.151965372454519e-05 1.109834895786036e-06 0.001618129410352471 1.109834994714683e-06 0.003024565667809575 \
1.109835153111357e-06 0.005482561958548801 1.109835370558587e-06 0.00923691162542661 1.10983555178081e-06 0.0126653356758144 1.109835763874906e-06 0.01697021734206094 \
1.109835926898563e-06 0.02046388365739064 1.109836087520979e-06 0.02403759527126768 1.109836241061221e-06 0.02755862871109176 1.109836389117902e-06 0.031036270750196 \
1.109836538198811e-06 0.03460722192241437 1.109836692728722e-06 0.03837091703902212 1.109836853379538e-06 0.04234026030123839 1.109837018034219e-06 0.04645786783841532 \
1.109837194575117e-06 0.05091770581196236 1.109837373537969e-06 0.05547793877747508 1.109837564281134e-06 0.0603721650098247 1.109837769062163e-06 0.06565647483694508 \
1.109837989534449e-06 0.07137203566208646 1.109838222394174e-06 0.0774299331224613 1.10983847158165e-06 0.08392829098722057 1.109838744423778e-06 0.09105513637423955 \
1.109839041127578e-06 0.09880974921055499 1.109839368453968e-06 0.1073623706929605 1.109839738105355e-06 0.11701033799881 1.109840132977169e-06 0.1273002725707723 \
1.10984059081541e-06 0.1392030195235975 1.10984112262225e-06 0.1529832553757746 1.109841747860046e-06 0.1691182447448397 1.109842433607517e-06 0.1867241161332086 \
1.109843236003391e-06 0.2071957342970069 1.109844134802183e-06 0.2299563735557614 1.109844940415632e-06 0.2501946571168963 1.109845654166966e-06 0.2679877251922811 \
1.109846283728848e-06 0.2835633151515627 1.109846854092298e-06 0.2975737963344939 1.10984738504768e-06 0.3105173405876944 1.109847886835131e-06 0.3226580892822354 \
1.109848366129684e-06 0.3341673054699896 1.109848831685103e-06 0.3452566901045974 1.109849295481511e-06 0.3562094254686541 1.109849751229541e-06 0.3668794056881832 \
1.109850211449675e-06 0.3775613305945491 1.109850749733646e-06 0.3899285626759094 1.109851250584179e-06 0.4013172511919189 1.109851650806863e-06 0.4103337945930838 \
1.109852157667644e-06 0.421642452039157 1.109852643633856e-06 0.4323669409017459 1.109853043148568e-06 0.4410997362599856 1.109853453760627e-06 0.4500002277813482 \
1.10985388268706e-06 0.4592207708982954 1.109854284201442e-06 0.4677760623951868 1.109854591591889e-06 0.4742753916877908 1.109854941833647e-06 0.4816249679276425 \
1.109855295073851e-06 0.4889795533930016 1.10985554824443e-06 0.4942125642332652 1.10985578118832e-06 0.4989990073547648 1.109856022831611e-06 0.5039392821429431 \
1.109856247822229e-06 0.5085102868389438 1.109856439858337e-06 0.5123881070394828 1.109856624670034e-06 0.5161059569497825 1.10985684696035e-06 0.5205538992744256 \
1.109857013671757e-06 0.5238726938135662 1.109857230888353e-06 0.5281726418673847 1.109857433967244e-06 0.5321820613122353 1.109857611378699e-06 0.5356681922482178 \
1.109857799451086e-06 0.5393528234657015 1.109858035483266e-06 0.5439555888699217 1.10985830136529e-06 0.5491186112539347 1.109858523127178e-06 0.5534070305875756 \
1.109858803185033e-06 0.5588091140818973 1.109859046184818e-06 0.5634839438879177 1.109859321538161e-06 0.5687575845994758 1.109859566533502e-06 0.5734440561015828 \
1.10985980682772e-06 0.5780305526007354 1.109860047867023e-06 0.5826153106864888 1.109860305457841e-06 0.5874946531182738 1.109860540824618e-06 0.5919209497705462 \
1.109860772126727e-06 0.5962518282209535 1.109860994653448e-06 0.6003950532231523 1.109861203013056e-06 0.6042587207462122 1.109861440854871e-06 0.6086392006348278 \
1.109861651715085e-06 0.612499186772883 1.109861907322267e-06 0.617151767543529 1.109862106050033e-06 0.620751700070918 1.109862381682677e-06 0.6257066023742009 \
1.109862604438798e-06 0.6296824120643636 1.109862897809922e-06 0.6348814180513288 1.109863130579923e-06 0.6389753720667986 1.109863350781309e-06 0.6428252659334456 \
1.109863552051921e-06 0.6463216644290061 1.109863769340793e-06 0.6500784077528632 1.109863944056704e-06 0.6530842133917786 1.109864130321333e-06 0.6562672470877895 \
1.109864309060386e-06 0.6593113758161715 1.109864471764399e-06 0.6620700940033843 1.10986463703341e-06 0.6648583661366954 1.109864780301224e-06 0.6672607123132118 \
1.109864919531648e-06 0.669583864918244 1.109865059332215e-06 0.6719085596965743 1.109865194107422e-06 0.6741424479378803 1.109865321601663e-06 0.6762463034350935 \
1.109865454555775e-06 0.6784344250006583 1.109865576160125e-06 0.680430207161383 1.109865704573366e-06 0.6825336955632141 1.109865820340421e-06 0.6844241240890321 \
1.109865918381594e-06 0.686020684362688 1.1098660190777e-06 0.687656981754083 1.109866128831462e-06 0.689434454762776 1.109866245599418e-06 0.6913211166705923 \
1.109866336826192e-06 0.6927889453402305 1.109866446031605e-06 0.6945396927028351 1.109866547140326e-06 0.6961566646470493 1.109866642540618e-06 0.6976767415743361 \
1.109866752022643e-06 0.6994136821864276 1.109866886474277e-06 0.7015344809028976 1.109867035493214e-06 0.7038694457768003 1.109867164423232e-06 0.7058755144243859 \
1.109867311083691e-06 0.7081418729260142 1.109867437868072e-06 0.7100885084081828 1.109867562465961e-06 0.7119899232102255 1.109867674319728e-06 0.7136874821928206 \
1.109867787275692e-06 0.7153928249203609 1.109867887829089e-06 0.716903336497302 1.109868025110592e-06 0.7189542886859326 1.109868144979452e-06 0.7207346491296758 \
1.109868264162204e-06 0.7224952472954583 1.109868391164314e-06 0.7243608783177121 1.109868515712665e-06 0.726179956024653 1.109868639383676e-06 0.7279757435764195 \
1.109868765971953e-06 0.7298035010246171 1.109868896541188e-06 0.7316777339938921 1.109869019056222e-06 0.7334262671520465 1.109869155299713e-06 0.7353588786631546 \
1.109869256742486e-06 0.7367901064855561 1.109869362765969e-06 0.7382789144707947 1.109869453297152e-06 0.7395446819117977 1.109869567123378e-06 0.7411267287627761 \
1.10986965478496e-06 0.742338113895605 1.109869760680238e-06 0.7437932991468792 1.109869891033532e-06 0.7455718205320391 1.10987000160114e-06 0.7470699275523445 \
1.109870106271611e-06 0.7484790865773925 1.109870230233143e-06 0.7501360792234356 1.109870378790597e-06 0.752105598322839 1.109870500473193e-06 0.7537054667443914 \
1.109870614584882e-06 0.7551949470168074 1.109870755005484e-06 0.7570132059451244 1.109870896533544e-06 0.7588296197226846 1.109871014322813e-06 0.7603289862386273 \
1.109871142522635e-06 0.7619481626911874 1.109871284590468e-06 0.7637269294216019 1.109871401465576e-06 0.7651780119234867 1.109871547139362e-06 0.7669714049983392 \
1.10987166887781e-06 0.7684572223066155 1.109871787518301e-06 0.7698939375992205 1.109871909984595e-06 0.7713653733660819 1.109872036701685e-06 0.7728756341192486 \
1.109872146603679e-06 0.7741754302862822 1.109872272219022e-06 0.7756497674172792 1.109872378029431e-06 0.7768823528242577 1.109872514199553e-06 0.7784559787239111 \
1.109872638546601e-06 0.7798807766277074 1.109872765971877e-06 0.7813271999647126 1.109872880527956e-06 0.7826155184370988 1.109872987208226e-06 0.7838050786084815 \
1.109873125150823e-06 0.785328674235108 1.109873274600319e-06 0.7869612315653352 1.109873419452536e-06 0.7885256944569791 1.109873538888287e-06 0.7898026796320731 \
1.10987367431316e-06 0.7912364721526877 1.109873795807481e-06 0.7925100718437531 1.109873939166555e-06 0.7939977458315933 1.109874082600237e-06 0.7954699260458764 \
1.109874208411247e-06 0.7967479640295563 1.109874327457928e-06 0.7979459892863545 1.109874439471573e-06 0.7990632136113104 1.109874544263454e-06 0.8000996927221937 \
1.109874639456303e-06 0.8010335634530776 1.109874775866829e-06 0.8023587211299719 1.109874892679005e-06 0.8034813603122919 1.109875012140248e-06 0.8046180202255495 \
1.1098751341806e-06 0.8057672874017472 1.109875257080697e-06 0.8069126780167393 1.109875384200053e-06 0.8080849010520604 1.109875509341915e-06 0.8092265787736463 \
1.109875639893142e-06 0.8104047139317369 1.109875765969389e-06 0.811530109085512 1.109875893966049e-06 0.8126603425876329 1.109875999427297e-06 0.8135823118114501 \
1.109876102696598e-06 0.814477091043954 1.109876195349946e-06 0.8152732203909091 1.109876319044181e-06 0.8163262937528154 1.109876406664096e-06 0.8170655553659417 \
1.109876505330151e-06 0.8178914289762149 1.109876648877154e-06 0.819080619224994 1.109876784463306e-06 0.8201904093102529 1.109876893653288e-06 0.8210742465492874 \
1.109877041102747e-06 0.8222539401850584 1.109877191506449e-06 0.8234410273756358 1.109877316975412e-06 0.8244188977545531 1.109877461141395e-06 0.8255287290252299 \
1.10987758542996e-06 0.8264738611628292 1.109877735900256e-06 0.8276038147969816 1.109877871506614e-06 0.8286089145501508 1.109877996601616e-06 0.8295251220930787 \
1.109878114317453e-06 0.8303776282987162 1.109878260203052e-06 0.8314210189912619 1.109878426696148e-06 0.8325942517713072 1.109878557562851e-06 0.833503494447128 \
1.109878731007462e-06 0.8346911703335461 1.109878899140202e-06 0.8358239212093587 1.10987906899395e-06 0.8369500705213252 1.109879249886955e-06 0.838129582835239 \
1.109879393021216e-06 0.8390486258646698 1.109879507119162e-06 0.8397723391454259 1.109879637246322e-06 0.8405879656882547 1.109879739102179e-06 0.8412191375388212 \
1.109879855947599e-06 0.8419354178465567 1.109879992919396e-06 0.84276453896487 1.109880190759142e-06 0.843942473808897 1.10988038244463e-06 0.8450620046306492 \
1.109880591850993e-06 0.8462610422160779 1.109880773861877e-06 0.8472832413425977 1.109880970977333e-06 0.8483697584184032 1.109881144290447e-06 0.8493077402131245 \
1.109881327325656e-06 0.8502809338042043 1.109881498478783e-06 0.8511747489972419 1.109881673131736e-06 0.8520708361396651 1.109881848382891e-06 0.8529540285731302 \
1.109882024530391e-06 0.8538259128238825 1.109882214836779e-06 0.8547503816925358 1.109882405427748e-06 0.8556583881771193 1.109882605979791e-06 0.8565949481971697 \
1.109882798582588e-06 0.8574764650234362 1.109883009331288e-06 0.8584213553684483 1.109883237362186e-06 0.8594210644592908 1.109883503241952e-06 0.8605573106989262 \
1.109883801820094e-06 0.8617960322792503 1.109884077983729e-06 0.8629075153790151 1.109884362230229e-06 0.8640180616030438 1.109884636414231e-06 0.8650581816846495 \
1.10988490866944e-06 0.8660616517296992 1.109885178858914e-06 0.8670295451208139 1.109885436023238e-06 0.8679256252637404 1.109885708596972e-06 0.8688492356117473 \
1.109885984602435e-06 0.8697577927663542 1.109886254710518e-06 0.8706213441784563 1.109886554568938e-06 0.8715508809746347 1.109886925582816e-06 0.8726599440782473 \
1.109887220515529e-06 0.873510245983525 1.109887474800896e-06 0.8742218447789023 1.109887773044171e-06 0.8750318897722944 1.109888046640929e-06 0.8757523113099853 \
1.109888282767907e-06 0.8763571312809064 1.109888523107206e-06 0.876957042728428 1.109888745440861e-06 0.8774982514557473 1.109888939446794e-06 0.8779599514934209 \
1.109889269165228e-06 0.8787226653583874 1.109889424338019e-06 0.8790722725343518 1.10988974207141e-06 0.8797700114458387 1.10988992093906e-06 0.880152324917399 \
1.109890263400534e-06 0.8808637455080008 1.109890447552368e-06 0.8812353200296749 1.109890922478418e-06 0.8821594045029107 1.109891089871654e-06 0.8824737723885729 \
1.109891555692961e-06 0.8833186808430151 1.109891736520447e-06 0.883635209600208 1.109892230549786e-06 0.8844687288968743 1.109892371887773e-06 0.8846990198924604 \
1.109892978249103e-06 0.8856473543416146 1.109893130320955e-06 0.8858754372639542 1.109893777008948e-06 0.8868048391838264 1.109893905303109e-06 0.8869818633102416 \
1.109894553496582e-06 0.8878410756373726 1.109894683245133e-06 0.8880061989117775 1.109895451498601e-06 0.8889361126992519 1.109895581240625e-06 0.8890847997417872 \
1.109896434697557e-06 0.8900046759307325 1.109896577924673e-06 0.8901495209380393 1.109897564158077e-06 0.8910738355210844 1.109897785636141e-06 0.8912643084423501 \
1.109898928653688e-06 0.8921737958641509 1.109899058631989e-06 0.8922730011388891 1.109900410338988e-06 0.8932565980587214 1.109900560692342e-06 0.8933589605607284 \
1.109902041315768e-06 0.8942730372387374 1.10990228021907e-06 0.8944047337041336 1.109904061344228e-06 0.8952702388217941 1.109904447325594e-06 0.8954343910560414 \
1.109906848871634e-06 0.896309305076933 1.10990732380842e-06 0.8964562995603377 1.109911141970139e-06 0.8973944547681553 1.109911624459336e-06 0.897487269196476 \
1.109919510474849e-06 0.898471373493449 1.10992012663754e-06 0.8985180228791175 1.110015282612379e-06 0.899508178894561 1.110016773214557e-06 0.8995204306067698 \
1.110128061288741e-06 0.9005118233983579 1.110128237625743e-06 0.9005706457326812 1.110131860757067e-06 0.8996048713171836 1.110132041955094e-06 0.8994654179496379 \
1.11013335307657e-06 0.8985275682722235 1.110133534953976e-06 0.8984123497545736 1.11013535794417e-06 0.8974436520388238 1.110135517857424e-06 0.8973766233009967 \
1.110148668688723e-06 0.8983720910457982 1.110148779670276e-06 0.8983905835035384 1.110157601254383e-06 0.8993863063850064 1.110158148023847e-06 0.8994226481040219 \
1.110650719976681e-06 0.9003987622903815 1.110650789769166e-06 0.9004496773542636 1.110651622421929e-06 0.9012853800543292 1.110651748468094e-06 0.9014513953152168 \
1.110652328988957e-06 0.9023435091985418 1.110652469953212e-06 0.9025895326188698 1.110652869091291e-06 0.9033428289365844 1.110653019240832e-06 0.9036449200440446 \
1.110653462322153e-06 0.9045762589490434 1.110653619494256e-06 0.9049121924877023 1.110654065120987e-06 0.9058152254958243 1.110654163577326e-06 0.9059929146639856 \
1.11065558025872e-06 0.9052304871087643 1.110655711415865e-06 0.904616184869324 1.110655880423041e-06 0.9036290332250884 1.110656045714916e-06 0.9024406226812831 \
1.110656151980698e-06 0.9015554774641358 1.110656255417528e-06 0.9006052096506509 1.110656341184247e-06 0.8997486040545581 1.110656430678233e-06 0.8987887485205278 \
1.110656554922632e-06 0.8973492764100613 1.11065667300358e-06 0.8958624931586439 1.110656760219672e-06 0.8946938835082598 1.110656884526716e-06 0.8929289312882503 \
1.110656991510644e-06 0.8913158670103165 1.110657091342348e-06 0.8897378501708729 1.110657217633174e-06 0.8876466417139378 1.110657385821785e-06 0.884705368138502 \
1.110657541521538e-06 0.8818365157686672 1.110657738126367e-06 0.8780362649814708 1.110657921747617e-06 0.8743271923380105 1.11065813325501e-06 0.8698916163736473 \
1.110658314064811e-06 0.8659808238081558 1.110658498645858e-06 0.8618945354625286 1.110658671649854e-06 0.8579913311618118 1.110658857050504e-06 0.8537436868396935 \
1.110659036133651e-06 0.8495884889292737 1.110659219722713e-06 0.8452850234109005 1.110659386484418e-06 0.8413449312544377 1.110659554574996e-06 0.8373487193315756 \
1.110659717684167e-06 0.8334514816705533 1.110659872870403e-06 0.829729402178684 1.110660045969282e-06 0.8255639501984255 1.110660231959738e-06 0.8210763864673301 \
1.110660396580222e-06 0.8170961425007568 1.110660561450132e-06 0.8131038678717658 1.110660736782165e-06 0.8088537582860886 1.110660901208668e-06 0.8048648186953292 \
1.110661069844279e-06 0.8007719922541914 1.110661260647645e-06 0.7961398815555145 1.110661446171818e-06 0.7916360074082958 1.110661655100628e-06 0.7865651471012967 \
1.110661879917618e-06 0.7811107659751856 1.110662069732705e-06 0.77650678233121 1.110662271590188e-06 0.7716133355283564 1.110662415860827e-06 0.76811790639139 \
1.110662557504392e-06 0.7646880872338248 1.110662685202102e-06 0.7615975116975136 1.110662796247943e-06 0.7589113686396982 1.11066292481058e-06 0.7558028559024855 \
1.110663057376087e-06 0.7525995467138866 1.110663170697783e-06 0.7498629233610832 1.110663307032409e-06 0.7465723252212872 1.110663413431661e-06 0.7440058350410135 \
1.110663572650447e-06 0.7401674766516904 1.110663745028142e-06 0.7360137588823189 1.110663907275386e-06 0.7321074183421575 1.110664079624344e-06 0.7279612819449855 \
1.110664239010527e-06 0.7241302920521341 1.110664446815714e-06 0.7191408067115369 1.110664607355379e-06 0.7152908836069264 1.110664799844715e-06 0.7106793324906435 \
1.110664985361064e-06 0.7062404417184839 1.110665155237109e-06 0.7021802791355866 1.110665347106947e-06 0.6975984806629684 1.110665493330962e-06 0.6941099299715526 \
1.110665653617309e-06 0.6902897983225644 1.110665856006145e-06 0.6854719661536142 1.110666037294609e-06 0.681161582477689 1.110666206116036e-06 0.6771536053116509 \
1.110666391961911e-06 0.6727470762459599 1.110666597892751e-06 0.6678715161770782 1.110666765819558e-06 0.6639016226084196 1.110666926081261e-06 0.6601182542089066 \
1.110667164933735e-06 0.65448589698252 1.110667332694849e-06 0.6505369020837752 1.110667513768288e-06 0.6462813620835641 1.110667674923199e-06 0.642499550819208 \
1.11066782119046e-06 0.6390715923276049 1.110667959878569e-06 0.6358268652274862 1.110668089235615e-06 0.6328040340451749 1.11066821862017e-06 0.6297855584526113 \
1.11066834694149e-06 0.6267952385336898 1.110668477143629e-06 0.6237652412672913 1.110668606160074e-06 0.6207683673242944 1.110668744735633e-06 0.6175525629501428 \
1.11066889281122e-06 0.6141227553162802 1.110669079138505e-06 0.60981438109949 1.110669226822204e-06 0.6064079319686639 1.11066946198641e-06 0.600995965122186 \
1.110669654434141e-06 0.5965821560879089 1.110669895003955e-06 0.5910808370261941 1.110670064051326e-06 0.587228367631822 1.11067020171775e-06 0.5840969866928536 \
1.110670329822727e-06 0.581191110277254 1.110670443409422e-06 0.5786182870235701 1.110670534774226e-06 0.5765512826027382 1.110670624196113e-06 0.5745328691003393 \
1.110670691457846e-06 0.573016830490748 1.110670757478049e-06 0.5715297341779608 1.110670809531724e-06 0.5703577032508095 1.110670873770593e-06 0.5689124506700958 \
1.110670935307116e-06 0.5675311492520995 1.11067099958866e-06 0.5660899724818867 1.110671052779755e-06 0.5648985048860162 1.11067114512554e-06 0.5628316153148989 \
1.110671221701441e-06 0.5611191615154557 1.110671277545091e-06 0.5598732849310241 1.1106713468882e-06 0.5583285932816697 1.110671452739476e-06 0.5559733466166974 \
1.11067153043128e-06 0.5542469170533902 1.110671631029868e-06 0.5520159549745236 1.110671759063078e-06 0.5491849411292137 1.11067185856046e-06 0.5469885705929382 \
1.110671971125811e-06 0.544508366501287 1.110672074170131e-06 0.5422442603473754 1.110672194219017e-06 0.5396115972585003 1.110672295833426e-06 0.5373863339265779 \
1.110672411457693e-06 0.5348611538529422 1.110672526573874e-06 0.5323536236546169 1.110672653010918e-06 0.529604142030661 1.110672778525186e-06 0.5268822104345234 \
1.110672925204862e-06 0.5237112381511962 1.11067306087557e-06 0.5207845659358002 1.110673218641409e-06 0.5173942078023266 1.11067338106335e-06 0.5139116507621072 \
1.110673561971818e-06 0.5100482739823553 1.110673754563972e-06 0.5059503908118104 1.110673967555743e-06 0.5014368974673542 1.110674199988459e-06 0.4965308659362653 \
1.110674457509373e-06 0.49112491222925 1.110674697473551e-06 0.4861095397820235 1.110674998677906e-06 0.4798501326413723 1.110675286975534e-06 0.4738957353990632 \
1.110675600061861e-06 0.4674739717793394 1.110675919588141e-06 0.4609631488871989 1.110676259085406e-06 0.4540919149088484 1.110676585275518e-06 0.4475353831519197 \
1.11067692175678e-06 0.4408159131180407 1.110677238467587e-06 0.4345373385230166 1.11067757255266e-06 0.4279587671099637 1.110677924261529e-06 0.4210864038135054 \
1.110678238746378e-06 0.4149846225409808 1.110678562192836e-06 0.4087533091618546 1.110679003120948e-06 0.400331870031168 1.110679344916025e-06 0.3938679283557566 \
1.110679644350069e-06 0.3882534014213259 1.110680018872672e-06 0.3812944595528024 1.11068034825039e-06 0.375233915169682 1.110680631354694e-06 0.3700684563936956 \
1.110680931099705e-06 0.3646408765157301 1.110681210595549e-06 0.3596219010422631 1.110681434267487e-06 0.3556377385586224 1.110681645979194e-06 0.3518907610576284 \
1.110681848481927e-06 0.3483292724130969 1.110682049543475e-06 0.3448190020587957 1.110682255221384e-06 0.3412518188287665 1.11068247359686e-06 0.3374887625241871 \
1.110682717359257e-06 0.3333167726275162 1.110682944115829e-06 0.3294678078423895 1.110683164026801e-06 0.3257615367192951 1.110683382451408e-06 0.3221060038181086 \
1.110683586476418e-06 0.318715141566024 1.110683788334208e-06 0.3153870758963987 1.110683988657595e-06 0.3121102802474151 1.110684175271502e-06 0.309079115007194 \
1.110684372573108e-06 0.3058982938882217 1.110684581156335e-06 0.3025606704206737 1.110684786791057e-06 0.2992974534031506 1.110685011523137e-06 0.2957609785165763 \
1.110685228418979e-06 0.2923771984023277 1.110685436098331e-06 0.2891642611511841 1.110685667149178e-06 0.2856239464683982 1.110685841949429e-06 0.2829684481899911 \
1.110686021147604e-06 0.2802647299798244 1.11068619002212e-06 0.2777348429135014 1.110686418345393e-06 0.274348458173166 1.110686595082661e-06 0.2717528218126659 \
1.110686763365392e-06 0.2693020894036587 1.110686935832162e-06 0.2668230333489093 1.110687069934441e-06 0.264903804409765 1.110687215894446e-06 0.2628277003548514 \
1.110687354589946e-06 0.2608803500812688 1.110687476871551e-06 0.2591684246570544 1.110687610990381e-06 0.2572942758553639 1.110687740091486e-06 0.2554978336754472 \
1.11068785952522e-06 0.2538430842138498 1.11068798636042e-06 0.2520939183506197 1.110688106001441e-06 0.2504447954274527 1.110688255617635e-06 0.2483797066042054 \
1.110688390481146e-06 0.2465170278296022 1.11068852003856e-06 0.2447289494531232 1.110688677103379e-06 0.2425624627506451 1.110688801099014e-06 0.2408491463446025 \
1.110688941247149e-06 0.2389135279283614 1.11068907114005e-06 0.2371200701944942 1.11068919175767e-06 0.2354534357320198 1.110689354230601e-06 0.2332087289724075 \
1.110689500284699e-06 0.2311905595759856 1.110689638605484e-06 0.2292825126447264 1.110689746532702e-06 0.2277949627009887 1.110689877317609e-06 0.225993474229161 \
1.110689975823626e-06 0.22463752857886 1.110690079906972e-06 0.2232056532573264 1.110690152783836e-06 0.2222046546567725 1.110690234937313e-06 0.2210804129356655 \
1.110690302346398e-06 0.2201585377209549 1.11069034905066e-06 0.2195201149856669 1.11069039846802e-06 0.2188449488487562 1.110690489422163e-06 0.2176035744446363 \
1.110690555816576e-06 0.2166983392055156 1.110690602779869e-06 0.2160586379972232 1.110690653091075e-06 0.2153737902794619 1.110690712240425e-06 0.2145693142997165 \
1.110690755086328e-06 0.2139870779821451 1.110690798893629e-06 0.2133941263688522 1.110690868423894e-06 0.2124566309962414 1.110690955340708e-06 0.2112864027023158 \
1.110691036529563e-06 0.2101949018929156 1.110691122429026e-06 0.2090416531541652 1.110691216575207e-06 0.2077796428137634 1.110691308329081e-06 0.2065517647617813 \
1.110691403625517e-06 0.2052788208685862 1.110691500104208e-06 0.2039945431316728 1.11069160092949e-06 0.2026602783061639 1.110691696885502e-06 0.2013924147365721 \
1.110691799571213e-06 0.2000377255165624 1.110691902607566e-06 0.1986831378210229 1.110692012697906e-06 0.1972405340748948 1.110692121449794e-06 0.1958206085628783 \
1.110692241171749e-06 0.1942631948714586 1.110692351614651e-06 0.1928328887741874 1.110692459617459e-06 0.1914411844406488 1.110692584973803e-06 0.1898318066870429 \
1.110692677907979e-06 0.1886434908940876 1.110692756278755e-06 0.1876443873000938 1.110692832918829e-06 0.1866698667869858 1.110692915430143e-06 0.1856249297118943 \
1.110692984939759e-06 0.1847473639743596 1.110693050895387e-06 0.1839166514106665 1.110693115162722e-06 0.1831089953192083 1.110693227146207e-06 0.1817072258029639 \
1.110693321200174e-06 0.1805353135896268 1.110693428841935e-06 0.1791985758407087 1.110693535314993e-06 0.1778827552324552 1.11069365530692e-06 0.1764073736674057 \
1.110693793359546e-06 0.174720142305475 1.110693909520101e-06 0.1733081217455876 1.110694071616903e-06 0.1713503924599185 1.11069418670542e-06 0.1699688234017716 \
1.110694326691019e-06 0.1682987764548305 1.110694443897095e-06 0.1669083002780509 1.110694554816447e-06 0.1655990025649634 1.110694652444933e-06 0.1644521190704843 \
1.110694747295481e-06 0.1633427224865242 1.110694863349894e-06 0.161991523106341 1.110694954898444e-06 0.1609305136382055 1.11069505100742e-06 0.1598214181625073 \
1.110695145225553e-06 0.1587403933520305 1.110695238726156e-06 0.1576732160104884 1.110695332323478e-06 0.1566104070550305 1.110695428005016e-06 0.1555300824433628 \
1.110695518592921e-06 0.1545132165873678 1.110695609606078e-06 0.1534969984004868 1.110695705154556e-06 0.1524358767948732 1.110695795820268e-06 0.1514342506187442 \
1.110695898892631e-06 0.1503020548964867 1.11069597134408e-06 0.1495100717445464 1.110696050444873e-06 0.148649146151682 1.110696124993091e-06 0.1478424742503694 \
1.1106961960245e-06 0.1470770917224498 1.110696268788982e-06 0.1462962409077327 1.110696343406157e-06 0.1454990959398698 1.110696413389118e-06 0.1447543557055888 \
1.110696487550038e-06 0.143968261688537 1.110696541295377e-06 0.1434005634796054 1.110696594578932e-06 0.1428396203849428 1.11069665977469e-06 0.1421555039833398 \
1.110696731080731e-06 0.141411576573238 1.110696795450793e-06 0.1407432786314442 1.110696868802754e-06 0.1399847409254479 1.110696929420321e-06 0.1393607073002494 \
1.110697015453805e-06 0.1384787080092832 1.11069709140482e-06 0.1377037134581418 1.110697181372726e-06 0.1367902106004182 1.110697263099684e-06 0.1359645165492482 \
1.110697345789662e-06 0.1351360437760365 1.110697428345969e-06 0.1343145513298757 1.110697533908125e-06 0.1332698421778018 1.110697615775408e-06 0.1324642397250402 \
1.110697713142868e-06 0.1315110876582503 1.110697803143729e-06 0.130634908321232 1.110697891113988e-06 0.1297829978838479 1.110697974043843e-06 0.1289892226181523 \
1.110698048280934e-06 0.1282822873521282 1.110698147931993e-06 0.1273377645104763 1.110698243687052e-06 0.1264350619688987 1.110698330534456e-06 0.1256206895242312 \
1.110698420535994e-06 0.1247808744623497 1.110698500868675e-06 0.1240346855852102 1.110698587562703e-06 0.1232365419604467 1.110698686393032e-06 0.1223331159004786 \
1.11069877647517e-06 0.1215131568528167 1.110698886718427e-06 0.1205141992263624 1.110698973949866e-06 0.1197275966302077 1.110699042523e-06 0.1191120727131645 \
1.110699127185393e-06 0.1183553887582162 1.110699193692874e-06 0.1177634990399222 1.110699265148799e-06 0.1171309945267847 1.110699334822604e-06 0.1165184920865242 \
1.110699412159692e-06 0.1158409171037389 1.110699507902974e-06 0.1150054407698888 1.110699579157887e-06 0.1143861389207103 1.11069964652742e-06 0.1138025718558601 \
1.110699714964191e-06 0.113211685696446 1.110699790554542e-06 0.1125613765304429 1.110699881296389e-06 0.1117840233035959 1.110699964000116e-06 0.1110788257213999 \
1.110700077599187e-06 0.1101151050704521 1.110700187474899e-06 0.1091895325357105 1.110700279674213e-06 0.1084169374841771 1.110700403623544e-06 0.1073835127717347 \
1.110700491987867e-06 0.1066505015902263 1.110700631446837e-06 0.1055001025916527 1.110700730743538e-06 0.1046863788921388 1.11070082339359e-06 0.1039306459201802 \
1.110700933598102e-06 0.1030359883605075 1.110701018892542e-06 0.1023467905686673 1.110701103793345e-06 0.101663637589173 1.110701186744308e-06 0.1009989740617136 \
1.11070130925421e-06 0.1000225794851696 1.110701431196063e-06 0.09905761200121259 1.110701557818349e-06 0.09806258992746317 1.110701670630472e-06 0.09718220909187772 \
1.110701815205956e-06 0.09606278874246346 1.110701952919884e-06 0.09500564015228773 1.110702069610674e-06 0.09411672853020667 1.110702197354242e-06 0.0931507147971556 \
1.110702297018758e-06 0.09240236948627445 1.110702376452637e-06 0.09180921593916676 1.110702475187935e-06 0.09107599640376031 1.110702553063239e-06 0.09050081472416407 \
1.110702634529155e-06 0.08990210528957472 1.110702709246463e-06 0.0893557072655629 1.110702789776201e-06 0.08876971652456604 1.110702908608526e-06 0.08791061481419053 \
1.110702998269062e-06 0.08726673116015753 1.110703103183109e-06 0.08651800316437093 1.110703234657667e-06 0.08558693768262025 1.110703395765802e-06 0.08445695903909305 \
1.110703535947497e-06 0.08348350561263763 1.110703684450103e-06 0.08246223579158835 1.110703821170292e-06 0.08153124812726546 1.110703961182002e-06 0.08058696725890066 \
1.110704098179202e-06 0.07967195061625794 1.110704236789813e-06 0.07875532825288725 1.1107043812627e-06 0.07780967510081127 1.110704528808937e-06 0.07685421131041187 \
1.110704686312648e-06 0.07584560580436887 1.110704850707884e-06 0.07480523464991846 1.110705018799982e-06 0.07375451744755303 1.110705199799341e-06 0.07263751640721161 \
1.110705398512623e-06 0.07142823309373261 1.110705611921415e-06 0.07014922396308329 1.1107058380853e-06 0.06881630383186611 1.110706078645623e-06 0.06742468841361035 \
1.110706356206535e-06 0.06585179211508728 1.110706653410938e-06 0.06420523370201831 1.110706971711662e-06 0.06248365192299224 1.110707361695962e-06 0.06043183534616462 \
1.110707760522748e-06 0.05839861031494715 1.110708202994687e-06 0.05621846258761681 1.11070858797559e-06 0.05438828987170503 1.110709000022182e-06 0.05249218901100536 \
1.110709351759698e-06 0.05092353490091287 1.11070968726435e-06 0.04946969867921969 1.110709997763245e-06 0.04816021644386199 1.110710291700064e-06 0.04695194805701195 \
1.110710584430997e-06 0.04577883625507727 1.110710859274204e-06 0.04470700909733757 1.110711133117927e-06 0.04366353526031765 1.110711398807687e-06 0.04267398813878486 \
1.110711674116703e-06 0.04167180388267511 1.110711958673621e-06 0.04066026046469497 1.110712254971736e-06 0.03963283340811159 1.110712513847122e-06 0.03875659098599576 \
1.110712741803528e-06 0.03800131046948733 1.110712960528722e-06 0.03729095380188759 1.110713180383449e-06 0.03659437723507575 1.110713521249513e-06 0.03554043311314246 \
1.110713797290394e-06 0.03470953269536187 1.110714090721169e-06 0.03384790442147732 1.110714373289092e-06 0.03303898052111545 1.110714628198529e-06 0.03232625790162248 \
1.110714908882988e-06 0.03155947796597136 1.110715154716382e-06 0.03090318379665042 1.11071538687767e-06 0.03029616297556957 1.110715627215008e-06 0.02968398395812225 \
1.110715862851843e-06 0.02909722707395018 1.110716091063021e-06 0.0285403787496557 1.110716507835749e-06 0.02755138287878544 1.110716702361127e-06 0.02710176794309662 \
1.110717088601532e-06 0.02623051698020805 1.110717267770925e-06 0.0258356865503758 1.110717618998108e-06 0.02507792837274256 1.110717786904157e-06 0.0247229612172224 \
1.110718171166812e-06 0.02392944198669211 1.110718286448541e-06 0.02369675911063252 1.110718728496378e-06 0.02282172072611499 1.110718950311652e-06 0.02239223679446916 \
1.110719473931311e-06 0.02139838041889957 1.11071962929382e-06 0.02110714647916685 1.110720146999887e-06 0.02015295207761772 1.110720272033152e-06 0.01992792118872039 \
1.110720796234659e-06 0.01901759738223179 1.110720932454034e-06 0.01879045572456909 1.11072153873049e-06 0.01783210191617334 1.110721705739623e-06 0.01758082406519646 \
1.110722348947267e-06 0.01666064795441237 1.110722528091535e-06 0.0164167113061686 1.110723218250269e-06 0.01551958953683085 1.110723381870153e-06 0.01531511209162885 \
1.11072414235084e-06 0.01440332854054019 1.110724289392963e-06 0.01423371673427115 1.110725107264621e-06 0.01333087949608782 1.110725226813134e-06 0.01320411419549955 \
1.110726142674656e-06 0.01227329163592313 1.110726284027572e-06 0.01213544173166964 1.110727232503148e-06 0.01124488043697059 1.110727391142586e-06 0.01110230805801717 \
1.11072857354363e-06 0.01011356759191894 1.11072867164402e-06 0.01003725601038859 1.11072993325548e-06 0.009120360285939955 1.11073006766933e-06 0.009028655389366201 \
1.110731608240655e-06 0.008043892937307966 1.110731689273999e-06 0.007992925041580451 1.110733277867931e-06 0.007023242357651564 1.110733410759078e-06 0.006948518507451114 \
1.11073538746242e-06 0.005952856104192286 1.110735569200568e-06 0.005869662958407677 1.110737671554228e-06 0.004980929874643355 1.110738112345997e-06 0.004810448874467742 \
1.110740767560855e-06 0.003892108290451164 1.110741244140394e-06 0.003745909362026665 1.110744882222615e-06 0.00279447349697209 1.110745407746061e-06 0.002678838783887205 \
1.110751013810845e-06 0.001700248310874221 1.110751324898547e-06 0.001653333728976835 1.110756459226246e-06 0.0006858192122199529 1.110756653206019e-06 0.0006440832883579712 \
1.113404576914862e-06 -0.0002037173203380238 1.113404741115283e-06 -0.0003889174928863678 1.113405314458091e-06 -0.001270938904608877 1.113405389392278e-06 -0.001411855863724778 \
1.113405849976055e-06 -0.002393592696522268 1.113405961916807e-06 -0.002660411672198376 1.113406215188795e-06 -0.003300974950034667 1.1134063815721e-06 -0.003745951779090856 \
1.11340667656787e-06 -0.004566571567208835 1.113406788055442e-06 -0.00488071790655901 1.113407067428216e-06 -0.005641221413069743 1.113407188386555e-06 -0.005938820066262044 \
1.113408282339389e-06 -0.005180465225493313 1.113408406471631e-06 -0.004410796826645887 1.113408530879049e-06 -0.003456122327429311 1.113408650435429e-06 -0.002364170815481491 \
1.113408748579805e-06 -0.001341064316055312 1.113408855004127e-06 -0.0001052154991983786 1.113408967239972e-06 0.001336046702817826 1.113409102195821e-06 0.003249882807978809 \
1.113409224782331e-06 0.005149402351921401 1.113409413644246e-06 0.008353592055059769 1.113409554826579e-06 0.01094873860302964 1.113409708187922e-06 0.01393943619118621 \
1.113409851561427e-06 0.01687898420971235 1.113410005752867e-06 0.02017576688295359 1.113410161892825e-06 0.02363796584892512 1.113410317618878e-06 0.02719811802828209 \
1.113410465112557e-06 0.03065407560139007 1.113410613784323e-06 0.03420778369279751 1.113410769114407e-06 0.03798436241030867 1.113410927740287e-06 0.04189786275883118 \
1.113411092673448e-06 0.0460171220807938 1.113411267096336e-06 0.05041857973200652 1.113411446085736e-06 0.05497510627343041 1.113411635385597e-06 0.05982852266675163 \
1.113411838393603e-06 0.06506368941101938 1.113412057870669e-06 0.07075025585284363 1.113412288935331e-06 0.07675903373893865 1.113412535995649e-06 0.08319974270080552 \
1.113412806420637e-06 0.0902619122132732 1.113413099984324e-06 0.09793335781011638 1.113413424033306e-06 0.1064001814721126 1.113413788254856e-06 0.1159066558703892 \
1.113414180806326e-06 0.1261372395632307 1.113414630304251e-06 0.1378252442462487 1.113415153096484e-06 0.1513754922073403 1.113415766694219e-06 0.1672157090591849 \
1.113416444455093e-06 0.184625848284817 1.113417232720212e-06 0.2047487967247964 1.113418115553072e-06 0.22712469896725 1.113418933839029e-06 0.2476994923478653 \
1.113419661268608e-06 0.2658503723959502 1.113420301381636e-06 0.2817009601644404 1.11342087568535e-06 0.2958213763442377 1.113421413251317e-06 0.3089396094373287 \
1.113421917248776e-06 0.3211464104224903 1.11342239337143e-06 0.3325930942309646 1.113422871259445e-06 0.3439912352478621 1.113423324592551e-06 0.3547121966731367 \
1.113423795885259e-06 0.3657614311162562 1.113424238561085e-06 0.3760518588326446 1.113424757059872e-06 0.3879885572071845 1.113425284221992e-06 0.3999987293386327 \
1.113425663131623e-06 0.4085537955782026 1.113426193047166e-06 0.4204060347738258 1.113426622963746e-06 0.429919877745455 1.113427076664521e-06 0.4398653393542544 \
1.113427543378037e-06 0.4500002271552926 1.113427981059267e-06 0.4594210430579985 1.113428389021531e-06 0.468120704286539 1.113428708454565e-06 0.4748816926501604 \
1.113429080589837e-06 0.4826992142337162 1.113429315571978e-06 0.4876010339127531 1.113429549178225e-06 0.4924491904621348 1.113429797190648e-06 0.4975647713404599 \
1.113430095592078e-06 0.5036796627825791 1.11343035194848e-06 0.5088948470128004 1.11343056424179e-06 0.5131878547336713 1.113430758259862e-06 0.5170959594548015 \
1.113430905246394e-06 0.5200432695146362 1.113431059224405e-06 0.523118600542271 1.113431277106154e-06 0.5274469616807909 1.11343153021048e-06 0.5324525256580425 \
1.113431740049324e-06 0.5365797337241586 1.113431951502633e-06 0.5407247601751553 1.113432233709534e-06 0.5462280430697679 1.113432463254817e-06 0.5506821559930507 \
1.113432679151024e-06 0.5548604062613707 1.113432961372541e-06 0.560308769190463 1.113433212680268e-06 0.5651538146135803 1.11343351034116e-06 0.5708625224168123 \
1.113433760568061e-06 0.5756519166658941 1.113434016931556e-06 0.5805516059354519 1.11343425734157e-06 0.585116682128892 1.113434515521386e-06 0.5900038400537884 \
1.113434739113591e-06 0.5942175703762435 1.113434977623163e-06 0.5986919452581434 1.113435185207862e-06 0.6025689278491061 1.113435401730486e-06 0.6065904171332736 \
1.113435651033092e-06 0.6111939272561876 1.113435856106535e-06 0.6149609706257601 1.11343610737886e-06 0.6195555361399968 1.113436310600886e-06 0.6232455818254186 \
1.113436507472791e-06 0.6267987644955494 1.113436700764307e-06 0.630267737067843 1.113436955542762e-06 0.6348113783570861 1.113437185753374e-06 0.638887973644319 \
1.113437403107185e-06 0.6427143472883045 1.113437701512908e-06 0.6479268061885751 1.113437916915757e-06 0.6516657345437264 1.113438118139476e-06 0.6551344108237934 \
1.113438293060984e-06 0.6581323437428509 1.113438458126254e-06 0.6609495238976936 1.113438627594775e-06 0.6638251431769452 1.113438779731612e-06 0.666392827642013 \
1.113438917642298e-06 0.6687037209181631 1.113439066478412e-06 0.6711867545200138 1.113439194593014e-06 0.6733159837320549 1.113439337815827e-06 0.6756849429836936 \
1.113439459090078e-06 0.6776819274526149 1.113439596688762e-06 0.6799401191146522 1.113439716069216e-06 0.6818929034138137 1.113439863176962e-06 0.6842914131385206 \
1.113439980378628e-06 0.6861933934268433 1.113440073884205e-06 0.6877071857403232 1.113440164873897e-06 0.6891752279197846 1.113440267615961e-06 0.6908280855439021 \
1.113440369133525e-06 0.6924555900607121 1.113440487516631e-06 0.6943444167618776 1.113440599637217e-06 0.6961264383846065 1.113440717192718e-06 0.6979868779962457 \
1.113440902343005e-06 0.7008959348649784 1.113441033535213e-06 0.7029413755586562 1.113441169703753e-06 0.7050491462541959 1.113441291222456e-06 0.7069171228306749 \
1.113441431145468e-06 0.7090538254196674 1.113441535088117e-06 0.7106315721465845 1.113441646249101e-06 0.712309798010818 1.113441750508965e-06 0.7138759052437967 \
1.113441880147056e-06 0.7158124745844324 1.113441977077769e-06 0.7172526339884565 1.113442116000004e-06 0.7193052800722975 1.113442235549293e-06 0.7210612846995991 \
1.113442355121865e-06 0.7228080613301419 1.113442480897243e-06 0.7246353354365959 1.113442607615586e-06 0.7264656873164689 1.113442729655437e-06 0.728218443613998 \
1.11344285780388e-06 0.7300486655261287 1.113442987872205e-06 0.7318956587421809 1.113443108863227e-06 0.7336041830685722 1.113443249633811e-06 0.7355801168346318 \
1.11344335060338e-06 0.7369898206659778 1.113443452204237e-06 0.7384020079314992 1.113443548224548e-06 0.7397310783624924 1.113443659137403e-06 0.7412570822736337 \
1.11344374678503e-06 0.7424563811251772 1.113443846639401e-06 0.7438154404043728 1.113443981404538e-06 0.7456370856934184 1.113444097699018e-06 0.747198032089633 \
1.113444201190815e-06 0.7485782798032956 1.113444325446263e-06 0.7502239458264747 1.113444470359203e-06 0.7521280942578691 1.113444588339771e-06 0.753666143975803 \
1.113444707270879e-06 0.7552056331692281 1.113444846850418e-06 0.7569980918234445 1.113444991202808e-06 0.7588357421297242 1.113445109263616e-06 0.7603265096672839 \
1.113445234085335e-06 0.7618908200857619 1.113445373916531e-06 0.7636286950759973 1.113445498679428e-06 0.7651662633748356 1.113445642192899e-06 0.7669199865864609 \
1.113445762878377e-06 0.7683824344671055 1.113445883722124e-06 0.7698356273746885 1.113446003367048e-06 0.7712633747646481 1.113446133074687e-06 0.7727989859455529 \
1.11344624181849e-06 0.7740766298596218 1.113446364466226e-06 0.7755070372682662 1.113446474242911e-06 0.7767778749889983 1.113446603267025e-06 0.7782599816788072 \
1.113446735043344e-06 0.7797610257751375 1.11344684835592e-06 0.7810403609326458 1.113446969441862e-06 0.7823954393038701 1.113447073314495e-06 0.7835479431998941 \
1.113447215597517e-06 0.785111775748914 1.113447363800666e-06 0.7867227488076519 1.113447522694201e-06 0.7884297907063792 1.113447642887223e-06 0.7897074707829422 \
1.11344779245393e-06 0.7912811323018302 1.113447916569147e-06 0.7925734175081853 1.113448042273444e-06 0.7938699048627912 1.113448145219011e-06 0.7949224966762399 \
1.113448259590165e-06 0.7960823495211882 1.113448372064409e-06 0.7972131756542409 1.113448462336983e-06 0.7981137961420948 1.113448551677879e-06 0.7989989930139054 \
1.113448676903817e-06 0.800229513878344 1.11344878467518e-06 0.8012785338618679 1.113448914342978e-06 0.8025281307685926 1.113449035722257e-06 0.8036855380110038 \
1.113449152278057e-06 0.8047859282369955 1.113449273083453e-06 0.80591497746663 1.113449405708758e-06 0.8071413435168892 1.113449527502378e-06 0.8082555056211007 \
1.113449654106103e-06 0.8094015704683005 1.113449779719621e-06 0.8105266036187198 1.113449899211046e-06 0.8115857443778658 1.113450037409299e-06 0.8127973981963581 \
1.113450146908547e-06 0.8137473213416323 1.113450231056662e-06 0.8144713378799666 1.11345035186072e-06 0.8155017394983226 1.113450447369557e-06 0.8163089346032877 \
1.11345058366036e-06 0.8174496006492775 1.113450726424414e-06 0.8186303638797883 1.113450860857535e-06 0.8197292014569521 1.113450970729519e-06 0.8206175763825388 \
1.113451114629137e-06 0.8217677661037901 1.11345126795672e-06 0.8229768690765377 1.113451395805574e-06 0.8239722812379519 1.113451536202905e-06 0.8250521595273246 \
1.113451662107844e-06 0.8260088941474263 1.11345181672401e-06 0.8271688948348412 1.11345194907934e-06 0.8281489842609937 1.113452075346168e-06 0.8290730392392056 \
1.113452193006695e-06 0.8299245984162376 1.113452341409092e-06 0.8309852945996649 1.11345250860326e-06 0.8321626230293395 1.113452641380572e-06 0.8330844501529713 \
1.113452814281769e-06 0.8342675727345584 1.113452982699063e-06 0.8354015168591284 1.113453152193536e-06 0.8365246342267009 1.113453333630418e-06 0.8377070668209077 \
1.113453476186559e-06 0.8386219603417975 1.11345359009745e-06 0.8393441765511721 1.113453720973658e-06 0.8401643924869071 1.113453822596633e-06 0.8407940582489307 \
1.113453939036871e-06 0.8415078269750864 1.113454074330057e-06 0.8423269142909066 1.113454271595159e-06 0.8435017451489455 1.113454462114483e-06 0.844614933042255 \
1.113454672039296e-06 0.8458175693076773 1.113454852817827e-06 0.8468334846981137 1.113455050185846e-06 0.8479221976595614 1.11345522404434e-06 0.8488638701886076 \
1.113455406558583e-06 0.8498353939890455 1.113455577902694e-06 0.8507314120859523 1.113455752248258e-06 0.8516272398309612 1.113455927651258e-06 0.8525125793730954 \
1.113456103896448e-06 0.8533864315694911 1.113456293665326e-06 0.8543099749208749 1.113456484423344e-06 0.8552205033559714 1.11345668621255e-06 0.8561646193034282 \
1.113456878916116e-06 0.8570482883232282 1.113457088356793e-06 0.8579892478796384 1.113457318098559e-06 0.8589986827500428 1.113457583567511e-06 0.8601360945383778 \
1.113457882213856e-06 0.8613786760148464 1.113458160601222e-06 0.8625023989005415 1.113458444791177e-06 0.8636161469557806 1.113458719285784e-06 0.8646608622318305 \
1.113458991377281e-06 0.8656672252055042 1.113459261593727e-06 0.8666387059277968 1.113459518761915e-06 0.8675381145236246 1.113459791320979e-06 0.8684653318325959 \
1.11346006734232e-06 0.8693777905953765 1.113460337484171e-06 0.8702455402709716 1.113460637231955e-06 0.8711796653984102 1.113461008105812e-06 0.872294745819888 \
1.113461303028797e-06 0.8731503023941 1.113461557284845e-06 0.8738665406311316 1.113461855515577e-06 0.8746822274488602 1.113462129133901e-06 0.8754080260278182 \
1.113462365269549e-06 0.8760175227551726 1.113462605621406e-06 0.876622281264788 1.113462827963785e-06 0.8771680781109068 1.113463021968128e-06 0.8776338860468618 \
1.113463351691207e-06 0.8784037109613512 1.11346350686397e-06 0.8787567114621292 1.113463824616497e-06 0.879461652496718 1.113464003481858e-06 0.8798480920375044 \
1.113464345943324e-06 0.8805675499479563 1.113464530084847e-06 0.8809434933546246 1.113465004990284e-06 0.8818790560183651 1.113465172384703e-06 0.8821975058309585 \
1.113465638216128e-06 0.8830540251881659 1.113465819040967e-06 0.8833751042472839 1.113466313074347e-06 0.8842212008576973 1.113466454417056e-06 0.884455124402366 \
1.113467060806836e-06 0.8854193259359495 1.113467212878983e-06 0.8856514227360587 1.11346785955747e-06 0.8865980751852495 1.113467987853824e-06 0.8867785329419297 \
1.113468635979926e-06 0.8876550049536978 1.113468765772447e-06 0.8878236738033012 1.113469544034095e-06 0.8887860366092379 1.113469659025973e-06 0.8889208282599539 \
1.113470514758392e-06 0.8898661633196656 1.113470660021537e-06 0.8900169066926564 1.113471645777722e-06 0.8909664261264102 1.113471866882863e-06 0.8911622482549515 \
1.113473011997307e-06 0.8921020388386462 1.113473143207264e-06 0.8922053928944147 1.113474330865799e-06 0.8931033243919096 1.113474484486091e-06 0.8932130731307282 \
1.113475894522803e-06 0.8941348173026452 1.113476117329622e-06 0.8942660193790342 1.11347779802033e-06 0.8951452796684343 1.113478125641509e-06 0.8952966652167414 \
1.113480355582631e-06 0.8961896554712738 1.113480908496592e-06 0.8963788593752812 1.113484476711123e-06 0.8973573335043913 1.113484800223538e-06 0.8974284307984646 \
1.113491156631826e-06 0.8984120886469452 1.113491705534673e-06 0.8984686671268907 1.113544207609024e-06 0.8994658645395698 1.113544850637886e-06 0.8994692460188505 \
1.11373698930852e-06 0.9004073346715066 1.113737190722491e-06 0.9004708280105613 1.113741150500432e-06 0.8995366825576255 1.11374133452723e-06 0.8993953949813248 \
1.113742651124504e-06 0.8984641879157507 1.113742823168359e-06 0.8983566564859006 1.113744719544654e-06 0.8973720929359315 1.113744893250842e-06 0.897304621671452 \
1.113757467177875e-06 0.8982933655523699 1.113757552368112e-06 0.8983081509245614 1.113765819241151e-06 0.8993078551592517 1.113766293960572e-06 0.8993433667976791 \
1.114259794870012e-06 0.9002974142054325 1.114259914349736e-06 0.9003767372269074 1.114260807172786e-06 0.9012336455299185 1.114260953429423e-06 0.901423267690772 \
1.114261548322101e-06 0.9023325668564308 1.114261683292918e-06 0.9025673929107925 1.114262187968707e-06 0.9035294259428087 1.114262320579608e-06 0.9038000271808221 \
1.114262721206973e-06 0.9046475051114249 1.114262865572371e-06 0.9049556543240072 1.11426328869358e-06 0.9058123566484279 1.114263384150638e-06 0.9059850892484415 \
1.114264808709455e-06 0.9052205906349737 1.114264933747309e-06 0.9046352442223391 1.114265060157898e-06 0.9039223775493039 1.114265162806642e-06 0.9032486771507763 \
1.114265290021932e-06 0.9022944222362175 1.114265408867758e-06 0.9012801950564071 1.114265506520237e-06 0.9003603330664713 1.114265588522258e-06 0.8995243596151602 \
1.114265668185821e-06 0.8986589236008835 1.114265778963989e-06 0.8973708307079206 1.114265880140004e-06 0.8961049472956977 1.114265963084475e-06 0.8950067229086057 \
1.114266071529893e-06 0.8934921260891034 1.11426617999385e-06 0.8918872687155874 1.114266275049989e-06 0.8904106867557802 1.114266395922641e-06 0.8884444419111864 \
1.114266516699262e-06 0.8863849482818795 1.114266629744433e-06 0.8843763393508186 1.114266732915182e-06 0.8824794505619851 1.114266818515338e-06 0.8808620855018965 \
1.114266892989399e-06 0.8794251273161163 1.114266987312942e-06 0.8775673968166831 1.114267075773858e-06 0.8757888800524039 1.11426715484687e-06 0.8741711975775893 \
1.114267248834225e-06 0.872216793437976 1.114267330179529e-06 0.8704993514258973 1.114267425093555e-06 0.8684673705816817 1.114267518136275e-06 0.8664480751909672 \
1.114267614922069e-06 0.8643215060814092 1.114267738217441e-06 0.8615778533848952 1.114267851664452e-06 0.859022019682563 1.114267977516491e-06 0.8561558571929792 \
1.114268100844635e-06 0.8533196845306243 1.114268230022926e-06 0.850323637950593 1.114268370619783e-06 0.8470370034914 1.114268479399505e-06 0.8444782910716596 \
1.114268614459257e-06 0.8412850455921466 1.114268724119566e-06 0.8386804253780991 1.114268853299345e-06 0.8356002443501571 1.114268979483175e-06 0.8325812421138936 \
1.11426910657353e-06 0.8295317031556502 1.114269235595804e-06 0.826427745883674 1.114269344676045e-06 0.8237985689995477 1.114269484526701e-06 0.8204223029647078 \
1.114269623954893e-06 0.8170507778356514 1.114269756708524e-06 0.8138366863616762 1.114269886777199e-06 0.8106848159989707 1.114270010472646e-06 0.8076853837479523 \
1.114270147427036e-06 0.8043627031572629 1.114270261138882e-06 0.8016030849198694 1.114270388615923e-06 0.7985086235398901 1.114270499416994e-06 0.7958187897651571 \
1.114270618603452e-06 0.7929254985494992 1.114270731982509e-06 0.7901733724735396 1.114270866292901e-06 0.7869138859547327 1.114270973387169e-06 0.7843152933129034 \
1.114271089404312e-06 0.7815009627552112 1.114271218595275e-06 0.778367508739124 1.11427131620771e-06 0.7760002683782802 1.114271421787151e-06 0.773440790716327 \
1.11427153046932e-06 0.7708069008430674 1.114271632885583e-06 0.7683258101021144 1.114271726279241e-06 0.7660641808432364 1.114271845835017e-06 0.7631702213567544 \
1.114271938307379e-06 0.7609327305817616 1.114272030945494e-06 0.7586922094322426 1.11427212937031e-06 0.7563124992069843 1.114272237347962e-06 0.7537030947613649 \
1.114272333616474e-06 0.7513778334636231 1.114272419872877e-06 0.7492952979736797 1.114272522736666e-06 0.7468128004450286 1.114272601580994e-06 0.744910856519283 \
1.114272702387036e-06 0.7424801602439853 1.114272836915276e-06 0.7392377693660663 1.114272974140136e-06 0.7359316755186537 1.114273117619987e-06 0.7324773442723981 \
1.114273266044177e-06 0.7289066083419234 1.114273409305472e-06 0.7254625447335662 1.114273549382451e-06 0.7220977259655398 1.114273705808317e-06 0.7183435968963056 \
1.114273830210067e-06 0.715360858370426 1.114273951271848e-06 0.7124600029613375 1.11427410478411e-06 0.7087850045121084 1.114274239566055e-06 0.7055614325718365 \
1.114274365665088e-06 0.7025479112911024 1.114274508839371e-06 0.6991289103945657 1.114274628921163e-06 0.6962626602560111 1.114274758155491e-06 0.6931807499479741 \
1.114274864640539e-06 0.6906432840523983 1.114274976916361e-06 0.6879696524977363 1.114275073251648e-06 0.6856773754336868 1.11427517606134e-06 0.683232326200841 \
1.114275270865193e-06 0.6809792012818872 1.114275376187123e-06 0.6784784437814733 1.114275484625777e-06 0.6759058899658261 1.114275583635058e-06 0.673558569590366 \
1.11427570039165e-06 0.6707929011939652 1.114275808476928e-06 0.6682347329991606 1.114275918483137e-06 0.6656332609774134 1.114276004570979e-06 0.6635992664604092 \
1.114276134166118e-06 0.6605400273835189 1.114276226767366e-06 0.6583552307294462 1.114276322555092e-06 0.6560965362104854 1.114276407507078e-06 0.6540950852804182 \
1.114276526801602e-06 0.6512869789851043 1.11427661407154e-06 0.6492343850333612 1.114276704778561e-06 0.6471030993779646 1.114276805943536e-06 0.6447280068361273 \
1.114276885774359e-06 0.6428551652550211 1.114276974560194e-06 0.6407732405330839 1.11427705225042e-06 0.6389536101386547 1.114277114019368e-06 0.6375081226244841 \
1.114277177784013e-06 0.6360167668935747 1.114277241018233e-06 0.634538653569437 1.114277280258806e-06 0.6336218002627473 1.114277320897828e-06 0.6326726453797233 \
1.114277400982362e-06 0.6308039353694699 1.114277470886542e-06 0.6291742390428672 1.114277521523257e-06 0.6279942052995945 1.114277560272899e-06 0.6270914175114127 \
1.114277599267879e-06 0.6261832343283663 1.114277643882627e-06 0.6251445623164014 1.114277686739083e-06 0.6241478292286105 1.114277737053687e-06 0.6229782634938205 \
1.114277788990864e-06 0.6217719122409077 1.114277874058449e-06 0.6197972300178722 1.114277934038866e-06 0.6184052992407258 1.114278023826075e-06 0.61632338076978 \
1.114278100290156e-06 0.6145529519516876 1.114278179854447e-06 0.6127119801362371 1.114278260891059e-06 0.6108383709630588 1.114278350105382e-06 0.6087775861620425 \
1.114278440965394e-06 0.6066826282541496 1.114278528184102e-06 0.6046739453334793 1.114278621957293e-06 0.6025158549334848 1.114278723642756e-06 0.6001788642681311 \
1.114278823240849e-06 0.5978941858483342 1.114278935095889e-06 0.5953317151711254 1.114279051129026e-06 0.5926772450523136 1.114279172750132e-06 0.5899020947998995 \
1.114279277133946e-06 0.5875236635596754 1.114279421924166e-06 0.5842296531729801 1.114279534584127e-06 0.5816734289694181 1.114279643596094e-06 0.5792035939892568 \
1.114279736075537e-06 0.5771100174076607 1.114279829526177e-06 0.5749994714793375 1.11427992185204e-06 0.5729181236728181 1.114279994438741e-06 0.571283073141143 \
1.114280050392967e-06 0.5700232888304386 1.114280111461248e-06 0.5686498830286455 1.114280209950764e-06 0.5664400707212188 1.114280273162208e-06 0.5650238531380825 \
1.114280333588177e-06 0.5636708824310654 1.11428041053656e-06 0.5619492451093103 1.114280473695101e-06 0.5605380106414651 1.11428056200871e-06 0.558569506627369 \
1.114280633210033e-06 0.5569845302974165 1.114280719745787e-06 0.555060151797141 1.11428084109856e-06 0.5523665438352664 1.114280969027808e-06 0.5495364947125975 \
1.114281067158439e-06 0.5473694328713704 1.114281180282435e-06 0.5448752016832871 1.114281282350254e-06 0.5426314425864434 1.114281401299124e-06 0.5400217272291628 \
1.114281504386832e-06 0.5377630705755105 1.114281618593986e-06 0.5352670017334624 1.114281732009658e-06 0.532794946211756 1.114281859080713e-06 0.5300302694710822 \
1.114281982900802e-06 0.5273426867079006 1.114282127689607e-06 0.5242103332418484 1.11428226351311e-06 0.5212782585303676 1.114282418567968e-06 0.5179428401013338 \
1.114282579419853e-06 0.5144913885072363 1.114282758149301e-06 0.5106699876709851 1.11428294832834e-06 0.5066200804011861 1.114283158230362e-06 0.5021665212646098 \
1.114283386936347e-06 0.4973332357952056 1.114283640864285e-06 0.4919960258408594 1.114283881797751e-06 0.4869529241725989 1.114284177960236e-06 0.4807889695952298 \
1.114284467957623e-06 0.4747910561470179 1.114284774200956e-06 0.4684976697011882 1.114285094876887e-06 0.4619520863481486 1.114285422744054e-06 0.4553041925245184 \
1.114285762989109e-06 0.4484521981997251 1.114286088414654e-06 0.4419418052309769 1.114286410321802e-06 0.4355465312739703 1.114286740535907e-06 0.4290298934287748 \
1.114287096528499e-06 0.4220583188787752 1.114287415406928e-06 0.4158579595363656 1.114287752858691e-06 0.4093433989943853 1.114288180725407e-06 0.4011531841887147 \
1.114288529437356e-06 0.3945419525178304 1.114288837073319e-06 0.388759214407489 1.114289216899811e-06 0.3816861832573664 1.114289548089372e-06 0.3755780492082042 \
1.114289831697452e-06 0.370391509977049 1.114290142516397e-06 0.3647512908748707 1.114290421833005e-06 0.3597258263082204 1.114290648329153e-06 0.3556836811642302 \
1.114290864011538e-06 0.3518598964090484 1.114291061295543e-06 0.3483842179544538 1.114291266280002e-06 0.3447988491770444 1.114291478501966e-06 0.3411119200457455 \
1.114291733807154e-06 0.33670771290924 1.114291975329403e-06 0.3325734463267218 1.114292206706731e-06 0.3286464933807047 1.114292421559231e-06 0.3250253651850565 \
1.114292642118388e-06 0.3213332986541765 1.114292843544355e-06 0.3179852906236645 1.114293046612606e-06 0.3146379646143546 1.114293244508216e-06 0.3114011111455273 \
1.114293431469302e-06 0.3083651674074345 1.114293625269522e-06 0.3052406640298299 1.114293829186134e-06 0.3019773030815858 1.114294008255468e-06 0.2991336297844484 \
1.114294243846324e-06 0.2954229173226265 1.114294444650423e-06 0.2922868215109002 1.114294645829315e-06 0.2891696385850206 1.114294869639057e-06 0.2857334090862961 \
1.114295034201803e-06 0.2832271910241367 1.114295211129189e-06 0.2805503385691353 1.114295396922194e-06 0.2777610713150803 1.11429557873767e-06 0.2750538970423583 \
1.114295757762463e-06 0.2724132377985424 1.114295925107616e-06 0.2699606650006489 1.114296085536534e-06 0.2676371805838822 1.114296208110285e-06 0.2658719571410424 \
1.114296357874814e-06 0.2637236906090554 1.11429648557194e-06 0.2619099339733745 1.114296592880312e-06 0.2603957336038235 1.114296708880974e-06 0.2587625259947361 \
1.11429681918957e-06 0.2572125806747212 1.114296945068767e-06 0.2554509781935611 1.114297060550618e-06 0.2538402638894013 1.114297195131521e-06 0.2519757335310172 \
1.114297307194775e-06 0.2504255755821768 1.114297457534135e-06 0.2483447107137444 1.114297597159989e-06 0.2464124269747185 1.11429774305181e-06 0.2444035064209518 \
1.114297876012448e-06 0.2425734862730615 1.114297999574161e-06 0.2408709992523319 1.114298146783853e-06 0.2388417729476062 1.114298263370682e-06 0.2372355665500016 \
1.114298402825831e-06 0.23532008003217 1.114298537000301e-06 0.2334768281602104 1.114298662976757e-06 0.2317465561243653 1.11429878237616e-06 0.2301094434087779 \
1.114298877230585e-06 0.2288105340759602 1.114298990368184e-06 0.2272617792622066 1.114299070684642e-06 0.2261626001158484 1.114299158249699e-06 0.2249657246820506 \
1.114299283786835e-06 0.2232507767215072 1.114299389480543e-06 0.2218101326756785 1.114299479135054e-06 0.2205921574607158 1.114299549986253e-06 0.2196300825522397 \
1.114299593014783e-06 0.2190460135436258 1.114299635305326e-06 0.2184724035808872 1.114299677647042e-06 0.2178984240735344 1.114299749842462e-06 0.2169203674089526 \
1.114299792235817e-06 0.2163464205126744 1.114299827490656e-06 0.2158693585303403 1.114299871682239e-06 0.2152716287340076 1.114299941290466e-06 0.2143309212991285 \
1.114299975633797e-06 0.2138672544767182 1.114300020093325e-06 0.2132698436071631 1.114300087771806e-06 0.2123628126304402 1.114300174199065e-06 0.2112058698236149 \
1.114300248835667e-06 0.2102078598594563 1.114300330137675e-06 0.2091219706754807 1.114300427015059e-06 0.2078300362310651 1.114300552998548e-06 0.2061528795789772 \
1.114300655533384e-06 0.2047906894256944 1.114300757016901e-06 0.2034500128132261 1.114300858082597e-06 0.202119416354989 1.114300954696816e-06 0.2008491615811921 \
1.11430105666124e-06 0.1995112314821507 1.114301163383484e-06 0.1981153840927639 1.114301271788624e-06 0.1967018790395962 1.114301383782779e-06 0.1952465002768531 \
1.114301496249907e-06 0.1937897263683151 1.114301608323246e-06 0.1923454332378671 1.114301716215721e-06 0.1909603537828802 1.114301817598649e-06 0.1896629368444172 \
1.114301909236098e-06 0.1884941330679491 1.114302003211707e-06 0.1872990757663449 1.114302074478072e-06 0.1863957871745983 1.11430215115336e-06 0.1854271890400033 \
1.114302254812475e-06 0.184122202819407 1.114302328479595e-06 0.1831974022686171 1.114302401825496e-06 0.1822796569444652 1.114302515215845e-06 0.1808667181969195 \
1.114302603074485e-06 0.1797760932362061 1.114302686923162e-06 0.1787387947787487 1.11430281588559e-06 0.1771515524267008 1.114302917772084e-06 0.1759040172436072 \
1.114303023472791e-06 0.1746156056808686 1.114303125120866e-06 0.1733818993219825 1.114303255982584e-06 0.1718019019596718 1.114303363179221e-06 0.1705140034701537 \
1.114303492508118e-06 0.168969083715685 1.11430360420461e-06 0.167642098072289 1.114303704535189e-06 0.1664555496840579 1.114303800335743e-06 0.1653276075899142 \
1.114303911148015e-06 0.1640289617085985 1.114303998548296e-06 0.1630090521997956 1.114304109869413e-06 0.1617156184952586 1.114304202821272e-06 0.1606409001560029 \
1.11430429039415e-06 0.1596330843918451 1.114304392025023e-06 0.1584700928658864 1.114304476479078e-06 0.1575086241734052 1.114304551583457e-06 0.1566573095634876 \
1.1143046294057e-06 0.1557789554714152 1.114304709763569e-06 0.1548759612316424 1.114304810818399e-06 0.1537464547857493 1.114304893251963e-06 0.1528311848879565 \
1.114304985556514e-06 0.1518114053368895 1.114305062490987e-06 0.150965812476358 1.114305145413557e-06 0.1500585909391909 1.114305216944298e-06 0.1492793026301012 \
1.114305313327797e-06 0.1482344968214558 1.114305383556283e-06 0.1474766665551334 1.114305466536561e-06 0.1465853655470201 1.114305527978825e-06 0.1459298106834085 \
1.114305599661209e-06 0.1451677491870439 1.114305668289752e-06 0.1444408762699853 1.114305718558261e-06 0.1439102090153988 1.114305766138067e-06 0.143409423336876 \
1.114305820187418e-06 0.1428423132663369 1.114305879529516e-06 0.1422216078256897 1.114305947564923e-06 0.1415124633834424 1.114306023828345e-06 0.1407207186008814 \
1.114306092108145e-06 0.1400161356079559 1.114306186894323e-06 0.1390460813732662 1.114306276448135e-06 0.1381341561933974 1.114306348133609e-06 0.1374075731330657 \
1.114306432085018e-06 0.1365606113096345 1.114306497397473e-06 0.1359045398875483 1.114306558840598e-06 0.1352895588344758 1.114306633117097e-06 0.1345490408254265 \
1.114306695327357e-06 0.1339328028964004 1.114306763298366e-06 0.133265236037424 1.114306822505406e-06 0.1326856657519672 1.114306895177878e-06 0.1319767402814105 \
1.114306970197988e-06 0.1312477270463112 1.114307055651411e-06 0.1304208267333309 1.11430714175175e-06 0.1295914604616623 1.114307241877205e-06 0.1286317929389105 \
1.114307323166875e-06 0.127857435971709 1.114307424934223e-06 0.1268981149578782 1.114307509182182e-06 0.1261072369695883 1.114307607998911e-06 0.1251836587365037 \
1.114307680839456e-06 0.1245055382686853 1.114307760865543e-06 0.1237631876254407 1.114307831351338e-06 0.1231117958237987 1.11430790388176e-06 0.1224439308288319 \
1.114307981350756e-06 0.1217331219782777 1.114308088702104e-06 0.1207554316575004 1.11430818934012e-06 0.1198442997624752 1.114308261927674e-06 0.1191899427853172 \
1.114308330759514e-06 0.1185715582611356 1.114308396546334e-06 0.1179824683205609 1.114308466175132e-06 0.1173610347366148 1.114308536558877e-06 0.1167350538439435 \
1.11430861173725e-06 0.1160688810594495 1.114308715991484e-06 0.1151493019715505 1.114308791126139e-06 0.114489769343061 1.114308860041223e-06 0.1138870655592168 \
1.114308923246094e-06 0.1133369146236164 1.11430899278746e-06 0.1127339156958381 1.114309050088964e-06 0.1122385190692166 1.114309121730019e-06 0.1116210355509516 \
1.114309179565093e-06 0.1111240709857579 1.114309251686527e-06 0.1105063809580559 1.11430931410261e-06 0.1099736279351742 1.114309398424131e-06 0.1092565349771765 \
1.1143094660201e-06 0.1086842173446869 1.114309574816032e-06 0.1077671916889585 1.114309679126564e-06 0.1068924975608609 1.114309758614772e-06 0.1062289053282379 \
1.114309846183183e-06 0.1055008617114655 1.114309909639535e-06 0.1049752776433979 1.114309971350652e-06 0.10446579874651 1.114310075190416e-06 0.103612238268202 \
1.114310157871117e-06 0.1029362225408096 1.114310256339144e-06 0.1021348761715451 1.114310340785582e-06 0.101450818648051 1.114310457263062e-06 0.1005121841703865 \
1.114310591996508e-06 0.09943411943161744 1.114310728066044e-06 0.0983541971400249 1.114310842385451e-06 0.09745369041838402 1.114310927852596e-06 0.09678457778867394 \
