5.001169805069058e-07 0.9137127811079708 5.001171480071349e-07 0.914504286313051 5.001176193673982e-07 0.9145217838087505 5.001178173163518e-07 0.9131640269569251 \
5.00117978090595e-07 0.9113346267648944 5.001180663953338e-07 0.910041664336402 5.001181539287612e-07 0.908567258693449 5.001182468203066e-07 0.9067913249607207 \
5.001183202627591e-07 0.9052411278657534 5.001184090098811e-07 0.9032017134587504 5.001185466530742e-07 0.8996915735089056 5.001186589946964e-07 0.8965314120175644 \
5.001187822917174e-07 0.892778172623249 5.001189384963758e-07 0.8876402979533503 5.001190620123612e-07 0.8833010177194197 5.001192323837925e-07 0.8769686903427227 \
5.001193800034191e-07 0.8711968848515086 5.001195318545579e-07 0.8650238565011712 5.001196679836116e-07 0.8593172646418706 5.001198100472282e-07 0.8532105227807962 \
5.00119945331887e-07 0.8472784593397693 5.001200839912582e-07 0.8411010749315838 5.001202312982803e-07 0.8344514077702887 5.001203778651285e-07 0.8277635723525925 \
5.00120539944527e-07 0.8202964899226535 5.001206873111724e-07 0.8134532267615989 5.001208588244698e-07 0.8054479178086997 5.001210422474358e-07 0.7968539002302991 \
5.00121244752722e-07 0.7873346372610658 5.001214564023841e-07 0.7773555108975432 5.001216773929431e-07 0.7669228693561837 5.0012190658697e-07 0.7561055044419139 \
5.001221831069207e-07 0.743046509132553 5.001224685936448e-07 0.7295848836660939 5.001227899085387e-07 0.7144535604611002 5.001230793784593e-07 0.7008559708795014 \
5.001233986483167e-07 0.6858669291494816 5.001237196636871e-07 0.6708097907125149 5.001240610997186e-07 0.654842287100785 5.001244537234066e-07 0.6364912117266992 \
5.001248083179958e-07 0.6199451687359452 5.001251731050783e-07 0.602895395464039 5.001255769217898e-07 0.5840362041416589 5.001259404503566e-07 0.56705803755797 \
5.00126371026893e-07 0.546963725974103 5.001267271887658e-07 0.5303181638661557 5.001271001981656e-07 0.5128834705750704 5.001274423832748e-07 0.4969084729771704 \
5.001277621248385e-07 0.4820272854775881 5.001280798688676e-07 0.4673068400017517 5.001283757203101e-07 0.453709089639897 5.001287037441391e-07 0.4388357619204879 \
5.001290132345767e-07 0.4250513307906954 5.001292997339751e-07 0.412542701771394 5.001296120885152e-07 0.3991541929604193 5.001299021997139e-07 0.3870087322563178 \
5.001302156657333e-07 0.3741657412501236 5.001304930286139e-07 0.3630444214925196 5.001307741261108e-07 0.3519744117192101 5.001310056073636e-07 0.3430374849397334 \
5.001312341747561e-07 0.3343354151638595 5.001314740666601e-07 0.3253394991495989 5.001317318484438e-07 0.3158318026516087 5.001319812183576e-07 0.3067925439309827 \
5.00132239531266e-07 0.297589150170473 5.001324860622872e-07 0.2889540805256016 5.001327733570433e-07 0.2790758510850415 5.001329967361242e-07 0.2715471379396955 \
5.001332175314858e-07 0.2642409610398131 5.0013341340532e-07 0.2578652581015776 5.001336001294005e-07 0.2519000449202701 5.001337713205379e-07 0.2465102462678049 \
5.001339463640633e-07 0.2410522141953559 5.001341093819267e-07 0.236036359124031 5.001342707863681e-07 0.2311389431166576 5.001344246037583e-07 0.2265774065811171 \
5.001345765404798e-07 0.2221477024102725 5.00134730763452e-07 0.2177012931700853 5.001349043990521e-07 0.2127672920349684 5.001350545160932e-07 0.2085590788965803 \
5.001351889678133e-07 0.2048346911951331 5.001353338801522e-07 0.2008962005616911 5.001354954147815e-07 0.1965999354189458 5.001356443031983e-07 0.1927083727438147 \
5.001357885433758e-07 0.1889957157254755 5.001359135867135e-07 0.1858267544518093 5.001360106534918e-07 0.183392498065703 5.001361456478894e-07 0.1800503036180525 \
5.001362551622506e-07 0.1773760505692391 5.001363931377782e-07 0.1740872877198338 5.001365131504133e-07 0.1712726271080235 5.001366300320898e-07 0.1685704901364905 \
5.001367566609351e-07 0.1656849030049582 5.001368926752681e-07 0.1626308514974385 5.001370260617698e-07 0.1596764551685698 5.001371530037036e-07 0.1569158519548911 \
5.001372816217377e-07 0.1541678007478876 5.001373955481781e-07 0.1517740356345986 5.001375058591172e-07 0.149496521787741 5.001376190003596e-07 0.1472133997668396 \
5.001377324794356e-07 0.1449590740078549 5.001378578442209e-07 0.1425075003983929 5.001380036381084e-07 0.1397077962434051 5.001381867800951e-07 0.1362681166668699 \
5.001383353874999e-07 0.1335395672637218 5.001384476393217e-07 0.1315146079855561 5.001385769927546e-07 0.1292194206906994 5.001386705289107e-07 0.1275846423925092 \
5.001387793207205e-07 0.1257099890290588 5.001388730748316e-07 0.1241165438085202 5.001389566824355e-07 0.1227229754719547 5.001390763363005e-07 0.1207568051616409 \
5.001392054252614e-07 0.1186746054627577 5.001393222794968e-07 0.1168252031377112 5.001394533685069e-07 0.1147891811469644 5.001395987235226e-07 0.1125787883659796 \
5.001397641334231e-07 0.110121919024741 5.001399328736703e-07 0.1076798417306999 5.001401257538154e-07 0.1049622523271389 5.001402997319428e-07 0.1025767092705754 \
5.001404879183132e-07 0.1000644866129177 5.001406703194105e-07 0.09769892895340802 5.001408499110243e-07 0.09544952095403336 5.001410264084269e-07 0.09330553315647841 \
5.001412109641775e-07 0.09112768523704891 5.001413962096449e-07 0.08900465024544718 5.001415782810569e-07 0.0869768268327742 5.001417743458045e-07 0.08485812802288394 \
5.001419447462217e-07 0.08306894814141007 5.001421229869926e-07 0.08125105909257219 5.001422986795187e-07 0.07951206376949813 5.001424990800232e-07 0.07758728548656671 \
5.00142695934063e-07 0.07575734486890456 5.001428658684992e-07 0.07422427017287291 5.001430365177502e-07 0.07272580243814712 5.001432196424959e-07 0.07116311580983979 \
5.001434132597429e-07 0.06956233824397716 5.001435948467066e-07 0.06811311716920317 5.00143793421027e-07 0.06657819701521293 5.001439499522991e-07 0.06540254085633944 \
5.001441335227451e-07 0.06406078399206196 5.001443064849855e-07 0.06283331112669251 5.001444719953625e-07 0.06169268945721457 5.001446203314103e-07 0.06069691796619666 \
5.00144757229627e-07 0.05979937680937147 5.00144904867328e-07 0.05885633029244827 5.00145037955006e-07 0.05802735218158511 5.001451614741417e-07 0.05727448785321319 \
5.001452775104291e-07 0.05658054160001152 5.001453911236973e-07 0.05591352504042409 5.001455157451721e-07 0.05519553885869784 5.001456365421113e-07 0.05451306145814139 \
5.001457964858298e-07 0.0536298481755812 5.001459318329125e-07 0.05289991373180127 5.001460321524118e-07 0.05236888834064994 5.001461326223724e-07 0.05184552065910697 \
5.001462315654583e-07 0.05133799434906983 5.001464100700205e-07 0.05044349321929222 5.00146509870119e-07 0.04995513630881745 5.001467100355682e-07 0.04899962929156078 \
5.001468009528507e-07 0.04857581029502876 5.001470077462978e-07 0.04763487432244629 5.001471129764305e-07 0.0471681110353394 5.001473093549223e-07 0.04631787013837765 \
5.001473946332178e-07 0.04595693884580357 5.001475750955807e-07 0.04521002446657041 5.001476502601712e-07 0.04490525014776706 5.001478681175704e-07 0.0440422972058082 \
5.001479516361654e-07 0.04372097365614635 5.001481415712709e-07 0.04300637120866019 5.001482663176105e-07 0.04254845761102347 5.001484515435786e-07 0.0418846242551883 \
5.001485543821369e-07 0.04152415866453074 5.001488438948116e-07 0.04053983903151908 5.001489328164065e-07 0.04024621147044882 5.001492414867604e-07 0.03925784365481538 \
5.001492976457642e-07 0.03908306666491448 5.001496112078655e-07 0.03813491809530275 5.001496671638485e-07 0.037970533835152 5.001499940781642e-07 0.03703805601095747 \
5.00150047341397e-07 0.03689043863681411 5.001503532654854e-07 0.03606517121743442 5.001504534292134e-07 0.0358032254974586 5.001507720449093e-07 0.03499570355391716 \
5.00150861523872e-07 0.03477583942316619 5.001512593644584e-07 0.03383675925705845 5.001513772457939e-07 0.03357186655877694 5.001517892479576e-07 0.03268299960645597 \
5.001519496108504e-07 0.03235094877383871 5.001523206292343e-07 0.03161177976826059 5.001525403826856e-07 0.03119164460703521 5.001529837669187e-07 0.03038142203317581 \
5.001532328105506e-07 0.0299476098095271 5.001537326667001e-07 0.02912178892962563 5.001539515582769e-07 0.02877747133829427 5.001544346720837e-07 0.02805819238630505 \
5.001547234993366e-07 0.02765301209416409 5.001554102473024e-07 0.02674723311374961 5.001556997628567e-07 0.02638861276123805 5.001564757361353e-07 0.02548835782609031 \
5.001566471895258e-07 0.02530065249352256 5.001574332713199e-07 0.02449144648051316 5.001576373003535e-07 0.02429465554580218 5.001587468983159e-07 0.02329883562822865 \
5.00158847813389e-07 0.02321388155873386 5.001600394040858e-07 0.02227529349501467 5.001602443122935e-07 0.0221260927003824 5.001616975083641e-07 0.02113958380755909 \
5.001619324927818e-07 0.02098788030205876 5.001634397606963e-07 0.02004942094855779 5.001637600611106e-07 0.01985604392354444 5.001649742394565e-07 0.01910354072181233 \
5.001654475441282e-07 0.01879991394003632 5.001667486779812e-07 0.01794965119692995 5.001671384705681e-07 0.01770179815419311 5.001685370187326e-07 0.01679702456340363 \
5.001688637688125e-07 0.01658609683275075 5.001699811040698e-07 0.01586843585740347 5.001706897903676e-07 0.01544169959229912 5.001724223763659e-07 0.01449858640399567 \
5.001726718388173e-07 0.01436065672582198 5.001744694357164e-07 0.01337694399212387 5.001748121293817e-07 0.01319104500849105 5.001769884628947e-07 0.01225973435293598 \
5.001772733192796e-07 0.01213579497780986 5.001791721626723e-07 0.01126438850740638 5.001796550251297e-07 0.01103474467122418 5.001819275205547e-07 0.01014901321627989 \
5.00182315058726e-07 0.01002270433864562 5.001849665648853e-07 0.009023867700259034 5.001852627688168e-07 0.00890332747207802 5.001876046069907e-07 0.00793111507746596 \
5.001878581913148e-07 0.007825942613114227 5.001908803610572e-07 0.006881067894167194 5.0019112999456e-07 0.006804700431426973 5.001950078918082e-07 0.005817006850260108 \
5.001952350713843e-07 0.005760637946475626 5.001980461896193e-07 0.00490690852483563 5.00198480606374e-07 0.004760206508803379 5.002010103666519e-07 0.003858115577918713 \
5.002014288631811e-07 0.003712016323791173 5.002044535343089e-07 0.00274875962184498 5.00204733759441e-07 0.002664158024812898 5.00208530584646e-07 0.001697446565651876 \
5.002088849639912e-07 0.001621705150764489 5.002144114789964e-07 0.0006347476112661908 5.002147089634814e-07 0.0005888553763099016 5.002222167274473e-07 -0.0003928413941844093 \
5.00222438401114e-07 -0.0004189941252107796 5.002365307848727e-07 -0.001410461992184868 5.002368896125909e-07 -0.001430649730572865 5.002502372454117e-07 -0.0004514903228812461 \
5.002504646425127e-07 -0.0004111859973536986 5.002559156120651e-07 0.0005614551864591434 5.002561788974843e-07 0.0006110884748384679 5.002608108374914e-07 0.001592952619583714 \
5.002611188696391e-07 0.001665522059460669 5.0026495308288e-07 0.002626457037572999 5.002653373828843e-07 0.002733556882532277 5.002690715761655e-07 0.003682507088408038 \
5.002692734414486e-07 0.00374945551670179 5.00272897693538e-07 0.004734851451646972 5.002730926227528e-07 0.004780391513086043 5.002764798221767e-07 0.005766866152453508 \
5.002766719106971e-07 0.005810149709068801 5.00280887542283e-07 0.006750994364636406 5.002812210794924e-07 0.006821678237255247 5.003059485403023e-07 0.005867117768706426 \
5.003062618172083e-07 0.005806676405157672 5.003108931929807e-07 0.004863125825100585 5.003111650442215e-07 0.004806306550559217 5.003161096881005e-07 0.003825328200913169 \
5.003165761419321e-07 0.003739629632037282 5.003224824058496e-07 0.002770751168227681 5.003227761301588e-07 0.002729631326985271 5.003316213590711e-07 0.001738601807147118 \
5.003318081264262e-07 0.001722695496451883 5.003520369591485e-07 0.0007253105668073048 5.003534715984433e-07 0.0006873447391178559 5.589900000000112e-07 3.130932490801775e-06 \
5.618834078303853e-07 -0.0008819623910157972 5.618836438792338e-07 -0.001161970612476729 5.618841023255621e-07 -0.001847355627596629 5.618843456126973e-07 -0.002293620068582415 \
5.618845958966645e-07 -0.00281405583725217 5.618848467026681e-07 -0.003393671496214343 5.618851595223304e-07 -0.004199192998005251 5.618853977322015e-07 -0.004872003934560885 \
5.618856441826353e-07 -0.005621391842385397 5.618858759271308e-07 -0.006370319304257691 5.618861831122488e-07 -0.007411941938624838 5.618864484061811e-07 -0.008326397880259807 \
5.618866936858074e-07 -0.009131457988769647 5.618870584173626e-07 -0.01007334593757064 5.618872864885395e-07 -0.01033898456945748 5.618876101281818e-07 -0.009994868194499993 \
5.61887810544735e-07 -0.009187286872421443 5.618880453495324e-07 -0.007487931918614563 5.618882264249876e-07 -0.005544847192362645 5.61888332865277e-07 -0.004119573247771668 \
5.618884711514237e-07 -0.001940540768574745 5.618885821773865e-07 7.563183370691832e-05 5.618887027988209e-07 0.002536824544301687 5.618888058640018e-07 0.004857398676819782 \
5.618889445712868e-07 0.008289235792766818 5.618890656805787e-07 0.01156496544863939 5.618892158843801e-07 0.01596809792775087 5.618893975299902e-07 0.02176080367268303 \
5.618895499652095e-07 0.02698454055473338 5.618897261154541e-07 0.03339084366291074 5.618899251155999e-07 0.04103368087207344 5.618900947875378e-07 0.04784290449723066 \
5.618902739815137e-07 0.05527749234857952 5.618904343978791e-07 0.06211990493347131 5.618905961918387e-07 0.06916698107316244 5.618907547427192e-07 0.07620053909780501 \
5.618909219353922e-07 0.08372027851346725 5.618910922933184e-07 0.09147114401158042 5.618912717305655e-07 0.0997240648901548 5.618914618530915e-07 0.1085375718081032 \
5.618916610920531e-07 0.1178373860957827 5.618918650693586e-07 0.1274102212870429 5.6189208614423e-07 0.1378300800073513 5.618923318007999e-07 0.1494365474357121 \
5.61892589151043e-07 0.1616443690283554 5.618928718421389e-07 0.1750899465505063 5.618931698935498e-07 0.1892663579759593 5.618935161701215e-07 0.2057792515135755 \
5.618938828852402e-07 0.2232517522030736 5.618942787974866e-07 0.2421754728923703 5.618947139088534e-07 0.2629945242020292 5.618951937188403e-07 0.2859861135989593 \
5.618957190371005e-07 0.3113450809673837 5.618962435732645e-07 0.3367514755549041 5.618968408927388e-07 0.3658546932050024 5.618976077178589e-07 0.4033613755922033 \
5.618980462067975e-07 0.4246376380793622 5.618985227203772e-07 0.4473946242989675 5.61898972555967e-07 0.4684360091747882 5.618995252401589e-07 0.4936960927629759 \
5.619002232363642e-07 0.5245486808074998 5.619008376384757e-07 0.5507582774516211 5.619014056089781e-07 0.5741722555225199 5.619019358622477e-07 0.5952266004882081 \
5.619023948316282e-07 0.6128068198589096 5.619029779997919e-07 0.6341908714213341 5.619035511577072e-07 0.6541368834277531 5.619041418420318e-07 0.6735006351351156 \
5.619048105153407e-07 0.6939224431220803 5.619054650004868e-07 0.7123419857223411 5.619062186316106e-07 0.7316435145596337 5.619071381113492e-07 0.7524771687756806 \
5.619078071184639e-07 0.7658582308664672 5.619085026848481e-07 0.7783426900018873 5.619092247217994e-07 0.7898435797332509 5.619098715050645e-07 0.7989777190578581 \
5.619106863983728e-07 0.809051394855074 5.619113442910833e-07 0.8161084932798452 5.619121090555768e-07 0.8232971874420545 5.619127055889394e-07 0.8281915934352191 \
5.619133336120951e-07 0.8327857747397983 5.619139640044049e-07 0.8368636793792511 5.619149496266399e-07 0.8423301485602825 5.619157053806965e-07 0.8458701801587535 \
5.619164686711315e-07 0.8489683054605098 5.61917277011917e-07 0.8518111549479527 5.619182659033657e-07 0.8547854532963984 5.619190089589793e-07 0.8567085856698495 \
5.61919831636168e-07 0.8585940601366741 5.619206128562235e-07 0.8601698380186774 5.619214164593907e-07 0.8616111415036141 5.619222037276377e-07 0.8628649505886673 \
5.619233957300522e-07 0.8644986110026872 5.619243183520358e-07 0.8655887935537701 5.619253772797718e-07 0.8666437563732095 5.61926250370494e-07 0.8673888282159752 \
5.619270194277644e-07 0.8679394432393451 5.619327760832006e-07 0.8675354626998435 5.61933384736608e-07 0.8669285211992742 5.61934348633067e-07 0.8661637309277684 \
5.619346970271228e-07 0.8657877651307159 5.619358657362972e-07 0.8648718022682493 5.619365074390833e-07 0.8645495171393598 5.619377237792426e-07 0.8636149212264693 \
5.619382109959972e-07 0.8633315979857124 5.619419957515129e-07 0.8637879096652611 5.619428035605935e-07 0.8644940879742092 5.619436767313112e-07 0.8654118536506241 \
5.619445258485199e-07 0.8664722967159353 5.619453943206631e-07 0.8676408136092975 5.619462207994818e-07 0.8688316482847912 5.619470672737481e-07 0.8700680498371385 \
5.619479937316665e-07 0.8714353201417473 5.619489227517378e-07 0.8727967357236968 5.619498903738162e-07 0.874169309418928 5.61950892855429e-07 0.8755268793700145 \
5.619519757862114e-07 0.8769279254876977 5.619531542588973e-07 0.8783524184654903 5.619543673598333e-07 0.8797057189093218 5.619556978206918e-07 0.8810544625232946 \
5.619571465319822e-07 0.8823882385150326 5.619588142667743e-07 0.8837386794148741 5.619604462986394e-07 0.8848798336526329 5.619624135908377e-07 0.8860652157953401 \
5.619645900944349e-07 0.8871729764751287 5.619668622498768e-07 0.8881691778223457 5.619691357549546e-07 0.8889896378135498 5.619710876656953e-07 0.8895771814349003 \
5.619739721002916e-07 0.8902862350409186 5.619768310366352e-07 0.8908501300162286 5.619799133237481e-07 0.8913157385816455 5.619917316745298e-07 0.8922670755128276 \
5.619940583186116e-07 0.8924600956555456 5.620009395174264e-07 0.8933233934443291 5.620029317728824e-07 0.8936033182227321 5.620075969639979e-07 0.8943294235126149 \
5.620099349735811e-07 0.894763749611499 5.620124353207703e-07 0.8952990768365913 5.62014909223274e-07 0.8959385502707948 5.620170353180257e-07 0.8965630758105964 \
5.620196246214939e-07 0.8973958942958599 5.620220486411288e-07 0.8982427248493853 5.620249404555526e-07 0.8993469797885378 5.620274501270732e-07 0.9003588137389537 \
5.620307885703227e-07 0.9017079510157455 5.620338675437542e-07 0.9029423170929788 5.620370606228689e-07 0.9042497182071535 5.620396562795079e-07 0.9052493492427333 \
5.62041664531596e-07 0.9059572885738179 5.620437727604824e-07 0.9066594295388942 5.620464614774176e-07 0.907478492737931 5.620489170700808e-07 0.9081366525620301 \
5.620512815901832e-07 0.9087089258990763 5.620538761545912e-07 0.9092804446275633 5.620562438698248e-07 0.9097121154337445 5.620636363095347e-07 0.9105880439508957 \
5.620669473854305e-07 0.9108097973553667 5.620906311042106e-07 0.9099572430838525 5.620935249940687e-07 0.9096028008700563 5.620996337217846e-07 0.9087795762164674 \
5.621026647849372e-07 0.9083311497095887 5.621090224429015e-07 0.9073557537429059 5.621129163890337e-07 0.906719613226565 5.621162893568661e-07 0.9061475060281556 \
5.621193749147294e-07 0.9055946669458763 5.621231206292774e-07 0.9048996522446952 5.621264870170349e-07 0.9043394102803256 5.621340774622411e-07 0.9034499723753743 \
5.621379534727773e-07 0.9031904105967781 5.621657177088619e-07 0.9022140906736803 5.621694938687786e-07 0.902100877529562 5.622009101005462e-07 0.9011025155537421 \
5.622075451903934e-07 0.9009020504869808 6.001105508058006e-07 0.8999193627810952 6.001107184817901e-07 0.8998913840591389 6.00113467033027e-07 0.8989010293823864 \
6.001135235739821e-07 0.8988795941121664 6.001147681785108e-07 0.8998357618405769 6.00114847007516e-07 0.9000722811707415 6.001150289676646e-07 0.9007374088026997 \
6.001151313078803e-07 0.9011852075627013 6.001153242840606e-07 0.9021545909398002 6.001154126459433e-07 0.9026487433775175 6.001155711571976e-07 0.9036053969378676 \
6.001156830548624e-07 0.9043311123122415 6.001158239719932e-07 0.9052897461292233 6.001159294051442e-07 0.9060407976354218 6.001160422821826e-07 0.9068700067857125 \
6.001161567140188e-07 0.9077320749581511 6.001162779947925e-07 0.9086625635419388 6.001164070303393e-07 0.9096610759972766 6.001165295691991e-07 0.9106054665418637 \
6.001166539241396e-07 0.9115433813509556 6.001167688242373e-07 0.912370851358936 6.00116872924634e-07 0.9130668181210778 6.001169805069058e-07 0.9137127811079708 \
6.001171480071349e-07 0.914504286313051 6.001176193673982e-07 0.9145217838087505 6.001178173163518e-07 0.9131640269569251 6.00117978090595e-07 0.9113346267648944 \
6.001180663953338e-07 0.910041664336402 6.001181539287613e-07 0.908567258693449 6.001182468203066e-07 0.9067913249607207 6.001183202627591e-07 0.9052411278657534 \
6.001184090098811e-07 0.9032017134587504 6.001185466530742e-07 0.8996915735089056 6.001186589946964e-07 0.8965314120175644 6.001187822917174e-07 0.892778172623249 \
6.001189384963758e-07 0.8876402979533503 6.001190620123612e-07 0.8833010177194197 6.001192323837925e-07 0.8769686903427227 6.001193800034191e-07 0.8711968848515086 \
6.001195318545579e-07 0.8650238565011712 6.001196679836116e-07 0.8593172646418706 6.001198100472282e-07 0.8532105227807962 6.00119945331887e-07 0.8472784593397693 \
6.001200839912582e-07 0.8411010749315838 6.001202312982803e-07 0.8344514077702887 6.001203778651284e-07 0.8277635723525925 6.001205399445271e-07 0.8202964899226535 \
6.001206873111723e-07 0.8134532267615989 6.001208588244698e-07 0.8054479178086997 6.001210422474358e-07 0.7968539002302991 6.00121244752722e-07 0.7873346372610658 \
6.001214564023841e-07 0.7773555108975432 6.001216773929431e-07 0.7669228693561837 6.0012190658697e-07 0.7561055044419139 6.001221831069207e-07 0.743046509132553 \
6.001224685936448e-07 0.7295848836660939 6.001227899085387e-07 0.7144535604611002 6.001230793784592e-07 0.7008559708795014 6.001233986483167e-07 0.6858669291494816 \
6.001237196636871e-07 0.6708097907125149 6.001240610997186e-07 0.654842287100785 6.001244537234066e-07 0.6364912117266992 6.001248083179958e-07 0.6199451687359452 \
6.001251731050783e-07 0.602895395464039 6.001255769217898e-07 0.5840362041416589 6.001259404503566e-07 0.56705803755797 6.00126371026893e-07 0.546963725974103 \
6.001267271887658e-07 0.5303181638661557 6.001271001981656e-07 0.5128834705750704 6.001274423832748e-07 0.4969084729771704 6.001277621248385e-07 0.4820272854775881 \
6.001280798688676e-07 0.4673068400017517 6.001283757203101e-07 0.453709089639897 6.001287037441391e-07 0.4388357619204879 6.001290132345767e-07 0.4250513307906954 \
6.001292997339751e-07 0.412542701771394 6.001296120885152e-07 0.3991541929604193 6.001299021997139e-07 0.3870087322563178 6.001302156657333e-07 0.3741657412501236 \
6.001304930286139e-07 0.3630444214925196 6.001307741261108e-07 0.3519744117192101 6.001310056073636e-07 0.3430374849397334 6.001312341747562e-07 0.3343354151638595 \
6.0013147406666e-07 0.3253394991495989 6.001317318484438e-07 0.3158318026516087 6.001319812183577e-07 0.3067925439309827 6.00132239531266e-07 0.297589150170473 \
6.001324860622872e-07 0.2889540805256016 6.001327733570433e-07 0.2790758510850415 6.001329967361242e-07 0.2715471379396955 6.001332175314858e-07 0.2642409610398131 \
6.0013341340532e-07 0.2578652581015776 6.001336001294005e-07 0.2519000449202701 6.001337713205379e-07 0.2465102462678049 6.001339463640633e-07 0.2410522141953559 \
6.001341093819267e-07 0.236036359124031 6.001342707863681e-07 0.2311389431166576 6.001344246037584e-07 0.2265774065811171 6.001345765404798e-07 0.2221477024102725 \
6.00134730763452e-07 0.2177012931700853 6.001349043990521e-07 0.2127672920349684 6.001350545160932e-07 0.2085590788965803 6.001351889678134e-07 0.2048346911951331 \
6.001353338801522e-07 0.2008962005616911 6.001354954147815e-07 0.1965999354189458 6.001356443031983e-07 0.1927083727438147 6.001357885433758e-07 0.1889957157254755 \
6.001359135867135e-07 0.1858267544518093 6.001360106534918e-07 0.183392498065703 6.001361456478894e-07 0.1800503036180525 6.001362551622505e-07 0.1773760505692391 \
6.001363931377782e-07 0.1740872877198338 6.001365131504133e-07 0.1712726271080235 6.001366300320898e-07 0.1685704901364905 6.001367566609351e-07 0.1656849030049582 \
6.001368926752681e-07 0.1626308514974385 6.001370260617698e-07 0.1596764551685698 6.001371530037036e-07 0.1569158519548911 6.001372816217377e-07 0.1541678007478876 \
6.001373955481781e-07 0.1517740356345986 6.001375058591172e-07 0.149496521787741 6.001376190003596e-07 0.1472133997668396 6.001377324794355e-07 0.1449590740078549 \
6.001378578442209e-07 0.1425075003983929 6.001380036381084e-07 0.1397077962434051 6.001381867800951e-07 0.1362681166668699 6.001383353874999e-07 0.1335395672637218 \
6.001384476393217e-07 0.1315146079855561 6.001385769927546e-07 0.1292194206906994 6.001386705289107e-07 0.1275846423925092 6.001387793207205e-07 0.1257099890290588 \
6.001388730748316e-07 0.1241165438085202 6.001389566824355e-07 0.1227229754719547 6.001390763363005e-07 0.1207568051616409 6.001392054252614e-07 0.1186746054627577 \
6.001393222794968e-07 0.1168252031377112 6.001394533685068e-07 0.1147891811469644 6.001395987235226e-07 0.1125787883659796 6.001397641334231e-07 0.110121919024741 \
6.001399328736702e-07 0.1076798417306999 6.001401257538154e-07 0.1049622523271389 6.001402997319429e-07 0.1025767092705754 6.001404879183132e-07 0.1000644866129177 \
6.001406703194105e-07 0.09769892895340802 6.001408499110243e-07 0.09544952095403336 6.001410264084269e-07 0.09330553315647841 6.001412109641775e-07 0.09112768523704891 \
6.001413962096449e-07 0.08900465024544718 6.001415782810569e-07 0.0869768268327742 6.001417743458045e-07 0.08485812802288394 6.001419447462217e-07 0.08306894814141007 \
6.001421229869926e-07 0.08125105909257219 6.001422986795187e-07 0.07951206376949813 6.001424990800232e-07 0.07758728548656671 6.00142695934063e-07 0.07575734486890456 \
6.001428658684992e-07 0.07422427017287291 6.001430365177502e-07 0.07272580243814712 6.001432196424959e-07 0.07116311580983979 6.001434132597429e-07 0.06956233824397716 \
6.001435948467066e-07 0.06811311716920317 6.00143793421027e-07 0.06657819701521293 6.001439499522991e-07 0.06540254085633944 6.001441335227451e-07 0.06406078399206196 \
6.001443064849856e-07 0.06283331112669251 6.001444719953625e-07 0.06169268945721457 6.001446203314103e-07 0.06069691796619666 6.001447572296269e-07 0.05979937680937147 \
6.00144904867328e-07 0.05885633029244827 6.00145037955006e-07 0.05802735218158511 6.001451614741417e-07 0.05727448785321319 6.00145277510429e-07 0.05658054160001152 \
6.001453911236973e-07 0.05591352504042409 6.001455157451721e-07 0.05519553885869784 6.001456365421113e-07 0.05451306145814139 6.001457964858298e-07 0.0536298481755812 \
6.001459318329125e-07 0.05289991373180127 6.001460321524118e-07 0.05236888834064994 6.001461326223724e-07 0.05184552065910697 6.001462315654583e-07 0.05133799434906983 \
6.001464100700205e-07 0.05044349321929222 6.00146509870119e-07 0.04995513630881745 6.001467100355682e-07 0.04899962929156078 6.001468009528507e-07 0.04857581029502876 \
6.001470077462978e-07 0.04763487432244629 6.001471129764305e-07 0.0471681110353394 6.001473093549223e-07 0.04631787013837765 6.001473946332178e-07 0.04595693884580357 \
6.001475750955807e-07 0.04521002446657041 6.001476502601712e-07 0.04490525014776706 6.001478681175704e-07 0.0440422972058082 6.001479516361653e-07 0.04372097365614635 \
6.001481415712709e-07 0.04300637120866019 6.001482663176105e-07 0.04254845761102347 6.001484515435786e-07 0.0418846242551883 6.001485543821369e-07 0.04152415866453074 \
6.001488438948116e-07 0.04053983903151908 6.001489328164065e-07 0.04024621147044882 6.001492414867604e-07 0.03925784365481538 6.001492976457641e-07 0.03908306666491448 \
6.001496112078655e-07 0.03813491809530275 6.001496671638485e-07 0.037970533835152 6.001499940781642e-07 0.03703805601095747 6.00150047341397e-07 0.03689043863681411 \
6.001503532654853e-07 0.03606517121743442 6.001504534292134e-07 0.0358032254974586 6.001507720449093e-07 0.03499570355391716 6.00150861523872e-07 0.03477583942316619 \
6.001512593644584e-07 0.03383675925705845 6.00151377245794e-07 0.03357186655877694 6.001517892479576e-07 0.03268299960645597 6.001519496108504e-07 0.03235094877383871 \
6.001523206292343e-07 0.03161177976826059 6.001525403826856e-07 0.03119164460703521 6.001529837669187e-07 0.03038142203317581 6.001532328105506e-07 0.0299476098095271 \
6.001537326667001e-07 0.02912178892962563 6.001539515582769e-07 0.02877747133829427 6.001544346720837e-07 0.02805819238630505 6.001547234993366e-07 0.02765301209416409 \
6.001554102473024e-07 0.02674723311374961 6.001556997628566e-07 0.02638861276123805 6.001564757361353e-07 0.02548835782609031 6.001566471895258e-07 0.02530065249352256 \
6.001574332713198e-07 0.02449144648051316 6.001576373003535e-07 0.02429465554580218 6.001587468983159e-07 0.02329883562822865 6.00158847813389e-07 0.02321388155873386 \
6.001600394040858e-07 0.02227529349501467 6.001602443122935e-07 0.0221260927003824 6.001616975083641e-07 0.02113958380755909 6.001619324927818e-07 0.02098788030205876 \
6.001634397606963e-07 0.02004942094855779 6.001637600611106e-07 0.01985604392354444 6.001649742394566e-07 0.01910354072181233 6.001654475441281e-07 0.01879991394003632 \
6.001667486779811e-07 0.01794965119692995 6.001671384705681e-07 0.01770179815419311 6.001685370187326e-07 0.01679702456340363 6.001688637688125e-07 0.01658609683275075 \
6.001699811040698e-07 0.01586843585740347 6.001706897903676e-07 0.01544169959229912 6.001724223763659e-07 0.01449858640399567 6.001726718388173e-07 0.01436065672582198 \
6.001744694357164e-07 0.01337694399212387 6.001748121293816e-07 0.01319104500849105 6.001769884628947e-07 0.01225973435293598 6.001772733192796e-07 0.01213579497780986 \
6.001791721626723e-07 0.01126438850740638 6.001796550251297e-07 0.01103474467122418 6.001819275205547e-07 0.01014901321627989 6.00182315058726e-07 0.01002270433864562 \
6.001849665648853e-07 0.009023867700259034 6.001852627688168e-07 0.00890332747207802 6.001876046069907e-07 0.00793111507746596 6.001878581913148e-07 0.007825942613114227 \
6.001908803610572e-07 0.006881067894167194 6.001911299945599e-07 0.006804700431426973 6.001950078918081e-07 0.005817006850260108 6.001952350713843e-07 0.005760637946475626 \
6.001980461896194e-07 0.00490690852483563 6.001984806063739e-07 0.004760206508803379 6.002010103666519e-07 0.003858115577918713 6.002014288631811e-07 0.003712016323791173 \
6.002044535343089e-07 0.00274875962184498 6.00204733759441e-07 0.002664158024812898 6.00208530584646e-07 0.001697446565651876 6.002088849639912e-07 0.001621705150764489 \
6.002144114789963e-07 0.0006347476112661908 6.002147089634815e-07 0.0005888553763099016 6.002222167274472e-07 -0.0003928413941844093 6.00222438401114e-07 -0.0004189941252107796 \
6.002365307848727e-07 -0.001410461992184868 6.00236889612591e-07 -0.001430649730572865 6.002502372454117e-07 -0.0004514903228812461 6.002504646425127e-07 -0.0004111859973536986 \
6.002559156120651e-07 0.0005614551864591434 6.002561788974843e-07 0.0006110884748384679 6.002608108374914e-07 0.001592952619583714 6.002611188696391e-07 0.001665522059460669 \
6.0026495308288e-07 0.002626457037572999 6.002653373828843e-07 0.002733556882532277 6.002690715761655e-07 0.003682507088408038 6.002692734414486e-07 0.00374945551670179 \
6.002728976935381e-07 0.004734851451646972 6.002730926227528e-07 0.004780391513086043 6.002764798221767e-07 0.005766866152453508 6.002766719106971e-07 0.005810149709068801 \
6.00280887542283e-07 0.006750994364636406 6.002812210794924e-07 0.006821678237255247 6.003059485403023e-07 0.005867117768706426 6.003062618172084e-07 0.005806676405157672 \
6.003108931929807e-07 0.004863125825100585 6.003111650442215e-07 0.004806306550559217 6.003161096881005e-07 0.003825328200913169 6.003165761419321e-07 0.003739629632037282 \
6.003224824058496e-07 0.002770751168227681 6.003227761301588e-07 0.002729631326985271 6.003316213590711e-07 0.001738601807147118 6.003318081264262e-07 0.001722695496451883 \
6.003520369591484e-07 0.0007253105668073048 6.003534715984433e-07 0.0006873447391178559 6.589900000000113e-07 3.130932490801775e-06 6.618834078303853e-07 -0.0008819623910157972 \
6.618836438792338e-07 -0.001161970612476729 6.618841023255621e-07 -0.001847355627596629 6.618843456126973e-07 -0.002293620068582415 6.618845958966645e-07 -0.00281405583725217 \
6.618848467026681e-07 -0.003393671496214343 6.618851595223305e-07 -0.004199192998005251 6.618853977322015e-07 -0.004872003934560885 6.618856441826353e-07 -0.005621391842385397 \
6.618858759271308e-07 -0.006370319304257691 6.618861831122488e-07 -0.007411941938624838 6.618864484061811e-07 -0.008326397880259807 6.618866936858074e-07 -0.009131457988769647 \
6.618870584173626e-07 -0.01007334593757064 6.618872864885395e-07 -0.01033898456945748 6.618876101281818e-07 -0.009994868194499993 6.618878105447351e-07 -0.009187286872421443 \
6.618880453495323e-07 -0.007487931918614563 6.618882264249876e-07 -0.005544847192362645 6.61888332865277e-07 -0.004119573247771668 6.618884711514237e-07 -0.001940540768574745 \
6.618885821773865e-07 7.563183370691832e-05 6.618887027988208e-07 0.002536824544301687 6.618888058640017e-07 0.004857398676819782 6.618889445712868e-07 0.008289235792766818 \
6.618890656805787e-07 0.01156496544863939 6.618892158843801e-07 0.01596809792775087 6.618893975299901e-07 0.02176080367268303 6.618895499652095e-07 0.02698454055473338 \
6.61889726115454e-07 0.03339084366291074 6.618899251155999e-07 0.04103368087207344 6.618900947875378e-07 0.04784290449723066 6.618902739815137e-07 0.05527749234857952 \
6.618904343978791e-07 0.06211990493347131 6.618905961918387e-07 0.06916698107316244 6.618907547427192e-07 0.07620053909780501 6.618909219353922e-07 0.08372027851346725 \
6.618910922933183e-07 0.09147114401158042 6.618912717305655e-07 0.0997240648901548 6.618914618530915e-07 0.1085375718081032 6.618916610920531e-07 0.1178373860957827 \
6.618918650693585e-07 0.1274102212870429 6.6189208614423e-07 0.1378300800073513 6.618923318007999e-07 0.1494365474357121 6.61892589151043e-07 0.1616443690283554 \
6.618928718421389e-07 0.1750899465505063 6.618931698935498e-07 0.1892663579759593 6.618935161701216e-07 0.2057792515135755 6.618938828852402e-07 0.2232517522030736 \
6.618942787974866e-07 0.2421754728923703 6.618947139088534e-07 0.2629945242020292 6.618951937188404e-07 0.2859861135989593 6.618957190371005e-07 0.3113450809673837 \
6.618962435732645e-07 0.3367514755549041 6.618968408927388e-07 0.3658546932050024 6.618976077178589e-07 0.4033613755922033 6.618980462067975e-07 0.4246376380793622 \
6.618985227203772e-07 0.4473946242989675 6.61898972555967e-07 0.4684360091747882 6.618995252401589e-07 0.4936960927629759 6.619002232363642e-07 0.5245486808074998 \
6.619008376384758e-07 0.5507582774516211 6.619014056089781e-07 0.5741722555225199 6.619019358622477e-07 0.5952266004882081 6.619023948316282e-07 0.6128068198589096 \
6.619029779997919e-07 0.6341908714213341 6.619035511577072e-07 0.6541368834277531 6.619041418420318e-07 0.6735006351351156 6.619048105153408e-07 0.6939224431220803 \
6.619054650004868e-07 0.7123419857223411 6.619062186316106e-07 0.7316435145596337 6.619071381113492e-07 0.7524771687756806 6.619078071184639e-07 0.7658582308664672 \
6.61908502684848e-07 0.7783426900018873 6.619092247217994e-07 0.7898435797332509 6.619098715050644e-07 0.7989777190578581 6.619106863983728e-07 0.809051394855074 \
6.619113442910833e-07 0.8161084932798452 6.619121090555767e-07 0.8232971874420545 6.619127055889392e-07 0.8281915934352191 6.619133336120952e-07 0.8327857747397983 \
6.619139640044049e-07 0.8368636793792511 6.619149496266399e-07 0.8423301485602825 6.619157053806965e-07 0.8458701801587535 6.619164686711315e-07 0.8489683054605098 \
6.61917277011917e-07 0.8518111549479527 6.619182659033657e-07 0.8547854532963984 6.619190089589792e-07 0.8567085856698495 6.61919831636168e-07 0.8585940601366741 \
6.619206128562235e-07 0.8601698380186774 6.619214164593908e-07 0.8616111415036141 6.619222037276377e-07 0.8628649505886673 6.619233957300522e-07 0.8644986110026872 \
6.619243183520358e-07 0.8655887935537701 6.619253772797718e-07 0.8666437563732095 6.61926250370494e-07 0.8673888282159752 6.619270194277644e-07 0.8679394432393451 \
6.619327760832005e-07 0.8675354626998435 6.61933384736608e-07 0.8669285211992742 6.61934348633067e-07 0.8661637309277684 6.619346970271228e-07 0.8657877651307159 \
6.619358657362972e-07 0.8648718022682493 6.619365074390832e-07 0.8645495171393598 6.619377237792426e-07 0.8636149212264693 6.619382109959973e-07 0.8633315979857124 \
6.619419957515128e-07 0.8637879096652611 6.619428035605935e-07 0.8644940879742092 6.619436767313112e-07 0.8654118536506241 6.619445258485199e-07 0.8664722967159353 \
6.619453943206631e-07 0.8676408136092975 6.619462207994818e-07 0.8688316482847912 6.61947067273748e-07 0.8700680498371385 6.619479937316665e-07 0.8714353201417473 \
6.619489227517378e-07 0.8727967357236968 6.619498903738162e-07 0.874169309418928 6.61950892855429e-07 0.8755268793700145 6.619519757862114e-07 0.8769279254876977 \
6.619531542588973e-07 0.8783524184654903 6.619543673598333e-07 0.8797057189093218 6.619556978206918e-07 0.8810544625232946 6.619571465319822e-07 0.8823882385150326 \
6.619588142667742e-07 0.8837386794148741 6.619604462986394e-07 0.8848798336526329 6.619624135908377e-07 0.8860652157953401 6.619645900944349e-07 0.8871729764751287 \
6.619668622498768e-07 0.8881691778223457 6.619691357549546e-07 0.8889896378135498 6.619710876656953e-07 0.8895771814349003 6.619739721002916e-07 0.8902862350409186 \
6.619768310366352e-07 0.8908501300162286 6.619799133237481e-07 0.8913157385816455 6.619917316745298e-07 0.8922670755128276 6.619940583186116e-07 0.8924600956555456 \
6.620009395174265e-07 0.8933233934443291 6.620029317728824e-07 0.8936033182227321 6.620075969639978e-07 0.8943294235126149 6.620099349735811e-07 0.894763749611499 \
6.620124353207703e-07 0.8952990768365913 6.62014909223274e-07 0.8959385502707948 6.620170353180257e-07 0.8965630758105964 6.620196246214939e-07 0.8973958942958599 \
6.620220486411287e-07 0.8982427248493853 6.620249404555526e-07 0.8993469797885378 6.620274501270732e-07 0.9003588137389537 6.620307885703227e-07 0.9017079510157455 \
6.620338675437542e-07 0.9029423170929788 6.620370606228689e-07 0.9042497182071535 6.620396562795079e-07 0.9052493492427333 6.62041664531596e-07 0.9059572885738179 \
6.620437727604824e-07 0.9066594295388942 6.620464614774176e-07 0.907478492737931 6.620489170700808e-07 0.9081366525620301 6.620512815901832e-07 0.9087089258990763 \
6.620538761545912e-07 0.9092804446275633 6.620562438698248e-07 0.9097121154337445 6.620636363095348e-07 0.9105880439508957 6.620669473854305e-07 0.9108097973553667 \
6.620906311042106e-07 0.9099572430838525 6.620935249940686e-07 0.9096028008700563 6.620996337217846e-07 0.9087795762164674 6.621026647849372e-07 0.9083311497095887 \
6.621090224429014e-07 0.9073557537429059 6.621129163890337e-07 0.906719613226565 6.621162893568661e-07 0.9061475060281556 6.621193749147294e-07 0.9055946669458763 \
6.621231206292774e-07 0.9048996522446952 6.621264870170349e-07 0.9043394102803256 6.621340774622412e-07 0.9034499723753743 6.621379534727773e-07 0.9031904105967781 \
6.621657177088619e-07 0.9022140906736803 6.621694938687786e-07 0.902100877529562 6.622009101005462e-07 0.9011025155537421 6.622075451903935e-07 0.9009020504869808 \
7.001105508058006e-07 0.8999193627810952 7.001107184817901e-07 0.8998913840591389 7.00113467033027e-07 0.8989010293823864 7.001135235739821e-07 0.8988795941121664 \
7.001147681785108e-07 0.8998357618405769 7.00114847007516e-07 0.9000722811707415 7.001150289676646e-07 0.9007374088026997 7.001151313078803e-07 0.9011852075627013 \
7.001153242840605e-07 0.9021545909398002 7.001154126459433e-07 0.9026487433775175 7.001155711571976e-07 0.9036053969378676 7.001156830548624e-07 0.9043311123122415 \
7.001158239719932e-07 0.9052897461292233 7.001159294051442e-07 0.9060407976354218 7.001160422821826e-07 0.9068700067857125 7.001161567140188e-07 0.9077320749581511 \
7.001162779947925e-07 0.9086625635419388 7.001164070303392e-07 0.9096610759972766 7.001165295691991e-07 0.9106054665418637 7.001166539241396e-07 0.9115433813509556 \
7.001167688242373e-07 0.912370851358936 7.00116872924634e-07 0.9130668181210778 7.001169805069058e-07 0.9137127811079708 7.001171480071349e-07 0.914504286313051 \
7.001176193673981e-07 0.9145217838087505 7.001178173163518e-07 0.9131640269569251 7.00117978090595e-07 0.9113346267648944 7.001180663953338e-07 0.910041664336402 \
7.001181539287612e-07 0.908567258693449 7.001182468203066e-07 0.9067913249607207 7.001183202627591e-07 0.9052411278657534 7.001184090098811e-07 0.9032017134587504 \
7.001185466530742e-07 0.8996915735089056 7.001186589946964e-07 0.8965314120175644 7.001187822917174e-07 0.892778172623249 7.001189384963758e-07 0.8876402979533503 \
7.001190620123612e-07 0.8833010177194197 7.001192323837925e-07 0.8769686903427227 7.001193800034191e-07 0.8711968848515086 7.001195318545579e-07 0.8650238565011712 \
7.001196679836116e-07 0.8593172646418706 7.001198100472282e-07 0.8532105227807962 7.00119945331887e-07 0.8472784593397693 7.001200839912582e-07 0.8411010749315838 \
7.001202312982803e-07 0.8344514077702887 7.001203778651285e-07 0.8277635723525925 7.00120539944527e-07 0.8202964899226535 7.001206873111724e-07 0.8134532267615989 \
7.001208588244698e-07 0.8054479178086997 7.001210422474358e-07 0.7968539002302991 7.00121244752722e-07 0.7873346372610658 7.00121456402384e-07 0.7773555108975432 \
7.001216773929431e-07 0.7669228693561837 7.0012190658697e-07 0.7561055044419139 7.001221831069207e-07 0.743046509132553 7.001224685936448e-07 0.7295848836660939 \
7.001227899085387e-07 0.7144535604611002 7.001230793784592e-07 0.7008559708795014 7.001233986483167e-07 0.6858669291494816 7.001237196636871e-07 0.6708097907125149 \
7.001240610997186e-07 0.654842287100785 7.001244537234066e-07 0.6364912117266992 7.001248083179958e-07 0.6199451687359452 7.001251731050783e-07 0.602895395464039 \
7.001255769217897e-07 0.5840362041416589 7.001259404503566e-07 0.56705803755797 7.00126371026893e-07 0.546963725974103 7.001267271887658e-07 0.5303181638661557 \
7.001271001981656e-07 0.5128834705750704 7.001274423832748e-07 0.4969084729771704 7.001277621248385e-07 0.4820272854775881 7.001280798688676e-07 0.4673068400017517 \
7.001283757203101e-07 0.453709089639897 7.001287037441391e-07 0.4388357619204879 7.001290132345766e-07 0.4250513307906954 7.001292997339751e-07 0.412542701771394 \
7.001296120885152e-07 0.3991541929604193 7.001299021997139e-07 0.3870087322563178 7.001302156657333e-07 0.3741657412501236 7.001304930286139e-07 0.3630444214925196 \
7.001307741261108e-07 0.3519744117192101 7.001310056073636e-07 0.3430374849397334 7.001312341747561e-07 0.3343354151638595 7.001314740666601e-07 0.3253394991495989 \
7.001317318484438e-07 0.3158318026516087 7.001319812183576e-07 0.3067925439309827 7.00132239531266e-07 0.297589150170473 7.001324860622872e-07 0.2889540805256016 \
7.001327733570433e-07 0.2790758510850415 7.001329967361242e-07 0.2715471379396955 7.001332175314858e-07 0.2642409610398131 7.0013341340532e-07 0.2578652581015776 \
7.001336001294005e-07 0.2519000449202701 7.001337713205379e-07 0.2465102462678049 7.001339463640633e-07 0.2410522141953559 7.001341093819267e-07 0.236036359124031 \
7.001342707863681e-07 0.2311389431166576 7.001344246037583e-07 0.2265774065811171 7.001345765404798e-07 0.2221477024102725 7.00134730763452e-07 0.2177012931700853 \
7.001349043990521e-07 0.2127672920349684 7.001350545160932e-07 0.2085590788965803 7.001351889678133e-07 0.2048346911951331 7.001353338801522e-07 0.2008962005616911 \
7.001354954147815e-07 0.1965999354189458 7.001356443031983e-07 0.1927083727438147 7.001357885433758e-07 0.1889957157254755 7.001359135867135e-07 0.1858267544518093 \
7.001360106534918e-07 0.183392498065703 7.001361456478894e-07 0.1800503036180525 7.001362551622506e-07 0.1773760505692391 7.001363931377782e-07 0.1740872877198338 \
7.001365131504133e-07 0.1712726271080235 7.001366300320898e-07 0.1685704901364905 7.001367566609351e-07 0.1656849030049582 7.001368926752681e-07 0.1626308514974385 \
7.001370260617698e-07 0.1596764551685698 7.001371530037036e-07 0.1569158519548911 7.001372816217376e-07 0.1541678007478876 7.001373955481781e-07 0.1517740356345986 \
7.001375058591172e-07 0.149496521787741 7.001376190003596e-07 0.1472133997668396 7.001377324794356e-07 0.1449590740078549 7.001378578442209e-07 0.1425075003983929 \
7.001380036381084e-07 0.1397077962434051 7.001381867800951e-07 0.1362681166668699 7.001383353874999e-07 0.1335395672637218 7.001384476393217e-07 0.1315146079855561 \
7.001385769927546e-07 0.1292194206906994 7.001386705289107e-07 0.1275846423925092 7.001387793207205e-07 0.1257099890290588 7.001388730748316e-07 0.1241165438085202 \
7.001389566824355e-07 0.1227229754719547 7.001390763363005e-07 0.1207568051616409 7.001392054252614e-07 0.1186746054627577 7.001393222794968e-07 0.1168252031377112 \
7.001394533685069e-07 0.1147891811469644 7.001395987235226e-07 0.1125787883659796 7.001397641334231e-07 0.110121919024741 7.001399328736703e-07 0.1076798417306999 \
7.001401257538154e-07 0.1049622523271389 7.001402997319428e-07 0.1025767092705754 7.001404879183132e-07 0.1000644866129177 7.001406703194105e-07 0.09769892895340802 \
7.001408499110243e-07 0.09544952095403336 7.001410264084269e-07 0.09330553315647841 7.001412109641775e-07 0.09112768523704891 7.001413962096449e-07 0.08900465024544718 \
7.001415782810569e-07 0.0869768268327742 7.001417743458045e-07 0.08485812802288394 7.001419447462217e-07 0.08306894814141007 7.001421229869926e-07 0.08125105909257219 \
7.001422986795187e-07 0.07951206376949813 7.001424990800232e-07 0.07758728548656671 7.00142695934063e-07 0.07575734486890456 7.001428658684992e-07 0.07422427017287291 \
7.001430365177502e-07 0.07272580243814712 7.001432196424959e-07 0.07116311580983979 7.001434132597429e-07 0.06956233824397716 7.001435948467066e-07 0.06811311716920317 \
7.00143793421027e-07 0.06657819701521293 7.001439499522991e-07 0.06540254085633944 7.001441335227451e-07 0.06406078399206196 7.001443064849855e-07 0.06283331112669251 \
7.001444719953625e-07 0.06169268945721457 7.001446203314103e-07 0.06069691796619666 7.001447572296269e-07 0.05979937680937147 7.00144904867328e-07 0.05885633029244827 \
7.00145037955006e-07 0.05802735218158511 7.001451614741417e-07 0.05727448785321319 7.00145277510429e-07 0.05658054160001152 7.001453911236973e-07 0.05591352504042409 \
7.001455157451721e-07 0.05519553885869784 7.001456365421113e-07 0.05451306145814139 7.001457964858298e-07 0.0536298481755812 7.001459318329125e-07 0.05289991373180127 \
7.001460321524118e-07 0.05236888834064994 7.001461326223724e-07 0.05184552065910697 7.001462315654583e-07 0.05133799434906983 7.001464100700205e-07 0.05044349321929222 \
7.00146509870119e-07 0.04995513630881745 7.001467100355682e-07 0.04899962929156078 7.001468009528507e-07 0.04857581029502876 7.001470077462978e-07 0.04763487432244629 \
7.001471129764305e-07 0.0471681110353394 7.001473093549223e-07 0.04631787013837765 7.001473946332177e-07 0.04595693884580357 7.001475750955807e-07 0.04521002446657041 \
7.001476502601712e-07 0.04490525014776706 7.001478681175704e-07 0.0440422972058082 7.001479516361654e-07 0.04372097365614635 7.001481415712709e-07 0.04300637120866019 \
7.001482663176105e-07 0.04254845761102347 7.001484515435786e-07 0.0418846242551883 7.001485543821369e-07 0.04152415866453074 7.001488438948116e-07 0.04053983903151908 \
7.001489328164065e-07 0.04024621147044882 7.001492414867604e-07 0.03925784365481538 7.001492976457642e-07 0.03908306666491448 7.001496112078655e-07 0.03813491809530275 \
7.001496671638485e-07 0.037970533835152 7.001499940781642e-07 0.03703805601095747 7.00150047341397e-07 0.03689043863681411 7.001503532654854e-07 0.03606517121743442 \
7.001504534292134e-07 0.0358032254974586 7.001507720449093e-07 0.03499570355391716 7.00150861523872e-07 0.03477583942316619 7.001512593644584e-07 0.03383675925705845 \
7.001513772457939e-07 0.03357186655877694 7.001517892479576e-07 0.03268299960645597 7.001519496108504e-07 0.03235094877383871 7.001523206292343e-07 0.03161177976826059 \
7.001525403826855e-07 0.03119164460703521 7.001529837669187e-07 0.03038142203317581 7.001532328105506e-07 0.0299476098095271 7.001537326667001e-07 0.02912178892962563 \
7.001539515582769e-07 0.02877747133829427 7.001544346720837e-07 0.02805819238630505 7.001547234993366e-07 0.02765301209416409 7.001554102473024e-07 0.02674723311374961 \
7.001556997628567e-07 0.02638861276123805 7.001564757361353e-07 0.02548835782609031 7.001566471895258e-07 0.02530065249352256 7.001574332713198e-07 0.02449144648051316 \
7.001576373003535e-07 0.02429465554580218 7.001587468983159e-07 0.02329883562822865 7.00158847813389e-07 0.02321388155873386 7.001600394040858e-07 0.02227529349501467 \
7.001602443122935e-07 0.0221260927003824 7.001616975083641e-07 0.02113958380755909 7.001619324927818e-07 0.02098788030205876 7.001634397606963e-07 0.02004942094855779 \
7.001637600611106e-07 0.01985604392354444 7.001649742394565e-07 0.01910354072181233 7.001654475441281e-07 0.01879991394003632 7.001667486779812e-07 0.01794965119692995 \
7.001671384705681e-07 0.01770179815419311 7.001685370187325e-07 0.01679702456340363 7.001688637688125e-07 0.01658609683275075 7.001699811040698e-07 0.01586843585740347 \
7.001706897903676e-07 0.01544169959229912 7.001724223763659e-07 0.01449858640399567 7.001726718388173e-07 0.01436065672582198 7.001744694357164e-07 0.01337694399212387 \
7.001748121293817e-07 0.01319104500849105 7.001769884628947e-07 0.01225973435293598 7.001772733192796e-07 0.01213579497780986 7.001791721626723e-07 0.01126438850740638 \
7.001796550251296e-07 0.01103474467122418 7.001819275205546e-07 0.01014901321627989 7.00182315058726e-07 0.01002270433864562 7.001849665648853e-07 0.009023867700259034 \
7.001852627688168e-07 0.00890332747207802 7.001876046069907e-07 0.00793111507746596 7.001878581913148e-07 0.007825942613114227 7.001908803610572e-07 0.006881067894167194 \
7.0019112999456e-07 0.006804700431426973 7.001950078918081e-07 0.005817006850260108 7.001952350713843e-07 0.005760637946475626 7.001980461896193e-07 0.00490690852483563 \
7.00198480606374e-07 0.004760206508803379 7.002010103666519e-07 0.003858115577918713 7.002014288631811e-07 0.003712016323791173 7.002044535343088e-07 0.00274875962184498 \
7.00204733759441e-07 0.002664158024812898 7.00208530584646e-07 0.001697446565651876 7.002088849639912e-07 0.001621705150764489 7.002144114789963e-07 0.0006347476112661908 \
7.002147089634814e-07 0.0005888553763099016 7.002222167274472e-07 -0.0003928413941844093 7.00222438401114e-07 -0.0004189941252107796 7.002365307848727e-07 -0.001410461992184868 \
7.002368896125909e-07 -0.001430649730572865 7.002502372454117e-07 -0.0004514903228812461 7.002504646425127e-07 -0.0004111859973536986 7.002559156120651e-07 0.0005614551864591434 \
7.002561788974843e-07 0.0006110884748384679 7.002608108374914e-07 0.001592952619583714 7.002611188696391e-07 0.001665522059460669 7.0026495308288e-07 0.002626457037572999 \
7.002653373828843e-07 0.002733556882532277 7.002690715761655e-07 0.003682507088408038 7.002692734414486e-07 0.00374945551670179 7.00272897693538e-07 0.004734851451646972 \
7.002730926227528e-07 0.004780391513086043 7.002764798221767e-07 0.005766866152453508 7.002766719106971e-07 0.005810149709068801 7.00280887542283e-07 0.006750994364636406 \
7.002812210794924e-07 0.006821678237255247 7.003059485403023e-07 0.005867117768706426 7.003062618172083e-07 0.005806676405157672 7.003108931929807e-07 0.004863125825100585 \
7.003111650442215e-07 0.004806306550559217 7.003161096881005e-07 0.003825328200913169 7.003165761419321e-07 0.003739629632037282 7.003224824058496e-07 0.002770751168227681 \
7.003227761301588e-07 0.002729631326985271 7.003316213590711e-07 0.001738601807147118 7.003318081264262e-07 0.001722695496451883 7.003520369591485e-07 0.0007253105668073048 \
7.003534715984433e-07 0.0006873447391178559 7.589900000000112e-07 3.130932490801775e-06 7.618834078303853e-07 -0.0008819623910157972 7.618836438792338e-07 -0.001161970612476729 \
7.618841023255621e-07 -0.001847355627596629 7.618843456126973e-07 -0.002293620068582415 7.618845958966645e-07 -0.00281405583725217 7.618848467026681e-07 -0.003393671496214343 \
7.618851595223304e-07 -0.004199192998005251 7.618853977322015e-07 -0.004872003934560885 7.618856441826353e-07 -0.005621391842385397 7.618858759271308e-07 -0.006370319304257691 \
7.618861831122488e-07 -0.007411941938624838 7.618864484061811e-07 -0.008326397880259807 7.618866936858074e-07 -0.009131457988769647 7.618870584173626e-07 -0.01007334593757064 \
7.618872864885395e-07 -0.01033898456945748 7.618876101281818e-07 -0.009994868194499993 7.61887810544735e-07 -0.009187286872421443 7.618880453495324e-07 -0.007487931918614563 \
7.618882264249876e-07 -0.005544847192362645 7.61888332865277e-07 -0.004119573247771668 7.618884711514237e-07 -0.001940540768574745 7.618885821773865e-07 7.563183370691832e-05 \
7.618887027988208e-07 0.002536824544301687 7.618888058640018e-07 0.004857398676819782 7.618889445712868e-07 0.008289235792766818 7.618890656805787e-07 0.01156496544863939 \
7.618892158843801e-07 0.01596809792775087 7.618893975299901e-07 0.02176080367268303 7.618895499652095e-07 0.02698454055473338 7.61889726115454e-07 0.03339084366291074 \
7.618899251155999e-07 0.04103368087207344 7.618900947875378e-07 0.04784290449723066 7.618902739815137e-07 0.05527749234857952 7.618904343978791e-07 0.06211990493347131 \
7.618905961918387e-07 0.06916698107316244 7.618907547427192e-07 0.07620053909780501 7.618909219353922e-07 0.08372027851346725 7.618910922933183e-07 0.09147114401158042 \
7.618912717305654e-07 0.0997240648901548 7.618914618530915e-07 0.1085375718081032 7.618916610920531e-07 0.1178373860957827 7.618918650693585e-07 0.1274102212870429 \
7.6189208614423e-07 0.1378300800073513 7.618923318007999e-07 0.1494365474357121 7.61892589151043e-07 0.1616443690283554 7.618928718421389e-07 0.1750899465505063 \
7.618931698935498e-07 0.1892663579759593 7.618935161701215e-07 0.2057792515135755 7.618938828852402e-07 0.2232517522030736 7.618942787974866e-07 0.2421754728923703 \
7.618947139088534e-07 0.2629945242020292 7.618951937188403e-07 0.2859861135989593 7.618957190371005e-07 0.3113450809673837 7.618962435732645e-07 0.3367514755549041 \
7.618968408927388e-07 0.3658546932050024 7.618976077178589e-07 0.4033613755922033 7.618980462067974e-07 0.4246376380793622 7.618985227203772e-07 0.4473946242989675 \
7.61898972555967e-07 0.4684360091747882 7.618995252401589e-07 0.4936960927629759 7.619002232363641e-07 0.5245486808074998 7.619008376384757e-07 0.5507582774516211 \
7.619014056089781e-07 0.5741722555225199 7.619019358622477e-07 0.5952266004882081 7.619023948316282e-07 0.6128068198589096 7.619029779997919e-07 0.6341908714213341 \
7.619035511577072e-07 0.6541368834277531 7.619041418420318e-07 0.6735006351351156 7.619048105153407e-07 0.6939224431220803 7.619054650004868e-07 0.7123419857223411 \
7.619062186316106e-07 0.7316435145596337 7.619071381113492e-07 0.7524771687756806 7.619078071184639e-07 0.7658582308664672 7.61908502684848e-07 0.7783426900018873 \
7.619092247217994e-07 0.7898435797332509 7.619098715050644e-07 0.7989777190578581 7.619106863983728e-07 0.809051394855074 7.619113442910833e-07 0.8161084932798452 \
7.619121090555767e-07 0.8232971874420545 7.619127055889394e-07 0.8281915934352191 7.619133336120951e-07 0.8327857747397983 7.619139640044049e-07 0.8368636793792511 \
7.619149496266399e-07 0.8423301485602825 7.619157053806965e-07 0.8458701801587535 7.619164686711315e-07 0.8489683054605098 7.61917277011917e-07 0.8518111549479527 \
7.619182659033657e-07 0.8547854532963984 7.619190089589792e-07 0.8567085856698495 7.61919831636168e-07 0.8585940601366741 7.619206128562234e-07 0.8601698380186774 \
7.619214164593907e-07 0.8616111415036141 7.619222037276377e-07 0.8628649505886673 7.619233957300522e-07 0.8644986110026872 7.619243183520358e-07 0.8655887935537701 \
7.619253772797718e-07 0.8666437563732095 7.61926250370494e-07 0.8673888282159752 7.619270194277644e-07 0.8679394432393451 7.619327760832006e-07 0.8675354626998435 \
7.619333847366079e-07 0.8669285211992742 7.61934348633067e-07 0.8661637309277684 7.619346970271228e-07 0.8657877651307159 7.619358657362972e-07 0.8648718022682493 \
7.619365074390833e-07 0.8645495171393598 7.619377237792426e-07 0.8636149212264693 7.619382109959972e-07 0.8633315979857124 7.619419957515129e-07 0.8637879096652611 \
7.619428035605935e-07 0.8644940879742092 7.619436767313112e-07 0.8654118536506241 7.619445258485199e-07 0.8664722967159353 7.61945394320663e-07 0.8676408136092975 \
7.619462207994818e-07 0.8688316482847912 7.61947067273748e-07 0.8700680498371385 7.619479937316665e-07 0.8714353201417473 7.619489227517378e-07 0.8727967357236968 \
7.619498903738162e-07 0.874169309418928 7.61950892855429e-07 0.8755268793700145 7.619519757862114e-07 0.8769279254876977 7.619531542588973e-07 0.8783524184654903 \
7.619543673598333e-07 0.8797057189093218 7.619556978206918e-07 0.8810544625232946 7.619571465319822e-07 0.8823882385150326 7.619588142667743e-07 0.8837386794148741 \
7.619604462986394e-07 0.8848798336526329 7.619624135908377e-07 0.8860652157953401 7.619645900944349e-07 0.8871729764751287 7.619668622498768e-07 0.8881691778223457 \
7.619691357549546e-07 0.8889896378135498 7.619710876656953e-07 0.8895771814349003 7.619739721002916e-07 0.8902862350409186 7.619768310366352e-07 0.8908501300162286 \
7.619799133237481e-07 0.8913157385816455 7.619917316745298e-07 0.8922670755128276 7.619940583186116e-07 0.8924600956555456 7.620009395174264e-07 0.8933233934443291 \
7.620029317728824e-07 0.8936033182227321 7.620075969639979e-07 0.8943294235126149 7.620099349735811e-07 0.894763749611499 7.620124353207703e-07 0.8952990768365913 \
7.62014909223274e-07 0.8959385502707948 7.620170353180256e-07 0.8965630758105964 7.620196246214939e-07 0.8973958942958599 7.620220486411288e-07 0.8982427248493853 \
7.620249404555525e-07 0.8993469797885378 7.620274501270732e-07 0.9003588137389537 7.620307885703227e-07 0.9017079510157455 7.620338675437542e-07 0.9029423170929788 \
7.620370606228689e-07 0.9042497182071535 7.620396562795079e-07 0.9052493492427333 7.62041664531596e-07 0.9059572885738179 7.620437727604824e-07 0.9066594295388942 \
7.620464614774176e-07 0.907478492737931 7.620489170700808e-07 0.9081366525620301 7.620512815901832e-07 0.9087089258990763 7.620538761545912e-07 0.9092804446275633 \
7.620562438698248e-07 0.9097121154337445 7.620636363095347e-07 0.9105880439508957 7.620669473854305e-07 0.9108097973553667 7.620906311042105e-07 0.9099572430838525 \
7.620935249940686e-07 0.9096028008700563 7.620996337217846e-07 0.9087795762164674 7.621026647849372e-07 0.9083311497095887 7.621090224429014e-07 0.9073557537429059 \
7.621129163890337e-07 0.906719613226565 7.621162893568661e-07 0.9061475060281556 7.621193749147294e-07 0.9055946669458763 7.621231206292774e-07 0.9048996522446952 \
7.621264870170349e-07 0.9043394102803256 7.62134077462241e-07 0.9034499723753743 7.621379534727773e-07 0.9031904105967781 7.621657177088619e-07 0.9022140906736803 \
7.621694938687786e-07 0.902100877529562 7.622009101005462e-07 0.9011025155537421 7.622075451903933e-07 0.9009020504869808 8.001105508058006e-07 0.8999193627810952 \
8.001107184817901e-07 0.8998913840591389 8.00113467033027e-07 0.8989010293823864 8.001135235739821e-07 0.8988795941121664 8.001147681785108e-07 0.8998357618405769 \
8.00114847007516e-07 0.9000722811707415 8.001150289676646e-07 0.9007374088026997 8.001151313078803e-07 0.9011852075627013 8.001153242840606e-07 0.9021545909398002 \
8.001154126459433e-07 0.9026487433775175 8.001155711571976e-07 0.9036053969378676 8.001156830548624e-07 0.9043311123122415 8.001158239719932e-07 0.9052897461292233 \
8.001159294051442e-07 0.9060407976354218 8.001160422821826e-07 0.9068700067857125 8.001161567140188e-07 0.9077320749581511 8.001162779947925e-07 0.9086625635419388 \
8.001164070303393e-07 0.9096610759972766 8.00116529569199e-07 0.9106054665418637 8.001166539241395e-07 0.9115433813509556 8.001167688242373e-07 0.912370851358936 \
8.00116872924634e-07 0.9130668181210778 8.001169805069058e-07 0.9137127811079708 8.001171480071349e-07 0.914504286313051 8.001176193673981e-07 0.9145217838087505 \
8.001178173163518e-07 0.9131640269569251 8.00117978090595e-07 0.9113346267648944 8.001180663953337e-07 0.910041664336402 8.001181539287613e-07 0.908567258693449 \
8.001182468203066e-07 0.9067913249607207 8.001183202627591e-07 0.9052411278657534 8.001184090098811e-07 0.9032017134587504 8.001185466530742e-07 0.8996915735089056 \
8.001186589946964e-07 0.8965314120175644 8.001187822917174e-07 0.892778172623249 8.001189384963758e-07 0.8876402979533503 8.001190620123612e-07 0.8833010177194197 \
8.001192323837925e-07 0.8769686903427227 8.001193800034191e-07 0.8711968848515086 8.001195318545579e-07 0.8650238565011712 8.001196679836116e-07 0.8593172646418706 \
8.001198100472282e-07 0.8532105227807962 8.00119945331887e-07 0.8472784593397693 8.001200839912582e-07 0.8411010749315838 8.001202312982803e-07 0.8344514077702887 \
8.001203778651284e-07 0.8277635723525925 8.001205399445271e-07 0.8202964899226535 8.001206873111723e-07 0.8134532267615989 8.001208588244698e-07 0.8054479178086997 \
8.001210422474358e-07 0.7968539002302991 8.00121244752722e-07 0.7873346372610658 8.00121456402384e-07 0.7773555108975432 8.001216773929431e-07 0.7669228693561837 \
8.0012190658697e-07 0.7561055044419139 8.001221831069207e-07 0.743046509132553 8.001224685936448e-07 0.7295848836660939 8.001227899085387e-07 0.7144535604611002 \
8.001230793784592e-07 0.7008559708795014 8.001233986483167e-07 0.6858669291494816 8.001237196636871e-07 0.6708097907125149 8.001240610997185e-07 0.654842287100785 \
8.001244537234066e-07 0.6364912117266992 8.001248083179958e-07 0.6199451687359452 8.001251731050783e-07 0.602895395464039 8.001255769217897e-07 0.5840362041416589 \
8.001259404503566e-07 0.56705803755797 8.00126371026893e-07 0.546963725974103 8.001267271887658e-07 0.5303181638661557 8.001271001981656e-07 0.5128834705750704 \
8.001274423832748e-07 0.4969084729771704 8.001277621248385e-07 0.4820272854775881 8.001280798688676e-07 0.4673068400017517 8.001283757203101e-07 0.453709089639897 \
8.001287037441391e-07 0.4388357619204879 8.001290132345766e-07 0.4250513307906954 8.001292997339751e-07 0.412542701771394 8.001296120885152e-07 0.3991541929604193 \
8.001299021997139e-07 0.3870087322563178 8.001302156657333e-07 0.3741657412501236 8.001304930286139e-07 0.3630444214925196 8.001307741261108e-07 0.3519744117192101 \
8.001310056073636e-07 0.3430374849397334 8.001312341747562e-07 0.3343354151638595 8.0013147406666e-07 0.3253394991495989 8.001317318484438e-07 0.3158318026516087 \
8.001319812183577e-07 0.3067925439309827 8.00132239531266e-07 0.297589150170473 8.001324860622872e-07 0.2889540805256016 8.001327733570433e-07 0.2790758510850415 \
8.001329967361242e-07 0.2715471379396955 8.001332175314858e-07 0.2642409610398131 8.0013341340532e-07 0.2578652581015776 8.001336001294005e-07 0.2519000449202701 \
8.001337713205379e-07 0.2465102462678049 8.001339463640633e-07 0.2410522141953559 8.001341093819267e-07 0.236036359124031 8.001342707863681e-07 0.2311389431166576 \
8.001344246037584e-07 0.2265774065811171 8.001345765404798e-07 0.2221477024102725 8.00134730763452e-07 0.2177012931700853 8.001349043990521e-07 0.2127672920349684 \
8.001350545160932e-07 0.2085590788965803 8.001351889678134e-07 0.2048346911951331 8.001353338801522e-07 0.2008962005616911 8.001354954147815e-07 0.1965999354189458 \
8.001356443031983e-07 0.1927083727438147 8.001357885433757e-07 0.1889957157254755 8.001359135867135e-07 0.1858267544518093 8.001360106534918e-07 0.183392498065703 \
8.001361456478894e-07 0.1800503036180525 8.001362551622505e-07 0.1773760505692391 8.001363931377782e-07 0.1740872877198338 8.001365131504133e-07 0.1712726271080235 \
8.001366300320898e-07 0.1685704901364905 8.00136756660935e-07 0.1656849030049582 8.001368926752681e-07 0.1626308514974385 8.001370260617698e-07 0.1596764551685698 \
8.001371530037036e-07 0.1569158519548911 8.001372816217376e-07 0.1541678007478876 8.001373955481781e-07 0.1517740356345986 8.001375058591172e-07 0.149496521787741 \
8.001376190003596e-07 0.1472133997668396 8.001377324794355e-07 0.1449590740078549 8.001378578442209e-07 0.1425075003983929 8.001380036381084e-07 0.1397077962434051 \
8.001381867800951e-07 0.1362681166668699 8.001383353874999e-07 0.1335395672637218 8.001384476393217e-07 0.1315146079855561 8.001385769927546e-07 0.1292194206906994 \
8.001386705289107e-07 0.1275846423925092 8.001387793207205e-07 0.1257099890290588 8.001388730748316e-07 0.1241165438085202 8.001389566824355e-07 0.1227229754719547 \
8.001390763363005e-07 0.1207568051616409 8.001392054252614e-07 0.1186746054627577 8.001393222794968e-07 0.1168252031377112 8.001394533685068e-07 0.1147891811469644 \
8.001395987235226e-07 0.1125787883659796 8.00139764133423e-07 0.110121919024741 8.001399328736702e-07 0.1076798417306999 8.001401257538154e-07 0.1049622523271389 \
8.001402997319429e-07 0.1025767092705754 8.001404879183132e-07 0.1000644866129177 8.001406703194105e-07 0.09769892895340802 8.001408499110243e-07 0.09544952095403336 \
8.001410264084269e-07 0.09330553315647841 8.001412109641775e-07 0.09112768523704891 8.001413962096449e-07 0.08900465024544718 8.001415782810569e-07 0.0869768268327742 \
8.001417743458045e-07 0.08485812802288394 8.001419447462217e-07 0.08306894814141007 8.001421229869926e-07 0.08125105909257219 8.001422986795187e-07 0.07951206376949813 \
8.001424990800232e-07 0.07758728548656671 8.00142695934063e-07 0.07575734486890456 8.001428658684992e-07 0.07422427017287291 8.001430365177502e-07 0.07272580243814712 \
8.001432196424959e-07 0.07116311580983979 8.001434132597429e-07 0.06956233824397716 8.001435948467066e-07 0.06811311716920317 8.001437934210269e-07 0.06657819701521293 \
8.001439499522991e-07 0.06540254085633944 8.001441335227451e-07 0.06406078399206196 8.001443064849856e-07 0.06283331112669251 8.001444719953625e-07 0.06169268945721457 \
8.001446203314103e-07 0.06069691796619666 8.001447572296269e-07 0.05979937680937147 8.00144904867328e-07 0.05885633029244827 8.00145037955006e-07 0.05802735218158511 \
8.001451614741417e-07 0.05727448785321319 8.00145277510429e-07 0.05658054160001152 8.001453911236973e-07 0.05591352504042409 8.001455157451721e-07 0.05519553885869784 \
8.001456365421113e-07 0.05451306145814139 8.001457964858298e-07 0.0536298481755812 8.001459318329125e-07 0.05289991373180127 8.001460321524118e-07 0.05236888834064994 \
8.001461326223724e-07 0.05184552065910697 8.001462315654583e-07 0.05133799434906983 8.001464100700205e-07 0.05044349321929222 8.00146509870119e-07 0.04995513630881745 \
8.001467100355682e-07 0.04899962929156078 8.001468009528507e-07 0.04857581029502876 8.001470077462978e-07 0.04763487432244629 8.001471129764304e-07 0.0471681110353394 \
8.001473093549223e-07 0.04631787013837765 8.001473946332177e-07 0.04595693884580357 8.001475750955806e-07 0.04521002446657041 8.001476502601712e-07 0.04490525014776706 \
8.001478681175704e-07 0.0440422972058082 8.001479516361653e-07 0.04372097365614635 8.001481415712709e-07 0.04300637120866019 8.001482663176105e-07 0.04254845761102347 \
8.001484515435786e-07 0.0418846242551883 8.001485543821369e-07 0.04152415866453074 8.001488438948115e-07 0.04053983903151908 8.001489328164065e-07 0.04024621147044882 \
8.001492414867604e-07 0.03925784365481538 8.001492976457641e-07 0.03908306666491448 8.001496112078655e-07 0.03813491809530275 8.001496671638485e-07 0.037970533835152 \
8.001499940781642e-07 0.03703805601095747 8.00150047341397e-07 0.03689043863681411 8.001503532654853e-07 0.03606517121743442 8.001504534292134e-07 0.0358032254974586 \
8.001507720449093e-07 0.03499570355391716 8.00150861523872e-07 0.03477583942316619 8.001512593644584e-07 0.03383675925705845 8.00151377245794e-07 0.03357186655877694 \
8.001517892479576e-07 0.03268299960645597 8.001519496108504e-07 0.03235094877383871 8.001523206292343e-07 0.03161177976826059 8.001525403826855e-07 0.03119164460703521 \
8.001529837669187e-07 0.03038142203317581 8.001532328105505e-07 0.0299476098095271 8.001537326667001e-07 0.02912178892962563 8.001539515582769e-07 0.02877747133829427 \
8.001544346720837e-07 0.02805819238630505 8.001547234993366e-07 0.02765301209416409 8.001554102473024e-07 0.02674723311374961 8.001556997628566e-07 0.02638861276123805 \
8.001564757361353e-07 0.02548835782609031 8.001566471895258e-07 0.02530065249352256 8.001574332713198e-07 0.02449144648051316 8.001576373003535e-07 0.02429465554580218 \
8.001587468983159e-07 0.02329883562822865 8.00158847813389e-07 0.02321388155873386 8.001600394040858e-07 0.02227529349501467 8.001602443122935e-07 0.0221260927003824 \
8.001616975083641e-07 0.02113958380755909 8.001619324927818e-07 0.02098788030205876 8.001634397606963e-07 0.02004942094855779 8.001637600611106e-07 0.01985604392354444 \
8.001649742394566e-07 0.01910354072181233 8.001654475441281e-07 0.01879991394003632 8.001667486779811e-07 0.01794965119692995 8.001671384705681e-07 0.01770179815419311 \
8.001685370187325e-07 0.01679702456340363 8.001688637688125e-07 0.01658609683275075 8.001699811040698e-07 0.01586843585740347 8.001706897903676e-07 0.01544169959229912 \
8.001724223763659e-07 0.01449858640399567 8.001726718388173e-07 0.01436065672582198 8.001744694357164e-07 0.01337694399212387 8.001748121293816e-07 0.01319104500849105 \
8.001769884628947e-07 0.01225973435293598 8.001772733192796e-07 0.01213579497780986 8.001791721626723e-07 0.01126438850740638 8.001796550251296e-07 0.01103474467122418 \
8.001819275205546e-07 0.01014901321627989 8.001823150587259e-07 0.01002270433864562 8.001849665648853e-07 0.009023867700259034 8.001852627688167e-07 0.00890332747207802 \
8.001876046069907e-07 0.00793111507746596 8.001878581913148e-07 0.007825942613114227 8.001908803610571e-07 0.006881067894167194 8.001911299945599e-07 0.006804700431426973 \
8.001950078918081e-07 0.005817006850260108 8.001952350713843e-07 0.005760637946475626 8.001980461896194e-07 0.00490690852483563 8.001984806063739e-07 0.004760206508803379 \
8.002010103666519e-07 0.003858115577918713 8.002014288631811e-07 0.003712016323791173 8.002044535343088e-07 0.00274875962184498 8.002047337594409e-07 0.002664158024812898 \
8.00208530584646e-07 0.001697446565651876 8.002088849639912e-07 0.001621705150764489 8.002144114789963e-07 0.0006347476112661908 8.002147089634815e-07 0.0005888553763099016 \
8.002222167274472e-07 -0.0003928413941844093 8.00222438401114e-07 -0.0004189941252107796 8.002365307848727e-07 -0.001410461992184868 8.00236889612591e-07 -0.001430649730572865 \
8.002502372454117e-07 -0.0004514903228812461 8.002504646425127e-07 -0.0004111859973536986 8.002559156120651e-07 0.0005614551864591434 8.002561788974843e-07 0.0006110884748384679 \
8.002608108374914e-07 0.001592952619583714 8.002611188696391e-07 0.001665522059460669 8.0026495308288e-07 0.002626457037572999 8.002653373828843e-07 0.002733556882532277 \
8.002690715761655e-07 0.003682507088408038 8.002692734414486e-07 0.00374945551670179 8.002728976935381e-07 0.004734851451646972 8.002730926227528e-07 0.004780391513086043 \
8.002764798221767e-07 0.005766866152453508 8.002766719106971e-07 0.005810149709068801 8.00280887542283e-07 0.006750994364636406 8.002812210794924e-07 0.006821678237255247 \
8.003059485403023e-07 0.005867117768706426 8.003062618172084e-07 0.005806676405157672 8.003108931929807e-07 0.004863125825100585 8.003111650442215e-07 0.004806306550559217 \
8.003161096881005e-07 0.003825328200913169 8.003165761419321e-07 0.003739629632037282 8.003224824058496e-07 0.002770751168227681 8.003227761301588e-07 0.002729631326985271 \
8.003316213590711e-07 0.001738601807147118 8.003318081264262e-07 0.001722695496451883 8.003520369591484e-07 0.0007253105668073048 8.003534715984433e-07 0.0006873447391178559 \
8.589900000000113e-07 3.130932490801775e-06 8.618834078303853e-07 -0.0008819623910157972 8.618836438792338e-07 -0.001161970612476729 8.618841023255621e-07 -0.001847355627596629 \
8.618843456126973e-07 -0.002293620068582415 8.618845958966645e-07 -0.00281405583725217 8.618848467026681e-07 -0.003393671496214343 8.618851595223305e-07 -0.004199192998005251 \
8.618853977322015e-07 -0.004872003934560885 8.618856441826353e-07 -0.005621391842385397 8.618858759271308e-07 -0.006370319304257691 8.618861831122488e-07 -0.007411941938624838 \
8.618864484061811e-07 -0.008326397880259807 8.618866936858074e-07 -0.009131457988769647 8.618870584173626e-07 -0.01007334593757064 8.618872864885395e-07 -0.01033898456945748 \
8.618876101281818e-07 -0.009994868194499993 8.618878105447351e-07 -0.009187286872421443 8.618880453495323e-07 -0.007487931918614563 8.618882264249876e-07 -0.005544847192362645 \
8.61888332865277e-07 -0.004119573247771668 8.618884711514237e-07 -0.001940540768574745 8.618885821773865e-07 7.563183370691832e-05 8.618887027988208e-07 0.002536824544301687 \
8.618888058640017e-07 0.004857398676819782 8.618889445712867e-07 0.008289235792766818 8.618890656805787e-07 0.01156496544863939 8.618892158843801e-07 0.01596809792775087 \
8.618893975299901e-07 0.02176080367268303 8.618895499652095e-07 0.02698454055473338 8.61889726115454e-07 0.03339084366291074 8.618899251155999e-07 0.04103368087207344 \
8.618900947875378e-07 0.04784290449723066 8.618902739815137e-07 0.05527749234857952 8.618904343978791e-07 0.06211990493347131 8.618905961918387e-07 0.06916698107316244 \
8.618907547427192e-07 0.07620053909780501 8.618909219353922e-07 0.08372027851346725 8.618910922933183e-07 0.09147114401158042 8.618912717305654e-07 0.0997240648901548 \
8.618914618530915e-07 0.1085375718081032 8.618916610920531e-07 0.1178373860957827 8.618918650693585e-07 0.1274102212870429 8.6189208614423e-07 0.1378300800073513 \
8.618923318007999e-07 0.1494365474357121 8.61892589151043e-07 0.1616443690283554 8.618928718421389e-07 0.1750899465505063 8.618931698935498e-07 0.1892663579759593 \
8.618935161701216e-07 0.2057792515135755 8.618938828852402e-07 0.2232517522030736 8.618942787974866e-07 0.2421754728923703 8.618947139088534e-07 0.2629945242020292 \
8.618951937188404e-07 0.2859861135989593 8.618957190371005e-07 0.3113450809673837 8.618962435732645e-07 0.3367514755549041 8.618968408927388e-07 0.3658546932050024 \
8.618976077178589e-07 0.4033613755922033 8.618980462067974e-07 0.4246376380793622 8.618985227203772e-07 0.4473946242989675 8.618989725559669e-07 0.4684360091747882 \
8.618995252401589e-07 0.4936960927629759 8.619002232363641e-07 0.5245486808074998 8.619008376384758e-07 0.5507582774516211 8.619014056089781e-07 0.5741722555225199 \
8.619019358622477e-07 0.5952266004882081 8.619023948316282e-07 0.6128068198589096 8.619029779997919e-07 0.6341908714213341 8.619035511577072e-07 0.6541368834277531 \
8.619041418420318e-07 0.6735006351351156 8.619048105153408e-07 0.6939224431220803 8.619054650004868e-07 0.7123419857223411 8.619062186316106e-07 0.7316435145596337 \
8.619071381113492e-07 0.7524771687756806 8.619078071184639e-07 0.7658582308664672 8.61908502684848e-07 0.7783426900018873 8.619092247217994e-07 0.7898435797332509 \
8.619098715050644e-07 0.7989777190578581 8.619106863983728e-07 0.809051394855074 8.619113442910833e-07 0.8161084932798452 8.619121090555767e-07 0.8232971874420545 \
8.619127055889392e-07 0.8281915934352191 8.619133336120952e-07 0.8327857747397983 8.619139640044049e-07 0.8368636793792511 8.619149496266399e-07 0.8423301485602825 \
8.619157053806965e-07 0.8458701801587535 8.619164686711315e-07 0.8489683054605098 8.61917277011917e-07 0.8518111549479527 8.619182659033657e-07 0.8547854532963984 \
8.619190089589792e-07 0.8567085856698495 8.61919831636168e-07 0.8585940601366741 8.619206128562234e-07 0.8601698380186774 8.619214164593908e-07 0.8616111415036141 \
8.619222037276376e-07 0.8628649505886673 8.619233957300522e-07 0.8644986110026872 8.619243183520358e-07 0.8655887935537701 8.619253772797718e-07 0.8666437563732095 \
8.61926250370494e-07 0.8673888282159752 8.619270194277644e-07 0.8679394432393451 8.619327760832005e-07 0.8675354626998435 8.619333847366079e-07 0.8669285211992742 \
8.61934348633067e-07 0.8661637309277684 8.619346970271228e-07 0.8657877651307159 8.619358657362972e-07 0.8648718022682493 8.619365074390832e-07 0.8645495171393598 \
8.619377237792426e-07 0.8636149212264693 8.619382109959973e-07 0.8633315979857124 8.619419957515128e-07 0.8637879096652611 8.619428035605935e-07 0.8644940879742092 \
8.619436767313112e-07 0.8654118536506241 8.619445258485199e-07 0.8664722967159353 8.61945394320663e-07 0.8676408136092975 8.619462207994818e-07 0.8688316482847912 \
8.61947067273748e-07 0.8700680498371385 8.619479937316665e-07 0.8714353201417473 8.619489227517378e-07 0.8727967357236968 8.619498903738162e-07 0.874169309418928 \
8.61950892855429e-07 0.8755268793700145 8.619519757862114e-07 0.8769279254876977 8.619531542588973e-07 0.8783524184654903 8.619543673598333e-07 0.8797057189093218 \
8.619556978206918e-07 0.8810544625232946 8.619571465319822e-07 0.8823882385150326 8.619588142667741e-07 0.8837386794148741 8.619604462986394e-07 0.8848798336526329 \
8.619624135908377e-07 0.8860652157953401 8.619645900944349e-07 0.8871729764751287 8.619668622498768e-07 0.8881691778223457 8.619691357549546e-07 0.8889896378135498 \
8.619710876656953e-07 0.8895771814349003 8.619739721002916e-07 0.8902862350409186 8.619768310366352e-07 0.8908501300162286 8.619799133237481e-07 0.8913157385816455 \
8.619917316745297e-07 0.8922670755128276 8.619940583186116e-07 0.8924600956555456 8.620009395174265e-07 0.8933233934443291 8.620029317728824e-07 0.8936033182227321 \
8.620075969639978e-07 0.8943294235126149 8.62009934973581e-07 0.894763749611499 8.620124353207703e-07 0.8952990768365913 8.62014909223274e-07 0.8959385502707948 \
8.620170353180256e-07 0.8965630758105964 8.620196246214939e-07 0.8973958942958599 8.620220486411287e-07 0.8982427248493853 8.620249404555525e-07 0.8993469797885378 \
8.620274501270732e-07 0.9003588137389537 8.620307885703227e-07 0.9017079510157455 8.620338675437542e-07 0.9029423170929788 8.620370606228689e-07 0.9042497182071535 \
8.620396562795079e-07 0.9052493492427333 8.62041664531596e-07 0.9059572885738179 8.620437727604824e-07 0.9066594295388942 8.620464614774176e-07 0.907478492737931 \
8.620489170700808e-07 0.9081366525620301 8.620512815901832e-07 0.9087089258990763 8.620538761545912e-07 0.9092804446275633 8.620562438698248e-07 0.9097121154337445 \
8.620636363095348e-07 0.9105880439508957 8.620669473854305e-07 0.9108097973553667 8.620906311042105e-07 0.9099572430838525 8.620935249940686e-07 0.9096028008700563 \
8.620996337217846e-07 0.9087795762164674 8.621026647849372e-07 0.9083311497095887 8.621090224429014e-07 0.9073557537429059 8.621129163890337e-07 0.906719613226565 \
8.621162893568661e-07 0.9061475060281556 8.621193749147294e-07 0.9055946669458763 8.621231206292774e-07 0.9048996522446952 8.621264870170349e-07 0.9043394102803256 \
8.621340774622411e-07 0.9034499723753743 8.621379534727773e-07 0.9031904105967781 8.621657177088619e-07 0.9022140906736803 8.621694938687786e-07 0.902100877529562 \
8.622009101005462e-07 0.9011025155537421 8.622075451903934e-07 0.9009020504869808 9.001105508058006e-07 0.8999193627810952 9.001107184817901e-07 0.8998913840591389 \
9.00113467033027e-07 0.8989010293823864 9.001135235739821e-07 0.8988795941121664 9.001147681785108e-07 0.8998357618405769 9.00114847007516e-07 0.9000722811707415 \
9.001150289676646e-07 0.9007374088026997 9.001151313078803e-07 0.9011852075627013 9.001153242840605e-07 0.9021545909398002 9.001154126459433e-07 0.9026487433775175 \
9.001155711571976e-07 0.9036053969378676 9.001156830548624e-07 0.9043311123122415 9.001158239719932e-07 0.9052897461292233 9.001159294051442e-07 0.9060407976354218 \
9.001160422821826e-07 0.9068700067857125 9.001161567140188e-07 0.9077320749581511 9.001162779947925e-07 0.9086625635419388 9.001164070303392e-07 0.9096610759972766 \
9.00116529569199e-07 0.9106054665418637 9.001166539241395e-07 0.9115433813509556 9.001167688242373e-07 0.912370851358936 9.001168729246339e-07 0.9130668181210778 \
9.001169805069057e-07 0.9137127811079708 9.001171480071349e-07 0.914504286313051 9.001176193673981e-07 0.9145217838087505 9.001178173163518e-07 0.9131640269569251 \
9.00117978090595e-07 0.9113346267648944 9.001180663953337e-07 0.910041664336402 9.001181539287612e-07 0.908567258693449 9.001182468203066e-07 0.9067913249607207 \
9.001183202627591e-07 0.9052411278657534 9.001184090098811e-07 0.9032017134587504 9.001185466530742e-07 0.8996915735089056 9.001186589946964e-07 0.8965314120175644 \
9.001187822917174e-07 0.892778172623249 9.001189384963758e-07 0.8876402979533503 9.001190620123612e-07 0.8833010177194197 9.001192323837925e-07 0.8769686903427227 \
9.001193800034191e-07 0.8711968848515086 9.001195318545579e-07 0.8650238565011712 9.001196679836116e-07 0.8593172646418706 9.001198100472282e-07 0.8532105227807962 \
9.00119945331887e-07 0.8472784593397693 9.001200839912582e-07 0.8411010749315838 9.001202312982803e-07 0.8344514077702887 9.001203778651285e-07 0.8277635723525925 \
9.00120539944527e-07 0.8202964899226535 9.001206873111724e-07 0.8134532267615989 9.001208588244698e-07 0.8054479178086997 9.001210422474358e-07 0.7968539002302991 \
9.00121244752722e-07 0.7873346372610658 9.00121456402384e-07 0.7773555108975432 9.001216773929431e-07 0.7669228693561837 9.0012190658697e-07 0.7561055044419139 \
9.001221831069207e-07 0.743046509132553 9.001224685936448e-07 0.7295848836660939 9.001227899085387e-07 0.7144535604611002 9.001230793784592e-07 0.7008559708795014 \
9.001233986483167e-07 0.6858669291494816 9.001237196636871e-07 0.6708097907125149 9.001240610997185e-07 0.654842287100785 9.001244537234066e-07 0.6364912117266992 \
9.001248083179958e-07 0.6199451687359452 9.001251731050783e-07 0.602895395464039 9.001255769217897e-07 0.5840362041416589 9.001259404503566e-07 0.56705803755797 \
9.00126371026893e-07 0.546963725974103 9.001267271887658e-07 0.5303181638661557 9.001271001981656e-07 0.5128834705750704 9.001274423832748e-07 0.4969084729771704 \
9.001277621248385e-07 0.4820272854775881 9.001280798688676e-07 0.4673068400017517 9.001283757203101e-07 0.453709089639897 9.001287037441391e-07 0.4388357619204879 \
9.001290132345766e-07 0.4250513307906954 9.001292997339751e-07 0.412542701771394 9.001296120885152e-07 0.3991541929604193 9.001299021997139e-07 0.3870087322563178 \
9.001302156657333e-07 0.3741657412501236 9.001304930286139e-07 0.3630444214925196 9.001307741261108e-07 0.3519744117192101 9.001310056073636e-07 0.3430374849397334 \
9.001312341747561e-07 0.3343354151638595 9.001314740666601e-07 0.3253394991495989 9.001317318484438e-07 0.3158318026516087 9.001319812183576e-07 0.3067925439309827 \
9.00132239531266e-07 0.297589150170473 9.001324860622872e-07 0.2889540805256016 9.001327733570433e-07 0.2790758510850415 9.001329967361242e-07 0.2715471379396955 \
9.001332175314858e-07 0.2642409610398131 9.0013341340532e-07 0.2578652581015776 9.001336001294005e-07 0.2519000449202701 9.001337713205379e-07 0.2465102462678049 \
9.001339463640633e-07 0.2410522141953559 9.001341093819267e-07 0.236036359124031 9.001342707863681e-07 0.2311389431166576 9.001344246037583e-07 0.2265774065811171 \
9.001345765404798e-07 0.2221477024102725 9.00134730763452e-07 0.2177012931700853 9.001349043990521e-07 0.2127672920349684 9.001350545160932e-07 0.2085590788965803 \
9.001351889678133e-07 0.2048346911951331 9.001353338801522e-07 0.2008962005616911 9.001354954147815e-07 0.1965999354189458 9.001356443031983e-07 0.1927083727438147 \
9.001357885433757e-07 0.1889957157254755 9.001359135867135e-07 0.1858267544518093 9.001360106534918e-07 0.183392498065703 9.001361456478894e-07 0.1800503036180525 \
9.001362551622506e-07 0.1773760505692391 9.001363931377782e-07 0.1740872877198338 9.001365131504133e-07 0.1712726271080235 9.001366300320898e-07 0.1685704901364905 \
9.00136756660935e-07 0.1656849030049582 9.001368926752681e-07 0.1626308514974385 9.001370260617698e-07 0.1596764551685698 9.001371530037036e-07 0.1569158519548911 \
9.001372816217376e-07 0.1541678007478876 9.001373955481781e-07 0.1517740356345986 9.001375058591172e-07 0.149496521787741 9.001376190003596e-07 0.1472133997668396 \
9.001377324794356e-07 0.1449590740078549 9.001378578442209e-07 0.1425075003983929 9.001380036381084e-07 0.1397077962434051 9.001381867800951e-07 0.1362681166668699 \
9.001383353874999e-07 0.1335395672637218 9.001384476393217e-07 0.1315146079855561 9.001385769927546e-07 0.1292194206906994 9.001386705289107e-07 0.1275846423925092 \
9.001387793207205e-07 0.1257099890290588 9.001388730748316e-07 0.1241165438085202 9.001389566824355e-07 0.1227229754719547 9.001390763363005e-07 0.1207568051616409 \
9.001392054252613e-07 0.1186746054627577 9.001393222794968e-07 0.1168252031377112 9.001394533685069e-07 0.1147891811469644 9.001395987235226e-07 0.1125787883659796 \
9.00139764133423e-07 0.110121919024741 9.001399328736703e-07 0.1076798417306999 9.001401257538154e-07 0.1049622523271389 9.001402997319428e-07 0.1025767092705754 \
9.001404879183132e-07 0.1000644866129177 9.001406703194105e-07 0.09769892895340802 9.001408499110243e-07 0.09544952095403336 9.001410264084269e-07 0.09330553315647841 \
9.001412109641775e-07 0.09112768523704891 9.001413962096449e-07 0.08900465024544718 9.001415782810569e-07 0.0869768268327742 9.001417743458045e-07 0.08485812802288394 \
9.001419447462217e-07 0.08306894814141007 9.001421229869926e-07 0.08125105909257219 9.001422986795187e-07 0.07951206376949813 9.001424990800232e-07 0.07758728548656671 \
9.00142695934063e-07 0.07575734486890456 9.001428658684992e-07 0.07422427017287291 9.001430365177502e-07 0.07272580243814712 9.001432196424959e-07 0.07116311580983979 \
9.001434132597429e-07 0.06956233824397716 9.001435948467065e-07 0.06811311716920317 9.001437934210269e-07 0.06657819701521293 9.001439499522991e-07 0.06540254085633944 \
9.001441335227451e-07 0.06406078399206196 9.001443064849855e-07 0.06283331112669251 9.001444719953625e-07 0.06169268945721457 9.001446203314103e-07 0.06069691796619666 \
9.001447572296269e-07 0.05979937680937147 9.00144904867328e-07 0.05885633029244827 9.00145037955006e-07 0.05802735218158511 9.001451614741417e-07 0.05727448785321319 \
9.00145277510429e-07 0.05658054160001152 9.001453911236973e-07 0.05591352504042409 9.001455157451721e-07 0.05519553885869784 9.001456365421113e-07 0.05451306145814139 \
9.001457964858298e-07 0.0536298481755812 9.001459318329125e-07 0.05289991373180127 9.001460321524118e-07 0.05236888834064994 9.001461326223724e-07 0.05184552065910697 \
9.001462315654583e-07 0.05133799434906983 9.001464100700205e-07 0.05044349321929222 9.001465098701189e-07 0.04995513630881745 9.001467100355682e-07 0.04899962929156078 \
9.001468009528507e-07 0.04857581029502876 9.001470077462978e-07 0.04763487432244629 9.001471129764304e-07 0.0471681110353394 9.001473093549223e-07 0.04631787013837765 \
9.001473946332177e-07 0.04595693884580357 9.001475750955806e-07 0.04521002446657041 9.001476502601712e-07 0.04490525014776706 9.001478681175704e-07 0.0440422972058082 \
9.001479516361654e-07 0.04372097365614635 9.001481415712709e-07 0.04300637120866019 9.001482663176105e-07 0.04254845761102347 9.001484515435786e-07 0.0418846242551883 \
9.001485543821369e-07 0.04152415866453074 9.001488438948115e-07 0.04053983903151908 9.001489328164065e-07 0.04024621147044882 9.001492414867604e-07 0.03925784365481538 \
9.001492976457642e-07 0.03908306666491448 9.001496112078655e-07 0.03813491809530275 9.001496671638485e-07 0.037970533835152 9.001499940781641e-07 0.03703805601095747 \
9.00150047341397e-07 0.03689043863681411 9.001503532654854e-07 0.03606517121743442 9.001504534292134e-07 0.0358032254974586 9.001507720449093e-07 0.03499570355391716 \
9.00150861523872e-07 0.03477583942316619 9.001512593644584e-07 0.03383675925705845 9.001513772457939e-07 0.03357186655877694 9.001517892479576e-07 0.03268299960645597 \
9.001519496108504e-07 0.03235094877383871 9.001523206292343e-07 0.03161177976826059 9.001525403826855e-07 0.03119164460703521 9.001529837669187e-07 0.03038142203317581 \
9.001532328105505e-07 0.0299476098095271 9.001537326667001e-07 0.02912178892962563 9.001539515582769e-07 0.02877747133829427 9.001544346720837e-07 0.02805819238630505 \
9.001547234993366e-07 0.02765301209416409 9.001554102473024e-07 0.02674723311374961 9.001556997628567e-07 0.02638861276123805 9.001564757361353e-07 0.02548835782609031 \
9.001566471895258e-07 0.02530065249352256 9.001574332713198e-07 0.02449144648051316 9.001576373003535e-07 0.02429465554580218 9.001587468983159e-07 0.02329883562822865 \
9.00158847813389e-07 0.02321388155873386 9.001600394040858e-07 0.02227529349501467 9.001602443122935e-07 0.0221260927003824 9.001616975083641e-07 0.02113958380755909 \
9.001619324927818e-07 0.02098788030205876 9.001634397606963e-07 0.02004942094855779 9.001637600611106e-07 0.01985604392354444 9.001649742394565e-07 0.01910354072181233 \
9.001654475441281e-07 0.01879991394003632 9.001667486779812e-07 0.01794965119692995 9.001671384705681e-07 0.01770179815419311 9.001685370187325e-07 0.01679702456340363 \
9.001688637688125e-07 0.01658609683275075 9.001699811040698e-07 0.01586843585740347 9.001706897903676e-07 0.01544169959229912 9.001724223763658e-07 0.01449858640399567 \
9.001726718388173e-07 0.01436065672582198 9.001744694357164e-07 0.01337694399212387 9.001748121293817e-07 0.01319104500849105 9.001769884628946e-07 0.01225973435293598 \
9.001772733192796e-07 0.01213579497780986 9.001791721626723e-07 0.01126438850740638 9.001796550251296e-07 0.01103474467122418 9.001819275205546e-07 0.01014901321627989 \
9.001823150587259e-07 0.01002270433864562 9.001849665648853e-07 0.009023867700259034 9.001852627688167e-07 0.00890332747207802 9.001876046069907e-07 0.00793111507746596 \
9.001878581913148e-07 0.007825942613114227 9.001908803610571e-07 0.006881067894167194 9.0019112999456e-07 0.006804700431426973 9.001950078918081e-07 0.005817006850260108 \
9.001952350713843e-07 0.005760637946475626 9.001980461896193e-07 0.00490690852483563 9.00198480606374e-07 0.004760206508803379 9.002010103666519e-07 0.003858115577918713 \
9.002014288631811e-07 0.003712016323791173 9.002044535343088e-07 0.00274875962184498 9.002047337594409e-07 0.002664158024812898 9.00208530584646e-07 0.001697446565651876 \
9.002088849639912e-07 0.001621705150764489 9.002144114789963e-07 0.0006347476112661908 9.002147089634814e-07 0.0005888553763099016 9.002222167274472e-07 -0.0003928413941844093 \
9.00222438401114e-07 -0.0004189941252107796 9.002365307848727e-07 -0.001410461992184868 9.002368896125909e-07 -0.001430649730572865 9.002502372454117e-07 -0.0004514903228812461 \
9.002504646425127e-07 -0.0004111859973536986 9.002559156120651e-07 0.0005614551864591434 9.002561788974843e-07 0.0006110884748384679 9.002608108374913e-07 0.001592952619583714 \
9.002611188696391e-07 0.001665522059460669 9.0026495308288e-07 0.002626457037572999 9.002653373828843e-07 0.002733556882532277 9.002690715761655e-07 0.003682507088408038 \
9.002692734414486e-07 0.00374945551670179 9.00272897693538e-07 0.004734851451646972 9.002730926227528e-07 0.004780391513086043 9.002764798221767e-07 0.005766866152453508 \
9.002766719106971e-07 0.005810149709068801 9.00280887542283e-07 0.006750994364636406 9.002812210794924e-07 0.006821678237255247 9.003059485403023e-07 0.005867117768706426 \
9.003062618172083e-07 0.005806676405157672 9.003108931929807e-07 0.004863125825100585 9.003111650442215e-07 0.004806306550559217 9.003161096881005e-07 0.003825328200913169 \
9.003165761419321e-07 0.003739629632037282 9.003224824058496e-07 0.002770751168227681 9.003227761301588e-07 0.002729631326985271 9.003316213590711e-07 0.001738601807147118 \
9.003318081264262e-07 0.001722695496451883 9.003520369591485e-07 0.0007253105668073048 9.003534715984433e-07 0.0006873447391178559 9.589900000000112e-07 3.130932490801775e-06 \
9.618834078303853e-07 -0.0008819623910157972 9.618836438792339e-07 -0.001161970612476729 9.61884102325562e-07 -0.001847355627596629 9.618843456126972e-07 -0.002293620068582415 \
9.618845958966646e-07 -0.00281405583725217 9.618848467026682e-07 -0.003393671496214343 9.618851595223304e-07 -0.004199192998005251 9.618853977322015e-07 -0.004872003934560885 \
9.618856441826354e-07 -0.005621391842385397 9.618858759271307e-07 -0.006370319304257691 9.618861831122488e-07 -0.007411941938624838 9.618864484061811e-07 -0.008326397880259807 \
9.618866936858074e-07 -0.009131457988769647 9.618870584173625e-07 -0.01007334593757064 9.618872864885395e-07 -0.01033898456945748 9.618876101281817e-07 -0.009994868194499993 \
9.61887810544735e-07 -0.009187286872421443 9.618880453495324e-07 -0.007487931918614563 9.618882264249877e-07 -0.005544847192362645 9.618883328652771e-07 -0.004119573247771668 \
9.618884711514237e-07 -0.001940540768574745 9.618885821773866e-07 7.563183370691832e-05 9.618887027988208e-07 0.002536824544301687 9.618888058640018e-07 0.004857398676819782 \
9.618889445712866e-07 0.008289235792766818 9.618890656805786e-07 0.01156496544863939 9.618892158843801e-07 0.01596809792775087 9.618893975299902e-07 0.02176080367268303 \
9.618895499652094e-07 0.02698454055473338 9.61889726115454e-07 0.03339084366291074 9.618899251155999e-07 0.04103368087207344 9.618900947875377e-07 0.04784290449723066 \
9.618902739815136e-07 0.05527749234857952 9.61890434397879e-07 0.06211990493347131 9.618905961918388e-07 0.06916698107316244 9.618907547427193e-07 0.07620053909780501 \
9.618909219353921e-07 0.08372027851346725 9.618910922933183e-07 0.09147114401158042 9.618912717305653e-07 0.0997240648901548 9.618914618530915e-07 0.1085375718081032 \
9.618916610920532e-07 0.1178373860957827 9.618918650693585e-07 0.1274102212870429 9.6189208614423e-07 0.1378300800073513 9.618923318007999e-07 0.1494365474357121 \
9.618925891510431e-07 0.1616443690283554 9.618928718421389e-07 0.1750899465505063 9.618931698935498e-07 0.1892663579759593 9.618935161701215e-07 0.2057792515135755 \
9.618938828852402e-07 0.2232517522030736 9.618942787974867e-07 0.2421754728923703 9.618947139088535e-07 0.2629945242020292 9.618951937188403e-07 0.2859861135989593 \
9.618957190371006e-07 0.3113450809673837 9.618962435732646e-07 0.3367514755549041 9.618968408927387e-07 0.3658546932050024 9.618976077178589e-07 0.4033613755922033 \
9.618980462067973e-07 0.4246376380793622 9.618985227203772e-07 0.4473946242989675 9.618989725559669e-07 0.4684360091747882 9.61899525240159e-07 0.4936960927629759 \
9.619002232363642e-07 0.5245486808074998 9.619008376384757e-07 0.5507582774516211 9.619014056089781e-07 0.5741722555225199 9.619019358622475e-07 0.5952266004882081 \
9.619023948316282e-07 0.6128068198589096 9.619029779997919e-07 0.6341908714213341 9.619035511577073e-07 0.6541368834277531 9.619041418420318e-07 0.6735006351351156 \
9.619048105153407e-07 0.6939224431220803 9.619054650004867e-07 0.7123419857223411 9.619062186316106e-07 0.7316435145596337 9.619071381113492e-07 0.7524771687756806 \
9.61907807118464e-07 0.7658582308664672 9.619085026848479e-07 0.7783426900018873 9.619092247217994e-07 0.7898435797332509 9.619098715050643e-07 0.7989777190578581 \
9.619106863983728e-07 0.809051394855074 9.619113442910834e-07 0.8161084932798452 9.619121090555768e-07 0.8232971874420545 9.619127055889393e-07 0.8281915934352191 \
9.619133336120951e-07 0.8327857747397983 9.619139640044049e-07 0.8368636793792511 9.6191494962664e-07 0.8423301485602825 9.619157053806966e-07 0.8458701801587535 \
9.619164686711316e-07 0.8489683054605098 9.619172770119171e-07 0.8518111549479527 9.619182659033656e-07 0.8547854532963984 9.619190089589791e-07 0.8567085856698495 \
9.61919831636168e-07 0.8585940601366741 9.619206128562233e-07 0.8601698380186774 9.619214164593907e-07 0.8616111415036141 9.619222037276375e-07 0.8628649505886673 \
9.619233957300523e-07 0.8644986110026872 9.619243183520358e-07 0.8655887935537701 9.619253772797719e-07 0.8666437563732095 9.619262503704939e-07 0.8673888282159752 \
9.619270194277643e-07 0.8679394432393451 9.619327760832006e-07 0.8675354626998435 9.61933384736608e-07 0.8669285211992742 9.619343486330671e-07 0.8661637309277684 \
9.619346970271229e-07 0.8657877651307159 9.619358657362972e-07 0.8648718022682493 9.619365074390833e-07 0.8645495171393598 9.619377237792426e-07 0.8636149212264693 \
9.619382109959972e-07 0.8633315979857124 9.619419957515129e-07 0.8637879096652611 9.619428035605935e-07 0.8644940879742092 9.619436767313112e-07 0.8654118536506241 \
9.619445258485198e-07 0.8664722967159353 9.619453943206629e-07 0.8676408136092975 9.619462207994818e-07 0.8688316482847912 9.619470672737479e-07 0.8700680498371385 \
9.619479937316664e-07 0.8714353201417473 9.619489227517378e-07 0.8727967357236968 9.619498903738162e-07 0.874169309418928 9.61950892855429e-07 0.8755268793700145 \
9.619519757862113e-07 0.8769279254876977 9.619531542588973e-07 0.8783524184654903 9.619543673598332e-07 0.8797057189093218 9.619556978206917e-07 0.8810544625232946 \
9.61957146531982e-07 0.8823882385150326 9.619588142667742e-07 0.8837386794148741 9.619604462986394e-07 0.8848798336526329 9.619624135908377e-07 0.8860652157953401 \
9.61964590094435e-07 0.8871729764751287 9.619668622498768e-07 0.8881691778223457 9.619691357549546e-07 0.8889896378135498 9.619710876656952e-07 0.8895771814349003 \
9.619739721002915e-07 0.8902862350409186 9.619768310366352e-07 0.8908501300162286 9.61979913323748e-07 0.8913157385816455 9.619917316745296e-07 0.8922670755128276 \
9.619940583186116e-07 0.8924600956555456 9.620009395174264e-07 0.8933233934443291 9.620029317728824e-07 0.8936033182227321 9.620075969639979e-07 0.8943294235126149 \
9.62009934973581e-07 0.894763749611499 9.620124353207703e-07 0.8952990768365913 9.620149092232741e-07 0.8959385502707948 9.620170353180256e-07 0.8965630758105964 \
9.620196246214938e-07 0.8973958942958599 9.620220486411288e-07 0.8982427248493853 9.620249404555524e-07 0.8993469797885378 9.620274501270731e-07 0.9003588137389537 \
9.620307885703227e-07 0.9017079510157455 9.620338675437541e-07 0.9029423170929788 9.620370606228689e-07 0.9042497182071535 9.620396562795079e-07 0.9052493492427333 \
9.62041664531596e-07 0.9059572885738179 9.620437727604825e-07 0.9066594295388942 9.620464614774176e-07 0.907478492737931 9.620489170700809e-07 0.9081366525620301 \
9.620512815901832e-07 0.9087089258990763 9.620538761545912e-07 0.9092804446275633 9.620562438698248e-07 0.9097121154337445 9.620636363095347e-07 0.9105880439508957 \
9.620669473854304e-07 0.9108097973553667 9.620906311042105e-07 0.9099572430838525 9.620935249940686e-07 0.9096028008700563 9.620996337217846e-07 0.9087795762164674 \
9.621026647849372e-07 0.9083311497095887 9.621090224429014e-07 0.9073557537429059 9.621129163890337e-07 0.906719613226565 9.62116289356866e-07 0.9061475060281556 \
9.621193749147294e-07 0.9055946669458763 9.621231206292774e-07 0.9048996522446952 9.621264870170348e-07 0.9043394102803256 9.62134077462241e-07 0.9034499723753743 \
9.621379534727774e-07 0.9031904105967781 9.621657177088619e-07 0.9022140906736803 9.621694938687787e-07 0.902100877529562 9.622009101005462e-07 0.9011025155537421 \
9.622075451903933e-07 0.9009020504869808 1.000110550805801e-06 0.8999193627810952 1.00011071848179e-06 0.8998913840591389 1.000113467033027e-06 0.8989010293823864 \
1.000113523573982e-06 0.8988795941121664 1.000114768178511e-06 0.8998357618405769 1.000114847007516e-06 0.9000722811707415 1.000115028967664e-06 0.9007374088026997 \
1.00011513130788e-06 0.9011852075627013 1.000115324284061e-06 0.9021545909398002 1.000115412645943e-06 0.9026487433775175 1.000115571157197e-06 0.9036053969378676 \
1.000115683054863e-06 0.9043311123122415 1.000115823971993e-06 0.9052897461292233 1.000115929405144e-06 0.9060407976354218 1.000116042282183e-06 0.9068700067857125 \
1.000116156714019e-06 0.9077320749581511 1.000116277994792e-06 0.9086625635419388 1.000116407030339e-06 0.9096610759972766 1.000116529569199e-06 0.9106054665418637 \
1.00011665392414e-06 0.9115433813509556 1.000116768824237e-06 0.912370851358936 1.000116872924634e-06 0.9130668181210778 1.000116980506906e-06 0.9137127811079708 \
1.000117148007135e-06 0.914504286313051 1.000117619367398e-06 0.9145217838087505 1.000117817316352e-06 0.9131640269569251 1.000117978090595e-06 0.9113346267648944 \
1.000118066395334e-06 0.910041664336402 1.000118153928761e-06 0.908567258693449 1.000118246820307e-06 0.9067913249607207 1.000118320262759e-06 0.9052411278657534 \
1.000118409009881e-06 0.9032017134587504 1.000118546653074e-06 0.8996915735089056 1.000118658994696e-06 0.8965314120175644 1.000118782291717e-06 0.892778172623249 \
1.000118938496376e-06 0.8876402979533503 1.000119062012361e-06 0.8833010177194197 1.000119232383792e-06 0.8769686903427227 1.000119380003419e-06 0.8711968848515086 \
1.000119531854558e-06 0.8650238565011712 1.000119667983612e-06 0.8593172646418706 1.000119810047228e-06 0.8532105227807962 1.000119945331887e-06 0.8472784593397693 \
1.000120083991258e-06 0.8411010749315838 1.00012023129828e-06 0.8344514077702887 1.000120377865128e-06 0.8277635723525925 1.000120539944527e-06 0.8202964899226535 \
1.000120687311172e-06 0.8134532267615989 1.00012085882447e-06 0.8054479178086997 1.000121042247436e-06 0.7968539002302991 1.000121244752722e-06 0.7873346372610658 \
1.000121456402384e-06 0.7773555108975432 1.000121677392943e-06 0.7669228693561837 1.00012190658697e-06 0.7561055044419139 1.000122183106921e-06 0.743046509132553 \
1.000122468593645e-06 0.7295848836660939 1.000122789908539e-06 0.7144535604611002 1.000123079378459e-06 0.7008559708795014 1.000123398648317e-06 0.6858669291494816 \
1.000123719663687e-06 0.6708097907125149 1.000124061099719e-06 0.654842287100785 1.000124453723407e-06 0.6364912117266992 1.000124808317996e-06 0.6199451687359452 \
1.000125173105078e-06 0.602895395464039 1.00012557692179e-06 0.5840362041416589 1.000125940450357e-06 0.56705803755797 1.000126371026893e-06 0.546963725974103 \
1.000126727188766e-06 0.5303181638661557 1.000127100198165e-06 0.5128834705750704 1.000127442383275e-06 0.4969084729771704 1.000127762124839e-06 0.4820272854775881 \
1.000128079868868e-06 0.4673068400017517 1.00012837572031e-06 0.453709089639897 1.000128703744139e-06 0.4388357619204879 1.000129013234577e-06 0.4250513307906954 \
1.000129299733975e-06 0.412542701771394 1.000129612088515e-06 0.3991541929604193 1.000129902199714e-06 0.3870087322563178 1.000130215665733e-06 0.3741657412501236 \
1.000130493028614e-06 0.3630444214925196 1.000130774126111e-06 0.3519744117192101 1.000131005607364e-06 0.3430374849397334 1.000131234174756e-06 0.3343354151638595 \
1.00013147406666e-06 0.3253394991495989 1.000131731848444e-06 0.3158318026516087 1.000131981218358e-06 0.3067925439309827 1.000132239531266e-06 0.297589150170473 \
1.000132486062287e-06 0.2889540805256016 1.000132773357043e-06 0.2790758510850415 1.000132996736124e-06 0.2715471379396955 1.000133217531486e-06 0.2642409610398131 \
1.00013341340532e-06 0.2578652581015776 1.0001336001294e-06 0.2519000449202701 1.000133771320538e-06 0.2465102462678049 1.000133946364063e-06 0.2410522141953559 \
1.000134109381927e-06 0.236036359124031 1.000134270786368e-06 0.2311389431166576 1.000134424603758e-06 0.2265774065811171 1.00013457654048e-06 0.2221477024102725 \
1.000134730763452e-06 0.2177012931700853 1.000134904399052e-06 0.2127672920349684 1.000135054516093e-06 0.2085590788965803 1.000135188967813e-06 0.2048346911951331 \
1.000135333880152e-06 0.2008962005616911 1.000135495414782e-06 0.1965999354189458 1.000135644303198e-06 0.1927083727438147 1.000135788543376e-06 0.1889957157254755 \
1.000135913586713e-06 0.1858267544518093 1.000136010653492e-06 0.183392498065703 1.000136145647889e-06 0.1800503036180525 1.000136255162251e-06 0.1773760505692391 \
1.000136393137778e-06 0.1740872877198338 1.000136513150413e-06 0.1712726271080235 1.00013663003209e-06 0.1685704901364905 1.000136756660935e-06 0.1656849030049582 \
1.000136892675268e-06 0.1626308514974385 1.00013702606177e-06 0.1596764551685698 1.000137153003704e-06 0.1569158519548911 1.000137281621738e-06 0.1541678007478876 \
1.000137395548178e-06 0.1517740356345986 1.000137505859117e-06 0.149496521787741 1.00013761900036e-06 0.1472133997668396 1.000137732479436e-06 0.1449590740078549 \
1.000137857844221e-06 0.1425075003983929 1.000138003638109e-06 0.1397077962434051 1.000138186780095e-06 0.1362681166668699 1.0001383353875e-06 0.1335395672637218 \
1.000138447639322e-06 0.1315146079855561 1.000138576992755e-06 0.1292194206906994 1.000138670528911e-06 0.1275846423925092 1.00013877932072e-06 0.1257099890290588 \
1.000138873074832e-06 0.1241165438085202 1.000138956682436e-06 0.1227229754719547 1.0001390763363e-06 0.1207568051616409 1.000139205425261e-06 0.1186746054627577 \
1.000139322279497e-06 0.1168252031377112 1.000139453368507e-06 0.1147891811469644 1.000139598723523e-06 0.1125787883659796 1.000139764133423e-06 0.110121919024741 \
1.00013993287367e-06 0.1076798417306999 1.000140125753815e-06 0.1049622523271389 1.000140299731943e-06 0.1025767092705754 1.000140487918313e-06 0.1000644866129177 \
1.000140670319411e-06 0.09769892895340802 1.000140849911024e-06 0.09544952095403336 1.000141026408427e-06 0.09330553315647841 1.000141210964178e-06 0.09112768523704891 \
1.000141396209645e-06 0.08900465024544718 1.000141578281057e-06 0.0869768268327742 1.000141774345804e-06 0.08485812802288394 1.000141944746222e-06 0.08306894814141007 \
1.000142122986993e-06 0.08125105909257219 1.000142298679519e-06 0.07951206376949813 1.000142499080023e-06 0.07758728548656671 1.000142695934063e-06 0.07575734486890456 \
1.000142865868499e-06 0.07422427017287291 1.00014303651775e-06 0.07272580243814712 1.000143219642496e-06 0.07116311580983979 1.000143413259743e-06 0.06956233824397716 \
1.000143594846707e-06 0.06811311716920317 1.000143793421027e-06 0.06657819701521293 1.000143949952299e-06 0.06540254085633944 1.000144133522745e-06 0.06406078399206196 \
1.000144306484986e-06 0.06283331112669251 1.000144471995363e-06 0.06169268945721457 1.00014462033141e-06 0.06069691796619666 1.000144757229627e-06 0.05979937680937147 \
1.000144904867328e-06 0.05885633029244827 1.000145037955006e-06 0.05802735218158511 1.000145161474142e-06 0.05727448785321319 1.000145277510429e-06 0.05658054160001152 \
1.000145391123697e-06 0.05591352504042409 1.000145515745172e-06 0.05519553885869784 1.000145636542111e-06 0.05451306145814139 1.00014579648583e-06 0.0536298481755812 \
1.000145931832913e-06 0.05289991373180127 1.000146032152412e-06 0.05236888834064994 1.000146132622372e-06 0.05184552065910697 1.000146231565458e-06 0.05133799434906983 \
1.00014641007002e-06 0.05044349321929222 1.000146509870119e-06 0.04995513630881745 1.000146710035568e-06 0.04899962929156078 1.000146800952851e-06 0.04857581029502876 \
1.000147007746298e-06 0.04763487432244629 1.000147112976431e-06 0.0471681110353394 1.000147309354922e-06 0.04631787013837765 1.000147394633218e-06 0.04595693884580357 \
1.000147575095581e-06 0.04521002446657041 1.000147650260171e-06 0.04490525014776706 1.00014786811757e-06 0.0440422972058082 1.000147951636165e-06 0.04372097365614635 \
1.000148141571271e-06 0.04300637120866019 1.00014826631761e-06 0.04254845761102347 1.000148451543579e-06 0.0418846242551883 1.000148554382137e-06 0.04152415866453074 \
1.000148843894812e-06 0.04053983903151908 1.000148932816406e-06 0.04024621147044882 1.00014924148676e-06 0.03925784365481538 1.000149297645764e-06 0.03908306666491448 \
1.000149611207866e-06 0.03813491809530275 1.000149667163848e-06 0.037970533835152 1.000149994078164e-06 0.03703805601095747 1.000150047341397e-06 0.03689043863681411 \
1.000150353265485e-06 0.03606517121743442 1.000150453429214e-06 0.0358032254974586 1.000150772044909e-06 0.03499570355391716 1.000150861523872e-06 0.03477583942316619 \
1.000151259364458e-06 0.03383675925705845 1.000151377245794e-06 0.03357186655877694 1.000151789247958e-06 0.03268299960645597 1.00015194961085e-06 0.03235094877383871 \
1.000152320629234e-06 0.03161177976826059 1.000152540382686e-06 0.03119164460703521 1.000152983766919e-06 0.03038142203317581 1.000153232810551e-06 0.0299476098095271 \
1.0001537326667e-06 0.02912178892962563 1.000153951558277e-06 0.02877747133829427 1.000154434672084e-06 0.02805819238630505 1.000154723499336e-06 0.02765301209416409 \
1.000155410247302e-06 0.02674723311374961 1.000155699762857e-06 0.02638861276123805 1.000156475736135e-06 0.02548835782609031 1.000156647189526e-06 0.02530065249352256 \
1.00015743327132e-06 0.02449144648051316 1.000157637300353e-06 0.02429465554580218 1.000158746898316e-06 0.02329883562822865 1.000158847813389e-06 0.02321388155873386 \
1.000160039404086e-06 0.02227529349501467 1.000160244312293e-06 0.0221260927003824 1.000161697508364e-06 0.02113958380755909 1.000161932492782e-06 0.02098788030205876 \
1.000163439760696e-06 0.02004942094855779 1.00016376006111e-06 0.01985604392354444 1.000164974239457e-06 0.01910354072181233 1.000165447544128e-06 0.01879991394003632 \
1.000166748677981e-06 0.01794965119692995 1.000167138470568e-06 0.01770179815419311 1.000168537018733e-06 0.01679702456340363 1.000168863768813e-06 0.01658609683275075 \
1.00016998110407e-06 0.01586843585740347 1.000170689790368e-06 0.01544169959229912 1.000172422376366e-06 0.01449858640399567 1.000172671838817e-06 0.01436065672582198 \
1.000174469435716e-06 0.01337694399212387 1.000174812129382e-06 0.01319104500849105 1.000176988462895e-06 0.01225973435293598 1.00017727331928e-06 0.01213579497780986 \
1.000179172162672e-06 0.01126438850740638 1.00017965502513e-06 0.01103474467122418 1.000181927520555e-06 0.01014901321627989 1.000182315058726e-06 0.01002270433864562 \
1.000184966564885e-06 0.009023867700259034 1.000185262768817e-06 0.00890332747207802 1.000187604606991e-06 0.00793111507746596 1.000187858191315e-06 0.007825942613114227 \
1.000190880361057e-06 0.006881067894167194 1.00019112999456e-06 0.006804700431426973 1.000195007891808e-06 0.005817006850260108 1.000195235071384e-06 0.005760637946475626 \
1.000198046189619e-06 0.00490690852483563 1.000198480606374e-06 0.004760206508803379 1.000201010366652e-06 0.003858115577918713 1.000201428863181e-06 0.003712016323791173 \
1.000204453534309e-06 0.00274875962184498 1.000204733759441e-06 0.002664158024812898 1.000208530584646e-06 0.001697446565651876 1.000208884963991e-06 0.001621705150764489 \
1.000214411478996e-06 0.0006347476112661908 1.000214708963482e-06 0.0005888553763099016 1.000222216727447e-06 -0.0003928413941844093 1.000222438401114e-06 -0.0004189941252107796 \
1.000236530784873e-06 -0.001410461992184868 1.000236889612591e-06 -0.001430649730572865 1.000250237245412e-06 -0.0004514903228812461 1.000250464642513e-06 -0.0004111859973536986 \
1.000255915612065e-06 0.0005614551864591434 1.000256178897484e-06 0.0006110884748384679 1.000260810837491e-06 0.001592952619583714 1.000261118869639e-06 0.001665522059460669 \
1.00026495308288e-06 0.002626457037572999 1.000265337382884e-06 0.002733556882532277 1.000269071576165e-06 0.003682507088408038 1.000269273441449e-06 0.00374945551670179 \
1.000272897693538e-06 0.004734851451646972 1.000273092622753e-06 0.004780391513086043 1.000276479822177e-06 0.005766866152453508 1.000276671910697e-06 0.005810149709068801 \
1.000280887542283e-06 0.006750994364636406 1.000281221079492e-06 0.006821678237255247 1.000305948540302e-06 0.005867117768706426 1.000306261817208e-06 0.005806676405157672 \
1.000310893192981e-06 0.004863125825100585 1.000311165044221e-06 0.004806306550559217 1.000316109688101e-06 0.003825328200913169 1.000316576141932e-06 0.003739629632037282 \
1.000322482405849e-06 0.002770751168227681 1.000322776130159e-06 0.002729631326985271 1.000331621359071e-06 0.001738601807147118 1.000331808126426e-06 0.001722695496451883 \
1.000352036959148e-06 0.0007253105668073048 1.000353471598443e-06 0.0006873447391178559 1.058990000000011e-06 3.130932490801775e-06 1.061883407830385e-06 -0.0008819623910157972 \
1.061883643879234e-06 -0.001161970612476729 1.061884102325562e-06 -0.001847355627596629 1.061884345612697e-06 -0.002293620068582415 1.061884595896664e-06 -0.00281405583725217 \
1.061884846702668e-06 -0.003393671496214343 1.06188515952233e-06 -0.004199192998005251 1.061885397732202e-06 -0.004872003934560885 1.061885644182635e-06 -0.005621391842385397 \
1.061885875927131e-06 -0.006370319304257691 1.061886183112249e-06 -0.007411941938624838 1.061886448406181e-06 -0.008326397880259807 1.061886693685807e-06 -0.009131457988769647 \
1.061887058417363e-06 -0.01007334593757064 1.06188728648854e-06 -0.01033898456945748 1.061887610128182e-06 -0.009994868194499993 1.061887810544735e-06 -0.009187286872421443 \
1.061888045349532e-06 -0.007487931918614563 1.061888226424988e-06 -0.005544847192362645 1.061888332865277e-06 -0.004119573247771668 1.061888471151424e-06 -0.001940540768574745 \
1.061888582177387e-06 7.563183370691832e-05 1.061888702798821e-06 0.002536824544301687 1.061888805864002e-06 0.004857398676819782 1.061888944571287e-06 0.008289235792766818 \
1.061889065680579e-06 0.01156496544863939 1.06188921588438e-06 0.01596809792775087 1.06188939752999e-06 0.02176080367268303 1.06188954996521e-06 0.02698454055473338 \
1.061889726115454e-06 0.03339084366291074 1.0618899251156e-06 0.04103368087207344 1.061890094787538e-06 0.04784290449723066 1.061890273981514e-06 0.05527749234857952 \
1.061890434397879e-06 0.06211990493347131 1.061890596191839e-06 0.06916698107316244 1.061890754742719e-06 0.07620053909780501 1.061890921935392e-06 0.08372027851346725 \
1.061891092293318e-06 0.09147114401158042 1.061891271730565e-06 0.0997240648901548 1.061891461853091e-06 0.1085375718081032 1.061891661092053e-06 0.1178373860957827 \
1.061891865069358e-06 0.1274102212870429 1.06189208614423e-06 0.1378300800073513 1.0618923318008e-06 0.1494365474357121 1.061892589151043e-06 0.1616443690283554 \
1.061892871842139e-06 0.1750899465505063 1.06189316989355e-06 0.1892663579759593 1.061893516170122e-06 0.2057792515135755 1.06189388288524e-06 0.2232517522030736 \
1.061894278797487e-06 0.2421754728923703 1.061894713908853e-06 0.2629945242020292 1.06189519371884e-06 0.2859861135989593 1.0618957190371e-06 0.3113450809673837 \
1.061896243573264e-06 0.3367514755549041 1.061896840892739e-06 0.3658546932050024 1.061897607717859e-06 0.4033613755922033 1.061898046206797e-06 0.4246376380793622 \
1.061898522720377e-06 0.4473946242989675 1.061898972555967e-06 0.4684360091747882 1.061899525240159e-06 0.4936960927629759 1.061900223236364e-06 0.5245486808074998 \
1.061900837638476e-06 0.5507582774516211 1.061901405608978e-06 0.5741722555225199 1.061901935862248e-06 0.5952266004882081 1.061902394831628e-06 0.6128068198589096 \
1.061902977999792e-06 0.6341908714213341 1.061903551157707e-06 0.6541368834277531 1.061904141842032e-06 0.6735006351351156 1.061904810515341e-06 0.6939224431220803 \
1.061905465000487e-06 0.7123419857223411 1.061906218631611e-06 0.7316435145596337 1.061907138111349e-06 0.7524771687756806 1.061907807118464e-06 0.7658582308664672 \
1.061908502684848e-06 0.7783426900018873 1.061909224721799e-06 0.7898435797332509 1.061909871505064e-06 0.7989777190578581 1.061910686398373e-06 0.809051394855074 \
1.061911344291083e-06 0.8161084932798452 1.061912109055577e-06 0.8232971874420545 1.061912705588939e-06 0.8281915934352191 1.061913333612095e-06 0.8327857747397983 \
1.061913964004405e-06 0.8368636793792511 1.06191494962664e-06 0.8423301485602825 1.061915705380696e-06 0.8458701801587535 1.061916468671131e-06 0.8489683054605098 \
1.061917277011917e-06 0.8518111549479527 1.061918265903366e-06 0.8547854532963984 1.061919008958979e-06 0.8567085856698495 1.061919831636168e-06 0.8585940601366741 \
1.061920612856223e-06 0.8601698380186774 1.061921416459391e-06 0.8616111415036141 1.061922203727638e-06 0.8628649505886673 1.061923395730052e-06 0.8644986110026872 \
1.061924318352036e-06 0.8655887935537701 1.061925377279772e-06 0.8666437563732095 1.061926250370494e-06 0.8673888282159752 1.061927019427764e-06 0.8679394432393451 \
1.0619327760832e-06 0.8675354626998435 1.061933384736608e-06 0.8669285211992742 1.061934348633067e-06 0.8661637309277684 1.061934697027123e-06 0.8657877651307159 \
1.061935865736297e-06 0.8648718022682493 1.061936507439083e-06 0.8645495171393598 1.061937723779243e-06 0.8636149212264693 1.061938210995997e-06 0.8633315979857124 \
1.061941995751513e-06 0.8637879096652611 1.061942803560594e-06 0.8644940879742092 1.061943676731311e-06 0.8654118536506241 1.06194452584852e-06 0.8664722967159353 \
1.061945394320663e-06 0.8676408136092975 1.061946220799482e-06 0.8688316482847912 1.061947067273748e-06 0.8700680498371385 1.061947993731667e-06 0.8714353201417473 \
1.061948922751738e-06 0.8727967357236968 1.061949890373816e-06 0.874169309418928 1.061950892855429e-06 0.8755268793700145 1.061951975786211e-06 0.8769279254876977 \
1.061953154258897e-06 0.8783524184654903 1.061954367359833e-06 0.8797057189093218 1.061955697820692e-06 0.8810544625232946 1.061957146531982e-06 0.8823882385150326 \
1.061958814266774e-06 0.8837386794148741 1.061960446298639e-06 0.8848798336526329 1.061962413590838e-06 0.8860652157953401 1.061964590094435e-06 0.8871729764751287 \
1.061966862249877e-06 0.8881691778223457 1.061969135754955e-06 0.8889896378135498 1.061971087665695e-06 0.8895771814349003 1.061973972100292e-06 0.8902862350409186 \
1.061976831036635e-06 0.8908501300162286 1.061979913323748e-06 0.8913157385816455 1.06199173167453e-06 0.8922670755128276 1.061994058318611e-06 0.8924600956555456 \
1.062000939517426e-06 0.8933233934443291 1.062002931772883e-06 0.8936033182227321 1.062007596963998e-06 0.8943294235126149 1.062009934973581e-06 0.894763749611499 \
1.06201243532077e-06 0.8952990768365913 1.062014909223274e-06 0.8959385502707948 1.062017035318026e-06 0.8965630758105964 1.062019624621494e-06 0.8973958942958599 \
1.062022048641129e-06 0.8982427248493853 1.062024940455553e-06 0.8993469797885378 1.062027450127073e-06 0.9003588137389537 1.062030788570323e-06 0.9017079510157455 \
1.062033867543754e-06 0.9029423170929788 1.062037060622869e-06 0.9042497182071535 1.062039656279508e-06 0.9052493492427333 1.062041664531596e-06 0.9059572885738179 \
1.062043772760482e-06 0.9066594295388942 1.062046461477417e-06 0.907478492737931 1.062048917070081e-06 0.9081366525620301 1.062051281590183e-06 0.9087089258990763 \
1.062053876154591e-06 0.9092804446275633 1.062056243869825e-06 0.9097121154337445 1.062063636309535e-06 0.9105880439508957 1.062066947385431e-06 0.9108097973553667 \
1.06209063110421e-06 0.9099572430838525 1.062093524994069e-06 0.9096028008700563 1.062099633721785e-06 0.9087795762164674 1.062102664784937e-06 0.9083311497095887 \
1.062109022442902e-06 0.9073557537429059 1.062112916389034e-06 0.906719613226565 1.062116289356866e-06 0.9061475060281556 1.062119374914729e-06 0.9055946669458763 \
1.062123120629277e-06 0.9048996522446952 1.062126487017035e-06 0.9043394102803256 1.062134077462241e-06 0.9034499723753743 1.062137953472777e-06 0.9031904105967781 \
1.062165717708862e-06 0.9022140906736803 1.062169493868779e-06 0.902100877529562 1.062200910100546e-06 0.9011025155537421 1.062207545190393e-06 0.9009020504869808 \
1.1001105508058e-06 0.8999193627810952 1.10011071848179e-06 0.8998913840591389 1.100113467033027e-06 0.8989010293823864 1.100113523573982e-06 0.8988795941121664 \
1.100114768178511e-06 0.8998357618405769 1.100114847007516e-06 0.9000722811707415 1.100115028967665e-06 0.9007374088026997 1.10011513130788e-06 0.9011852075627013 \
1.100115324284061e-06 0.9021545909398002 1.100115412645943e-06 0.9026487433775175 1.100115571157198e-06 0.9036053969378676 1.100115683054862e-06 0.9043311123122415 \
1.100115823971993e-06 0.9052897461292233 1.100115929405144e-06 0.9060407976354218 1.100116042282182e-06 0.9068700067857125 1.100116156714019e-06 0.9077320749581511 \
1.100116277994792e-06 0.9086625635419388 1.100116407030339e-06 0.9096610759972766 1.100116529569199e-06 0.9106054665418637 1.10011665392414e-06 0.9115433813509556 \
1.100116768824237e-06 0.912370851358936 1.100116872924634e-06 0.9130668181210778 1.100116980506906e-06 0.9137127811079708 1.100117148007135e-06 0.914504286313051 \
1.100117619367398e-06 0.9145217838087505 1.100117817316352e-06 0.9131640269569251 1.100117978090595e-06 0.9113346267648944 1.100118066395334e-06 0.910041664336402 \
1.100118153928761e-06 0.908567258693449 1.100118246820306e-06 0.9067913249607207 1.100118320262759e-06 0.9052411278657534 1.100118409009881e-06 0.9032017134587504 \
1.100118546653074e-06 0.8996915735089056 1.100118658994696e-06 0.8965314120175644 1.100118782291718e-06 0.892778172623249 1.100118938496376e-06 0.8876402979533503 \
1.100119062012361e-06 0.8833010177194197 1.100119232383792e-06 0.8769686903427227 1.100119380003419e-06 0.8711968848515086 1.100119531854558e-06 0.8650238565011712 \
1.100119667983612e-06 0.8593172646418706 1.100119810047228e-06 0.8532105227807962 1.100119945331887e-06 0.8472784593397693 1.100120083991258e-06 0.8411010749315838 \
1.10012023129828e-06 0.8344514077702887 1.100120377865129e-06 0.8277635723525925 1.100120539944527e-06 0.8202964899226535 1.100120687311172e-06 0.8134532267615989 \
1.10012085882447e-06 0.8054479178086997 1.100121042247436e-06 0.7968539002302991 1.100121244752722e-06 0.7873346372610658 1.100121456402384e-06 0.7773555108975432 \
1.100121677392943e-06 0.7669228693561837 1.10012190658697e-06 0.7561055044419139 1.100122183106921e-06 0.743046509132553 1.100122468593645e-06 0.7295848836660939 \
1.100122789908539e-06 0.7144535604611002 1.100123079378459e-06 0.7008559708795014 1.100123398648317e-06 0.6858669291494816 1.100123719663687e-06 0.6708097907125149 \
1.100124061099719e-06 0.654842287100785 1.100124453723407e-06 0.6364912117266992 1.100124808317996e-06 0.6199451687359452 1.100125173105078e-06 0.602895395464039 \
1.10012557692179e-06 0.5840362041416589 1.100125940450357e-06 0.56705803755797 1.100126371026893e-06 0.546963725974103 1.100126727188766e-06 0.5303181638661557 \
1.100127100198166e-06 0.5128834705750704 1.100127442383275e-06 0.4969084729771704 1.100127762124838e-06 0.4820272854775881 1.100128079868868e-06 0.4673068400017517 \
1.10012837572031e-06 0.453709089639897 1.100128703744139e-06 0.4388357619204879 1.100129013234577e-06 0.4250513307906954 1.100129299733975e-06 0.412542701771394 \
1.100129612088515e-06 0.3991541929604193 1.100129902199714e-06 0.3870087322563178 1.100130215665733e-06 0.3741657412501236 1.100130493028614e-06 0.3630444214925196 \
1.100130774126111e-06 0.3519744117192101 1.100131005607363e-06 0.3430374849397334 1.100131234174756e-06 0.3343354151638595 1.10013147406666e-06 0.3253394991495989 \
1.100131731848444e-06 0.3158318026516087 1.100131981218358e-06 0.3067925439309827 1.100132239531266e-06 0.297589150170473 1.100132486062287e-06 0.2889540805256016 \
1.100132773357043e-06 0.2790758510850415 1.100132996736124e-06 0.2715471379396955 1.100133217531486e-06 0.2642409610398131 1.10013341340532e-06 0.2578652581015776 \
1.100133600129401e-06 0.2519000449202701 1.100133771320538e-06 0.2465102462678049 1.100133946364063e-06 0.2410522141953559 1.100134109381927e-06 0.236036359124031 \
1.100134270786368e-06 0.2311389431166576 1.100134424603758e-06 0.2265774065811171 1.10013457654048e-06 0.2221477024102725 1.100134730763452e-06 0.2177012931700853 \
1.100134904399052e-06 0.2127672920349684 1.100135054516093e-06 0.2085590788965803 1.100135188967813e-06 0.2048346911951331 1.100135333880152e-06 0.2008962005616911 \
1.100135495414782e-06 0.1965999354189458 1.100135644303198e-06 0.1927083727438147 1.100135788543376e-06 0.1889957157254755 1.100135913586713e-06 0.1858267544518093 \
1.100136010653492e-06 0.183392498065703 1.100136145647889e-06 0.1800503036180525 1.100136255162251e-06 0.1773760505692391 1.100136393137778e-06 0.1740872877198338 \
1.100136513150413e-06 0.1712726271080235 1.10013663003209e-06 0.1685704901364905 1.100136756660935e-06 0.1656849030049582 1.100136892675268e-06 0.1626308514974385 \
1.10013702606177e-06 0.1596764551685698 1.100137153003703e-06 0.1569158519548911 1.100137281621738e-06 0.1541678007478876 1.100137395548178e-06 0.1517740356345986 \
1.100137505859117e-06 0.149496521787741 1.10013761900036e-06 0.1472133997668396 1.100137732479436e-06 0.1449590740078549 1.100137857844221e-06 0.1425075003983929 \
1.100138003638108e-06 0.1397077962434051 1.100138186780095e-06 0.1362681166668699 1.1001383353875e-06 0.1335395672637218 1.100138447639322e-06 0.1315146079855561 \
1.100138576992755e-06 0.1292194206906994 1.100138670528911e-06 0.1275846423925092 1.10013877932072e-06 0.1257099890290588 1.100138873074831e-06 0.1241165438085202 \
1.100138956682436e-06 0.1227229754719547 1.1001390763363e-06 0.1207568051616409 1.100139205425261e-06 0.1186746054627577 1.100139322279497e-06 0.1168252031377112 \
1.100139453368507e-06 0.1147891811469644 1.100139598723523e-06 0.1125787883659796 1.100139764133423e-06 0.110121919024741 1.10013993287367e-06 0.1076798417306999 \
1.100140125753816e-06 0.1049622523271389 1.100140299731943e-06 0.1025767092705754 1.100140487918313e-06 0.1000644866129177 1.100140670319411e-06 0.09769892895340802 \
1.100140849911024e-06 0.09544952095403336 1.100141026408427e-06 0.09330553315647841 1.100141210964177e-06 0.09112768523704891 1.100141396209645e-06 0.08900465024544718 \
1.100141578281057e-06 0.0869768268327742 1.100141774345804e-06 0.08485812802288394 1.100141944746222e-06 0.08306894814141007 1.100142122986993e-06 0.08125105909257219 \
1.100142298679519e-06 0.07951206376949813 1.100142499080023e-06 0.07758728548656671 1.100142695934063e-06 0.07575734486890456 1.100142865868499e-06 0.07422427017287291 \
1.10014303651775e-06 0.07272580243814712 1.100143219642496e-06 0.07116311580983979 1.100143413259743e-06 0.06956233824397716 1.100143594846707e-06 0.06811311716920317 \
1.100143793421027e-06 0.06657819701521293 1.100143949952299e-06 0.06540254085633944 1.100144133522745e-06 0.06406078399206196 1.100144306484986e-06 0.06283331112669251 \
1.100144471995363e-06 0.06169268945721457 1.10014462033141e-06 0.06069691796619666 1.100144757229627e-06 0.05979937680937147 1.100144904867328e-06 0.05885633029244827 \
1.100145037955006e-06 0.05802735218158511 1.100145161474142e-06 0.05727448785321319 1.100145277510429e-06 0.05658054160001152 1.100145391123697e-06 0.05591352504042409 \
1.100145515745172e-06 0.05519553885869784 1.100145636542111e-06 0.05451306145814139 1.10014579648583e-06 0.0536298481755812 1.100145931832913e-06 0.05289991373180127 \
1.100146032152412e-06 0.05236888834064994 1.100146132622372e-06 0.05184552065910697 1.100146231565458e-06 0.05133799434906983 1.10014641007002e-06 0.05044349321929222 \
1.100146509870119e-06 0.04995513630881745 1.100146710035568e-06 0.04899962929156078 1.100146800952851e-06 0.04857581029502876 1.100147007746298e-06 0.04763487432244629 \
1.10014711297643e-06 0.0471681110353394 1.100147309354922e-06 0.04631787013837765 1.100147394633218e-06 0.04595693884580357 1.100147575095581e-06 0.04521002446657041 \
1.100147650260171e-06 0.04490525014776706 1.10014786811757e-06 0.0440422972058082 1.100147951636165e-06 0.04372097365614635 1.100148141571271e-06 0.04300637120866019 \
1.10014826631761e-06 0.04254845761102347 1.100148451543578e-06 0.0418846242551883 1.100148554382137e-06 0.04152415866453074 1.100148843894812e-06 0.04053983903151908 \
1.100148932816406e-06 0.04024621147044882 1.10014924148676e-06 0.03925784365481538 1.100149297645764e-06 0.03908306666491448 1.100149611207866e-06 0.03813491809530275 \
1.100149667163848e-06 0.037970533835152 1.100149994078164e-06 0.03703805601095747 1.100150047341397e-06 0.03689043863681411 1.100150353265485e-06 0.03606517121743442 \
1.100150453429213e-06 0.0358032254974586 1.100150772044909e-06 0.03499570355391716 1.100150861523872e-06 0.03477583942316619 1.100151259364458e-06 0.03383675925705845 \
1.100151377245794e-06 0.03357186655877694 1.100151789247957e-06 0.03268299960645597 1.10015194961085e-06 0.03235094877383871 1.100152320629234e-06 0.03161177976826059 \
1.100152540382686e-06 0.03119164460703521 1.100152983766919e-06 0.03038142203317581 1.100153232810551e-06 0.0299476098095271 1.1001537326667e-06 0.02912178892962563 \
1.100153951558277e-06 0.02877747133829427 1.100154434672084e-06 0.02805819238630505 1.100154723499337e-06 0.02765301209416409 1.100155410247302e-06 0.02674723311374961 \
1.100155699762857e-06 0.02638861276123805 1.100156475736135e-06 0.02548835782609031 1.100156647189526e-06 0.02530065249352256 1.10015743327132e-06 0.02449144648051316 \
1.100157637300353e-06 0.02429465554580218 1.100158746898316e-06 0.02329883562822865 1.100158847813389e-06 0.02321388155873386 1.100160039404086e-06 0.02227529349501467 \
1.100160244312293e-06 0.0221260927003824 1.100161697508364e-06 0.02113958380755909 1.100161932492782e-06 0.02098788030205876 1.100163439760696e-06 0.02004942094855779 \
1.100163760061111e-06 0.01985604392354444 1.100164974239456e-06 0.01910354072181233 1.100165447544128e-06 0.01879991394003632 1.100166748677981e-06 0.01794965119692995 \
1.100167138470568e-06 0.01770179815419311 1.100168537018733e-06 0.01679702456340363 1.100168863768813e-06 0.01658609683275075 1.10016998110407e-06 0.01586843585740347 \
1.100170689790368e-06 0.01544169959229912 1.100172422376366e-06 0.01449858640399567 1.100172671838817e-06 0.01436065672582198 1.100174469435716e-06 0.01337694399212387 \
1.100174812129382e-06 0.01319104500849105 1.100176988462895e-06 0.01225973435293598 1.10017727331928e-06 0.01213579497780986 1.100179172162672e-06 0.01126438850740638 \
1.10017965502513e-06 0.01103474467122418 1.100181927520555e-06 0.01014901321627989 1.100182315058726e-06 0.01002270433864562 1.100184966564885e-06 0.009023867700259034 \
1.100185262768817e-06 0.00890332747207802 1.100187604606991e-06 0.00793111507746596 1.100187858191315e-06 0.007825942613114227 1.100190880361057e-06 0.006881067894167194 \
1.10019112999456e-06 0.006804700431426973 1.100195007891808e-06 0.005817006850260108 1.100195235071384e-06 0.005760637946475626 1.100198046189619e-06 0.00490690852483563 \
1.100198480606374e-06 0.004760206508803379 1.100201010366652e-06 0.003858115577918713 1.100201428863181e-06 0.003712016323791173 1.100204453534309e-06 0.00274875962184498 \
1.100204733759441e-06 0.002664158024812898 1.100208530584646e-06 0.001697446565651876 1.100208884963991e-06 0.001621705150764489 1.100214411478996e-06 0.0006347476112661908 \
1.100214708963481e-06 0.0005888553763099016 1.100222216727447e-06 -0.0003928413941844093 1.100222438401114e-06 -0.0004189941252107796 1.100236530784873e-06 -0.001410461992184868 \
1.100236889612591e-06 -0.001430649730572865 1.100250237245412e-06 -0.0004514903228812461 1.100250464642513e-06 -0.0004111859973536986 1.100255915612065e-06 0.0005614551864591434 \
1.100256178897484e-06 0.0006110884748384679 1.100260810837491e-06 0.001592952619583714 1.100261118869639e-06 0.001665522059460669 1.10026495308288e-06 0.002626457037572999 \
1.100265337382884e-06 0.002733556882532277 1.100269071576165e-06 0.003682507088408038 1.100269273441448e-06 0.00374945551670179 1.100272897693538e-06 0.004734851451646972 \
1.100273092622753e-06 0.004780391513086043 1.100276479822177e-06 0.005766866152453508 1.100276671910697e-06 0.005810149709068801 1.100280887542283e-06 0.006750994364636406 \
1.100281221079492e-06 0.006821678237255247 1.100305948540302e-06 0.005867117768706426 1.100306261817208e-06 0.005806676405157672 1.100310893192981e-06 0.004863125825100585 \
1.100311165044222e-06 0.004806306550559217 1.100316109688101e-06 0.003825328200913169 1.100316576141932e-06 0.003739629632037282 1.10032248240585e-06 0.002770751168227681 \
1.100322776130159e-06 0.002729631326985271 1.100331621359071e-06 0.001738601807147118 1.100331808126426e-06 0.001722695496451883 1.100352036959149e-06 0.0007253105668073048 \
1.100353471598443e-06 0.0006873447391178559 1.158990000000011e-06 3.130932490801775e-06 1.161883407830385e-06 -0.0008819623910157972 1.161883643879234e-06 -0.001161970612476729 \
1.161884102325562e-06 -0.001847355627596629 1.161884345612697e-06 -0.002293620068582415 1.161884595896665e-06 -0.00281405583725217 1.161884846702668e-06 -0.003393671496214343 \
1.161885159522331e-06 -0.004199192998005251 1.161885397732202e-06 -0.004872003934560885 1.161885644182635e-06 -0.005621391842385397 1.161885875927131e-06 -0.006370319304257691 \
1.161886183112249e-06 -0.007411941938624838 1.161886448406181e-06 -0.008326397880259807 1.161886693685808e-06 -0.009131457988769647 1.161887058417363e-06 -0.01007334593757064 \
1.16188728648854e-06 -0.01033898456945748 1.161887610128182e-06 -0.009994868194499993 1.161887810544735e-06 -0.009187286872421443 1.161888045349532e-06 -0.007487931918614563 \
1.161888226424988e-06 -0.005544847192362645 1.161888332865277e-06 -0.004119573247771668 1.161888471151424e-06 -0.001940540768574745 1.161888582177387e-06 7.563183370691832e-05 \
1.161888702798821e-06 0.002536824544301687 1.161888805864002e-06 0.004857398676819782 1.161888944571287e-06 0.008289235792766818 1.161889065680579e-06 0.01156496544863939 \
1.16188921588438e-06 0.01596809792775087 1.16188939752999e-06 0.02176080367268303 1.16188954996521e-06 0.02698454055473338 1.161889726115454e-06 0.03339084366291074 \
1.1618899251156e-06 0.04103368087207344 1.161890094787538e-06 0.04784290449723066 1.161890273981514e-06 0.05527749234857952 1.161890434397879e-06 0.06211990493347131 \
1.161890596191839e-06 0.06916698107316244 1.161890754742719e-06 0.07620053909780501 1.161890921935392e-06 0.08372027851346725 1.161891092293318e-06 0.09147114401158042 \
1.161891271730566e-06 0.0997240648901548 1.161891461853091e-06 0.1085375718081032 1.161891661092053e-06 0.1178373860957827 1.161891865069359e-06 0.1274102212870429 \
1.16189208614423e-06 0.1378300800073513 1.1618923318008e-06 0.1494365474357121 1.161892589151043e-06 0.1616443690283554 1.161892871842139e-06 0.1750899465505063 \
1.16189316989355e-06 0.1892663579759593 1.161893516170122e-06 0.2057792515135755 1.16189388288524e-06 0.2232517522030736 1.161894278797487e-06 0.2421754728923703 \
1.161894713908853e-06 0.2629945242020292 1.161895193718841e-06 0.2859861135989593 1.161895719037101e-06 0.3113450809673837 1.161896243573265e-06 0.3367514755549041 \
1.161896840892739e-06 0.3658546932050024 1.161897607717859e-06 0.4033613755922033 1.161898046206798e-06 0.4246376380793622 1.161898522720377e-06 0.4473946242989675 \
1.161898972555967e-06 0.4684360091747882 1.161899525240159e-06 0.4936960927629759 1.161900223236364e-06 0.5245486808074998 1.161900837638476e-06 0.5507582774516211 \
1.161901405608978e-06 0.5741722555225199 1.161901935862248e-06 0.5952266004882081 1.161902394831628e-06 0.6128068198589096 1.161902977999792e-06 0.6341908714213341 \
1.161903551157707e-06 0.6541368834277531 1.161904141842032e-06 0.6735006351351156 1.161904810515341e-06 0.6939224431220803 1.161905465000487e-06 0.7123419857223411 \
1.161906218631611e-06 0.7316435145596337 1.161907138111349e-06 0.7524771687756806 1.161907807118464e-06 0.7658582308664672 1.161908502684848e-06 0.7783426900018873 \
1.161909224721799e-06 0.7898435797332509 1.161909871505065e-06 0.7989777190578581 1.161910686398373e-06 0.809051394855074 1.161911344291083e-06 0.8161084932798452 \
1.161912109055577e-06 0.8232971874420545 1.161912705588939e-06 0.8281915934352191 1.161913333612095e-06 0.8327857747397983 1.161913964004405e-06 0.8368636793792511 \
1.16191494962664e-06 0.8423301485602825 1.161915705380697e-06 0.8458701801587535 1.161916468671132e-06 0.8489683054605098 1.161917277011917e-06 0.8518111549479527 \
1.161918265903366e-06 0.8547854532963984 1.161919008958979e-06 0.8567085856698495 1.161919831636168e-06 0.8585940601366741 1.161920612856224e-06 0.8601698380186774 \
1.161921416459391e-06 0.8616111415036141 1.161922203727638e-06 0.8628649505886673 1.161923395730052e-06 0.8644986110026872 1.161924318352036e-06 0.8655887935537701 \
1.161925377279772e-06 0.8666437563732095 1.161926250370494e-06 0.8673888282159752 1.161927019427764e-06 0.8679394432393451 1.161932776083201e-06 0.8675354626998435 \
1.161933384736608e-06 0.8669285211992742 1.161934348633067e-06 0.8661637309277684 1.161934697027123e-06 0.8657877651307159 1.161935865736297e-06 0.8648718022682493 \
1.161936507439083e-06 0.8645495171393598 1.161937723779243e-06 0.8636149212264693 1.161938210995997e-06 0.8633315979857124 1.161941995751513e-06 0.8637879096652611 \
1.161942803560594e-06 0.8644940879742092 1.161943676731311e-06 0.8654118536506241 1.16194452584852e-06 0.8664722967159353 1.161945394320663e-06 0.8676408136092975 \
1.161946220799482e-06 0.8688316482847912 1.161947067273748e-06 0.8700680498371385 1.161947993731667e-06 0.8714353201417473 1.161948922751738e-06 0.8727967357236968 \
1.161949890373816e-06 0.874169309418928 1.161950892855429e-06 0.8755268793700145 1.161951975786211e-06 0.8769279254876977 1.161953154258897e-06 0.8783524184654903 \
1.161954367359833e-06 0.8797057189093218 1.161955697820692e-06 0.8810544625232946 1.161957146531982e-06 0.8823882385150326 1.161958814266774e-06 0.8837386794148741 \
1.16196044629864e-06 0.8848798336526329 1.161962413590838e-06 0.8860652157953401 1.161964590094435e-06 0.8871729764751287 1.161966862249877e-06 0.8881691778223457 \
1.161969135754955e-06 0.8889896378135498 1.161971087665695e-06 0.8895771814349003 1.161973972100292e-06 0.8902862350409186 1.161976831036635e-06 0.8908501300162286 \
1.161979913323748e-06 0.8913157385816455 1.16199173167453e-06 0.8922670755128276 1.161994058318612e-06 0.8924600956555456 1.162000939517427e-06 0.8933233934443291 \
1.162002931772883e-06 0.8936033182227321 1.162007596963998e-06 0.8943294235126149 1.162009934973581e-06 0.894763749611499 1.16201243532077e-06 0.8952990768365913 \
1.162014909223274e-06 0.8959385502707948 1.162017035318026e-06 0.8965630758105964 1.162019624621494e-06 0.8973958942958599 1.162022048641129e-06 0.8982427248493853 \
1.162024940455553e-06 0.8993469797885378 1.162027450127073e-06 0.9003588137389537 1.162030788570323e-06 0.9017079510157455 1.162033867543754e-06 0.9029423170929788 \
1.162037060622869e-06 0.9042497182071535 1.162039656279508e-06 0.9052493492427333 1.162041664531596e-06 0.9059572885738179 1.162043772760483e-06 0.9066594295388942 \
1.162046461477418e-06 0.907478492737931 1.162048917070081e-06 0.9081366525620301 1.162051281590183e-06 0.9087089258990763 1.162053876154591e-06 0.9092804446275633 \
1.162056243869825e-06 0.9097121154337445 1.162063636309535e-06 0.9105880439508957 1.162066947385431e-06 0.9108097973553667 1.162090631104211e-06 0.9099572430838525 \
1.162093524994069e-06 0.9096028008700563 1.162099633721785e-06 0.9087795762164674 1.162102664784937e-06 0.9083311497095887 1.162109022442901e-06 0.9073557537429059 \
1.162112916389034e-06 0.906719613226565 1.162116289356866e-06 0.9061475060281556 1.16211937491473e-06 0.9055946669458763 1.162123120629278e-06 0.9048996522446952 \
1.162126487017035e-06 0.9043394102803256 1.162134077462241e-06 0.9034499723753743 1.162137953472777e-06 0.9031904105967781 1.162165717708862e-06 0.9022140906736803 \
1.162169493868779e-06 0.902100877529562 1.162200910100546e-06 0.9011025155537421 1.162207545190394e-06 0.9009020504869808 1.200110550805801e-06 0.8999193627810952 \
1.20011071848179e-06 0.8998913840591389 1.200113467033027e-06 0.8989010293823864 1.200113523573982e-06 0.8988795941121664 1.200114768178511e-06 0.8998357618405769 \
1.200114847007516e-06 0.9000722811707415 1.200115028967665e-06 0.9007374088026997 1.20011513130788e-06 0.9011852075627013 1.200115324284061e-06 0.9021545909398002 \
1.200115412645943e-06 0.9026487433775175 1.200115571157198e-06 0.9036053969378676 1.200115683054863e-06 0.9043311123122415 1.200115823971993e-06 0.9052897461292233 \
1.200115929405144e-06 0.9060407976354218 1.200116042282183e-06 0.9068700067857125 1.200116156714019e-06 0.9077320749581511 1.200116277994793e-06 0.9086625635419388 \
1.200116407030339e-06 0.9096610759972766 1.200116529569199e-06 0.9106054665418637 1.20011665392414e-06 0.9115433813509556 1.200116768824237e-06 0.912370851358936 \
1.200116872924634e-06 0.9130668181210778 1.200116980506906e-06 0.9137127811079708 1.200117148007135e-06 0.914504286313051 1.200117619367398e-06 0.9145217838087505 \
1.200117817316352e-06 0.9131640269569251 1.200117978090595e-06 0.9113346267648944 1.200118066395334e-06 0.910041664336402 1.200118153928761e-06 0.908567258693449 \
1.200118246820307e-06 0.9067913249607207 1.200118320262759e-06 0.9052411278657534 1.200118409009881e-06 0.9032017134587504 1.200118546653074e-06 0.8996915735089056 \
1.200118658994696e-06 0.8965314120175644 1.200118782291718e-06 0.892778172623249 1.200118938496376e-06 0.8876402979533503 1.200119062012361e-06 0.8833010177194197 \
1.200119232383793e-06 0.8769686903427227 1.200119380003419e-06 0.8711968848515086 1.200119531854558e-06 0.8650238565011712 1.200119667983612e-06 0.8593172646418706 \
1.200119810047228e-06 0.8532105227807962 1.200119945331887e-06 0.8472784593397693 1.200120083991258e-06 0.8411010749315838 1.20012023129828e-06 0.8344514077702887 \
1.200120377865129e-06 0.8277635723525925 1.200120539944527e-06 0.8202964899226535 1.200120687311173e-06 0.8134532267615989 1.20012085882447e-06 0.8054479178086997 \
1.200121042247436e-06 0.7968539002302991 1.200121244752722e-06 0.7873346372610658 1.200121456402384e-06 0.7773555108975432 1.200121677392943e-06 0.7669228693561837 \
1.20012190658697e-06 0.7561055044419139 1.200122183106921e-06 0.743046509132553 1.200122468593645e-06 0.7295848836660939 1.200122789908539e-06 0.7144535604611002 \
1.200123079378459e-06 0.7008559708795014 1.200123398648317e-06 0.6858669291494816 1.200123719663687e-06 0.6708097907125149 1.200124061099719e-06 0.654842287100785 \
1.200124453723407e-06 0.6364912117266992 1.200124808317996e-06 0.6199451687359452 1.200125173105078e-06 0.602895395464039 1.20012557692179e-06 0.5840362041416589 \
1.200125940450357e-06 0.56705803755797 1.200126371026893e-06 0.546963725974103 1.200126727188766e-06 0.5303181638661557 1.200127100198166e-06 0.5128834705750704 \
1.200127442383275e-06 0.4969084729771704 1.200127762124839e-06 0.4820272854775881 1.200128079868868e-06 0.4673068400017517 1.20012837572031e-06 0.453709089639897 \
1.200128703744139e-06 0.4388357619204879 1.200129013234577e-06 0.4250513307906954 1.200129299733975e-06 0.412542701771394 1.200129612088515e-06 0.3991541929604193 \
1.200129902199714e-06 0.3870087322563178 1.200130215665733e-06 0.3741657412501236 1.200130493028614e-06 0.3630444214925196 1.200130774126111e-06 0.3519744117192101 \
1.200131005607364e-06 0.3430374849397334 1.200131234174756e-06 0.3343354151638595 1.20013147406666e-06 0.3253394991495989 1.200131731848444e-06 0.3158318026516087 \
1.200131981218358e-06 0.3067925439309827 1.200132239531266e-06 0.297589150170473 1.200132486062287e-06 0.2889540805256016 1.200132773357043e-06 0.2790758510850415 \
1.200132996736124e-06 0.2715471379396955 1.200133217531486e-06 0.2642409610398131 1.20013341340532e-06 0.2578652581015776 1.2001336001294e-06 0.2519000449202701 \
1.200133771320538e-06 0.2465102462678049 1.200133946364063e-06 0.2410522141953559 1.200134109381927e-06 0.236036359124031 1.200134270786368e-06 0.2311389431166576 \
1.200134424603758e-06 0.2265774065811171 1.20013457654048e-06 0.2221477024102725 1.200134730763452e-06 0.2177012931700853 1.200134904399052e-06 0.2127672920349684 \
1.200135054516093e-06 0.2085590788965803 1.200135188967813e-06 0.2048346911951331 1.200135333880152e-06 0.2008962005616911 1.200135495414782e-06 0.1965999354189458 \
1.200135644303198e-06 0.1927083727438147 1.200135788543376e-06 0.1889957157254755 1.200135913586714e-06 0.1858267544518093 1.200136010653492e-06 0.183392498065703 \
1.200136145647889e-06 0.1800503036180525 1.200136255162251e-06 0.1773760505692391 1.200136393137778e-06 0.1740872877198338 1.200136513150414e-06 0.1712726271080235 \
1.20013663003209e-06 0.1685704901364905 1.200136756660935e-06 0.1656849030049582 1.200136892675268e-06 0.1626308514974385 1.20013702606177e-06 0.1596764551685698 \
1.200137153003704e-06 0.1569158519548911 1.200137281621738e-06 0.1541678007478876 1.200137395548178e-06 0.1517740356345986 1.200137505859117e-06 0.149496521787741 \
1.20013761900036e-06 0.1472133997668396 1.200137732479436e-06 0.1449590740078549 1.200137857844221e-06 0.1425075003983929 1.200138003638109e-06 0.1397077962434051 \
1.200138186780095e-06 0.1362681166668699 1.2001383353875e-06 0.1335395672637218 1.200138447639322e-06 0.1315146079855561 1.200138576992755e-06 0.1292194206906994 \
1.200138670528911e-06 0.1275846423925092 1.20013877932072e-06 0.1257099890290588 1.200138873074832e-06 0.1241165438085202 1.200138956682436e-06 0.1227229754719547 \
1.2001390763363e-06 0.1207568051616409 1.200139205425262e-06 0.1186746054627577 1.200139322279497e-06 0.1168252031377112 1.200139453368507e-06 0.1147891811469644 \
1.200139598723523e-06 0.1125787883659796 1.200139764133423e-06 0.110121919024741 1.20013993287367e-06 0.1076798417306999 1.200140125753816e-06 0.1049622523271389 \
1.200140299731943e-06 0.1025767092705754 1.200140487918313e-06 0.1000644866129177 1.200140670319411e-06 0.09769892895340802 1.200140849911024e-06 0.09544952095403336 \
1.200141026408427e-06 0.09330553315647841 1.200141210964178e-06 0.09112768523704891 1.200141396209645e-06 0.08900465024544718 1.200141578281057e-06 0.0869768268327742 \
1.200141774345804e-06 0.08485812802288394 1.200141944746222e-06 0.08306894814141007 1.200142122986993e-06 0.08125105909257219 1.200142298679519e-06 0.07951206376949813 \
1.200142499080023e-06 0.07758728548656671 1.200142695934063e-06 0.07575734486890456 1.200142865868499e-06 0.07422427017287291 1.20014303651775e-06 0.07272580243814712 \
1.200143219642496e-06 0.07116311580983979 1.200143413259743e-06 0.06956233824397716 1.200143594846707e-06 0.06811311716920317 1.200143793421027e-06 0.06657819701521293 \
1.200143949952299e-06 0.06540254085633944 1.200144133522745e-06 0.06406078399206196 1.200144306484986e-06 0.06283331112669251 1.200144471995363e-06 0.06169268945721457 \
1.20014462033141e-06 0.06069691796619666 1.200144757229627e-06 0.05979937680937147 1.200144904867328e-06 0.05885633029244827 1.200145037955006e-06 0.05802735218158511 \
1.200145161474142e-06 0.05727448785321319 1.200145277510429e-06 0.05658054160001152 1.200145391123697e-06 0.05591352504042409 1.200145515745172e-06 0.05519553885869784 \
1.200145636542111e-06 0.05451306145814139 1.20014579648583e-06 0.0536298481755812 1.200145931832913e-06 0.05289991373180127 1.200146032152412e-06 0.05236888834064994 \
1.200146132622373e-06 0.05184552065910697 1.200146231565458e-06 0.05133799434906983 1.200146410070021e-06 0.05044349321929222 1.200146509870119e-06 0.04995513630881745 \
1.200146710035568e-06 0.04899962929156078 1.200146800952851e-06 0.04857581029502876 1.200147007746298e-06 0.04763487432244629 1.200147112976431e-06 0.0471681110353394 \
1.200147309354922e-06 0.04631787013837765 1.200147394633218e-06 0.04595693884580357 1.200147575095581e-06 0.04521002446657041 1.200147650260171e-06 0.04490525014776706 \
1.20014786811757e-06 0.0440422972058082 1.200147951636166e-06 0.04372097365614635 1.200148141571271e-06 0.04300637120866019 1.200148266317611e-06 0.04254845761102347 \
1.200148451543579e-06 0.0418846242551883 1.200148554382137e-06 0.04152415866453074 1.200148843894812e-06 0.04053983903151908 1.200148932816407e-06 0.04024621147044882 \
1.20014924148676e-06 0.03925784365481538 1.200149297645764e-06 0.03908306666491448 1.200149611207866e-06 0.03813491809530275 1.200149667163849e-06 0.037970533835152 \
1.200149994078164e-06 0.03703805601095747 1.200150047341397e-06 0.03689043863681411 1.200150353265486e-06 0.03606517121743442 1.200150453429214e-06 0.0358032254974586 \
1.200150772044909e-06 0.03499570355391716 1.200150861523872e-06 0.03477583942316619 1.200151259364458e-06 0.03383675925705845 1.200151377245794e-06 0.03357186655877694 \
1.200151789247958e-06 0.03268299960645597 1.200151949610851e-06 0.03235094877383871 1.200152320629235e-06 0.03161177976826059 1.200152540382686e-06 0.03119164460703521 \
1.200152983766919e-06 0.03038142203317581 1.200153232810551e-06 0.0299476098095271 1.2001537326667e-06 0.02912178892962563 1.200153951558277e-06 0.02877747133829427 \
1.200154434672084e-06 0.02805819238630505 1.200154723499337e-06 0.02765301209416409 1.200155410247302e-06 0.02674723311374961 1.200155699762857e-06 0.02638861276123805 \
1.200156475736136e-06 0.02548835782609031 1.200156647189526e-06 0.02530065249352256 1.20015743327132e-06 0.02449144648051316 1.200157637300354e-06 0.02429465554580218 \
1.200158746898316e-06 0.02329883562822865 1.200158847813389e-06 0.02321388155873386 1.200160039404086e-06 0.02227529349501467 1.200160244312294e-06 0.0221260927003824 \
1.200161697508364e-06 0.02113958380755909 1.200161932492782e-06 0.02098788030205876 1.200163439760696e-06 0.02004942094855779 1.200163760061111e-06 0.01985604392354444 \
1.200164974239457e-06 0.01910354072181233 1.200165447544128e-06 0.01879991394003632 1.200166748677981e-06 0.01794965119692995 1.200167138470568e-06 0.01770179815419311 \
1.200168537018733e-06 0.01679702456340363 1.200168863768813e-06 0.01658609683275075 1.20016998110407e-06 0.01586843585740347 1.200170689790368e-06 0.01544169959229912 \
1.200172422376366e-06 0.01449858640399567 1.200172671838817e-06 0.01436065672582198 1.200174469435716e-06 0.01337694399212387 1.200174812129382e-06 0.01319104500849105 \
1.200176988462895e-06 0.01225973435293598 1.20017727331928e-06 0.01213579497780986 1.200179172162672e-06 0.01126438850740638 1.20017965502513e-06 0.01103474467122418 \
1.200181927520555e-06 0.01014901321627989 1.200182315058726e-06 0.01002270433864562 1.200184966564885e-06 0.009023867700259034 1.200185262768817e-06 0.00890332747207802 \
1.200187604606991e-06 0.00793111507746596 1.200187858191315e-06 0.007825942613114227 1.200190880361057e-06 0.006881067894167194 1.20019112999456e-06 0.006804700431426973 \
1.200195007891808e-06 0.005817006850260108 1.200195235071384e-06 0.005760637946475626 1.200198046189619e-06 0.00490690852483563 1.200198480606374e-06 0.004760206508803379 \
1.200201010366652e-06 0.003858115577918713 1.200201428863181e-06 0.003712016323791173 1.200204453534309e-06 0.00274875962184498 1.200204733759441e-06 0.002664158024812898 \
1.200208530584646e-06 0.001697446565651876 1.200208884963991e-06 0.001621705150764489 1.200214411478997e-06 0.0006347476112661908 1.200214708963482e-06 0.0005888553763099016 \
1.200222216727447e-06 -0.0003928413941844093 1.200222438401114e-06 -0.0004189941252107796 1.200236530784873e-06 -0.001410461992184868 1.200236889612591e-06 -0.001430649730572865 \
1.200250237245412e-06 -0.0004514903228812461 1.200250464642513e-06 -0.0004111859973536986 1.200255915612065e-06 0.0005614551864591434 1.200256178897484e-06 0.0006110884748384679 \
1.200260810837491e-06 0.001592952619583714 1.200261118869639e-06 0.001665522059460669 1.20026495308288e-06 0.002626457037572999 1.200265337382884e-06 0.002733556882532277 \
1.200269071576165e-06 0.003682507088408038 1.200269273441449e-06 0.00374945551670179 1.200272897693538e-06 0.004734851451646972 1.200273092622753e-06 0.004780391513086043 \
1.200276479822177e-06 0.005766866152453508 1.200276671910697e-06 0.005810149709068801 1.200280887542283e-06 0.006750994364636406 1.200281221079492e-06 0.006821678237255247 \
1.200305948540302e-06 0.005867117768706426 1.200306261817208e-06 0.005806676405157672 1.200310893192981e-06 0.004863125825100585 1.200311165044222e-06 0.004806306550559217 \
1.200316109688101e-06 0.003825328200913169 1.200316576141932e-06 0.003739629632037282 1.20032248240585e-06 0.002770751168227681 1.200322776130159e-06 0.002729631326985271 \
1.200331621359071e-06 0.001738601807147118 1.200331808126426e-06 0.001722695496451883 1.200352036959149e-06 0.0007253105668073048 1.200353471598443e-06 0.0006873447391178559 \
1.258990000000011e-06 3.130932490801775e-06 1.261883407830385e-06 -0.0008819623910157972 1.261883643879234e-06 -0.001161970612476729 1.261884102325562e-06 -0.001847355627596629 \
1.261884345612697e-06 -0.002293620068582415 1.261884595896664e-06 -0.00281405583725217 1.261884846702668e-06 -0.003393671496214343 1.26188515952233e-06 -0.004199192998005251 \
1.261885397732202e-06 -0.004872003934560885 1.261885644182635e-06 -0.005621391842385397 1.261885875927131e-06 -0.006370319304257691 1.261886183112249e-06 -0.007411941938624838 \
1.261886448406181e-06 -0.008326397880259807 1.261886693685807e-06 -0.009131457988769647 1.261887058417363e-06 -0.01007334593757064 1.26188728648854e-06 -0.01033898456945748 \
1.261887610128182e-06 -0.009994868194499993 1.261887810544735e-06 -0.009187286872421443 1.261888045349532e-06 -0.007487931918614563 1.261888226424988e-06 -0.005544847192362645 \
1.261888332865277e-06 -0.004119573247771668 1.261888471151424e-06 -0.001940540768574745 1.261888582177387e-06 7.563183370691832e-05 1.261888702798821e-06 0.002536824544301687 \
1.261888805864002e-06 0.004857398676819782 1.261888944571287e-06 0.008289235792766818 1.261889065680579e-06 0.01156496544863939 1.26188921588438e-06 0.01596809792775087 \
1.26188939752999e-06 0.02176080367268303 1.26188954996521e-06 0.02698454055473338 1.261889726115454e-06 0.03339084366291074 1.2618899251156e-06 0.04103368087207344 \
1.261890094787538e-06 0.04784290449723066 1.261890273981514e-06 0.05527749234857952 1.261890434397879e-06 0.06211990493347131 1.261890596191839e-06 0.06916698107316244 \
1.261890754742719e-06 0.07620053909780501 1.261890921935392e-06 0.08372027851346725 1.261891092293318e-06 0.09147114401158042 1.261891271730565e-06 0.0997240648901548 \
1.261891461853091e-06 0.1085375718081032 1.261891661092053e-06 0.1178373860957827 1.261891865069358e-06 0.1274102212870429 1.26189208614423e-06 0.1378300800073513 \
1.2618923318008e-06 0.1494365474357121 1.261892589151043e-06 0.1616443690283554 1.261892871842139e-06 0.1750899465505063 1.26189316989355e-06 0.1892663579759593 \
1.261893516170122e-06 0.2057792515135755 1.26189388288524e-06 0.2232517522030736 1.261894278797487e-06 0.2421754728923703 1.261894713908853e-06 0.2629945242020292 \
1.26189519371884e-06 0.2859861135989593 1.2618957190371e-06 0.3113450809673837 1.261896243573264e-06 0.3367514755549041 1.261896840892739e-06 0.3658546932050024 \
1.261897607717859e-06 0.4033613755922033 1.261898046206797e-06 0.4246376380793622 1.261898522720377e-06 0.4473946242989675 1.261898972555967e-06 0.4684360091747882 \
1.261899525240159e-06 0.4936960927629759 1.261900223236364e-06 0.5245486808074998 1.261900837638476e-06 0.5507582774516211 1.261901405608978e-06 0.5741722555225199 \
1.261901935862248e-06 0.5952266004882081 1.261902394831628e-06 0.6128068198589096 1.261902977999792e-06 0.6341908714213341 1.261903551157707e-06 0.6541368834277531 \
1.261904141842032e-06 0.6735006351351156 1.261904810515341e-06 0.6939224431220803 1.261905465000487e-06 0.7123419857223411 1.261906218631611e-06 0.7316435145596337 \
1.261907138111349e-06 0.7524771687756806 1.261907807118464e-06 0.7658582308664672 1.261908502684848e-06 0.7783426900018873 1.261909224721799e-06 0.7898435797332509 \
1.261909871505064e-06 0.7989777190578581 1.261910686398373e-06 0.809051394855074 1.261911344291083e-06 0.8161084932798452 1.261912109055577e-06 0.8232971874420545 \
1.261912705588939e-06 0.8281915934352191 1.261913333612095e-06 0.8327857747397983 1.261913964004405e-06 0.8368636793792511 1.26191494962664e-06 0.8423301485602825 \
1.261915705380696e-06 0.8458701801587535 1.261916468671131e-06 0.8489683054605098 1.261917277011917e-06 0.8518111549479527 1.261918265903366e-06 0.8547854532963984 \
1.261919008958979e-06 0.8567085856698495 1.261919831636168e-06 0.8585940601366741 1.261920612856223e-06 0.8601698380186774 1.261921416459391e-06 0.8616111415036141 \
1.261922203727638e-06 0.8628649505886673 1.261923395730052e-06 0.8644986110026872 1.261924318352036e-06 0.8655887935537701 1.261925377279772e-06 0.8666437563732095 \
1.261926250370494e-06 0.8673888282159752 1.261927019427764e-06 0.8679394432393451 1.2619327760832e-06 0.8675354626998435 1.261933384736608e-06 0.8669285211992742 \
1.261934348633067e-06 0.8661637309277684 1.261934697027123e-06 0.8657877651307159 1.261935865736297e-06 0.8648718022682493 1.261936507439083e-06 0.8645495171393598 \
1.261937723779243e-06 0.8636149212264693 1.261938210995997e-06 0.8633315979857124 1.261941995751513e-06 0.8637879096652611 1.261942803560594e-06 0.8644940879742092 \
1.261943676731311e-06 0.8654118536506241 1.26194452584852e-06 0.8664722967159353 1.261945394320663e-06 0.8676408136092975 1.261946220799482e-06 0.8688316482847912 \
1.261947067273748e-06 0.8700680498371385 1.261947993731666e-06 0.8714353201417473 1.261948922751738e-06 0.8727967357236968 1.261949890373816e-06 0.874169309418928 \
1.261950892855429e-06 0.8755268793700145 1.261951975786211e-06 0.8769279254876977 1.261953154258897e-06 0.8783524184654903 1.261954367359833e-06 0.8797057189093218 \
1.261955697820692e-06 0.8810544625232946 1.261957146531982e-06 0.8823882385150326 1.261958814266774e-06 0.8837386794148741 1.26196044629864e-06 0.8848798336526329 \
1.261962413590838e-06 0.8860652157953401 1.261964590094435e-06 0.8871729764751287 1.261966862249877e-06 0.8881691778223457 1.261969135754955e-06 0.8889896378135498 \
1.261971087665695e-06 0.8895771814349003 1.261973972100292e-06 0.8902862350409186 1.261976831036635e-06 0.8908501300162286 1.261979913323748e-06 0.8913157385816455 \
1.26199173167453e-06 0.8922670755128276 1.261994058318611e-06 0.8924600956555456 1.262000939517426e-06 0.8933233934443291 1.262002931772883e-06 0.8936033182227321 \
1.262007596963998e-06 0.8943294235126149 1.262009934973581e-06 0.894763749611499 1.26201243532077e-06 0.8952990768365913 1.262014909223274e-06 0.8959385502707948 \
1.262017035318026e-06 0.8965630758105964 1.262019624621494e-06 0.8973958942958599 1.262022048641129e-06 0.8982427248493853 1.262024940455553e-06 0.8993469797885378 \
1.262027450127073e-06 0.9003588137389537 1.262030788570323e-06 0.9017079510157455 1.262033867543754e-06 0.9029423170929788 1.262037060622869e-06 0.9042497182071535 \
1.262039656279508e-06 0.9052493492427333 1.262041664531596e-06 0.9059572885738179 1.262043772760482e-06 0.9066594295388942 1.262046461477417e-06 0.907478492737931 \
1.262048917070081e-06 0.9081366525620301 1.262051281590183e-06 0.9087089258990763 1.262053876154591e-06 0.9092804446275633 1.262056243869825e-06 0.9097121154337445 \
1.262063636309535e-06 0.9105880439508957 1.26206694738543e-06 0.9108097973553667 1.262090631104211e-06 0.9099572430838525 1.262093524994069e-06 0.9096028008700563 \
1.262099633721785e-06 0.9087795762164674 1.262102664784937e-06 0.9083311497095887 1.262109022442901e-06 0.9073557537429059 1.262112916389034e-06 0.906719613226565 \
1.262116289356866e-06 0.9061475060281556 1.262119374914729e-06 0.9055946669458763 1.262123120629277e-06 0.9048996522446952 1.262126487017035e-06 0.9043394102803256 \
1.262134077462241e-06 0.9034499723753743 1.262137953472777e-06 0.9031904105967781 1.262165717708862e-06 0.9022140906736803 1.262169493868779e-06 0.902100877529562 \
1.262200910100546e-06 0.9011025155537421 1.262207545190393e-06 0.9009020504869808 1.300110550805801e-06 0.8999193627810952 1.30011071848179e-06 0.8998913840591389 \
1.300113467033027e-06 0.8989010293823864 1.300113523573982e-06 0.8988795941121664 1.300114768178511e-06 0.8998357618405769 1.300114847007516e-06 0.9000722811707415 \
1.300115028967665e-06 0.9007374088026997 1.30011513130788e-06 0.9011852075627013 1.30011532428406e-06 0.9021545909398002 1.300115412645943e-06 0.9026487433775175 \
1.300115571157198e-06 0.9036053969378676 1.300115683054862e-06 0.9043311123122415 1.300115823971993e-06 0.9052897461292233 1.300115929405144e-06 0.9060407976354218 \
1.300116042282182e-06 0.9068700067857125 1.300116156714019e-06 0.9077320749581511 1.300116277994792e-06 0.9086625635419388 1.300116407030339e-06 0.9096610759972766 \
1.300116529569199e-06 0.9106054665418637 1.30011665392414e-06 0.9115433813509556 1.300116768824237e-06 0.912370851358936 1.300116872924634e-06 0.9130668181210778 \
1.300116980506906e-06 0.9137127811079708 1.300117148007135e-06 0.914504286313051 1.300117619367398e-06 0.9145217838087505 1.300117817316352e-06 0.9131640269569251 \
1.300117978090595e-06 0.9113346267648944 1.300118066395334e-06 0.910041664336402 1.300118153928761e-06 0.908567258693449 1.300118246820306e-06 0.9067913249607207 \
1.300118320262759e-06 0.9052411278657534 1.300118409009881e-06 0.9032017134587504 1.300118546653074e-06 0.8996915735089056 1.300118658994696e-06 0.8965314120175644 \
1.300118782291718e-06 0.892778172623249 1.300118938496376e-06 0.8876402979533503 1.300119062012361e-06 0.8833010177194197 1.300119232383792e-06 0.8769686903427227 \
1.300119380003419e-06 0.8711968848515086 1.300119531854558e-06 0.8650238565011712 1.300119667983612e-06 0.8593172646418706 1.300119810047228e-06 0.8532105227807962 \
1.300119945331887e-06 0.8472784593397693 1.300120083991258e-06 0.8411010749315838 1.30012023129828e-06 0.8344514077702887 1.300120377865128e-06 0.8277635723525925 \
1.300120539944527e-06 0.8202964899226535 1.300120687311172e-06 0.8134532267615989 1.30012085882447e-06 0.8054479178086997 1.300121042247436e-06 0.7968539002302991 \
1.300121244752722e-06 0.7873346372610658 1.300121456402384e-06 0.7773555108975432 1.300121677392943e-06 0.7669228693561837 1.30012190658697e-06 0.7561055044419139 \
1.300122183106921e-06 0.743046509132553 1.300122468593645e-06 0.7295848836660939 1.300122789908539e-06 0.7144535604611002 1.300123079378459e-06 0.7008559708795014 \
1.300123398648317e-06 0.6858669291494816 1.300123719663687e-06 0.6708097907125149 1.300124061099719e-06 0.654842287100785 1.300124453723407e-06 0.6364912117266992 \
1.300124808317996e-06 0.6199451687359452 1.300125173105078e-06 0.602895395464039 1.30012557692179e-06 0.5840362041416589 1.300125940450357e-06 0.56705803755797 \
1.300126371026893e-06 0.546963725974103 1.300126727188766e-06 0.5303181638661557 1.300127100198166e-06 0.5128834705750704 1.300127442383275e-06 0.4969084729771704 \
1.300127762124838e-06 0.4820272854775881 1.300128079868868e-06 0.4673068400017517 1.30012837572031e-06 0.453709089639897 1.300128703744139e-06 0.4388357619204879 \
1.300129013234577e-06 0.4250513307906954 1.300129299733975e-06 0.412542701771394 1.300129612088515e-06 0.3991541929604193 1.300129902199714e-06 0.3870087322563178 \
1.300130215665733e-06 0.3741657412501236 1.300130493028614e-06 0.3630444214925196 1.300130774126111e-06 0.3519744117192101 1.300131005607363e-06 0.3430374849397334 \
1.300131234174756e-06 0.3343354151638595 1.30013147406666e-06 0.3253394991495989 1.300131731848444e-06 0.3158318026516087 1.300131981218358e-06 0.3067925439309827 \
1.300132239531266e-06 0.297589150170473 1.300132486062287e-06 0.2889540805256016 1.300132773357043e-06 0.2790758510850415 1.300132996736124e-06 0.2715471379396955 \
1.300133217531486e-06 0.2642409610398131 1.30013341340532e-06 0.2578652581015776 1.3001336001294e-06 0.2519000449202701 1.300133771320538e-06 0.2465102462678049 \
1.300133946364063e-06 0.2410522141953559 1.300134109381927e-06 0.236036359124031 1.300134270786368e-06 0.2311389431166576 1.300134424603758e-06 0.2265774065811171 \
1.30013457654048e-06 0.2221477024102725 1.300134730763452e-06 0.2177012931700853 1.300134904399052e-06 0.2127672920349684 1.300135054516093e-06 0.2085590788965803 \
1.300135188967813e-06 0.2048346911951331 1.300135333880152e-06 0.2008962005616911 1.300135495414782e-06 0.1965999354189458 1.300135644303198e-06 0.1927083727438147 \
1.300135788543376e-06 0.1889957157254755 1.300135913586713e-06 0.1858267544518093 1.300136010653492e-06 0.183392498065703 1.300136145647889e-06 0.1800503036180525 \
1.300136255162251e-06 0.1773760505692391 1.300136393137778e-06 0.1740872877198338 1.300136513150413e-06 0.1712726271080235 1.30013663003209e-06 0.1685704901364905 \
1.300136756660935e-06 0.1656849030049582 1.300136892675268e-06 0.1626308514974385 1.30013702606177e-06 0.1596764551685698 1.300137153003703e-06 0.1569158519548911 \
1.300137281621738e-06 0.1541678007478876 1.300137395548178e-06 0.1517740356345986 1.300137505859117e-06 0.149496521787741 1.30013761900036e-06 0.1472133997668396 \
1.300137732479436e-06 0.1449590740078549 1.300137857844221e-06 0.1425075003983929 1.300138003638108e-06 0.1397077962434051 1.300138186780095e-06 0.1362681166668699 \
1.3001383353875e-06 0.1335395672637218 1.300138447639322e-06 0.1315146079855561 1.300138576992755e-06 0.1292194206906994 1.300138670528911e-06 0.1275846423925092 \
1.30013877932072e-06 0.1257099890290588 1.300138873074831e-06 0.1241165438085202 1.300138956682436e-06 0.1227229754719547 1.3001390763363e-06 0.1207568051616409 \
1.300139205425261e-06 0.1186746054627577 1.300139322279497e-06 0.1168252031377112 1.300139453368507e-06 0.1147891811469644 1.300139598723523e-06 0.1125787883659796 \
1.300139764133423e-06 0.110121919024741 1.30013993287367e-06 0.1076798417306999 1.300140125753816e-06 0.1049622523271389 1.300140299731943e-06 0.1025767092705754 \
1.300140487918313e-06 0.1000644866129177 1.300140670319411e-06 0.09769892895340802 1.300140849911024e-06 0.09544952095403336 1.300141026408427e-06 0.09330553315647841 \
1.300141210964177e-06 0.09112768523704891 1.300141396209645e-06 0.08900465024544718 1.300141578281057e-06 0.0869768268327742 1.300141774345804e-06 0.08485812802288394 \
1.300141944746222e-06 0.08306894814141007 1.300142122986993e-06 0.08125105909257219 1.300142298679519e-06 0.07951206376949813 1.300142499080023e-06 0.07758728548656671 \
1.300142695934063e-06 0.07575734486890456 1.300142865868499e-06 0.07422427017287291 1.30014303651775e-06 0.07272580243814712 1.300143219642496e-06 0.07116311580983979 \
1.300143413259743e-06 0.06956233824397716 1.300143594846707e-06 0.06811311716920317 1.300143793421027e-06 0.06657819701521293 1.300143949952299e-06 0.06540254085633944 \
1.300144133522745e-06 0.06406078399206196 1.300144306484985e-06 0.06283331112669251 1.300144471995363e-06 0.06169268945721457 1.30014462033141e-06 0.06069691796619666 \
1.300144757229627e-06 0.05979937680937147 1.300144904867328e-06 0.05885633029244827 1.300145037955006e-06 0.05802735218158511 1.300145161474142e-06 0.05727448785321319 \
1.300145277510429e-06 0.05658054160001152 1.300145391123697e-06 0.05591352504042409 1.300145515745172e-06 0.05519553885869784 1.300145636542111e-06 0.05451306145814139 \
1.30014579648583e-06 0.0536298481755812 1.300145931832913e-06 0.05289991373180127 1.300146032152412e-06 0.05236888834064994 1.300146132622372e-06 0.05184552065910697 \
1.300146231565458e-06 0.05133799434906983 1.30014641007002e-06 0.05044349321929222 1.300146509870119e-06 0.04995513630881745 1.300146710035568e-06 0.04899962929156078 \
1.300146800952851e-06 0.04857581029502876 1.300147007746298e-06 0.04763487432244629 1.30014711297643e-06 0.0471681110353394 1.300147309354922e-06 0.04631787013837765 \
1.300147394633218e-06 0.04595693884580357 1.300147575095581e-06 0.04521002446657041 1.300147650260171e-06 0.04490525014776706 1.30014786811757e-06 0.0440422972058082 \
1.300147951636165e-06 0.04372097365614635 1.300148141571271e-06 0.04300637120866019 1.30014826631761e-06 0.04254845761102347 1.300148451543578e-06 0.0418846242551883 \
1.300148554382137e-06 0.04152415866453074 1.300148843894812e-06 0.04053983903151908 1.300148932816406e-06 0.04024621147044882 1.30014924148676e-06 0.03925784365481538 \
1.300149297645764e-06 0.03908306666491448 1.300149611207866e-06 0.03813491809530275 1.300149667163848e-06 0.037970533835152 1.300149994078164e-06 0.03703805601095747 \
1.300150047341397e-06 0.03689043863681411 1.300150353265485e-06 0.03606517121743442 1.300150453429213e-06 0.0358032254974586 1.300150772044909e-06 0.03499570355391716 \
1.300150861523872e-06 0.03477583942316619 1.300151259364458e-06 0.03383675925705845 1.300151377245794e-06 0.03357186655877694 1.300151789247958e-06 0.03268299960645597 \
1.30015194961085e-06 0.03235094877383871 1.300152320629234e-06 0.03161177976826059 1.300152540382686e-06 0.03119164460703521 1.300152983766919e-06 0.03038142203317581 \
1.300153232810551e-06 0.0299476098095271 1.3001537326667e-06 0.02912178892962563 1.300153951558277e-06 0.02877747133829427 1.300154434672084e-06 0.02805819238630505 \
1.300154723499337e-06 0.02765301209416409 1.300155410247302e-06 0.02674723311374961 1.300155699762857e-06 0.02638861276123805 1.300156475736135e-06 0.02548835782609031 \
1.300156647189526e-06 0.02530065249352256 1.30015743327132e-06 0.02449144648051316 1.300157637300353e-06 0.02429465554580218 1.300158746898316e-06 0.02329883562822865 \
1.300158847813389e-06 0.02321388155873386 1.300160039404086e-06 0.02227529349501467 1.300160244312293e-06 0.0221260927003824 1.300161697508364e-06 0.02113958380755909 \
1.300161932492782e-06 0.02098788030205876 1.300163439760696e-06 0.02004942094855779 1.300163760061111e-06 0.01985604392354444 1.300164974239456e-06 0.01910354072181233 \
1.300165447544128e-06 0.01879991394003632 1.300166748677981e-06 0.01794965119692995 1.300167138470568e-06 0.01770179815419311 1.300168537018733e-06 0.01679702456340363 \
1.300168863768813e-06 0.01658609683275075 1.30016998110407e-06 0.01586843585740347 1.300170689790367e-06 0.01544169959229912 1.300172422376366e-06 0.01449858640399567 \
1.300172671838817e-06 0.01436065672582198 1.300174469435716e-06 0.01337694399212387 1.300174812129382e-06 0.01319104500849105 1.300176988462895e-06 0.01225973435293598 \
1.30017727331928e-06 0.01213579497780986 1.300179172162672e-06 0.01126438850740638 1.30017965502513e-06 0.01103474467122418 1.300181927520555e-06 0.01014901321627989 \
1.300182315058726e-06 0.01002270433864562 1.300184966564885e-06 0.009023867700259034 1.300185262768817e-06 0.00890332747207802 1.300187604606991e-06 0.00793111507746596 \
1.300187858191315e-06 0.007825942613114227 1.300190880361057e-06 0.006881067894167194 1.30019112999456e-06 0.006804700431426973 1.300195007891808e-06 0.005817006850260108 \
1.300195235071384e-06 0.005760637946475626 1.300198046189619e-06 0.00490690852483563 1.300198480606374e-06 0.004760206508803379 1.300201010366652e-06 0.003858115577918713 \
1.300201428863181e-06 0.003712016323791173 1.300204453534309e-06 0.00274875962184498 1.300204733759441e-06 0.002664158024812898 1.300208530584646e-06 0.001697446565651876 \
1.300208884963991e-06 0.001621705150764489 1.300214411478996e-06 0.0006347476112661908 1.300214708963481e-06 0.0005888553763099016 1.300222216727447e-06 -0.0003928413941844093 \
1.300222438401114e-06 -0.0004189941252107796 1.300236530784873e-06 -0.001410461992184868 1.300236889612591e-06 -0.001430649730572865 1.300250237245412e-06 -0.0004514903228812461 \
1.300250464642513e-06 -0.0004111859973536986 1.300255915612065e-06 0.0005614551864591434 1.300256178897484e-06 0.0006110884748384679 1.300260810837491e-06 0.001592952619583714 \
1.300261118869639e-06 0.001665522059460669 1.30026495308288e-06 0.002626457037572999 1.300265337382884e-06 0.002733556882532277 1.300269071576165e-06 0.003682507088408038 \
1.300269273441448e-06 0.00374945551670179 1.300272897693538e-06 0.004734851451646972 1.300273092622753e-06 0.004780391513086043 1.300276479822177e-06 0.005766866152453508 \
1.300276671910697e-06 0.005810149709068801 1.300280887542283e-06 0.006750994364636406 1.300281221079492e-06 0.006821678237255247 1.300305948540302e-06 0.005867117768706426 \
1.300306261817208e-06 0.005806676405157672 1.300310893192981e-06 0.004863125825100585 1.300311165044221e-06 0.004806306550559217 1.300316109688101e-06 0.003825328200913169 \
1.300316576141932e-06 0.003739629632037282 1.30032248240585e-06 0.002770751168227681 1.300322776130159e-06 0.002729631326985271 1.300331621359071e-06 0.001738601807147118 \
1.300331808126426e-06 0.001722695496451883 1.300352036959148e-06 0.0007253105668073048 1.300353471598443e-06 0.0006873447391178559 1.358990000000011e-06 3.130932490801775e-06 \
1.361883407830385e-06 -0.0008819623910157972 1.361883643879234e-06 -0.001161970612476729 1.361884102325562e-06 -0.001847355627596629 1.361884345612697e-06 -0.002293620068582415 \
1.361884595896664e-06 -0.00281405583725217 1.361884846702668e-06 -0.003393671496214343 1.36188515952233e-06 -0.004199192998005251 1.361885397732201e-06 -0.004872003934560885 \
1.361885644182635e-06 -0.005621391842385397 1.361885875927131e-06 -0.006370319304257691 1.361886183112249e-06 -0.007411941938624838 1.361886448406181e-06 -0.008326397880259807 \
1.361886693685807e-06 -0.009131457988769647 1.361887058417362e-06 -0.01007334593757064 1.361887286488539e-06 -0.01033898456945748 1.361887610128182e-06 -0.009994868194499993 \
1.361887810544735e-06 -0.009187286872421443 1.361888045349532e-06 -0.007487931918614563 1.361888226424987e-06 -0.005544847192362645 1.361888332865277e-06 -0.004119573247771668 \
1.361888471151424e-06 -0.001940540768574745 1.361888582177386e-06 7.563183370691832e-05 1.361888702798821e-06 0.002536824544301687 1.361888805864002e-06 0.004857398676819782 \
1.361888944571287e-06 0.008289235792766818 1.361889065680579e-06 0.01156496544863939 1.36188921588438e-06 0.01596809792775087 1.36188939752999e-06 0.02176080367268303 \
1.361889549965209e-06 0.02698454055473338 1.361889726115454e-06 0.03339084366291074 1.3618899251156e-06 0.04103368087207344 1.361890094787538e-06 0.04784290449723066 \
1.361890273981514e-06 0.05527749234857952 1.361890434397879e-06 0.06211990493347131 1.361890596191839e-06 0.06916698107316244 1.361890754742719e-06 0.07620053909780501 \
1.361890921935392e-06 0.08372027851346725 1.361891092293318e-06 0.09147114401158042 1.361891271730565e-06 0.0997240648901548 1.361891461853091e-06 0.1085375718081032 \
1.361891661092053e-06 0.1178373860957827 1.361891865069358e-06 0.1274102212870429 1.36189208614423e-06 0.1378300800073513 1.3618923318008e-06 0.1494365474357121 \
1.361892589151043e-06 0.1616443690283554 1.361892871842139e-06 0.1750899465505063 1.36189316989355e-06 0.1892663579759593 1.361893516170122e-06 0.2057792515135755 \
1.36189388288524e-06 0.2232517522030736 1.361894278797486e-06 0.2421754728923703 1.361894713908853e-06 0.2629945242020292 1.36189519371884e-06 0.2859861135989593 \
1.3618957190371e-06 0.3113450809673837 1.361896243573264e-06 0.3367514755549041 1.361896840892739e-06 0.3658546932050024 1.361897607717859e-06 0.4033613755922033 \
1.361898046206797e-06 0.4246376380793622 1.361898522720377e-06 0.4473946242989675 1.361898972555967e-06 0.4684360091747882 1.361899525240159e-06 0.4936960927629759 \
1.361900223236364e-06 0.5245486808074998 1.361900837638476e-06 0.5507582774516211 1.361901405608978e-06 0.5741722555225199 1.361901935862248e-06 0.5952266004882081 \
1.361902394831628e-06 0.6128068198589096 1.361902977999792e-06 0.6341908714213341 1.361903551157707e-06 0.6541368834277531 1.361904141842032e-06 0.6735006351351156 \
1.361904810515341e-06 0.6939224431220803 1.361905465000487e-06 0.7123419857223411 1.361906218631611e-06 0.7316435145596337 1.361907138111349e-06 0.7524771687756806 \
1.361907807118464e-06 0.7658582308664672 1.361908502684848e-06 0.7783426900018873 1.361909224721799e-06 0.7898435797332509 1.361909871505064e-06 0.7989777190578581 \
1.361910686398373e-06 0.809051394855074 1.361911344291083e-06 0.8161084932798452 1.361912109055577e-06 0.8232971874420545 1.361912705588939e-06 0.8281915934352191 \
1.361913333612095e-06 0.8327857747397983 1.361913964004405e-06 0.8368636793792511 1.36191494962664e-06 0.8423301485602825 1.361915705380696e-06 0.8458701801587535 \
1.361916468671131e-06 0.8489683054605098 1.361917277011917e-06 0.8518111549479527 1.361918265903366e-06 0.8547854532963984 1.361919008958979e-06 0.8567085856698495 \
1.361919831636168e-06 0.8585940601366741 1.361920612856223e-06 0.8601698380186774 1.361921416459391e-06 0.8616111415036141 1.361922203727638e-06 0.8628649505886673 \
1.361923395730052e-06 0.8644986110026872 1.361924318352036e-06 0.8655887935537701 1.361925377279772e-06 0.8666437563732095 1.361926250370494e-06 0.8673888282159752 \
1.361927019427764e-06 0.8679394432393451 1.3619327760832e-06 0.8675354626998435 1.361933384736608e-06 0.8669285211992742 1.361934348633067e-06 0.8661637309277684 \
1.361934697027123e-06 0.8657877651307159 1.361935865736297e-06 0.8648718022682493 1.361936507439083e-06 0.8645495171393598 1.361937723779243e-06 0.8636149212264693 \
1.361938210995997e-06 0.8633315979857124 1.361941995751513e-06 0.8637879096652611 1.361942803560593e-06 0.8644940879742092 1.361943676731311e-06 0.8654118536506241 \
1.36194452584852e-06 0.8664722967159353 1.361945394320663e-06 0.8676408136092975 1.361946220799482e-06 0.8688316482847912 1.361947067273748e-06 0.8700680498371385 \
1.361947993731666e-06 0.8714353201417473 1.361948922751738e-06 0.8727967357236968 1.361949890373816e-06 0.874169309418928 1.361950892855429e-06 0.8755268793700145 \
1.361951975786211e-06 0.8769279254876977 1.361953154258897e-06 0.8783524184654903 1.361954367359833e-06 0.8797057189093218 1.361955697820692e-06 0.8810544625232946 \
1.361957146531982e-06 0.8823882385150326 1.361958814266774e-06 0.8837386794148741 1.361960446298639e-06 0.8848798336526329 1.361962413590838e-06 0.8860652157953401 \
1.361964590094435e-06 0.8871729764751287 1.361966862249877e-06 0.8881691778223457 1.361969135754955e-06 0.8889896378135498 1.361971087665695e-06 0.8895771814349003 \
1.361973972100292e-06 0.8902862350409186 1.361976831036635e-06 0.8908501300162286 1.361979913323748e-06 0.8913157385816455 1.36199173167453e-06 0.8922670755128276 \
1.361994058318611e-06 0.8924600956555456 1.362000939517426e-06 0.8933233934443291 1.362002931772882e-06 0.8936033182227321 1.362007596963998e-06 0.8943294235126149 \
1.362009934973581e-06 0.894763749611499 1.36201243532077e-06 0.8952990768365913 1.362014909223274e-06 0.8959385502707948 1.362017035318025e-06 0.8965630758105964 \
1.362019624621494e-06 0.8973958942958599 1.362022048641129e-06 0.8982427248493853 1.362024940455552e-06 0.8993469797885378 1.362027450127073e-06 0.9003588137389537 \
1.362030788570323e-06 0.9017079510157455 1.362033867543754e-06 0.9029423170929788 1.362037060622869e-06 0.9042497182071535 1.362039656279508e-06 0.9052493492427333 \
1.362041664531596e-06 0.9059572885738179 1.362043772760482e-06 0.9066594295388942 1.362046461477417e-06 0.907478492737931 1.362048917070081e-06 0.9081366525620301 \
1.362051281590183e-06 0.9087089258990763 1.362053876154591e-06 0.9092804446275633 1.362056243869825e-06 0.9097121154337445 1.362063636309535e-06 0.9105880439508957 \
1.36206694738543e-06 0.9108097973553667 1.362090631104211e-06 0.9099572430838525 1.362093524994068e-06 0.9096028008700563 1.362099633721785e-06 0.9087795762164674 \
1.362102664784937e-06 0.9083311497095887 1.362109022442901e-06 0.9073557537429059 1.362112916389034e-06 0.906719613226565 1.362116289356866e-06 0.9061475060281556 \
1.362119374914729e-06 0.9055946669458763 1.362123120629277e-06 0.9048996522446952 1.362126487017035e-06 0.9043394102803256 1.362134077462241e-06 0.9034499723753743 \
1.362137953472777e-06 0.9031904105967781 1.362165717708862e-06 0.9022140906736803 1.362169493868778e-06 0.902100877529562 1.362200910100546e-06 0.9011025155537421 \
1.362207545190393e-06 0.9009020504869808 1.400110550805801e-06 0.8999193627810952 1.40011071848179e-06 0.8998913840591389 1.400113467033027e-06 0.8989010293823864 \
1.400113523573982e-06 0.8988795941121664 1.400114768178511e-06 0.8998357618405769 1.400114847007516e-06 0.9000722811707415 1.400115028967664e-06 0.9007374088026997 \
1.40011513130788e-06 0.9011852075627013 1.40011532428406e-06 0.9021545909398002 1.400115412645943e-06 0.9026487433775175 1.400115571157197e-06 0.9036053969378676 \
1.400115683054862e-06 0.9043311123122415 1.400115823971993e-06 0.9052897461292233 1.400115929405144e-06 0.9060407976354218 1.400116042282182e-06 0.9068700067857125 \
1.400116156714019e-06 0.9077320749581511 1.400116277994792e-06 0.9086625635419388 1.400116407030339e-06 0.9096610759972766 1.400116529569199e-06 0.9106054665418637 \
1.40011665392414e-06 0.9115433813509556 1.400116768824237e-06 0.912370851358936 1.400116872924634e-06 0.9130668181210778 1.400116980506906e-06 0.9137127811079708 \
1.400117148007135e-06 0.914504286313051 1.400117619367398e-06 0.9145217838087505 1.400117817316352e-06 0.9131640269569251 1.400117978090595e-06 0.9113346267648944 \
1.400118066395334e-06 0.910041664336402 1.400118153928761e-06 0.908567258693449 1.400118246820306e-06 0.9067913249607207 1.400118320262759e-06 0.9052411278657534 \
1.400118409009881e-06 0.9032017134587504 1.400118546653074e-06 0.8996915735089056 1.400118658994696e-06 0.8965314120175644 1.400118782291717e-06 0.892778172623249 \
1.400118938496376e-06 0.8876402979533503 1.400119062012361e-06 0.8833010177194197 1.400119232383792e-06 0.8769686903427227 1.400119380003419e-06 0.8711968848515086 \
1.400119531854558e-06 0.8650238565011712 1.400119667983612e-06 0.8593172646418706 1.400119810047228e-06 0.8532105227807962 1.400119945331887e-06 0.8472784593397693 \
1.400120083991258e-06 0.8411010749315838 1.40012023129828e-06 0.8344514077702887 1.400120377865128e-06 0.8277635723525925 1.400120539944527e-06 0.8202964899226535 \
1.400120687311172e-06 0.8134532267615989 1.40012085882447e-06 0.8054479178086997 1.400121042247436e-06 0.7968539002302991 1.400121244752722e-06 0.7873346372610658 \
1.400121456402384e-06 0.7773555108975432 1.400121677392943e-06 0.7669228693561837 1.40012190658697e-06 0.7561055044419139 1.400122183106921e-06 0.743046509132553 \
1.400122468593645e-06 0.7295848836660939 1.400122789908538e-06 0.7144535604611002 1.400123079378459e-06 0.7008559708795014 1.400123398648317e-06 0.6858669291494816 \
1.400123719663687e-06 0.6708097907125149 1.400124061099719e-06 0.654842287100785 1.400124453723407e-06 0.6364912117266992 1.400124808317996e-06 0.6199451687359452 \
1.400125173105078e-06 0.602895395464039 1.40012557692179e-06 0.5840362041416589 1.400125940450356e-06 0.56705803755797 1.400126371026893e-06 0.546963725974103 \
1.400126727188766e-06 0.5303181638661557 1.400127100198165e-06 0.5128834705750704 1.400127442383275e-06 0.4969084729771704 1.400127762124838e-06 0.4820272854775881 \
1.400128079868868e-06 0.4673068400017517 1.40012837572031e-06 0.453709089639897 1.400128703744139e-06 0.4388357619204879 1.400129013234577e-06 0.4250513307906954 \
1.400129299733975e-06 0.412542701771394 1.400129612088515e-06 0.3991541929604193 1.400129902199714e-06 0.3870087322563178 1.400130215665733e-06 0.3741657412501236 \
1.400130493028614e-06 0.3630444214925196 1.400130774126111e-06 0.3519744117192101 1.400131005607363e-06 0.3430374849397334 1.400131234174756e-06 0.3343354151638595 \
1.40013147406666e-06 0.3253394991495989 1.400131731848444e-06 0.3158318026516087 1.400131981218357e-06 0.3067925439309827 1.400132239531266e-06 0.297589150170473 \
1.400132486062287e-06 0.2889540805256016 1.400132773357043e-06 0.2790758510850415 1.400132996736124e-06 0.2715471379396955 1.400133217531486e-06 0.2642409610398131 \
1.40013341340532e-06 0.2578652581015776 1.4001336001294e-06 0.2519000449202701 1.400133771320538e-06 0.2465102462678049 1.400133946364063e-06 0.2410522141953559 \
1.400134109381927e-06 0.236036359124031 1.400134270786368e-06 0.2311389431166576 1.400134424603758e-06 0.2265774065811171 1.40013457654048e-06 0.2221477024102725 \
1.400134730763452e-06 0.2177012931700853 1.400134904399052e-06 0.2127672920349684 1.400135054516093e-06 0.2085590788965803 1.400135188967813e-06 0.2048346911951331 \
1.400135333880152e-06 0.2008962005616911 1.400135495414782e-06 0.1965999354189458 1.400135644303198e-06 0.1927083727438147 1.400135788543376e-06 0.1889957157254755 \
1.400135913586713e-06 0.1858267544518093 1.400136010653492e-06 0.183392498065703 1.400136145647889e-06 0.1800503036180525 1.40013625516225e-06 0.1773760505692391 \
1.400136393137778e-06 0.1740872877198338 1.400136513150413e-06 0.1712726271080235 1.40013663003209e-06 0.1685704901364905 1.400136756660935e-06 0.1656849030049582 \
1.400136892675268e-06 0.1626308514974385 1.40013702606177e-06 0.1596764551685698 1.400137153003703e-06 0.1569158519548911 1.400137281621738e-06 0.1541678007478876 \
1.400137395548178e-06 0.1517740356345986 1.400137505859117e-06 0.149496521787741 1.400137619000359e-06 0.1472133997668396 1.400137732479435e-06 0.1449590740078549 \
1.400137857844221e-06 0.1425075003983929 1.400138003638108e-06 0.1397077962434051 1.400138186780095e-06 0.1362681166668699 1.4001383353875e-06 0.1335395672637218 \
1.400138447639322e-06 0.1315146079855561 1.400138576992754e-06 0.1292194206906994 1.400138670528911e-06 0.1275846423925092 1.40013877932072e-06 0.1257099890290588 \
1.400138873074831e-06 0.1241165438085202 1.400138956682435e-06 0.1227229754719547 1.4001390763363e-06 0.1207568051616409 1.400139205425261e-06 0.1186746054627577 \
1.400139322279497e-06 0.1168252031377112 1.400139453368507e-06 0.1147891811469644 1.400139598723522e-06 0.1125787883659796 1.400139764133423e-06 0.110121919024741 \
1.40013993287367e-06 0.1076798417306999 1.400140125753815e-06 0.1049622523271389 1.400140299731943e-06 0.1025767092705754 1.400140487918313e-06 0.1000644866129177 \
1.40014067031941e-06 0.09769892895340802 1.400140849911024e-06 0.09544952095403336 1.400141026408427e-06 0.09330553315647841 1.400141210964177e-06 0.09112768523704891 \
1.400141396209645e-06 0.08900465024544718 1.400141578281057e-06 0.0869768268327742 1.400141774345804e-06 0.08485812802288394 1.400141944746221e-06 0.08306894814141007 \
1.400142122986993e-06 0.08125105909257219 1.400142298679519e-06 0.07951206376949813 1.400142499080023e-06 0.07758728548656671 1.400142695934063e-06 0.07575734486890456 \
1.400142865868499e-06 0.07422427017287291 1.40014303651775e-06 0.07272580243814712 1.400143219642496e-06 0.07116311580983979 1.400143413259743e-06 0.06956233824397716 \
1.400143594846707e-06 0.06811311716920317 1.400143793421027e-06 0.06657819701521293 1.400143949952299e-06 0.06540254085633944 1.400144133522745e-06 0.06406078399206196 \
1.400144306484985e-06 0.06283331112669251 1.400144471995362e-06 0.06169268945721457 1.40014462033141e-06 0.06069691796619666 1.400144757229627e-06 0.05979937680937147 \
1.400144904867328e-06 0.05885633029244827 1.400145037955006e-06 0.05802735218158511 1.400145161474142e-06 0.05727448785321319 1.400145277510429e-06 0.05658054160001152 \
1.400145391123697e-06 0.05591352504042409 1.400145515745172e-06 0.05519553885869784 1.400145636542111e-06 0.05451306145814139 1.40014579648583e-06 0.0536298481755812 \
1.400145931832912e-06 0.05289991373180127 1.400146032152412e-06 0.05236888834064994 1.400146132622372e-06 0.05184552065910697 1.400146231565458e-06 0.05133799434906983 \
1.40014641007002e-06 0.05044349321929222 1.400146509870119e-06 0.04995513630881745 1.400146710035568e-06 0.04899962929156078 1.400146800952851e-06 0.04857581029502876 \
1.400147007746298e-06 0.04763487432244629 1.40014711297643e-06 0.0471681110353394 1.400147309354922e-06 0.04631787013837765 1.400147394633218e-06 0.04595693884580357 \
1.400147575095581e-06 0.04521002446657041 1.400147650260171e-06 0.04490525014776706 1.40014786811757e-06 0.0440422972058082 1.400147951636165e-06 0.04372097365614635 \
1.400148141571271e-06 0.04300637120866019 1.40014826631761e-06 0.04254845761102347 1.400148451543578e-06 0.0418846242551883 1.400148554382137e-06 0.04152415866453074 \
1.400148843894812e-06 0.04053983903151908 1.400148932816406e-06 0.04024621147044882 1.40014924148676e-06 0.03925784365481538 1.400149297645764e-06 0.03908306666491448 \
1.400149611207866e-06 0.03813491809530275 1.400149667163848e-06 0.037970533835152 1.400149994078164e-06 0.03703805601095747 1.400150047341397e-06 0.03689043863681411 \
1.400150353265485e-06 0.03606517121743442 1.400150453429213e-06 0.0358032254974586 1.400150772044909e-06 0.03499570355391716 1.400150861523872e-06 0.03477583942316619 \
1.400151259364458e-06 0.03383675925705845 1.400151377245794e-06 0.03357186655877694 1.400151789247958e-06 0.03268299960645597 1.40015194961085e-06 0.03235094877383871 \
1.400152320629234e-06 0.03161177976826059 1.400152540382685e-06 0.03119164460703521 1.400152983766919e-06 0.03038142203317581 1.400153232810551e-06 0.0299476098095271 \
1.4001537326667e-06 0.02912178892962563 1.400153951558277e-06 0.02877747133829427 1.400154434672084e-06 0.02805819238630505 1.400154723499336e-06 0.02765301209416409 \
1.400155410247302e-06 0.02674723311374961 1.400155699762857e-06 0.02638861276123805 1.400156475736135e-06 0.02548835782609031 1.400156647189526e-06 0.02530065249352256 \
1.40015743327132e-06 0.02449144648051316 1.400157637300353e-06 0.02429465554580218 1.400158746898316e-06 0.02329883562822865 1.400158847813389e-06 0.02321388155873386 \
1.400160039404086e-06 0.02227529349501467 1.400160244312293e-06 0.0221260927003824 1.400161697508364e-06 0.02113958380755909 1.400161932492782e-06 0.02098788030205876 \
1.400163439760696e-06 0.02004942094855779 1.40016376006111e-06 0.01985604392354444 1.400164974239456e-06 0.01910354072181233 1.400165447544128e-06 0.01879991394003632 \
1.400166748677981e-06 0.01794965119692995 1.400167138470568e-06 0.01770179815419311 1.400168537018732e-06 0.01679702456340363 1.400168863768812e-06 0.01658609683275075 \
1.40016998110407e-06 0.01586843585740347 1.400170689790367e-06 0.01544169959229912 1.400172422376366e-06 0.01449858640399567 1.400172671838817e-06 0.01436065672582198 \
1.400174469435716e-06 0.01337694399212387 1.400174812129382e-06 0.01319104500849105 1.400176988462895e-06 0.01225973435293598 1.40017727331928e-06 0.01213579497780986 \
1.400179172162672e-06 0.01126438850740638 1.40017965502513e-06 0.01103474467122418 1.400181927520555e-06 0.01014901321627989 1.400182315058726e-06 0.01002270433864562 \
1.400184966564885e-06 0.009023867700259034 1.400185262768817e-06 0.00890332747207802 1.40018760460699e-06 0.00793111507746596 1.400187858191315e-06 0.007825942613114227 \
1.400190880361057e-06 0.006881067894167194 1.40019112999456e-06 0.006804700431426973 1.400195007891808e-06 0.005817006850260108 1.400195235071384e-06 0.005760637946475626 \
1.400198046189619e-06 0.00490690852483563 1.400198480606374e-06 0.004760206508803379 1.400201010366652e-06 0.003858115577918713 1.400201428863181e-06 0.003712016323791173 \
1.400204453534309e-06 0.00274875962184498 1.400204733759441e-06 0.002664158024812898 1.400208530584646e-06 0.001697446565651876 1.400208884963991e-06 0.001621705150764489 \
1.400214411478996e-06 0.0006347476112661908 1.400214708963481e-06 0.0005888553763099016 1.400222216727447e-06 -0.0003928413941844093 1.400222438401114e-06 -0.0004189941252107796 \
1.400236530784873e-06 -0.001410461992184868 1.400236889612591e-06 -0.001430649730572865 1.400250237245411e-06 -0.0004514903228812461 1.400250464642512e-06 -0.0004111859973536986 \
1.400255915612065e-06 0.0005614551864591434 1.400256178897484e-06 0.0006110884748384679 1.400260810837491e-06 0.001592952619583714 1.400261118869639e-06 0.001665522059460669 \
1.40026495308288e-06 0.002626457037572999 1.400265337382884e-06 0.002733556882532277 1.400269071576165e-06 0.003682507088408038 1.400269273441448e-06 0.00374945551670179 \
1.400272897693538e-06 0.004734851451646972 1.400273092622753e-06 0.004780391513086043 1.400276479822177e-06 0.005766866152453508 1.400276671910697e-06 0.005810149709068801 \
1.400280887542283e-06 0.006750994364636406 1.400281221079492e-06 0.006821678237255247 1.400305948540302e-06 0.005867117768706426 1.400306261817208e-06 0.005806676405157672 \
1.400310893192981e-06 0.004863125825100585 1.400311165044221e-06 0.004806306550559217 1.4003161096881e-06 0.003825328200913169 1.400316576141932e-06 0.003739629632037282 \
1.400322482405849e-06 0.002770751168227681 1.400322776130159e-06 0.002729631326985271 1.400331621359071e-06 0.001738601807147118 1.400331808126426e-06 0.001722695496451883 \
1.400352036959148e-06 0.0007253105668073048 1.400353471598443e-06 0.0006873447391178559 1.458990000000011e-06 3.130932490801775e-06 1.461883407830385e-06 -0.0008819623910157972 \
1.461883643879234e-06 -0.001161970612476729 1.461884102325562e-06 -0.001847355627596629 1.461884345612697e-06 -0.002293620068582415 1.461884595896664e-06 -0.00281405583725217 \
1.461884846702668e-06 -0.003393671496214343 1.46188515952233e-06 -0.004199192998005251 1.461885397732202e-06 -0.004872003934560885 1.461885644182635e-06 -0.005621391842385397 \
1.461885875927131e-06 -0.006370319304257691 1.461886183112249e-06 -0.007411941938624838 1.461886448406181e-06 -0.008326397880259807 1.461886693685807e-06 -0.009131457988769647 \
1.461887058417363e-06 -0.01007334593757064 1.46188728648854e-06 -0.01033898456945748 1.461887610128182e-06 -0.009994868194499993 1.461887810544735e-06 -0.009187286872421443 \
1.461888045349532e-06 -0.007487931918614563 1.461888226424988e-06 -0.005544847192362645 1.461888332865277e-06 -0.004119573247771668 1.461888471151424e-06 -0.001940540768574745 \
1.461888582177387e-06 7.563183370691832e-05 1.461888702798821e-06 0.002536824544301687 1.461888805864002e-06 0.004857398676819782 1.461888944571287e-06 0.008289235792766818 \
1.461889065680579e-06 0.01156496544863939 1.46188921588438e-06 0.01596809792775087 1.46188939752999e-06 0.02176080367268303 1.46188954996521e-06 0.02698454055473338 \
1.461889726115454e-06 0.03339084366291074 1.4618899251156e-06 0.04103368087207344 1.461890094787538e-06 0.04784290449723066 1.461890273981514e-06 0.05527749234857952 \
1.461890434397879e-06 0.06211990493347131 1.461890596191839e-06 0.06916698107316244 1.461890754742719e-06 0.07620053909780501 1.461890921935392e-06 0.08372027851346725 \
1.461891092293318e-06 0.09147114401158042 1.461891271730565e-06 0.0997240648901548 1.461891461853091e-06 0.1085375718081032 1.461891661092053e-06 0.1178373860957827 \
1.461891865069358e-06 0.1274102212870429 1.46189208614423e-06 0.1378300800073513 1.4618923318008e-06 0.1494365474357121 1.461892589151043e-06 0.1616443690283554 \
1.461892871842139e-06 0.1750899465505063 1.46189316989355e-06 0.1892663579759593 1.461893516170122e-06 0.2057792515135755 1.46189388288524e-06 0.2232517522030736 \
1.461894278797487e-06 0.2421754728923703 1.461894713908853e-06 0.2629945242020292 1.46189519371884e-06 0.2859861135989593 1.4618957190371e-06 0.3113450809673837 \
1.461896243573264e-06 0.3367514755549041 1.461896840892739e-06 0.3658546932050024 1.461897607717859e-06 0.4033613755922033 1.461898046206797e-06 0.4246376380793622 \
1.461898522720377e-06 0.4473946242989675 1.461898972555967e-06 0.4684360091747882 1.461899525240159e-06 0.4936960927629759 1.461900223236364e-06 0.5245486808074998 \
1.461900837638476e-06 0.5507582774516211 1.461901405608978e-06 0.5741722555225199 1.461901935862248e-06 0.5952266004882081 1.461902394831628e-06 0.6128068198589096 \
1.461902977999792e-06 0.6341908714213341 1.461903551157707e-06 0.6541368834277531 1.461904141842032e-06 0.6735006351351156 1.461904810515341e-06 0.6939224431220803 \
1.461905465000487e-06 0.7123419857223411 1.461906218631611e-06 0.7316435145596337 1.461907138111349e-06 0.7524771687756806 1.461907807118464e-06 0.7658582308664672 \
1.461908502684848e-06 0.7783426900018873 1.461909224721799e-06 0.7898435797332509 1.461909871505064e-06 0.7989777190578581 1.461910686398373e-06 0.809051394855074 \
1.461911344291083e-06 0.8161084932798452 1.461912109055577e-06 0.8232971874420545 1.461912705588939e-06 0.8281915934352191 1.461913333612095e-06 0.8327857747397983 \
1.461913964004405e-06 0.8368636793792511 1.46191494962664e-06 0.8423301485602825 1.461915705380696e-06 0.8458701801587535 1.461916468671131e-06 0.8489683054605098 \
1.461917277011917e-06 0.8518111549479527 1.461918265903366e-06 0.8547854532963984 1.461919008958979e-06 0.8567085856698495 1.461919831636168e-06 0.8585940601366741 \
1.461920612856223e-06 0.8601698380186774 1.461921416459391e-06 0.8616111415036141 1.461922203727638e-06 0.8628649505886673 1.461923395730052e-06 0.8644986110026872 \
1.461924318352036e-06 0.8655887935537701 1.461925377279772e-06 0.8666437563732095 1.461926250370494e-06 0.8673888282159752 1.461927019427764e-06 0.8679394432393451 \
1.4619327760832e-06 0.8675354626998435 1.461933384736608e-06 0.8669285211992742 1.461934348633067e-06 0.8661637309277684 1.461934697027123e-06 0.8657877651307159 \
1.461935865736297e-06 0.8648718022682493 1.461936507439083e-06 0.8645495171393598 1.461937723779243e-06 0.8636149212264693 1.461938210995997e-06 0.8633315979857124 \
1.461941995751513e-06 0.8637879096652611 1.461942803560594e-06 0.8644940879742092 1.461943676731311e-06 0.8654118536506241 1.46194452584852e-06 0.8664722967159353 \
1.461945394320663e-06 0.8676408136092975 1.461946220799482e-06 0.8688316482847912 1.461947067273748e-06 0.8700680498371385 1.461947993731666e-06 0.8714353201417473 \
1.461948922751738e-06 0.8727967357236968 1.461949890373816e-06 0.874169309418928 1.461950892855429e-06 0.8755268793700145 1.461951975786211e-06 0.8769279254876977 \
1.461953154258897e-06 0.8783524184654903 1.461954367359833e-06 0.8797057189093218 1.461955697820692e-06 0.8810544625232946 1.461957146531982e-06 0.8823882385150326 \
1.461958814266774e-06 0.8837386794148741 1.461960446298639e-06 0.8848798336526329 1.461962413590838e-06 0.8860652157953401 1.461964590094435e-06 0.8871729764751287 \
1.461966862249877e-06 0.8881691778223457 1.461969135754955e-06 0.8889896378135498 1.461971087665695e-06 0.8895771814349003 1.461973972100292e-06 0.8902862350409186 \
1.461976831036635e-06 0.8908501300162286 1.461979913323748e-06 0.8913157385816455 1.46199173167453e-06 0.8922670755128276 1.461994058318611e-06 0.8924600956555456 \
1.462000939517426e-06 0.8933233934443291 1.462002931772882e-06 0.8936033182227321 1.462007596963998e-06 0.8943294235126149 1.462009934973581e-06 0.894763749611499 \
1.46201243532077e-06 0.8952990768365913 1.462014909223274e-06 0.8959385502707948 1.462017035318026e-06 0.8965630758105964 1.462019624621494e-06 0.8973958942958599 \
1.462022048641129e-06 0.8982427248493853 1.462024940455553e-06 0.8993469797885378 1.462027450127073e-06 0.9003588137389537 1.462030788570323e-06 0.9017079510157455 \
1.462033867543754e-06 0.9029423170929788 1.462037060622869e-06 0.9042497182071535 1.462039656279508e-06 0.9052493492427333 1.462041664531596e-06 0.9059572885738179 \
1.462043772760482e-06 0.9066594295388942 1.462046461477417e-06 0.907478492737931 1.462048917070081e-06 0.9081366525620301 1.462051281590183e-06 0.9087089258990763 \
1.462053876154591e-06 0.9092804446275633 1.462056243869825e-06 0.9097121154337445 1.462063636309535e-06 0.9105880439508957 1.46206694738543e-06 0.9108097973553667 \
1.46209063110421e-06 0.9099572430838525 1.462093524994069e-06 0.9096028008700563 1.462099633721785e-06 0.9087795762164674 1.462102664784937e-06 0.9083311497095887 \
1.462109022442902e-06 0.9073557537429059 1.462112916389034e-06 0.906719613226565 1.462116289356866e-06 0.9061475060281556 1.462119374914729e-06 0.9055946669458763 \
1.462123120629277e-06 0.9048996522446952 1.462126487017035e-06 0.9043394102803256 1.462134077462241e-06 0.9034499723753743 1.462137953472777e-06 0.9031904105967781 \
1.462165717708862e-06 0.9022140906736803 1.462169493868779e-06 0.902100877529562 1.462200910100546e-06 0.9011025155537421 1.462207545190393e-06 0.9009020504869808 \
1.5001105508058e-06 0.8999193627810952 1.50011071848179e-06 0.8998913840591389 1.500113467033027e-06 0.8989010293823864 1.500113523573982e-06 0.8988795941121664 \
1.500114768178511e-06 0.8998357618405769 1.500114847007516e-06 0.9000722811707415 1.500115028967665e-06 0.9007374088026997 1.50011513130788e-06 0.9011852075627013 \
1.50011532428406e-06 0.9021545909398002 1.500115412645943e-06 0.9026487433775175 1.500115571157198e-06 0.9036053969378676 1.500115683054862e-06 0.9043311123122415 \
1.500115823971993e-06 0.9052897461292233 1.500115929405144e-06 0.9060407976354218 1.500116042282182e-06 0.9068700067857125 1.500116156714019e-06 0.9077320749581511 \
1.500116277994792e-06 0.9086625635419388 1.500116407030339e-06 0.9096610759972766 1.500116529569199e-06 0.9106054665418637 1.50011665392414e-06 0.9115433813509556 \
1.500116768824237e-06 0.912370851358936 1.500116872924634e-06 0.9130668181210778 1.500116980506906e-06 0.9137127811079708 1.500117148007135e-06 0.914504286313051 \
1.500117619367398e-06 0.9145217838087505 1.500117817316352e-06 0.9131640269569251 1.500117978090595e-06 0.9113346267648944 1.500118066395334e-06 0.910041664336402 \
1.500118153928761e-06 0.908567258693449 1.500118246820306e-06 0.9067913249607207 1.500118320262759e-06 0.9052411278657534 1.500118409009881e-06 0.9032017134587504 \
1.500118546653074e-06 0.8996915735089056 1.500118658994696e-06 0.8965314120175644 1.500118782291718e-06 0.892778172623249 1.500118938496376e-06 0.8876402979533503 \
1.500119062012361e-06 0.8833010177194197 1.500119232383792e-06 0.8769686903427227 1.500119380003419e-06 0.8711968848515086 1.500119531854558e-06 0.8650238565011712 \
1.500119667983612e-06 0.8593172646418706 1.500119810047228e-06 0.8532105227807962 1.500119945331887e-06 0.8472784593397693 1.500120083991258e-06 0.8411010749315838 \
1.50012023129828e-06 0.8344514077702887 1.500120377865128e-06 0.8277635723525925 1.500120539944527e-06 0.8202964899226535 1.500120687311172e-06 0.8134532267615989 \
1.50012085882447e-06 0.8054479178086997 1.500121042247436e-06 0.7968539002302991 1.500121244752722e-06 0.7873346372610658 1.500121456402384e-06 0.7773555108975432 \
1.500121677392943e-06 0.7669228693561837 1.50012190658697e-06 0.7561055044419139 1.500122183106921e-06 0.743046509132553 1.500122468593645e-06 0.7295848836660939 \
1.500122789908539e-06 0.7144535604611002 1.500123079378459e-06 0.7008559708795014 1.500123398648317e-06 0.6858669291494816 1.500123719663687e-06 0.6708097907125149 \
1.500124061099719e-06 0.654842287100785 1.500124453723407e-06 0.6364912117266992 1.500124808317996e-06 0.6199451687359452 1.500125173105078e-06 0.602895395464039 \
1.50012557692179e-06 0.5840362041416589 1.500125940450357e-06 0.56705803755797 1.500126371026893e-06 0.546963725974103 1.500126727188766e-06 0.5303181638661557 \
1.500127100198166e-06 0.5128834705750704 1.500127442383275e-06 0.4969084729771704 1.500127762124838e-06 0.4820272854775881 1.500128079868868e-06 0.4673068400017517 \
1.50012837572031e-06 0.453709089639897 1.500128703744139e-06 0.4388357619204879 1.500129013234577e-06 0.4250513307906954 1.500129299733975e-06 0.412542701771394 \
1.500129612088515e-06 0.3991541929604193 1.500129902199714e-06 0.3870087322563178 1.500130215665733e-06 0.3741657412501236 1.500130493028614e-06 0.3630444214925196 \
1.500130774126111e-06 0.3519744117192101 1.500131005607363e-06 0.3430374849397334 1.500131234174756e-06 0.3343354151638595 1.50013147406666e-06 0.3253394991495989 \
1.500131731848444e-06 0.3158318026516087 1.500131981218358e-06 0.3067925439309827 1.500132239531266e-06 0.297589150170473 1.500132486062287e-06 0.2889540805256016 \
1.500132773357043e-06 0.2790758510850415 1.500132996736124e-06 0.2715471379396955 1.500133217531486e-06 0.2642409610398131 1.50013341340532e-06 0.2578652581015776 \
1.500133600129401e-06 0.2519000449202701 1.500133771320538e-06 0.2465102462678049 1.500133946364063e-06 0.2410522141953559 1.500134109381927e-06 0.236036359124031 \
1.500134270786368e-06 0.2311389431166576 1.500134424603758e-06 0.2265774065811171 1.50013457654048e-06 0.2221477024102725 1.500134730763452e-06 0.2177012931700853 \
1.500134904399052e-06 0.2127672920349684 1.500135054516093e-06 0.2085590788965803 1.500135188967813e-06 0.2048346911951331 1.500135333880152e-06 0.2008962005616911 \
1.500135495414782e-06 0.1965999354189458 1.500135644303198e-06 0.1927083727438147 1.500135788543376e-06 0.1889957157254755 1.500135913586713e-06 0.1858267544518093 \
1.500136010653492e-06 0.183392498065703 1.500136145647889e-06 0.1800503036180525 1.500136255162251e-06 0.1773760505692391 1.500136393137778e-06 0.1740872877198338 \
1.500136513150413e-06 0.1712726271080235 1.50013663003209e-06 0.1685704901364905 1.500136756660935e-06 0.1656849030049582 1.500136892675268e-06 0.1626308514974385 \
1.50013702606177e-06 0.1596764551685698 1.500137153003703e-06 0.1569158519548911 1.500137281621738e-06 0.1541678007478876 1.500137395548178e-06 0.1517740356345986 \
1.500137505859117e-06 0.149496521787741 1.50013761900036e-06 0.1472133997668396 1.500137732479436e-06 0.1449590740078549 1.500137857844221e-06 0.1425075003983929 \
1.500138003638108e-06 0.1397077962434051 1.500138186780095e-06 0.1362681166668699 1.5001383353875e-06 0.1335395672637218 1.500138447639322e-06 0.1315146079855561 \
1.500138576992755e-06 0.1292194206906994 1.500138670528911e-06 0.1275846423925092 1.50013877932072e-06 0.1257099890290588 1.500138873074831e-06 0.1241165438085202 \
1.500138956682436e-06 0.1227229754719547 1.5001390763363e-06 0.1207568051616409 1.500139205425261e-06 0.1186746054627577 1.500139322279497e-06 0.1168252031377112 \
1.500139453368507e-06 0.1147891811469644 1.500139598723523e-06 0.1125787883659796 1.500139764133423e-06 0.110121919024741 1.50013993287367e-06 0.1076798417306999 \
1.500140125753816e-06 0.1049622523271389 1.500140299731943e-06 0.1025767092705754 1.500140487918313e-06 0.1000644866129177 1.500140670319411e-06 0.09769892895340802 \
1.500140849911024e-06 0.09544952095403336 1.500141026408427e-06 0.09330553315647841 1.500141210964177e-06 0.09112768523704891 1.500141396209645e-06 0.08900465024544718 \
1.500141578281057e-06 0.0869768268327742 1.500141774345804e-06 0.08485812802288394 1.500141944746222e-06 0.08306894814141007 1.500142122986993e-06 0.08125105909257219 \
1.500142298679519e-06 0.07951206376949813 1.500142499080023e-06 0.07758728548656671 1.500142695934063e-06 0.07575734486890456 1.500142865868499e-06 0.07422427017287291 \
1.50014303651775e-06 0.07272580243814712 1.500143219642496e-06 0.07116311580983979 1.500143413259743e-06 0.06956233824397716 1.500143594846707e-06 0.06811311716920317 \
1.500143793421027e-06 0.06657819701521293 1.500143949952299e-06 0.06540254085633944 1.500144133522745e-06 0.06406078399206196 1.500144306484985e-06 0.06283331112669251 \
1.500144471995363e-06 0.06169268945721457 1.50014462033141e-06 0.06069691796619666 1.500144757229627e-06 0.05979937680937147 1.500144904867328e-06 0.05885633029244827 \
1.500145037955006e-06 0.05802735218158511 1.500145161474142e-06 0.05727448785321319 1.500145277510429e-06 0.05658054160001152 1.500145391123697e-06 0.05591352504042409 \
1.500145515745172e-06 0.05519553885869784 1.500145636542111e-06 0.05451306145814139 1.50014579648583e-06 0.0536298481755812 1.500145931832913e-06 0.05289991373180127 \
1.500146032152412e-06 0.05236888834064994 1.500146132622372e-06 0.05184552065910697 1.500146231565458e-06 0.05133799434906983 1.50014641007002e-06 0.05044349321929222 \
1.500146509870119e-06 0.04995513630881745 1.500146710035568e-06 0.04899962929156078 1.500146800952851e-06 0.04857581029502876 1.500147007746298e-06 0.04763487432244629 \
1.50014711297643e-06 0.0471681110353394 1.500147309354922e-06 0.04631787013837765 1.500147394633218e-06 0.04595693884580357 1.500147575095581e-06 0.04521002446657041 \
1.500147650260171e-06 0.04490525014776706 1.50014786811757e-06 0.0440422972058082 1.500147951636165e-06 0.04372097365614635 1.500148141571271e-06 0.04300637120866019 \
1.50014826631761e-06 0.04254845761102347 1.500148451543578e-06 0.0418846242551883 1.500148554382137e-06 0.04152415866453074 1.500148843894812e-06 0.04053983903151908 \
1.500148932816406e-06 0.04024621147044882 1.50014924148676e-06 0.03925784365481538 1.500149297645764e-06 0.03908306666491448 1.500149611207866e-06 0.03813491809530275 \
1.500149667163848e-06 0.037970533835152 1.500149994078164e-06 0.03703805601095747 1.500150047341397e-06 0.03689043863681411 1.500150353265485e-06 0.03606517121743442 \
1.500150453429213e-06 0.0358032254974586 1.500150772044909e-06 0.03499570355391716 1.500150861523872e-06 0.03477583942316619 1.500151259364458e-06 0.03383675925705845 \
1.500151377245794e-06 0.03357186655877694 1.500151789247957e-06 0.03268299960645597 1.50015194961085e-06 0.03235094877383871 1.500152320629234e-06 0.03161177976826059 \
1.500152540382686e-06 0.03119164460703521 1.500152983766919e-06 0.03038142203317581 1.500153232810551e-06 0.0299476098095271 1.5001537326667e-06 0.02912178892962563 \
1.500153951558277e-06 0.02877747133829427 1.500154434672084e-06 0.02805819238630505 1.500154723499337e-06 0.02765301209416409 1.500155410247302e-06 0.02674723311374961 \
1.500155699762857e-06 0.02638861276123805 1.500156475736135e-06 0.02548835782609031 1.500156647189526e-06 0.02530065249352256 1.50015743327132e-06 0.02449144648051316 \
1.500157637300353e-06 0.02429465554580218 1.500158746898316e-06 0.02329883562822865 1.500158847813389e-06 0.02321388155873386 1.500160039404086e-06 0.02227529349501467 \
1.500160244312293e-06 0.0221260927003824 1.500161697508364e-06 0.02113958380755909 1.500161932492782e-06 0.02098788030205876 1.500163439760696e-06 0.02004942094855779 \
1.500163760061111e-06 0.01985604392354444 1.500164974239456e-06 0.01910354072181233 1.500165447544128e-06 0.01879991394003632 1.500166748677981e-06 0.01794965119692995 \
1.500167138470568e-06 0.01770179815419311 1.500168537018733e-06 0.01679702456340363 1.500168863768812e-06 0.01658609683275075 1.50016998110407e-06 0.01586843585740347 \
1.500170689790368e-06 0.01544169959229912 1.500172422376366e-06 0.01449858640399567 1.500172671838817e-06 0.01436065672582198 1.500174469435716e-06 0.01337694399212387 \
1.500174812129382e-06 0.01319104500849105 1.500176988462895e-06 0.01225973435293598 1.50017727331928e-06 0.01213579497780986 1.500179172162672e-06 0.01126438850740638 \
1.50017965502513e-06 0.01103474467122418 1.500181927520555e-06 0.01014901321627989 1.500182315058726e-06 0.01002270433864562 1.500184966564885e-06 0.009023867700259034 \
1.500185262768817e-06 0.00890332747207802 1.500187604606991e-06 0.00793111507746596 1.500187858191315e-06 0.007825942613114227 1.500190880361057e-06 0.006881067894167194 \
1.50019112999456e-06 0.006804700431426973 1.500195007891808e-06 0.005817006850260108 1.500195235071384e-06 0.005760637946475626 1.500198046189619e-06 0.00490690852483563 \
1.500198480606374e-06 0.004760206508803379 1.500201010366652e-06 0.003858115577918713 1.500201428863181e-06 0.003712016323791173 1.500204453534309e-06 0.00274875962184498 \
1.500204733759441e-06 0.002664158024812898 1.500208530584646e-06 0.001697446565651876 1.500208884963991e-06 0.001621705150764489 1.500214411478996e-06 0.0006347476112661908 \
1.500214708963481e-06 0.0005888553763099016 1.500222216727447e-06 -0.0003928413941844093 1.500222438401114e-06 -0.0004189941252107796 1.500236530784873e-06 -0.001410461992184868 \
1.500236889612591e-06 -0.001430649730572865 1.500250237245412e-06 -0.0004514903228812461 1.500250464642513e-06 -0.0004111859973536986 1.500255915612065e-06 0.0005614551864591434 \
1.500256178897484e-06 0.0006110884748384679 1.500260810837491e-06 0.001592952619583714 1.500261118869639e-06 0.001665522059460669 1.50026495308288e-06 0.002626457037572999 \
1.500265337382884e-06 0.002733556882532277 1.500269071576165e-06 0.003682507088408038 1.500269273441448e-06 0.00374945551670179 1.500272897693538e-06 0.004734851451646972 \
1.500273092622753e-06 0.004780391513086043 1.500276479822177e-06 0.005766866152453508 1.500276671910697e-06 0.005810149709068801 1.500280887542283e-06 0.006750994364636406 \
1.500281221079492e-06 0.006821678237255247 1.500305948540302e-06 0.005867117768706426 1.500306261817208e-06 0.005806676405157672 1.500310893192981e-06 0.004863125825100585 \
1.500311165044221e-06 0.004806306550559217 1.500316109688101e-06 0.003825328200913169 1.500316576141932e-06 0.003739629632037282 1.50032248240585e-06 0.002770751168227681 \
1.500322776130159e-06 0.002729631326985271 1.500331621359071e-06 0.001738601807147118 1.500331808126426e-06 0.001722695496451883 1.500352036959148e-06 0.0007253105668073048 \
1.500353471598443e-06 0.0006873447391178559 1.558990000000011e-06 3.130932490801775e-06 1.561883407830385e-06 -0.0008819623910157972 1.561883643879234e-06 -0.001161970612476729 \
1.561884102325562e-06 -0.001847355627596629 1.561884345612697e-06 -0.002293620068582415 1.561884595896665e-06 -0.00281405583725217 1.561884846702668e-06 -0.003393671496214343 \
1.561885159522331e-06 -0.004199192998005251 1.561885397732202e-06 -0.004872003934560885 1.561885644182635e-06 -0.005621391842385397 1.561885875927131e-06 -0.006370319304257691 \
1.561886183112249e-06 -0.007411941938624838 1.561886448406181e-06 -0.008326397880259807 1.561886693685808e-06 -0.009131457988769647 1.561887058417363e-06 -0.01007334593757064 \
1.56188728648854e-06 -0.01033898456945748 1.561887610128182e-06 -0.009994868194499993 1.561887810544735e-06 -0.009187286872421443 1.561888045349532e-06 -0.007487931918614563 \
1.561888226424988e-06 -0.005544847192362645 1.561888332865277e-06 -0.004119573247771668 1.561888471151424e-06 -0.001940540768574745 1.561888582177387e-06 7.563183370691832e-05 \
1.561888702798821e-06 0.002536824544301687 1.561888805864002e-06 0.004857398676819782 1.561888944571287e-06 0.008289235792766818 1.561889065680579e-06 0.01156496544863939 \
1.56188921588438e-06 0.01596809792775087 1.56188939752999e-06 0.02176080367268303 1.56188954996521e-06 0.02698454055473338 1.561889726115454e-06 0.03339084366291074 \
1.5618899251156e-06 0.04103368087207344 1.561890094787538e-06 0.04784290449723066 1.561890273981514e-06 0.05527749234857952 1.561890434397879e-06 0.06211990493347131 \
1.561890596191839e-06 0.06916698107316244 1.561890754742719e-06 0.07620053909780501 1.561890921935392e-06 0.08372027851346725 1.561891092293318e-06 0.09147114401158042 \
1.561891271730566e-06 0.0997240648901548 1.561891461853091e-06 0.1085375718081032 1.561891661092053e-06 0.1178373860957827 1.561891865069359e-06 0.1274102212870429 \
1.56189208614423e-06 0.1378300800073513 1.5618923318008e-06 0.1494365474357121 1.561892589151043e-06 0.1616443690283554 1.561892871842139e-06 0.1750899465505063 \
1.56189316989355e-06 0.1892663579759593 1.561893516170122e-06 0.2057792515135755 1.56189388288524e-06 0.2232517522030736 1.561894278797487e-06 0.2421754728923703 \
1.561894713908853e-06 0.2629945242020292 1.561895193718841e-06 0.2859861135989593 1.561895719037101e-06 0.3113450809673837 1.561896243573265e-06 0.3367514755549041 \
1.561896840892739e-06 0.3658546932050024 1.561897607717859e-06 0.4033613755922033 1.561898046206798e-06 0.4246376380793622 1.561898522720377e-06 0.4473946242989675 \
1.561898972555967e-06 0.4684360091747882 1.561899525240159e-06 0.4936960927629759 1.561900223236364e-06 0.5245486808074998 1.561900837638476e-06 0.5507582774516211 \
1.561901405608978e-06 0.5741722555225199 1.561901935862248e-06 0.5952266004882081 1.561902394831628e-06 0.6128068198589096 1.561902977999792e-06 0.6341908714213341 \
1.561903551157707e-06 0.6541368834277531 1.561904141842032e-06 0.6735006351351156 1.561904810515341e-06 0.6939224431220803 1.561905465000487e-06 0.7123419857223411 \
1.561906218631611e-06 0.7316435145596337 1.561907138111349e-06 0.7524771687756806 1.561907807118464e-06 0.7658582308664672 1.561908502684848e-06 0.7783426900018873 \
1.561909224721799e-06 0.7898435797332509 1.561909871505065e-06 0.7989777190578581 1.561910686398373e-06 0.809051394855074 1.561911344291083e-06 0.8161084932798452 \
1.561912109055577e-06 0.8232971874420545 1.561912705588939e-06 0.8281915934352191 1.561913333612095e-06 0.8327857747397983 1.561913964004405e-06 0.8368636793792511 \
1.56191494962664e-06 0.8423301485602825 1.561915705380697e-06 0.8458701801587535 1.561916468671132e-06 0.8489683054605098 1.561917277011917e-06 0.8518111549479527 \
1.561918265903366e-06 0.8547854532963984 1.561919008958979e-06 0.8567085856698495 1.561919831636168e-06 0.8585940601366741 1.561920612856224e-06 0.8601698380186774 \
1.561921416459391e-06 0.8616111415036141 1.561922203727638e-06 0.8628649505886673 1.561923395730052e-06 0.8644986110026872 1.561924318352036e-06 0.8655887935537701 \
1.561925377279772e-06 0.8666437563732095 1.561926250370494e-06 0.8673888282159752 1.561927019427764e-06 0.8679394432393451 1.561932776083201e-06 0.8675354626998435 \
1.561933384736608e-06 0.8669285211992742 1.561934348633067e-06 0.8661637309277684 1.561934697027123e-06 0.8657877651307159 1.561935865736297e-06 0.8648718022682493 \
1.561936507439083e-06 0.8645495171393598 1.561937723779243e-06 0.8636149212264693 1.561938210995997e-06 0.8633315979857124 1.561941995751513e-06 0.8637879096652611 \
1.561942803560594e-06 0.8644940879742092 1.561943676731311e-06 0.8654118536506241 1.56194452584852e-06 0.8664722967159353 1.561945394320663e-06 0.8676408136092975 \
1.561946220799482e-06 0.8688316482847912 1.561947067273748e-06 0.8700680498371385 1.561947993731667e-06 0.8714353201417473 1.561948922751738e-06 0.8727967357236968 \
1.561949890373816e-06 0.874169309418928 1.561950892855429e-06 0.8755268793700145 1.561951975786211e-06 0.8769279254876977 1.561953154258897e-06 0.8783524184654903 \
1.561954367359833e-06 0.8797057189093218 1.561955697820692e-06 0.8810544625232946 1.561957146531982e-06 0.8823882385150326 1.561958814266774e-06 0.8837386794148741 \
1.56196044629864e-06 0.8848798336526329 1.561962413590838e-06 0.8860652157953401 1.561964590094435e-06 0.8871729764751287 1.561966862249877e-06 0.8881691778223457 \
1.561969135754955e-06 0.8889896378135498 1.561971087665695e-06 0.8895771814349003 1.561973972100292e-06 0.8902862350409186 1.561976831036635e-06 0.8908501300162286 \
1.561979913323748e-06 0.8913157385816455 1.56199173167453e-06 0.8922670755128276 1.561994058318612e-06 0.8924600956555456 1.562000939517427e-06 0.8933233934443291 \
1.562002931772883e-06 0.8936033182227321 1.562007596963998e-06 0.8943294235126149 1.562009934973581e-06 0.894763749611499 1.56201243532077e-06 0.8952990768365913 \
1.562014909223274e-06 0.8959385502707948 1.562017035318026e-06 0.8965630758105964 1.562019624621494e-06 0.8973958942958599 1.562022048641129e-06 0.8982427248493853 \
1.562024940455553e-06 0.8993469797885378 1.562027450127073e-06 0.9003588137389537 1.562030788570323e-06 0.9017079510157455 1.562033867543754e-06 0.9029423170929788 \
1.562037060622869e-06 0.9042497182071535 1.562039656279508e-06 0.9052493492427333 1.562041664531596e-06 0.9059572885738179 1.562043772760482e-06 0.9066594295388942 \
1.562046461477418e-06 0.907478492737931 1.562048917070081e-06 0.9081366525620301 1.562051281590183e-06 0.9087089258990763 1.562053876154591e-06 0.9092804446275633 \
1.562056243869825e-06 0.9097121154337445 1.562063636309535e-06 0.9105880439508957 1.562066947385431e-06 0.9108097973553667 1.562090631104211e-06 0.9099572430838525 \
1.562093524994069e-06 0.9096028008700563 1.562099633721785e-06 0.9087795762164674 1.562102664784937e-06 0.9083311497095887 1.562109022442901e-06 0.9073557537429059 \
1.562112916389034e-06 0.906719613226565 1.562116289356866e-06 0.9061475060281556 1.56211937491473e-06 0.9055946669458763 1.562123120629278e-06 0.9048996522446952 \
1.562126487017035e-06 0.9043394102803256 1.562134077462241e-06 0.9034499723753743 1.562137953472777e-06 0.9031904105967781 1.562165717708862e-06 0.9022140906736803 \
1.562169493868779e-06 0.902100877529562 1.562200910100546e-06 0.9011025155537421 1.562207545190394e-06 0.9009020504869808 1.600110550805801e-06 0.8999193627810952 \
1.60011071848179e-06 0.8998913840591389 1.600113467033027e-06 0.8989010293823864 1.600113523573982e-06 0.8988795941121664 1.600114768178511e-06 0.8998357618405769 \
1.600114847007516e-06 0.9000722811707415 1.600115028967665e-06 0.9007374088026997 1.60011513130788e-06 0.9011852075627013 1.600115324284061e-06 0.9021545909398002 \
1.600115412645943e-06 0.9026487433775175 1.600115571157198e-06 0.9036053969378676 1.600115683054863e-06 0.9043311123122415 1.600115823971993e-06 0.9052897461292233 \
1.600115929405144e-06 0.9060407976354218 1.600116042282183e-06 0.9068700067857125 1.600116156714019e-06 0.9077320749581511 1.600116277994793e-06 0.9086625635419388 \
1.600116407030339e-06 0.9096610759972766 1.600116529569199e-06 0.9106054665418637 1.60011665392414e-06 0.9115433813509556 1.600116768824237e-06 0.912370851358936 \
1.600116872924634e-06 0.9130668181210778 1.600116980506906e-06 0.9137127811079708 1.600117148007135e-06 0.914504286313051 1.600117619367398e-06 0.9145217838087505 \
1.600117817316352e-06 0.9131640269569251 1.600117978090595e-06 0.9113346267648944 1.600118066395334e-06 0.910041664336402 1.600118153928761e-06 0.908567258693449 \
1.600118246820307e-06 0.9067913249607207 1.600118320262759e-06 0.9052411278657534 1.600118409009881e-06 0.9032017134587504 1.600118546653074e-06 0.8996915735089056 \
1.600118658994696e-06 0.8965314120175644 1.600118782291718e-06 0.892778172623249 1.600118938496376e-06 0.8876402979533503 1.600119062012361e-06 0.8833010177194197 \
1.600119232383793e-06 0.8769686903427227 1.600119380003419e-06 0.8711968848515086 1.600119531854558e-06 0.8650238565011712 1.600119667983612e-06 0.8593172646418706 \
1.600119810047228e-06 0.8532105227807962 1.600119945331887e-06 0.8472784593397693 1.600120083991258e-06 0.8411010749315838 1.60012023129828e-06 0.8344514077702887 \
1.600120377865129e-06 0.8277635723525925 1.600120539944527e-06 0.8202964899226535 1.600120687311172e-06 0.8134532267615989 1.60012085882447e-06 0.8054479178086997 \
1.600121042247436e-06 0.7968539002302991 1.600121244752722e-06 0.7873346372610658 1.600121456402384e-06 0.7773555108975432 1.600121677392943e-06 0.7669228693561837 \
1.60012190658697e-06 0.7561055044419139 1.600122183106921e-06 0.743046509132553 1.600122468593645e-06 0.7295848836660939 1.600122789908539e-06 0.7144535604611002 \
1.600123079378459e-06 0.7008559708795014 1.600123398648317e-06 0.6858669291494816 1.600123719663687e-06 0.6708097907125149 1.600124061099719e-06 0.654842287100785 \
1.600124453723407e-06 0.6364912117266992 1.600124808317996e-06 0.6199451687359452 1.600125173105078e-06 0.602895395464039 1.60012557692179e-06 0.5840362041416589 \
1.600125940450357e-06 0.56705803755797 1.600126371026893e-06 0.546963725974103 1.600126727188766e-06 0.5303181638661557 1.600127100198166e-06 0.5128834705750704 \
1.600127442383275e-06 0.4969084729771704 1.600127762124839e-06 0.4820272854775881 1.600128079868868e-06 0.4673068400017517 1.60012837572031e-06 0.453709089639897 \
1.600128703744139e-06 0.4388357619204879 1.600129013234577e-06 0.4250513307906954 1.600129299733975e-06 0.412542701771394 1.600129612088515e-06 0.3991541929604193 \
1.600129902199714e-06 0.3870087322563178 1.600130215665733e-06 0.3741657412501236 1.600130493028614e-06 0.3630444214925196 1.600130774126111e-06 0.3519744117192101 \
1.600131005607364e-06 0.3430374849397334 1.600131234174756e-06 0.3343354151638595 1.60013147406666e-06 0.3253394991495989 1.600131731848444e-06 0.3158318026516087 \
1.600131981218358e-06 0.3067925439309827 1.600132239531266e-06 0.297589150170473 1.600132486062287e-06 0.2889540805256016 1.600132773357043e-06 0.2790758510850415 \
1.600132996736124e-06 0.2715471379396955 1.600133217531486e-06 0.2642409610398131 1.60013341340532e-06 0.2578652581015776 1.6001336001294e-06 0.2519000449202701 \
1.600133771320538e-06 0.2465102462678049 1.600133946364063e-06 0.2410522141953559 1.600134109381927e-06 0.236036359124031 1.600134270786368e-06 0.2311389431166576 \
1.600134424603758e-06 0.2265774065811171 1.60013457654048e-06 0.2221477024102725 1.600134730763452e-06 0.2177012931700853 1.600134904399052e-06 0.2127672920349684 \
1.600135054516093e-06 0.2085590788965803 1.600135188967813e-06 0.2048346911951331 1.600135333880152e-06 0.2008962005616911 1.600135495414782e-06 0.1965999354189458 \
1.600135644303198e-06 0.1927083727438147 1.600135788543376e-06 0.1889957157254755 1.600135913586714e-06 0.1858267544518093 1.600136010653492e-06 0.183392498065703 \
1.600136145647889e-06 0.1800503036180525 1.600136255162251e-06 0.1773760505692391 1.600136393137778e-06 0.1740872877198338 1.600136513150414e-06 0.1712726271080235 \
1.60013663003209e-06 0.1685704901364905 1.600136756660935e-06 0.1656849030049582 1.600136892675268e-06 0.1626308514974385 1.60013702606177e-06 0.1596764551685698 \
1.600137153003704e-06 0.1569158519548911 1.600137281621738e-06 0.1541678007478876 1.600137395548178e-06 0.1517740356345986 1.600137505859117e-06 0.149496521787741 \
1.60013761900036e-06 0.1472133997668396 1.600137732479436e-06 0.1449590740078549 1.600137857844221e-06 0.1425075003983929 1.600138003638109e-06 0.1397077962434051 \
1.600138186780095e-06 0.1362681166668699 1.6001383353875e-06 0.1335395672637218 1.600138447639322e-06 0.1315146079855561 1.600138576992755e-06 0.1292194206906994 \
1.600138670528911e-06 0.1275846423925092 1.60013877932072e-06 0.1257099890290588 1.600138873074832e-06 0.1241165438085202 1.600138956682436e-06 0.1227229754719547 \
1.6001390763363e-06 0.1207568051616409 1.600139205425262e-06 0.1186746054627577 1.600139322279497e-06 0.1168252031377112 1.600139453368507e-06 0.1147891811469644 \
1.600139598723523e-06 0.1125787883659796 1.600139764133423e-06 0.110121919024741 1.60013993287367e-06 0.1076798417306999 1.600140125753816e-06 0.1049622523271389 \
1.600140299731943e-06 0.1025767092705754 1.600140487918313e-06 0.1000644866129177 1.600140670319411e-06 0.09769892895340802 1.600140849911024e-06 0.09544952095403336 \
1.600141026408427e-06 0.09330553315647841 1.600141210964178e-06 0.09112768523704891 1.600141396209645e-06 0.08900465024544718 1.600141578281057e-06 0.0869768268327742 \
1.600141774345804e-06 0.08485812802288394 1.600141944746222e-06 0.08306894814141007 1.600142122986993e-06 0.08125105909257219 1.600142298679519e-06 0.07951206376949813 \
1.600142499080023e-06 0.07758728548656671 1.600142695934063e-06 0.07575734486890456 1.600142865868499e-06 0.07422427017287291 1.60014303651775e-06 0.07272580243814712 \
1.600143219642496e-06 0.07116311580983979 1.600143413259743e-06 0.06956233824397716 1.600143594846707e-06 0.06811311716920317 1.600143793421027e-06 0.06657819701521293 \
1.600143949952299e-06 0.06540254085633944 1.600144133522745e-06 0.06406078399206196 1.600144306484986e-06 0.06283331112669251 1.600144471995363e-06 0.06169268945721457 \
1.60014462033141e-06 0.06069691796619666 1.600144757229627e-06 0.05979937680937147 1.600144904867328e-06 0.05885633029244827 1.600145037955006e-06 0.05802735218158511 \
1.600145161474142e-06 0.05727448785321319 1.600145277510429e-06 0.05658054160001152 1.600145391123697e-06 0.05591352504042409 1.600145515745172e-06 0.05519553885869784 \
1.600145636542111e-06 0.05451306145814139 1.60014579648583e-06 0.0536298481755812 1.600145931832913e-06 0.05289991373180127 1.600146032152412e-06 0.05236888834064994 \
1.600146132622372e-06 0.05184552065910697 1.600146231565458e-06 0.05133799434906983 1.600146410070021e-06 0.05044349321929222 1.600146509870119e-06 0.04995513630881745 \
1.600146710035568e-06 0.04899962929156078 1.600146800952851e-06 0.04857581029502876 1.600147007746298e-06 0.04763487432244629 1.600147112976431e-06 0.0471681110353394 \
1.600147309354922e-06 0.04631787013837765 1.600147394633218e-06 0.04595693884580357 1.600147575095581e-06 0.04521002446657041 1.600147650260171e-06 0.04490525014776706 \
1.60014786811757e-06 0.0440422972058082 1.600147951636165e-06 0.04372097365614635 1.600148141571271e-06 0.04300637120866019 1.600148266317611e-06 0.04254845761102347 \
1.600148451543579e-06 0.0418846242551883 1.600148554382137e-06 0.04152415866453074 1.600148843894812e-06 0.04053983903151908 1.600148932816407e-06 0.04024621147044882 \
1.60014924148676e-06 0.03925784365481538 1.600149297645764e-06 0.03908306666491448 1.600149611207866e-06 0.03813491809530275 1.600149667163849e-06 0.037970533835152 \
1.600149994078164e-06 0.03703805601095747 1.600150047341397e-06 0.03689043863681411 1.600150353265485e-06 0.03606517121743442 1.600150453429214e-06 0.0358032254974586 \
1.600150772044909e-06 0.03499570355391716 1.600150861523872e-06 0.03477583942316619 1.600151259364458e-06 0.03383675925705845 1.600151377245794e-06 0.03357186655877694 \
1.600151789247958e-06 0.03268299960645597 1.600151949610851e-06 0.03235094877383871 1.600152320629235e-06 0.03161177976826059 1.600152540382686e-06 0.03119164460703521 \
1.600152983766919e-06 0.03038142203317581 1.600153232810551e-06 0.0299476098095271 1.6001537326667e-06 0.02912178892962563 1.600153951558277e-06 0.02877747133829427 \
1.600154434672084e-06 0.02805819238630505 1.600154723499337e-06 0.02765301209416409 1.600155410247302e-06 0.02674723311374961 1.600155699762857e-06 0.02638861276123805 \
1.600156475736136e-06 0.02548835782609031 1.600156647189526e-06 0.02530065249352256 1.60015743327132e-06 0.02449144648051316 1.600157637300354e-06 0.02429465554580218 \
1.600158746898316e-06 0.02329883562822865 1.600158847813389e-06 0.02321388155873386 1.600160039404086e-06 0.02227529349501467 1.600160244312294e-06 0.0221260927003824 \
1.600161697508364e-06 0.02113958380755909 1.600161932492782e-06 0.02098788030205876 1.600163439760696e-06 0.02004942094855779 1.600163760061111e-06 0.01985604392354444 \
1.600164974239457e-06 0.01910354072181233 1.600165447544128e-06 0.01879991394003632 1.600166748677981e-06 0.01794965119692995 1.600167138470568e-06 0.01770179815419311 \
1.600168537018733e-06 0.01679702456340363 1.600168863768813e-06 0.01658609683275075 1.60016998110407e-06 0.01586843585740347 1.600170689790368e-06 0.01544169959229912 \
1.600172422376366e-06 0.01449858640399567 1.600172671838817e-06 0.01436065672582198 1.600174469435716e-06 0.01337694399212387 1.600174812129382e-06 0.01319104500849105 \
1.600176988462895e-06 0.01225973435293598 1.60017727331928e-06 0.01213579497780986 1.600179172162672e-06 0.01126438850740638 1.60017965502513e-06 0.01103474467122418 \
1.600181927520555e-06 0.01014901321627989 1.600182315058726e-06 0.01002270433864562 1.600184966564885e-06 0.009023867700259034 1.600185262768817e-06 0.00890332747207802 \
1.600187604606991e-06 0.00793111507746596 1.600187858191315e-06 0.007825942613114227 1.600190880361057e-06 0.006881067894167194 1.60019112999456e-06 0.006804700431426973 \
1.600195007891808e-06 0.005817006850260108 1.600195235071384e-06 0.005760637946475626 1.600198046189619e-06 0.00490690852483563 1.600198480606374e-06 0.004760206508803379 \
1.600201010366652e-06 0.003858115577918713 1.600201428863181e-06 0.003712016323791173 1.600204453534309e-06 0.00274875962184498 1.600204733759441e-06 0.002664158024812898 \
1.600208530584646e-06 0.001697446565651876 1.600208884963991e-06 0.001621705150764489 1.600214411478997e-06 0.0006347476112661908 1.600214708963481e-06 0.0005888553763099016 \
1.600222216727447e-06 -0.0003928413941844093 1.600222438401114e-06 -0.0004189941252107796 1.600236530784873e-06 -0.001410461992184868 1.600236889612591e-06 -0.001430649730572865 \
1.600250237245412e-06 -0.0004514903228812461 1.600250464642513e-06 -0.0004111859973536986 1.600255915612065e-06 0.0005614551864591434 1.600256178897484e-06 0.0006110884748384679 \
1.600260810837491e-06 0.001592952619583714 1.600261118869639e-06 0.001665522059460669 1.60026495308288e-06 0.002626457037572999 1.600265337382884e-06 0.002733556882532277 \
1.600269071576165e-06 0.003682507088408038 1.600269273441449e-06 0.00374945551670179 1.600272897693538e-06 0.004734851451646972 1.600273092622753e-06 0.004780391513086043 \
1.600276479822177e-06 0.005766866152453508 1.600276671910697e-06 0.005810149709068801 1.600280887542283e-06 0.006750994364636406 1.600281221079492e-06 0.006821678237255247 \
1.600305948540302e-06 0.005867117768706426 1.600306261817208e-06 0.005806676405157672 1.600310893192981e-06 0.004863125825100585 1.600311165044222e-06 0.004806306550559217 \
1.600316109688101e-06 0.003825328200913169 1.600316576141932e-06 0.003739629632037282 1.60032248240585e-06 0.002770751168227681 1.600322776130159e-06 0.002729631326985271 \
1.600331621359071e-06 0.001738601807147118 1.600331808126426e-06 0.001722695496451883 1.600352036959149e-06 0.0007253105668073048 1.600353471598443e-06 0.0006873447391178559 \
1.658990000000011e-06 3.130932490801775e-06 1.661883407830385e-06 -0.0008819623910157972 1.661883643879234e-06 -0.001161970612476729 1.661884102325562e-06 -0.001847355627596629 \
1.661884345612697e-06 -0.002293620068582415 1.661884595896664e-06 -0.00281405583725217 1.661884846702668e-06 -0.003393671496214343 1.66188515952233e-06 -0.004199192998005251 \
1.661885397732202e-06 -0.004872003934560885 1.661885644182635e-06 -0.005621391842385397 1.661885875927131e-06 -0.006370319304257691 1.661886183112249e-06 -0.007411941938624838 \
1.661886448406181e-06 -0.008326397880259807 1.661886693685807e-06 -0.009131457988769647 1.661887058417363e-06 -0.01007334593757064 1.66188728648854e-06 -0.01033898456945748 \
1.661887610128182e-06 -0.009994868194499993 1.661887810544735e-06 -0.009187286872421443 1.661888045349532e-06 -0.007487931918614563 1.661888226424988e-06 -0.005544847192362645 \
1.661888332865277e-06 -0.004119573247771668 1.661888471151424e-06 -0.001940540768574745 1.661888582177386e-06 7.563183370691832e-05 1.661888702798821e-06 0.002536824544301687 \
1.661888805864002e-06 0.004857398676819782 1.661888944571287e-06 0.008289235792766818 1.661889065680579e-06 0.01156496544863939 1.66188921588438e-06 0.01596809792775087 \
1.66188939752999e-06 0.02176080367268303 1.66188954996521e-06 0.02698454055473338 1.661889726115454e-06 0.03339084366291074 1.6618899251156e-06 0.04103368087207344 \
1.661890094787538e-06 0.04784290449723066 1.661890273981514e-06 0.05527749234857952 1.661890434397879e-06 0.06211990493347131 1.661890596191839e-06 0.06916698107316244 \
1.661890754742719e-06 0.07620053909780501 1.661890921935392e-06 0.08372027851346725 1.661891092293318e-06 0.09147114401158042 1.661891271730565e-06 0.0997240648901548 \
1.661891461853091e-06 0.1085375718081032 1.661891661092053e-06 0.1178373860957827 1.661891865069358e-06 0.1274102212870429 1.66189208614423e-06 0.1378300800073513 \
1.6618923318008e-06 0.1494365474357121 1.661892589151043e-06 0.1616443690283554 1.661892871842139e-06 0.1750899465505063 1.66189316989355e-06 0.1892663579759593 \
1.661893516170122e-06 0.2057792515135755 1.66189388288524e-06 0.2232517522030736 1.661894278797487e-06 0.2421754728923703 1.661894713908853e-06 0.2629945242020292 \
1.66189519371884e-06 0.2859861135989593 1.6618957190371e-06 0.3113450809673837 1.661896243573264e-06 0.3367514755549041 1.661896840892739e-06 0.3658546932050024 \
1.661897607717859e-06 0.4033613755922033 1.661898046206797e-06 0.4246376380793622 1.661898522720377e-06 0.4473946242989675 1.661898972555967e-06 0.4684360091747882 \
1.661899525240159e-06 0.4936960927629759 1.661900223236364e-06 0.5245486808074998 1.661900837638476e-06 0.5507582774516211 1.661901405608978e-06 0.5741722555225199 \
1.661901935862248e-06 0.5952266004882081 1.661902394831628e-06 0.6128068198589096 1.661902977999792e-06 0.6341908714213341 1.661903551157707e-06 0.6541368834277531 \
1.661904141842032e-06 0.6735006351351156 1.661904810515341e-06 0.6939224431220803 1.661905465000487e-06 0.7123419857223411 1.661906218631611e-06 0.7316435145596337 \
1.661907138111349e-06 0.7524771687756806 1.661907807118464e-06 0.7658582308664672 1.661908502684848e-06 0.7783426900018873 1.661909224721799e-06 0.7898435797332509 \
1.661909871505064e-06 0.7989777190578581 1.661910686398373e-06 0.809051394855074 1.661911344291083e-06 0.8161084932798452 1.661912109055577e-06 0.8232971874420545 \
1.661912705588939e-06 0.8281915934352191 1.661913333612095e-06 0.8327857747397983 1.661913964004405e-06 0.8368636793792511 1.66191494962664e-06 0.8423301485602825 \
1.661915705380696e-06 0.8458701801587535 1.661916468671131e-06 0.8489683054605098 1.661917277011917e-06 0.8518111549479527 1.661918265903366e-06 0.8547854532963984 \
1.661919008958979e-06 0.8567085856698495 1.661919831636168e-06 0.8585940601366741 1.661920612856223e-06 0.8601698380186774 1.661921416459391e-06 0.8616111415036141 \
1.661922203727638e-06 0.8628649505886673 1.661923395730052e-06 0.8644986110026872 1.661924318352036e-06 0.8655887935537701 1.661925377279772e-06 0.8666437563732095 \
1.661926250370494e-06 0.8673888282159752 1.661927019427764e-06 0.8679394432393451 1.6619327760832e-06 0.8675354626998435 1.661933384736608e-06 0.8669285211992742 \
1.661934348633067e-06 0.8661637309277684 1.661934697027123e-06 0.8657877651307159 1.661935865736297e-06 0.8648718022682493 1.661936507439083e-06 0.8645495171393598 \
1.661937723779243e-06 0.8636149212264693 1.661938210995997e-06 0.8633315979857124 1.661941995751513e-06 0.8637879096652611 1.661942803560594e-06 0.8644940879742092 \
1.661943676731311e-06 0.8654118536506241 1.66194452584852e-06 0.8664722967159353 1.661945394320663e-06 0.8676408136092975 1.661946220799482e-06 0.8688316482847912 \
1.661947067273748e-06 0.8700680498371385 1.661947993731666e-06 0.8714353201417473 1.661948922751738e-06 0.8727967357236968 1.661949890373816e-06 0.874169309418928 \
1.661950892855429e-06 0.8755268793700145 1.661951975786211e-06 0.8769279254876977 1.661953154258897e-06 0.8783524184654903 1.661954367359833e-06 0.8797057189093218 \
1.661955697820692e-06 0.8810544625232946 1.661957146531982e-06 0.8823882385150326 1.661958814266774e-06 0.8837386794148741 1.661960446298639e-06 0.8848798336526329 \
1.661962413590838e-06 0.8860652157953401 1.661964590094435e-06 0.8871729764751287 1.661966862249877e-06 0.8881691778223457 1.661969135754955e-06 0.8889896378135498 \
1.661971087665695e-06 0.8895771814349003 1.661973972100292e-06 0.8902862350409186 1.661976831036635e-06 0.8908501300162286 1.661979913323748e-06 0.8913157385816455 \
1.66199173167453e-06 0.8922670755128276 1.661994058318611e-06 0.8924600956555456 1.662000939517426e-06 0.8933233934443291 1.662002931772882e-06 0.8936033182227321 \
1.662007596963998e-06 0.8943294235126149 1.662009934973581e-06 0.894763749611499 1.66201243532077e-06 0.8952990768365913 1.662014909223274e-06 0.8959385502707948 \
1.662017035318026e-06 0.8965630758105964 1.662019624621494e-06 0.8973958942958599 1.662022048641129e-06 0.8982427248493853 1.662024940455553e-06 0.8993469797885378 \
1.662027450127073e-06 0.9003588137389537 1.662030788570323e-06 0.9017079510157455 1.662033867543754e-06 0.9029423170929788 1.662037060622869e-06 0.9042497182071535 \
1.662039656279508e-06 0.9052493492427333 1.662041664531596e-06 0.9059572885738179 1.662043772760482e-06 0.9066594295388942 1.662046461477417e-06 0.907478492737931 \
1.662048917070081e-06 0.9081366525620301 1.662051281590183e-06 0.9087089258990763 1.662053876154591e-06 0.9092804446275633 1.662056243869825e-06 0.9097121154337445 \
1.662063636309535e-06 0.9105880439508957 1.66206694738543e-06 0.9108097973553667 1.662090631104211e-06 0.9099572430838525 1.662093524994068e-06 0.9096028008700563 \
1.662099633721785e-06 0.9087795762164674 1.662102664784937e-06 0.9083311497095887 1.662109022442901e-06 0.9073557537429059 1.662112916389034e-06 0.906719613226565 \
1.662116289356866e-06 0.9061475060281556 1.662119374914729e-06 0.9055946669458763 1.662123120629277e-06 0.9048996522446952 1.662126487017035e-06 0.9043394102803256 \
1.662134077462241e-06 0.9034499723753743 1.662137953472777e-06 0.9031904105967781 1.662165717708862e-06 0.9022140906736803 1.662169493868779e-06 0.902100877529562 \
1.662200910100546e-06 0.9011025155537421 1.662207545190393e-06 0.9009020504869808 1.700110550805801e-06 0.8999193627810952 1.70011071848179e-06 0.8998913840591389 \
1.700113467033027e-06 0.8989010293823864 1.700113523573982e-06 0.8988795941121664 1.700114768178511e-06 0.8998357618405769 1.700114847007516e-06 0.9000722811707415 \
1.700115028967665e-06 0.9007374088026997 1.70011513130788e-06 0.9011852075627013 1.70011532428406e-06 0.9021545909398002 1.700115412645943e-06 0.9026487433775175 \
1.700115571157198e-06 0.9036053969378676 1.700115683054862e-06 0.9043311123122415 1.700115823971993e-06 0.9052897461292233 1.700115929405144e-06 0.9060407976354218 \
1.700116042282182e-06 0.9068700067857125 1.700116156714019e-06 0.9077320749581511 1.700116277994792e-06 0.9086625635419388 1.700116407030339e-06 0.9096610759972766 \
1.700116529569199e-06 0.9106054665418637 1.70011665392414e-06 0.9115433813509556 1.700116768824237e-06 0.912370851358936 1.700116872924634e-06 0.9130668181210778 \
1.700116980506906e-06 0.9137127811079708 1.700117148007135e-06 0.914504286313051 1.700117619367398e-06 0.9145217838087505 1.700117817316352e-06 0.9131640269569251 \
1.700117978090595e-06 0.9113346267648944 1.700118066395334e-06 0.910041664336402 1.700118153928761e-06 0.908567258693449 1.700118246820306e-06 0.9067913249607207 \
1.700118320262759e-06 0.9052411278657534 1.700118409009881e-06 0.9032017134587504 1.700118546653074e-06 0.8996915735089056 1.700118658994696e-06 0.8965314120175644 \
1.700118782291717e-06 0.892778172623249 1.700118938496376e-06 0.8876402979533503 1.700119062012361e-06 0.8833010177194197 1.700119232383792e-06 0.8769686903427227 \
1.700119380003419e-06 0.8711968848515086 1.700119531854558e-06 0.8650238565011712 1.700119667983612e-06 0.8593172646418706 1.700119810047228e-06 0.8532105227807962 \
1.700119945331887e-06 0.8472784593397693 1.700120083991258e-06 0.8411010749315838 1.70012023129828e-06 0.8344514077702887 1.700120377865128e-06 0.8277635723525925 \
1.700120539944527e-06 0.8202964899226535 1.700120687311172e-06 0.8134532267615989 1.70012085882447e-06 0.8054479178086997 1.700121042247436e-06 0.7968539002302991 \
1.700121244752722e-06 0.7873346372610658 1.700121456402384e-06 0.7773555108975432 1.700121677392943e-06 0.7669228693561837 1.70012190658697e-06 0.7561055044419139 \
1.700122183106921e-06 0.743046509132553 1.700122468593645e-06 0.7295848836660939 1.700122789908539e-06 0.7144535604611002 1.700123079378459e-06 0.7008559708795014 \
1.700123398648317e-06 0.6858669291494816 1.700123719663687e-06 0.6708097907125149 1.700124061099719e-06 0.654842287100785 1.700124453723407e-06 0.6364912117266992 \
1.700124808317996e-06 0.6199451687359452 1.700125173105078e-06 0.602895395464039 1.70012557692179e-06 0.5840362041416589 1.700125940450357e-06 0.56705803755797 \
1.700126371026893e-06 0.546963725974103 1.700126727188766e-06 0.5303181638661557 1.700127100198166e-06 0.5128834705750704 1.700127442383275e-06 0.4969084729771704 \
1.700127762124838e-06 0.4820272854775881 1.700128079868868e-06 0.4673068400017517 1.70012837572031e-06 0.453709089639897 1.700128703744139e-06 0.4388357619204879 \
1.700129013234577e-06 0.4250513307906954 1.700129299733975e-06 0.412542701771394 1.700129612088515e-06 0.3991541929604193 1.700129902199714e-06 0.3870087322563178 \
1.700130215665733e-06 0.3741657412501236 1.700130493028614e-06 0.3630444214925196 1.700130774126111e-06 0.3519744117192101 1.700131005607363e-06 0.3430374849397334 \
1.700131234174756e-06 0.3343354151638595 1.70013147406666e-06 0.3253394991495989 1.700131731848444e-06 0.3158318026516087 1.700131981218358e-06 0.3067925439309827 \
1.700132239531266e-06 0.297589150170473 1.700132486062287e-06 0.2889540805256016 1.700132773357043e-06 0.2790758510850415 1.700132996736124e-06 0.2715471379396955 \
1.700133217531486e-06 0.2642409610398131 1.70013341340532e-06 0.2578652581015776 1.7001336001294e-06 0.2519000449202701 1.700133771320538e-06 0.2465102462678049 \
1.700133946364063e-06 0.2410522141953559 1.700134109381927e-06 0.236036359124031 1.700134270786368e-06 0.2311389431166576 1.700134424603758e-06 0.2265774065811171 \
1.70013457654048e-06 0.2221477024102725 1.700134730763452e-06 0.2177012931700853 1.700134904399052e-06 0.2127672920349684 1.700135054516093e-06 0.2085590788965803 \
1.700135188967813e-06 0.2048346911951331 1.700135333880152e-06 0.2008962005616911 1.700135495414782e-06 0.1965999354189458 1.700135644303198e-06 0.1927083727438147 \
1.700135788543376e-06 0.1889957157254755 1.700135913586713e-06 0.1858267544518093 1.700136010653492e-06 0.183392498065703 1.700136145647889e-06 0.1800503036180525 \
1.700136255162251e-06 0.1773760505692391 1.700136393137778e-06 0.1740872877198338 1.700136513150413e-06 0.1712726271080235 1.70013663003209e-06 0.1685704901364905 \
1.700136756660935e-06 0.1656849030049582 1.700136892675268e-06 0.1626308514974385 1.70013702606177e-06 0.1596764551685698 1.700137153003703e-06 0.1569158519548911 \
1.700137281621738e-06 0.1541678007478876 1.700137395548178e-06 0.1517740356345986 1.700137505859117e-06 0.149496521787741 1.70013761900036e-06 0.1472133997668396 \
1.700137732479436e-06 0.1449590740078549 1.700137857844221e-06 0.1425075003983929 1.700138003638108e-06 0.1397077962434051 1.700138186780095e-06 0.1362681166668699 \
1.7001383353875e-06 0.1335395672637218 1.700138447639322e-06 0.1315146079855561 1.700138576992755e-06 0.1292194206906994 1.700138670528911e-06 0.1275846423925092 \
1.70013877932072e-06 0.1257099890290588 1.700138873074831e-06 0.1241165438085202 1.700138956682435e-06 0.1227229754719547 1.7001390763363e-06 0.1207568051616409 \
1.700139205425261e-06 0.1186746054627577 1.700139322279497e-06 0.1168252031377112 1.700139453368507e-06 0.1147891811469644 1.700139598723523e-06 0.1125787883659796 \
1.700139764133423e-06 0.110121919024741 1.70013993287367e-06 0.1076798417306999 1.700140125753815e-06 0.1049622523271389 1.700140299731943e-06 0.1025767092705754 \
1.700140487918313e-06 0.1000644866129177 1.700140670319411e-06 0.09769892895340802 1.700140849911024e-06 0.09544952095403336 1.700141026408427e-06 0.09330553315647841 \
1.700141210964177e-06 0.09112768523704891 1.700141396209645e-06 0.08900465024544718 1.700141578281057e-06 0.0869768268327742 1.700141774345804e-06 0.08485812802288394 \
1.700141944746222e-06 0.08306894814141007 1.700142122986993e-06 0.08125105909257219 1.700142298679519e-06 0.07951206376949813 1.700142499080023e-06 0.07758728548656671 \
1.700142695934063e-06 0.07575734486890456 1.700142865868499e-06 0.07422427017287291 1.70014303651775e-06 0.07272580243814712 1.700143219642496e-06 0.07116311580983979 \
1.700143413259743e-06 0.06956233824397716 1.700143594846707e-06 0.06811311716920317 1.700143793421027e-06 0.06657819701521293 1.700143949952299e-06 0.06540254085633944 \
1.700144133522745e-06 0.06406078399206196 1.700144306484985e-06 0.06283331112669251 1.700144471995362e-06 0.06169268945721457 1.70014462033141e-06 0.06069691796619666 \
1.700144757229627e-06 0.05979937680937147 1.700144904867328e-06 0.05885633029244827 1.700145037955006e-06 0.05802735218158511 1.700145161474142e-06 0.05727448785321319 \
1.700145277510429e-06 0.05658054160001152 1.700145391123697e-06 0.05591352504042409 1.700145515745172e-06 0.05519553885869784 1.700145636542111e-06 0.05451306145814139 \
1.70014579648583e-06 0.0536298481755812 1.700145931832913e-06 0.05289991373180127 1.700146032152412e-06 0.05236888834064994 1.700146132622372e-06 0.05184552065910697 \
1.700146231565458e-06 0.05133799434906983 1.70014641007002e-06 0.05044349321929222 1.700146509870119e-06 0.04995513630881745 1.700146710035568e-06 0.04899962929156078 \
1.700146800952851e-06 0.04857581029502876 1.700147007746298e-06 0.04763487432244629 1.70014711297643e-06 0.0471681110353394 1.700147309354922e-06 0.04631787013837765 \
1.700147394633218e-06 0.04595693884580357 1.700147575095581e-06 0.04521002446657041 1.700147650260171e-06 0.04490525014776706 1.70014786811757e-06 0.0440422972058082 \
1.700147951636165e-06 0.04372097365614635 1.700148141571271e-06 0.04300637120866019 1.70014826631761e-06 0.04254845761102347 1.700148451543578e-06 0.0418846242551883 \
1.700148554382137e-06 0.04152415866453074 1.700148843894812e-06 0.04053983903151908 1.700148932816406e-06 0.04024621147044882 1.70014924148676e-06 0.03925784365481538 \
1.700149297645764e-06 0.03908306666491448 1.700149611207866e-06 0.03813491809530275 1.700149667163848e-06 0.037970533835152 1.700149994078164e-06 0.03703805601095747 \
1.700150047341397e-06 0.03689043863681411 1.700150353265485e-06 0.03606517121743442 1.700150453429213e-06 0.0358032254974586 1.700150772044909e-06 0.03499570355391716 \
1.700150861523872e-06 0.03477583942316619 1.700151259364458e-06 0.03383675925705845 1.700151377245794e-06 0.03357186655877694 1.700151789247958e-06 0.03268299960645597 \
1.70015194961085e-06 0.03235094877383871 1.700152320629234e-06 0.03161177976826059 1.700152540382686e-06 0.03119164460703521 1.700152983766919e-06 0.03038142203317581 \
1.700153232810551e-06 0.0299476098095271 1.7001537326667e-06 0.02912178892962563 1.700153951558277e-06 0.02877747133829427 1.700154434672084e-06 0.02805819238630505 \
1.700154723499337e-06 0.02765301209416409 1.700155410247302e-06 0.02674723311374961 1.700155699762857e-06 0.02638861276123805 1.700156475736135e-06 0.02548835782609031 \
1.700156647189526e-06 0.02530065249352256 1.70015743327132e-06 0.02449144648051316 1.700157637300353e-06 0.02429465554580218 1.700158746898316e-06 0.02329883562822865 \
1.700158847813389e-06 0.02321388155873386 1.700160039404086e-06 0.02227529349501467 1.700160244312293e-06 0.0221260927003824 1.700161697508364e-06 0.02113958380755909 \
1.700161932492782e-06 0.02098788030205876 1.700163439760696e-06 0.02004942094855779 1.700163760061111e-06 0.01985604392354444 1.700164974239456e-06 0.01910354072181233 \
1.700165447544128e-06 0.01879991394003632 1.700166748677981e-06 0.01794965119692995 1.700167138470568e-06 0.01770179815419311 1.700168537018733e-06 0.01679702456340363 \
1.700168863768812e-06 0.01658609683275075 1.70016998110407e-06 0.01586843585740347 1.700170689790367e-06 0.01544169959229912 1.700172422376366e-06 0.01449858640399567 \
1.700172671838817e-06 0.01436065672582198 1.700174469435716e-06 0.01337694399212387 1.700174812129382e-06 0.01319104500849105 1.700176988462895e-06 0.01225973435293598 \
1.70017727331928e-06 0.01213579497780986 1.700179172162672e-06 0.01126438850740638 1.70017965502513e-06 0.01103474467122418 1.700181927520555e-06 0.01014901321627989 \
1.700182315058726e-06 0.01002270433864562 1.700184966564885e-06 0.009023867700259034 1.700185262768817e-06 0.00890332747207802 1.700187604606991e-06 0.00793111507746596 \
1.700187858191315e-06 0.007825942613114227 1.700190880361057e-06 0.006881067894167194 1.70019112999456e-06 0.006804700431426973 1.700195007891808e-06 0.005817006850260108 \
1.700195235071384e-06 0.005760637946475626 1.700198046189619e-06 0.00490690852483563 1.700198480606374e-06 0.004760206508803379 1.700201010366652e-06 0.003858115577918713 \
1.700201428863181e-06 0.003712016323791173 1.700204453534309e-06 0.00274875962184498 1.700204733759441e-06 0.002664158024812898 1.700208530584646e-06 0.001697446565651876 \
1.700208884963991e-06 0.001621705150764489 1.700214411478996e-06 0.0006347476112661908 1.700214708963481e-06 0.0005888553763099016 1.700222216727447e-06 -0.0003928413941844093 \
1.700222438401114e-06 -0.0004189941252107796 1.700236530784873e-06 -0.001410461992184868 1.700236889612591e-06 -0.001430649730572865 1.700250237245412e-06 -0.0004514903228812461 \
1.700250464642513e-06 -0.0004111859973536986 1.700255915612065e-06 0.0005614551864591434 1.700256178897484e-06 0.0006110884748384679 1.700260810837491e-06 0.001592952619583714 \
1.700261118869639e-06 0.001665522059460669 1.70026495308288e-06 0.002626457037572999 1.700265337382884e-06 0.002733556882532277 1.700269071576165e-06 0.003682507088408038 \
1.700269273441448e-06 0.00374945551670179 1.700272897693538e-06 0.004734851451646972 1.700273092622753e-06 0.004780391513086043 1.700276479822177e-06 0.005766866152453508 \
1.700276671910697e-06 0.005810149709068801 1.700280887542283e-06 0.006750994364636406 1.700281221079492e-06 0.006821678237255247 1.700305948540302e-06 0.005867117768706426 \
1.700306261817208e-06 0.005806676405157672 1.700310893192981e-06 0.004863125825100585 1.700311165044221e-06 0.004806306550559217 1.7003161096881e-06 0.003825328200913169 \
1.700316576141932e-06 0.003739629632037282 1.70032248240585e-06 0.002770751168227681 1.700322776130159e-06 0.002729631326985271 1.700331621359071e-06 0.001738601807147118 \
1.700331808126426e-06 0.001722695496451883 1.700352036959148e-06 0.0007253105668073048 1.700353471598443e-06 0.0006873447391178559 1.758990000000011e-06 3.130932490801775e-06 \
1.761883407830385e-06 -0.0008819623910157972 1.761883643879234e-06 -0.001161970612476729 1.761884102325562e-06 -0.001847355627596629 1.761884345612697e-06 -0.002293620068582415 \
1.761884595896664e-06 -0.00281405583725217 1.761884846702668e-06 -0.003393671496214343 1.76188515952233e-06 -0.004199192998005251 1.761885397732201e-06 -0.004872003934560885 \
1.761885644182635e-06 -0.005621391842385397 1.761885875927131e-06 -0.006370319304257691 1.761886183112249e-06 -0.007411941938624838 1.761886448406181e-06 -0.008326397880259807 \
1.761886693685807e-06 -0.009131457988769647 1.761887058417362e-06 -0.01007334593757064 1.761887286488539e-06 -0.01033898456945748 1.761887610128182e-06 -0.009994868194499993 \
1.761887810544735e-06 -0.009187286872421443 1.761888045349532e-06 -0.007487931918614563 1.761888226424987e-06 -0.005544847192362645 1.761888332865277e-06 -0.004119573247771668 \
1.761888471151424e-06 -0.001940540768574745 1.761888582177386e-06 7.563183370691832e-05 1.761888702798821e-06 0.002536824544301687 1.761888805864002e-06 0.004857398676819782 \
1.761888944571287e-06 0.008289235792766818 1.761889065680579e-06 0.01156496544863939 1.76188921588438e-06 0.01596809792775087 1.76188939752999e-06 0.02176080367268303 \
1.761889549965209e-06 0.02698454055473338 1.761889726115454e-06 0.03339084366291074 1.7618899251156e-06 0.04103368087207344 1.761890094787538e-06 0.04784290449723066 \
1.761890273981514e-06 0.05527749234857952 1.761890434397879e-06 0.06211990493347131 1.761890596191839e-06 0.06916698107316244 1.761890754742719e-06 0.07620053909780501 \
1.761890921935392e-06 0.08372027851346725 1.761891092293318e-06 0.09147114401158042 1.761891271730565e-06 0.0997240648901548 1.761891461853091e-06 0.1085375718081032 \
1.761891661092053e-06 0.1178373860957827 1.761891865069358e-06 0.1274102212870429 1.76189208614423e-06 0.1378300800073513 1.7618923318008e-06 0.1494365474357121 \
1.761892589151043e-06 0.1616443690283554 1.761892871842139e-06 0.1750899465505063 1.76189316989355e-06 0.1892663579759593 1.761893516170121e-06 0.2057792515135755 \
1.76189388288524e-06 0.2232517522030736 1.761894278797486e-06 0.2421754728923703 1.761894713908853e-06 0.2629945242020292 1.76189519371884e-06 0.2859861135989593 \
1.7618957190371e-06 0.3113450809673837 1.761896243573264e-06 0.3367514755549041 1.761896840892739e-06 0.3658546932050024 1.761897607717859e-06 0.4033613755922033 \
1.761898046206797e-06 0.4246376380793622 1.761898522720377e-06 0.4473946242989675 1.761898972555967e-06 0.4684360091747882 1.761899525240159e-06 0.4936960927629759 \
1.761900223236364e-06 0.5245486808074998 1.761900837638476e-06 0.5507582774516211 1.761901405608978e-06 0.5741722555225199 1.761901935862248e-06 0.5952266004882081 \
1.761902394831628e-06 0.6128068198589096 1.761902977999792e-06 0.6341908714213341 1.761903551157707e-06 0.6541368834277531 1.761904141842032e-06 0.6735006351351156 \
1.761904810515341e-06 0.6939224431220803 1.761905465000487e-06 0.7123419857223411 1.761906218631611e-06 0.7316435145596337 1.761907138111349e-06 0.7524771687756806 \
1.761907807118464e-06 0.7658582308664672 1.761908502684848e-06 0.7783426900018873 1.761909224721799e-06 0.7898435797332509 1.761909871505064e-06 0.7989777190578581 \
1.761910686398373e-06 0.809051394855074 1.761911344291083e-06 0.8161084932798452 1.761912109055577e-06 0.8232971874420545 1.761912705588939e-06 0.8281915934352191 \
1.761913333612095e-06 0.8327857747397983 1.761913964004405e-06 0.8368636793792511 1.76191494962664e-06 0.8423301485602825 1.761915705380696e-06 0.8458701801587535 \
1.761916468671131e-06 0.8489683054605098 1.761917277011917e-06 0.8518111549479527 1.761918265903366e-06 0.8547854532963984 1.761919008958979e-06 0.8567085856698495 \
1.761919831636168e-06 0.8585940601366741 1.761920612856223e-06 0.8601698380186774 1.761921416459391e-06 0.8616111415036141 1.761922203727638e-06 0.8628649505886673 \
1.761923395730052e-06 0.8644986110026872 1.761924318352036e-06 0.8655887935537701 1.761925377279772e-06 0.8666437563732095 1.761926250370494e-06 0.8673888282159752 \
1.761927019427764e-06 0.8679394432393451 1.7619327760832e-06 0.8675354626998435 1.761933384736608e-06 0.8669285211992742 1.761934348633067e-06 0.8661637309277684 \
1.761934697027123e-06 0.8657877651307159 1.761935865736297e-06 0.8648718022682493 1.761936507439083e-06 0.8645495171393598 1.761937723779243e-06 0.8636149212264693 \
1.761938210995997e-06 0.8633315979857124 1.761941995751513e-06 0.8637879096652611 1.761942803560593e-06 0.8644940879742092 1.761943676731311e-06 0.8654118536506241 \
1.76194452584852e-06 0.8664722967159353 1.761945394320663e-06 0.8676408136092975 1.761946220799482e-06 0.8688316482847912 1.761947067273748e-06 0.8700680498371385 \
1.761947993731666e-06 0.8714353201417473 1.761948922751738e-06 0.8727967357236968 1.761949890373816e-06 0.874169309418928 1.761950892855429e-06 0.8755268793700145 \
1.761951975786211e-06 0.8769279254876977 1.761953154258897e-06 0.8783524184654903 1.761954367359833e-06 0.8797057189093218 1.761955697820692e-06 0.8810544625232946 \
1.761957146531982e-06 0.8823882385150326 1.761958814266774e-06 0.8837386794148741 1.761960446298639e-06 0.8848798336526329 1.761962413590838e-06 0.8860652157953401 \
1.761964590094435e-06 0.8871729764751287 1.761966862249877e-06 0.8881691778223457 1.761969135754955e-06 0.8889896378135498 1.761971087665695e-06 0.8895771814349003 \
1.761973972100292e-06 0.8902862350409186 1.761976831036635e-06 0.8908501300162286 1.761979913323748e-06 0.8913157385816455 1.76199173167453e-06 0.8922670755128276 \
1.761994058318611e-06 0.8924600956555456 1.762000939517426e-06 0.8933233934443291 1.762002931772882e-06 0.8936033182227321 1.762007596963998e-06 0.8943294235126149 \
1.762009934973581e-06 0.894763749611499 1.76201243532077e-06 0.8952990768365913 1.762014909223274e-06 0.8959385502707948 1.762017035318025e-06 0.8965630758105964 \
1.762019624621494e-06 0.8973958942958599 1.762022048641129e-06 0.8982427248493853 1.762024940455552e-06 0.8993469797885378 1.762027450127073e-06 0.9003588137389537 \
1.762030788570323e-06 0.9017079510157455 1.762033867543754e-06 0.9029423170929788 1.762037060622869e-06 0.9042497182071535 1.762039656279508e-06 0.9052493492427333 \
1.762041664531596e-06 0.9059572885738179 1.762043772760482e-06 0.9066594295388942 1.762046461477417e-06 0.907478492737931 1.762048917070081e-06 0.9081366525620301 \
1.762051281590183e-06 0.9087089258990763 1.762053876154591e-06 0.9092804446275633 1.762056243869825e-06 0.9097121154337445 1.762063636309535e-06 0.9105880439508957 \
1.76206694738543e-06 0.9108097973553667 1.762090631104211e-06 0.9099572430838525 1.762093524994068e-06 0.9096028008700563 1.762099633721785e-06 0.9087795762164674 \
1.762102664784937e-06 0.9083311497095887 1.762109022442901e-06 0.9073557537429059 1.762112916389034e-06 0.906719613226565 1.762116289356866e-06 0.9061475060281556 \
1.762119374914729e-06 0.9055946669458763 1.762123120629277e-06 0.9048996522446952 1.762126487017035e-06 0.9043394102803256 1.762134077462241e-06 0.9034499723753743 \
1.762137953472777e-06 0.9031904105967781 1.762165717708862e-06 0.9022140906736803 1.762169493868778e-06 0.902100877529562 1.762200910100546e-06 0.9011025155537421 \
1.762207545190393e-06 0.9009020504869808 1.800110550805801e-06 0.8999193627810952 1.80011071848179e-06 0.8998913840591389 1.800113467033027e-06 0.8989010293823864 \
1.800113523573982e-06 0.8988795941121664 1.800114768178511e-06 0.8998357618405769 1.800114847007516e-06 0.9000722811707415 1.800115028967664e-06 0.9007374088026997 \
1.80011513130788e-06 0.9011852075627013 1.80011532428406e-06 0.9021545909398002 1.800115412645943e-06 0.9026487433775175 1.800115571157197e-06 0.9036053969378676 \
1.800115683054862e-06 0.9043311123122415 1.800115823971993e-06 0.9052897461292233 1.800115929405144e-06 0.9060407976354218 1.800116042282182e-06 0.9068700067857125 \
1.800116156714019e-06 0.9077320749581511 1.800116277994792e-06 0.9086625635419388 1.800116407030339e-06 0.9096610759972766 1.800116529569199e-06 0.9106054665418637 \
1.80011665392414e-06 0.9115433813509556 1.800116768824237e-06 0.912370851358936 1.800116872924634e-06 0.9130668181210778 1.800116980506906e-06 0.9137127811079708 \
1.800117148007135e-06 0.914504286313051 1.800117619367398e-06 0.9145217838087505 1.800117817316352e-06 0.9131640269569251 1.800117978090595e-06 0.9113346267648944 \
1.800118066395334e-06 0.910041664336402 1.800118153928761e-06 0.908567258693449 1.800118246820306e-06 0.9067913249607207 1.800118320262759e-06 0.9052411278657534 \
1.800118409009881e-06 0.9032017134587504 1.800118546653074e-06 0.8996915735089056 1.800118658994696e-06 0.8965314120175644 1.800118782291717e-06 0.892778172623249 \
1.800118938496376e-06 0.8876402979533503 1.800119062012361e-06 0.8833010177194197 1.800119232383792e-06 0.8769686903427227 1.800119380003419e-06 0.8711968848515086 \
1.800119531854558e-06 0.8650238565011712 1.800119667983612e-06 0.8593172646418706 1.800119810047228e-06 0.8532105227807962 1.800119945331887e-06 0.8472784593397693 \
1.800120083991258e-06 0.8411010749315838 1.80012023129828e-06 0.8344514077702887 1.800120377865128e-06 0.8277635723525925 1.800120539944527e-06 0.8202964899226535 \
1.800120687311172e-06 0.8134532267615989 1.80012085882447e-06 0.8054479178086997 1.800121042247436e-06 0.7968539002302991 1.800121244752722e-06 0.7873346372610658 \
1.800121456402384e-06 0.7773555108975432 1.800121677392943e-06 0.7669228693561837 1.80012190658697e-06 0.7561055044419139 1.800122183106921e-06 0.743046509132553 \
1.800122468593645e-06 0.7295848836660939 1.800122789908538e-06 0.7144535604611002 1.800123079378459e-06 0.7008559708795014 1.800123398648317e-06 0.6858669291494816 \
1.800123719663687e-06 0.6708097907125149 1.800124061099719e-06 0.654842287100785 1.800124453723407e-06 0.6364912117266992 1.800124808317996e-06 0.6199451687359452 \
1.800125173105078e-06 0.602895395464039 1.80012557692179e-06 0.5840362041416589 1.800125940450356e-06 0.56705803755797 1.800126371026893e-06 0.546963725974103 \
1.800126727188766e-06 0.5303181638661557 1.800127100198165e-06 0.5128834705750704 1.800127442383275e-06 0.4969084729771704 1.800127762124838e-06 0.4820272854775881 \
1.800128079868868e-06 0.4673068400017517 1.80012837572031e-06 0.453709089639897 1.800128703744139e-06 0.4388357619204879 1.800129013234576e-06 0.4250513307906954 \
1.800129299733975e-06 0.412542701771394 1.800129612088515e-06 0.3991541929604193 1.800129902199714e-06 0.3870087322563178 1.800130215665733e-06 0.3741657412501236 \
1.800130493028614e-06 0.3630444214925196 1.800130774126111e-06 0.3519744117192101 1.800131005607363e-06 0.3430374849397334 1.800131234174756e-06 0.3343354151638595 \
1.80013147406666e-06 0.3253394991495989 1.800131731848444e-06 0.3158318026516087 1.800131981218357e-06 0.3067925439309827 1.800132239531266e-06 0.297589150170473 \
1.800132486062287e-06 0.2889540805256016 1.800132773357043e-06 0.2790758510850415 1.800132996736124e-06 0.2715471379396955 1.800133217531486e-06 0.2642409610398131 \
1.80013341340532e-06 0.2578652581015776 1.8001336001294e-06 0.2519000449202701 1.800133771320538e-06 0.2465102462678049 1.800133946364063e-06 0.2410522141953559 \
1.800134109381927e-06 0.236036359124031 1.800134270786368e-06 0.2311389431166576 1.800134424603758e-06 0.2265774065811171 1.80013457654048e-06 0.2221477024102725 \
1.800134730763452e-06 0.2177012931700853 1.800134904399052e-06 0.2127672920349684 1.800135054516093e-06 0.2085590788965803 1.800135188967813e-06 0.2048346911951331 \
1.800135333880152e-06 0.2008962005616911 1.800135495414781e-06 0.1965999354189458 1.800135644303198e-06 0.1927083727438147 1.800135788543376e-06 0.1889957157254755 \
1.800135913586713e-06 0.1858267544518093 1.800136010653492e-06 0.183392498065703 1.800136145647889e-06 0.1800503036180525 1.80013625516225e-06 0.1773760505692391 \
1.800136393137778e-06 0.1740872877198338 1.800136513150413e-06 0.1712726271080235 1.80013663003209e-06 0.1685704901364905 1.800136756660935e-06 0.1656849030049582 \
1.800136892675268e-06 0.1626308514974385 1.80013702606177e-06 0.1596764551685698 1.800137153003703e-06 0.1569158519548911 1.800137281621738e-06 0.1541678007478876 \
1.800137395548178e-06 0.1517740356345986 1.800137505859117e-06 0.149496521787741 1.800137619000359e-06 0.1472133997668396 1.800137732479435e-06 0.1449590740078549 \
1.800137857844221e-06 0.1425075003983929 1.800138003638108e-06 0.1397077962434051 1.800138186780095e-06 0.1362681166668699 1.8001383353875e-06 0.1335395672637218 \
1.800138447639322e-06 0.1315146079855561 1.800138576992754e-06 0.1292194206906994 1.800138670528911e-06 0.1275846423925092 1.80013877932072e-06 0.1257099890290588 \
1.800138873074831e-06 0.1241165438085202 1.800138956682435e-06 0.1227229754719547 1.8001390763363e-06 0.1207568051616409 1.800139205425261e-06 0.1186746054627577 \
1.800139322279497e-06 0.1168252031377112 1.800139453368507e-06 0.1147891811469644 1.800139598723522e-06 0.1125787883659796 1.800139764133423e-06 0.110121919024741 \
1.80013993287367e-06 0.1076798417306999 1.800140125753815e-06 0.1049622523271389 1.800140299731943e-06 0.1025767092705754 1.800140487918313e-06 0.1000644866129177 \
1.80014067031941e-06 0.09769892895340802 1.800140849911024e-06 0.09544952095403336 1.800141026408427e-06 0.09330553315647841 1.800141210964177e-06 0.09112768523704891 \
1.800141396209645e-06 0.08900465024544718 1.800141578281057e-06 0.0869768268327742 1.800141774345804e-06 0.08485812802288394 1.800141944746221e-06 0.08306894814141007 \
1.800142122986992e-06 0.08125105909257219 1.800142298679519e-06 0.07951206376949813 1.800142499080023e-06 0.07758728548656671 1.800142695934063e-06 0.07575734486890456 \
1.800142865868499e-06 0.07422427017287291 1.80014303651775e-06 0.07272580243814712 1.800143219642496e-06 0.07116311580983979 1.800143413259743e-06 0.06956233824397716 \
1.800143594846707e-06 0.06811311716920317 1.800143793421027e-06 0.06657819701521293 1.800143949952299e-06 0.06540254085633944 1.800144133522745e-06 0.06406078399206196 \
1.800144306484985e-06 0.06283331112669251 1.800144471995362e-06 0.06169268945721457 1.80014462033141e-06 0.06069691796619666 1.800144757229627e-06 0.05979937680937147 \
1.800144904867328e-06 0.05885633029244827 1.800145037955006e-06 0.05802735218158511 1.800145161474142e-06 0.05727448785321319 1.800145277510429e-06 0.05658054160001152 \
1.800145391123697e-06 0.05591352504042409 1.800145515745172e-06 0.05519553885869784 1.800145636542111e-06 0.05451306145814139 1.80014579648583e-06 0.0536298481755812 \
1.800145931832912e-06 0.05289991373180127 1.800146032152412e-06 0.05236888834064994 1.800146132622372e-06 0.05184552065910697 1.800146231565458e-06 0.05133799434906983 \
1.80014641007002e-06 0.05044349321929222 1.800146509870119e-06 0.04995513630881745 1.800146710035568e-06 0.04899962929156078 1.800146800952851e-06 0.04857581029502876 \
1.800147007746298e-06 0.04763487432244629 1.80014711297643e-06 0.0471681110353394 1.800147309354922e-06 0.04631787013837765 1.800147394633218e-06 0.04595693884580357 \
1.80014757509558e-06 0.04521002446657041 1.800147650260171e-06 0.04490525014776706 1.80014786811757e-06 0.0440422972058082 1.800147951636165e-06 0.04372097365614635 \
1.800148141571271e-06 0.04300637120866019 1.80014826631761e-06 0.04254845761102347 1.800148451543578e-06 0.0418846242551883 1.800148554382137e-06 0.04152415866453074 \
1.800148843894812e-06 0.04053983903151908 1.800148932816406e-06 0.04024621147044882 1.80014924148676e-06 0.03925784365481538 1.800149297645764e-06 0.03908306666491448 \
1.800149611207865e-06 0.03813491809530275 1.800149667163848e-06 0.037970533835152 1.800149994078164e-06 0.03703805601095747 1.800150047341397e-06 0.03689043863681411 \
1.800150353265485e-06 0.03606517121743442 1.800150453429213e-06 0.0358032254974586 1.800150772044909e-06 0.03499570355391716 1.800150861523872e-06 0.03477583942316619 \
1.800151259364458e-06 0.03383675925705845 1.800151377245794e-06 0.03357186655877694 1.800151789247958e-06 0.03268299960645597 1.80015194961085e-06 0.03235094877383871 \
1.800152320629234e-06 0.03161177976826059 1.800152540382685e-06 0.03119164460703521 1.800152983766919e-06 0.03038142203317581 1.800153232810551e-06 0.0299476098095271 \
1.8001537326667e-06 0.02912178892962563 1.800153951558277e-06 0.02877747133829427 1.800154434672084e-06 0.02805819238630505 1.800154723499336e-06 0.02765301209416409 \
1.800155410247302e-06 0.02674723311374961 1.800155699762857e-06 0.02638861276123805 1.800156475736135e-06 0.02548835782609031 1.800156647189526e-06 0.02530065249352256 \
1.80015743327132e-06 0.02449144648051316 1.800157637300353e-06 0.02429465554580218 1.800158746898316e-06 0.02329883562822865 1.800158847813389e-06 0.02321388155873386 \
1.800160039404086e-06 0.02227529349501467 1.800160244312293e-06 0.0221260927003824 1.800161697508364e-06 0.02113958380755909 1.800161932492782e-06 0.02098788030205876 \
1.800163439760696e-06 0.02004942094855779 1.80016376006111e-06 0.01985604392354444 1.800164974239456e-06 0.01910354072181233 1.800165447544128e-06 0.01879991394003632 \
1.800166748677981e-06 0.01794965119692995 1.800167138470568e-06 0.01770179815419311 1.800168537018732e-06 0.01679702456340363 1.800168863768812e-06 0.01658609683275075 \
1.80016998110407e-06 0.01586843585740347 1.800170689790367e-06 0.01544169959229912 1.800172422376366e-06 0.01449858640399567 1.800172671838817e-06 0.01436065672582198 \
1.800174469435716e-06 0.01337694399212387 1.800174812129382e-06 0.01319104500849105 1.800176988462895e-06 0.01225973435293598 1.80017727331928e-06 0.01213579497780986 \
1.800179172162672e-06 0.01126438850740638 1.800179655025129e-06 0.01103474467122418 1.800181927520555e-06 0.01014901321627989 1.800182315058726e-06 0.01002270433864562 \
1.800184966564885e-06 0.009023867700259034 1.800185262768817e-06 0.00890332747207802 1.80018760460699e-06 0.00793111507746596 1.800187858191315e-06 0.007825942613114227 \
1.800190880361057e-06 0.006881067894167194 1.80019112999456e-06 0.006804700431426973 1.800195007891808e-06 0.005817006850260108 1.800195235071384e-06 0.005760637946475626 \
1.800198046189619e-06 0.00490690852483563 1.800198480606374e-06 0.004760206508803379 1.800201010366652e-06 0.003858115577918713 1.800201428863181e-06 0.003712016323791173 \
1.800204453534309e-06 0.00274875962184498 1.800204733759441e-06 0.002664158024812898 1.800208530584646e-06 0.001697446565651876 1.800208884963991e-06 0.001621705150764489 \
1.800214411478996e-06 0.0006347476112661908 1.800214708963481e-06 0.0005888553763099016 1.800222216727447e-06 -0.0003928413941844093 1.800222438401114e-06 -0.0004189941252107796 \
1.800236530784873e-06 -0.001410461992184868 1.800236889612591e-06 -0.001430649730572865 1.800250237245411e-06 -0.0004514903228812461 1.800250464642512e-06 -0.0004111859973536986 \
1.800255915612065e-06 0.0005614551864591434 1.800256178897484e-06 0.0006110884748384679 1.800260810837491e-06 0.001592952619583714 1.800261118869639e-06 0.001665522059460669 \
1.80026495308288e-06 0.002626457037572999 1.800265337382884e-06 0.002733556882532277 1.800269071576165e-06 0.003682507088408038 1.800269273441448e-06 0.00374945551670179 \
1.800272897693538e-06 0.004734851451646972 1.800273092622753e-06 0.004780391513086043 1.800276479822177e-06 0.005766866152453508 1.800276671910697e-06 0.005810149709068801 \
1.800280887542283e-06 0.006750994364636406 1.800281221079492e-06 0.006821678237255247 1.800305948540302e-06 0.005867117768706426 1.800306261817208e-06 0.005806676405157672 \
1.800310893192981e-06 0.004863125825100585 1.800311165044221e-06 0.004806306550559217 1.8003161096881e-06 0.003825328200913169 1.800316576141932e-06 0.003739629632037282 \
1.800322482405849e-06 0.002770751168227681 1.800322776130159e-06 0.002729631326985271 1.800331621359071e-06 0.001738601807147118 1.800331808126426e-06 0.001722695496451883 \
1.800352036959148e-06 0.0007253105668073048 1.800353471598443e-06 0.0006873447391178559 1.858990000000011e-06 3.130932490801775e-06 1.861883407830385e-06 -0.0008819623910157972 \
1.861883643879234e-06 -0.001161970612476729 1.861884102325562e-06 -0.001847355627596629 1.861884345612697e-06 -0.002293620068582415 1.861884595896664e-06 -0.00281405583725217 \
1.861884846702668e-06 -0.003393671496214343 1.86188515952233e-06 -0.004199192998005251 1.861885397732202e-06 -0.004872003934560885 1.861885644182635e-06 -0.005621391842385397 \
1.861885875927131e-06 -0.006370319304257691 1.861886183112249e-06 -0.007411941938624838 1.861886448406181e-06 -0.008326397880259807 1.861886693685807e-06 -0.009131457988769647 \
1.861887058417363e-06 -0.01007334593757064 1.86188728648854e-06 -0.01033898456945748 1.861887610128182e-06 -0.009994868194499993 1.861887810544735e-06 -0.009187286872421443 \
1.861888045349532e-06 -0.007487931918614563 1.861888226424988e-06 -0.005544847192362645 1.861888332865277e-06 -0.004119573247771668 1.861888471151424e-06 -0.001940540768574745 \
1.861888582177386e-06 7.563183370691832e-05 1.861888702798821e-06 0.002536824544301687 1.861888805864002e-06 0.004857398676819782 1.861888944571287e-06 0.008289235792766818 \
1.861889065680579e-06 0.01156496544863939 1.86188921588438e-06 0.01596809792775087 1.86188939752999e-06 0.02176080367268303 1.86188954996521e-06 0.02698454055473338 \
1.861889726115454e-06 0.03339084366291074 1.8618899251156e-06 0.04103368087207344 1.861890094787538e-06 0.04784290449723066 1.861890273981513e-06 0.05527749234857952 \
1.861890434397879e-06 0.06211990493347131 1.861890596191839e-06 0.06916698107316244 1.861890754742719e-06 0.07620053909780501 1.861890921935392e-06 0.08372027851346725 \
1.861891092293318e-06 0.09147114401158042 1.861891271730565e-06 0.0997240648901548 1.861891461853091e-06 0.1085375718081032 1.861891661092053e-06 0.1178373860957827 \
1.861891865069358e-06 0.1274102212870429 1.86189208614423e-06 0.1378300800073513 1.8618923318008e-06 0.1494365474357121 1.861892589151043e-06 0.1616443690283554 \
1.861892871842139e-06 0.1750899465505063 1.86189316989355e-06 0.1892663579759593 1.861893516170122e-06 0.2057792515135755 1.86189388288524e-06 0.2232517522030736 \
1.861894278797487e-06 0.2421754728923703 1.861894713908853e-06 0.2629945242020292 1.86189519371884e-06 0.2859861135989593 1.8618957190371e-06 0.3113450809673837 \
1.861896243573264e-06 0.3367514755549041 1.861896840892739e-06 0.3658546932050024 1.861897607717859e-06 0.4033613755922033 1.861898046206797e-06 0.4246376380793622 \
1.861898522720377e-06 0.4473946242989675 1.861898972555967e-06 0.4684360091747882 1.861899525240159e-06 0.4936960927629759 1.861900223236364e-06 0.5245486808074998 \
1.861900837638476e-06 0.5507582774516211 1.861901405608978e-06 0.5741722555225199 1.861901935862248e-06 0.5952266004882081 1.861902394831628e-06 0.6128068198589096 \
1.861902977999792e-06 0.6341908714213341 1.861903551157707e-06 0.6541368834277531 1.861904141842032e-06 0.6735006351351156 1.861904810515341e-06 0.6939224431220803 \
1.861905465000487e-06 0.7123419857223411 1.861906218631611e-06 0.7316435145596337 1.861907138111349e-06 0.7524771687756806 1.861907807118464e-06 0.7658582308664672 \
1.861908502684848e-06 0.7783426900018873 1.861909224721799e-06 0.7898435797332509 1.861909871505064e-06 0.7989777190578581 1.861910686398373e-06 0.809051394855074 \
1.861911344291083e-06 0.8161084932798452 1.861912109055577e-06 0.8232971874420545 1.861912705588939e-06 0.8281915934352191 1.861913333612095e-06 0.8327857747397983 \
1.861913964004405e-06 0.8368636793792511 1.86191494962664e-06 0.8423301485602825 1.861915705380696e-06 0.8458701801587535 1.861916468671131e-06 0.8489683054605098 \
1.861917277011917e-06 0.8518111549479527 1.861918265903366e-06 0.8547854532963984 1.861919008958979e-06 0.8567085856698495 1.861919831636168e-06 0.8585940601366741 \
1.861920612856223e-06 0.8601698380186774 1.861921416459391e-06 0.8616111415036141 1.861922203727638e-06 0.8628649505886673 1.861923395730052e-06 0.8644986110026872 \
1.861924318352036e-06 0.8655887935537701 1.861925377279772e-06 0.8666437563732095 1.861926250370494e-06 0.8673888282159752 1.861927019427764e-06 0.8679394432393451 \
1.8619327760832e-06 0.8675354626998435 1.861933384736608e-06 0.8669285211992742 1.861934348633067e-06 0.8661637309277684 1.861934697027123e-06 0.8657877651307159 \
1.861935865736297e-06 0.8648718022682493 1.861936507439083e-06 0.8645495171393598 1.861937723779243e-06 0.8636149212264693 1.861938210995997e-06 0.8633315979857124 \
1.861941995751513e-06 0.8637879096652611 1.861942803560594e-06 0.8644940879742092 1.861943676731311e-06 0.8654118536506241 1.86194452584852e-06 0.8664722967159353 \
1.861945394320663e-06 0.8676408136092975 1.861946220799482e-06 0.8688316482847912 1.861947067273748e-06 0.8700680498371385 1.861947993731666e-06 0.8714353201417473 \
1.861948922751738e-06 0.8727967357236968 1.861949890373816e-06 0.874169309418928 1.861950892855429e-06 0.8755268793700145 1.861951975786211e-06 0.8769279254876977 \
1.861953154258897e-06 0.8783524184654903 1.861954367359833e-06 0.8797057189093218 1.861955697820692e-06 0.8810544625232946 1.861957146531982e-06 0.8823882385150326 \
1.861958814266774e-06 0.8837386794148741 1.861960446298639e-06 0.8848798336526329 1.861962413590838e-06 0.8860652157953401 1.861964590094435e-06 0.8871729764751287 \
1.861966862249877e-06 0.8881691778223457 1.861969135754955e-06 0.8889896378135498 1.861971087665695e-06 0.8895771814349003 1.861973972100292e-06 0.8902862350409186 \
1.861976831036635e-06 0.8908501300162286 1.861979913323748e-06 0.8913157385816455 1.86199173167453e-06 0.8922670755128276 1.861994058318611e-06 0.8924600956555456 \
1.862000939517426e-06 0.8933233934443291 1.862002931772882e-06 0.8936033182227321 1.862007596963998e-06 0.8943294235126149 1.862009934973581e-06 0.894763749611499 \
1.86201243532077e-06 0.8952990768365913 1.862014909223274e-06 0.8959385502707948 1.862017035318025e-06 0.8965630758105964 1.862019624621494e-06 0.8973958942958599 \
1.862022048641129e-06 0.8982427248493853 1.862024940455552e-06 0.8993469797885378 1.862027450127073e-06 0.9003588137389537 1.862030788570323e-06 0.9017079510157455 \
1.862033867543754e-06 0.9029423170929788 1.862037060622869e-06 0.9042497182071535 1.862039656279508e-06 0.9052493492427333 1.862041664531596e-06 0.9059572885738179 \
1.862043772760482e-06 0.9066594295388942 1.862046461477417e-06 0.907478492737931 1.862048917070081e-06 0.9081366525620301 1.862051281590183e-06 0.9087089258990763 \
1.862053876154591e-06 0.9092804446275633 1.862056243869825e-06 0.9097121154337445 1.862063636309535e-06 0.9105880439508957 1.86206694738543e-06 0.9108097973553667 \
1.86209063110421e-06 0.9099572430838525 1.862093524994068e-06 0.9096028008700563 1.862099633721785e-06 0.9087795762164674 1.862102664784937e-06 0.9083311497095887 \
1.862109022442901e-06 0.9073557537429059 1.862112916389034e-06 0.906719613226565 1.862116289356866e-06 0.9061475060281556 1.862119374914729e-06 0.9055946669458763 \
1.862123120629277e-06 0.9048996522446952 1.862126487017035e-06 0.9043394102803256 1.862134077462241e-06 0.9034499723753743 1.862137953472777e-06 0.9031904105967781 \
1.862165717708862e-06 0.9022140906736803 1.862169493868779e-06 0.902100877529562 1.862200910100546e-06 0.9011025155537421 1.862207545190393e-06 0.9009020504869808 \
1.9001105508058e-06 0.8999193627810952 1.90011071848179e-06 0.8998913840591389 1.900113467033027e-06 0.8989010293823864 1.900113523573982e-06 0.8988795941121664 \
1.900114768178511e-06 0.8998357618405769 1.900114847007516e-06 0.9000722811707415 1.900115028967665e-06 0.9007374088026997 1.90011513130788e-06 0.9011852075627013 \
1.90011532428406e-06 0.9021545909398002 1.900115412645943e-06 0.9026487433775175 1.900115571157198e-06 0.9036053969378676 1.900115683054862e-06 0.9043311123122415 \
1.900115823971993e-06 0.9052897461292233 1.900115929405144e-06 0.9060407976354218 1.900116042282182e-06 0.9068700067857125 1.900116156714019e-06 0.9077320749581511 \
1.900116277994792e-06 0.9086625635419388 1.900116407030339e-06 0.9096610759972766 1.900116529569199e-06 0.9106054665418637 1.90011665392414e-06 0.9115433813509556 \
1.900116768824237e-06 0.912370851358936 1.900116872924634e-06 0.9130668181210778 1.900116980506906e-06 0.9137127811079708 1.900117148007135e-06 0.914504286313051 \
1.900117619367398e-06 0.9145217838087505 1.900117817316352e-06 0.9131640269569251 1.900117978090595e-06 0.9113346267648944 1.900118066395334e-06 0.910041664336402 \
1.900118153928761e-06 0.908567258693449 1.900118246820306e-06 0.9067913249607207 1.900118320262759e-06 0.9052411278657534 1.900118409009881e-06 0.9032017134587504 \
1.900118546653074e-06 0.8996915735089056 1.900118658994696e-06 0.8965314120175644 1.900118782291717e-06 0.892778172623249 1.900118938496376e-06 0.8876402979533503 \
1.900119062012361e-06 0.8833010177194197 1.900119232383792e-06 0.8769686903427227 1.900119380003419e-06 0.8711968848515086 1.900119531854558e-06 0.8650238565011712 \
1.900119667983612e-06 0.8593172646418706 1.900119810047228e-06 0.8532105227807962 1.900119945331887e-06 0.8472784593397693 1.900120083991258e-06 0.8411010749315838 \
1.90012023129828e-06 0.8344514077702887 1.900120377865128e-06 0.8277635723525925 1.900120539944527e-06 0.8202964899226535 1.900120687311172e-06 0.8134532267615989 \
1.90012085882447e-06 0.8054479178086997 1.900121042247436e-06 0.7968539002302991 1.900121244752722e-06 0.7873346372610658 1.900121456402384e-06 0.7773555108975432 \
1.900121677392943e-06 0.7669228693561837 1.90012190658697e-06 0.7561055044419139 1.900122183106921e-06 0.743046509132553 1.900122468593645e-06 0.7295848836660939 \
1.900122789908539e-06 0.7144535604611002 1.900123079378459e-06 0.7008559708795014 1.900123398648317e-06 0.6858669291494816 1.900123719663687e-06 0.6708097907125149 \
1.900124061099719e-06 0.654842287100785 1.900124453723407e-06 0.6364912117266992 1.900124808317996e-06 0.6199451687359452 1.900125173105078e-06 0.602895395464039 \
1.90012557692179e-06 0.5840362041416589 1.900125940450357e-06 0.56705803755797 1.900126371026893e-06 0.546963725974103 1.900126727188766e-06 0.5303181638661557 \
1.900127100198166e-06 0.5128834705750704 1.900127442383275e-06 0.4969084729771704 1.900127762124838e-06 0.4820272854775881 1.900128079868868e-06 0.4673068400017517 \
1.90012837572031e-06 0.453709089639897 1.900128703744139e-06 0.4388357619204879 1.900129013234577e-06 0.4250513307906954 1.900129299733975e-06 0.412542701771394 \
1.900129612088515e-06 0.3991541929604193 1.900129902199714e-06 0.3870087322563178 1.900130215665733e-06 0.3741657412501236 1.900130493028614e-06 0.3630444214925196 \
1.900130774126111e-06 0.3519744117192101 1.900131005607363e-06 0.3430374849397334 1.900131234174756e-06 0.3343354151638595 1.90013147406666e-06 0.3253394991495989 \
1.900131731848444e-06 0.3158318026516087 1.900131981218358e-06 0.3067925439309827 1.900132239531266e-06 0.297589150170473 1.900132486062287e-06 0.2889540805256016 \
1.900132773357043e-06 0.2790758510850415 1.900132996736124e-06 0.2715471379396955 1.900133217531486e-06 0.2642409610398131 1.90013341340532e-06 0.2578652581015776 \
1.900133600129401e-06 0.2519000449202701 1.900133771320538e-06 0.2465102462678049 1.900133946364063e-06 0.2410522141953559 1.900134109381927e-06 0.236036359124031 \
1.900134270786368e-06 0.2311389431166576 1.900134424603758e-06 0.2265774065811171 1.90013457654048e-06 0.2221477024102725 1.900134730763452e-06 0.2177012931700853 \
1.900134904399052e-06 0.2127672920349684 1.900135054516093e-06 0.2085590788965803 1.900135188967813e-06 0.2048346911951331 1.900135333880152e-06 0.2008962005616911 \
1.900135495414782e-06 0.1965999354189458 1.900135644303198e-06 0.1927083727438147 1.900135788543376e-06 0.1889957157254755 1.900135913586713e-06 0.1858267544518093 \
1.900136010653492e-06 0.183392498065703 1.900136145647889e-06 0.1800503036180525 1.900136255162251e-06 0.1773760505692391 1.900136393137778e-06 0.1740872877198338 \
1.900136513150413e-06 0.1712726271080235 1.90013663003209e-06 0.1685704901364905 1.900136756660935e-06 0.1656849030049582 1.900136892675268e-06 0.1626308514974385 \
1.90013702606177e-06 0.1596764551685698 1.900137153003703e-06 0.1569158519548911 1.900137281621738e-06 0.1541678007478876 1.900137395548178e-06 0.1517740356345986 \
1.900137505859117e-06 0.149496521787741 1.90013761900036e-06 0.1472133997668396 1.900137732479436e-06 0.1449590740078549 1.900137857844221e-06 0.1425075003983929 \
1.900138003638108e-06 0.1397077962434051 1.900138186780095e-06 0.1362681166668699 1.9001383353875e-06 0.1335395672637218 1.900138447639322e-06 0.1315146079855561 \
1.900138576992755e-06 0.1292194206906994 1.900138670528911e-06 0.1275846423925092 1.90013877932072e-06 0.1257099890290588 1.900138873074831e-06 0.1241165438085202 \
1.900138956682435e-06 0.1227229754719547 1.9001390763363e-06 0.1207568051616409 1.900139205425261e-06 0.1186746054627577 1.900139322279497e-06 0.1168252031377112 \
1.900139453368507e-06 0.1147891811469644 1.900139598723523e-06 0.1125787883659796 1.900139764133423e-06 0.110121919024741 1.90013993287367e-06 0.1076798417306999 \
1.900140125753815e-06 0.1049622523271389 1.900140299731943e-06 0.1025767092705754 1.900140487918313e-06 0.1000644866129177 1.900140670319411e-06 0.09769892895340802 \
1.900140849911024e-06 0.09544952095403336 1.900141026408427e-06 0.09330553315647841 1.900141210964177e-06 0.09112768523704891 1.900141396209645e-06 0.08900465024544718 \
1.900141578281057e-06 0.0869768268327742 1.900141774345804e-06 0.08485812802288394 1.900141944746222e-06 0.08306894814141007 1.900142122986993e-06 0.08125105909257219 \
1.900142298679519e-06 0.07951206376949813 1.900142499080023e-06 0.07758728548656671 1.900142695934063e-06 0.07575734486890456 1.900142865868499e-06 0.07422427017287291 \
1.90014303651775e-06 0.07272580243814712 1.900143219642496e-06 0.07116311580983979 1.900143413259743e-06 0.06956233824397716 1.900143594846707e-06 0.06811311716920317 \
1.900143793421027e-06 0.06657819701521293 1.900143949952299e-06 0.06540254085633944 1.900144133522745e-06 0.06406078399206196 1.900144306484985e-06 0.06283331112669251 \
1.900144471995362e-06 0.06169268945721457 1.90014462033141e-06 0.06069691796619666 1.900144757229627e-06 0.05979937680937147 1.900144904867328e-06 0.05885633029244827 \
1.900145037955006e-06 0.05802735218158511 1.900145161474142e-06 0.05727448785321319 1.900145277510429e-06 0.05658054160001152 1.900145391123697e-06 0.05591352504042409 \
1.900145515745172e-06 0.05519553885869784 1.900145636542111e-06 0.05451306145814139 1.90014579648583e-06 0.0536298481755812 1.900145931832913e-06 0.05289991373180127 \
1.900146032152412e-06 0.05236888834064994 1.900146132622372e-06 0.05184552065910697 1.900146231565458e-06 0.05133799434906983 1.90014641007002e-06 0.05044349321929222 \
1.900146509870119e-06 0.04995513630881745 1.900146710035568e-06 0.04899962929156078 1.900146800952851e-06 0.04857581029502876 1.900147007746298e-06 0.04763487432244629 \
1.90014711297643e-06 0.0471681110353394 1.900147309354922e-06 0.04631787013837765 1.900147394633218e-06 0.04595693884580357 1.900147575095581e-06 0.04521002446657041 \
1.900147650260171e-06 0.04490525014776706 1.90014786811757e-06 0.0440422972058082 1.900147951636165e-06 0.04372097365614635 1.900148141571271e-06 0.04300637120866019 \
1.90014826631761e-06 0.04254845761102347 1.900148451543578e-06 0.0418846242551883 1.900148554382137e-06 0.04152415866453074 1.900148843894812e-06 0.04053983903151908 \
1.900148932816406e-06 0.04024621147044882 1.90014924148676e-06 0.03925784365481538 1.900149297645764e-06 0.03908306666491448 1.900149611207866e-06 0.03813491809530275 \
1.900149667163848e-06 0.037970533835152 1.900149994078164e-06 0.03703805601095747 1.900150047341397e-06 0.03689043863681411 1.900150353265485e-06 0.03606517121743442 \
1.900150453429213e-06 0.0358032254974586 1.900150772044909e-06 0.03499570355391716 1.900150861523872e-06 0.03477583942316619 1.900151259364458e-06 0.03383675925705845 \
1.900151377245794e-06 0.03357186655877694 1.900151789247957e-06 0.03268299960645597 1.90015194961085e-06 0.03235094877383871 1.900152320629234e-06 0.03161177976826059 \
1.900152540382685e-06 0.03119164460703521 1.900152983766919e-06 0.03038142203317581 1.900153232810551e-06 0.0299476098095271 1.9001537326667e-06 0.02912178892962563 \
1.900153951558277e-06 0.02877747133829427 1.900154434672084e-06 0.02805819238630505 1.900154723499337e-06 0.02765301209416409 1.900155410247302e-06 0.02674723311374961 \
1.900155699762857e-06 0.02638861276123805 1.900156475736135e-06 0.02548835782609031 1.900156647189526e-06 0.02530065249352256 1.90015743327132e-06 0.02449144648051316 \
1.900157637300353e-06 0.02429465554580218 1.900158746898316e-06 0.02329883562822865 1.900158847813389e-06 0.02321388155873386 1.900160039404086e-06 0.02227529349501467 \
1.900160244312293e-06 0.0221260927003824 1.900161697508364e-06 0.02113958380755909 1.900161932492782e-06 0.02098788030205876 1.900163439760696e-06 0.02004942094855779 \
1.900163760061111e-06 0.01985604392354444 1.900164974239456e-06 0.01910354072181233 1.900165447544128e-06 0.01879991394003632 1.900166748677981e-06 0.01794965119692995 \
1.900167138470568e-06 0.01770179815419311 1.900168537018732e-06 0.01679702456340363 1.900168863768812e-06 0.01658609683275075 1.90016998110407e-06 0.01586843585740347 \
1.900170689790368e-06 0.01544169959229912 1.900172422376366e-06 0.01449858640399567 1.900172671838817e-06 0.01436065672582198 1.900174469435716e-06 0.01337694399212387 \
1.900174812129382e-06 0.01319104500849105 1.900176988462895e-06 0.01225973435293598 1.90017727331928e-06 0.01213579497780986 1.900179172162672e-06 0.01126438850740638 \
1.90017965502513e-06 0.01103474467122418 1.900181927520555e-06 0.01014901321627989 1.900182315058726e-06 0.01002270433864562 1.900184966564885e-06 0.009023867700259034 \
1.900185262768817e-06 0.00890332747207802 1.900187604606991e-06 0.00793111507746596 1.900187858191315e-06 0.007825942613114227 1.900190880361057e-06 0.006881067894167194 \
1.90019112999456e-06 0.006804700431426973 1.900195007891808e-06 0.005817006850260108 1.900195235071384e-06 0.005760637946475626 1.900198046189619e-06 0.00490690852483563 \
1.900198480606374e-06 0.004760206508803379 1.900201010366652e-06 0.003858115577918713 1.900201428863181e-06 0.003712016323791173 1.900204453534309e-06 0.00274875962184498 \
1.900204733759441e-06 0.002664158024812898 1.900208530584646e-06 0.001697446565651876 1.900208884963991e-06 0.001621705150764489 1.900214411478996e-06 0.0006347476112661908 \
1.900214708963481e-06 0.0005888553763099016 1.900222216727447e-06 -0.0003928413941844093 1.900222438401114e-06 -0.0004189941252107796 1.900236530784873e-06 -0.001410461992184868 \
1.900236889612591e-06 -0.001430649730572865 1.900250237245412e-06 -0.0004514903228812461 1.900250464642513e-06 -0.0004111859973536986 1.900255915612065e-06 0.0005614551864591434 \
1.900256178897484e-06 0.0006110884748384679 1.900260810837491e-06 0.001592952619583714 1.900261118869639e-06 0.001665522059460669 1.90026495308288e-06 0.002626457037572999 \
1.900265337382884e-06 0.002733556882532277 1.900269071576165e-06 0.003682507088408038 1.900269273441448e-06 0.00374945551670179 1.900272897693538e-06 0.004734851451646972 \
1.900273092622753e-06 0.004780391513086043 1.900276479822177e-06 0.005766866152453508 1.900276671910697e-06 0.005810149709068801 1.900280887542283e-06 0.006750994364636406 \
1.900281221079492e-06 0.006821678237255247 1.900305948540302e-06 0.005867117768706426 1.900306261817208e-06 0.005806676405157672 1.900310893192981e-06 0.004863125825100585 \
1.900311165044221e-06 0.004806306550559217 1.9003161096881e-06 0.003825328200913169 1.900316576141932e-06 0.003739629632037282 1.90032248240585e-06 0.002770751168227681 \
1.900322776130159e-06 0.002729631326985271 1.900331621359071e-06 0.001738601807147118 1.900331808126426e-06 0.001722695496451883 1.900352036959148e-06 0.0007253105668073048 \
1.900353471598443e-06 0.0006873447391178559 1.958990000000011e-06 3.130932490801775e-06 1.961883407830385e-06 -0.0008819623910157972 1.961883643879234e-06 -0.001161970612476729 \
1.961884102325562e-06 -0.001847355627596629 1.961884345612697e-06 -0.002293620068582415 1.961884595896665e-06 -0.00281405583725217 1.961884846702668e-06 -0.003393671496214343 \
1.96188515952233e-06 -0.004199192998005251 1.961885397732202e-06 -0.004872003934560885 1.961885644182635e-06 -0.005621391842385397 1.961885875927131e-06 -0.006370319304257691 \
1.961886183112249e-06 -0.007411941938624838 1.961886448406181e-06 -0.008326397880259807 1.961886693685808e-06 -0.009131457988769647 1.961887058417362e-06 -0.01007334593757064 \
1.961887286488539e-06 -0.01033898456945748 1.961887610128182e-06 -0.009994868194499993 1.961887810544735e-06 -0.009187286872421443 1.961888045349532e-06 -0.007487931918614563 \
1.961888226424988e-06 -0.005544847192362645 1.961888332865277e-06 -0.004119573247771668 1.961888471151424e-06 -0.001940540768574745 1.961888582177387e-06 7.563183370691832e-05 \
1.961888702798821e-06 0.002536824544301687 1.961888805864002e-06 0.004857398676819782 1.961888944571287e-06 0.008289235792766818 1.961889065680579e-06 0.01156496544863939 \
1.96188921588438e-06 0.01596809792775087 1.96188939752999e-06 0.02176080367268303 1.96188954996521e-06 0.02698454055473338 1.961889726115454e-06 0.03339084366291074 \
1.9618899251156e-06 0.04103368087207344 1.961890094787538e-06 0.04784290449723066 1.961890273981514e-06 0.05527749234857952 1.961890434397879e-06 0.06211990493347131 \
1.961890596191839e-06 0.06916698107316244 1.961890754742719e-06 0.07620053909780501 1.961890921935392e-06 0.08372027851346725 1.961891092293318e-06 0.09147114401158042 \
1.961891271730565e-06 0.0997240648901548 1.961891461853091e-06 0.1085375718081032 1.961891661092053e-06 0.1178373860957827 1.961891865069359e-06 0.1274102212870429 \
1.96189208614423e-06 0.1378300800073513 1.9618923318008e-06 0.1494365474357121 1.961892589151043e-06 0.1616443690283554 1.961892871842139e-06 0.1750899465505063 \
1.96189316989355e-06 0.1892663579759593 1.961893516170121e-06 0.2057792515135755 1.96189388288524e-06 0.2232517522030736 1.961894278797487e-06 0.2421754728923703 \
1.961894713908854e-06 0.2629945242020292 1.96189519371884e-06 0.2859861135989593 1.961895719037101e-06 0.3113450809673837 1.961896243573265e-06 0.3367514755549041 \
1.961896840892739e-06 0.3658546932050024 1.961897607717859e-06 0.4033613755922033 1.961898046206797e-06 0.4246376380793622 1.961898522720377e-06 0.4473946242989675 \
1.961898972555967e-06 0.4684360091747882 1.961899525240159e-06 0.4936960927629759 1.961900223236364e-06 0.5245486808074998 1.961900837638476e-06 0.5507582774516211 \
1.961901405608978e-06 0.5741722555225199 1.961901935862248e-06 0.5952266004882081 1.961902394831628e-06 0.6128068198589096 1.961902977999792e-06 0.6341908714213341 \
1.961903551157707e-06 0.6541368834277531 1.961904141842032e-06 0.6735006351351156 1.961904810515341e-06 0.6939224431220803 1.961905465000487e-06 0.7123419857223411 \
1.961906218631611e-06 0.7316435145596337 1.961907138111349e-06 0.7524771687756806 1.961907807118464e-06 0.7658582308664672 1.961908502684848e-06 0.7783426900018873 \
1.961909224721799e-06 0.7898435797332509 1.961909871505064e-06 0.7989777190578581 1.961910686398373e-06 0.809051394855074 1.961911344291084e-06 0.8161084932798452 \
1.961912109055577e-06 0.8232971874420545 1.96191270558894e-06 0.8281915934352191 1.961913333612095e-06 0.8327857747397983 1.961913964004405e-06 0.8368636793792511 \
1.96191494962664e-06 0.8423301485602825 1.961915705380697e-06 0.8458701801587535 1.961916468671132e-06 0.8489683054605098 1.961917277011917e-06 0.8518111549479527 \
1.961918265903366e-06 0.8547854532963984 1.961919008958979e-06 0.8567085856698495 1.961919831636168e-06 0.8585940601366741 1.961920612856223e-06 0.8601698380186774 \
1.961921416459391e-06 0.8616111415036141 1.961922203727638e-06 0.8628649505886673 1.961923395730052e-06 0.8644986110026872 1.961924318352036e-06 0.8655887935537701 \
1.961925377279772e-06 0.8666437563732095 1.961926250370494e-06 0.8673888282159752 1.961927019427764e-06 0.8679394432393451 1.961932776083201e-06 0.8675354626998435 \
1.961933384736608e-06 0.8669285211992742 1.961934348633067e-06 0.8661637309277684 1.961934697027123e-06 0.8657877651307159 1.961935865736297e-06 0.8648718022682493 \
1.961936507439083e-06 0.8645495171393598 1.961937723779243e-06 0.8636149212264693 1.961938210995997e-06 0.8633315979857124 1.961941995751513e-06 0.8637879096652611 \
1.961942803560594e-06 0.8644940879742092 1.961943676731311e-06 0.8654118536506241 1.96194452584852e-06 0.8664722967159353 1.961945394320663e-06 0.8676408136092975 \
1.961946220799482e-06 0.8688316482847912 1.961947067273748e-06 0.8700680498371385 1.961947993731666e-06 0.8714353201417473 1.961948922751738e-06 0.8727967357236968 \
1.961949890373816e-06 0.874169309418928 1.961950892855429e-06 0.8755268793700145 1.961951975786211e-06 0.8769279254876977 1.961953154258897e-06 0.8783524184654903 \
1.961954367359833e-06 0.8797057189093218 1.961955697820692e-06 0.8810544625232946 1.961957146531982e-06 0.8823882385150326 1.961958814266774e-06 0.8837386794148741 \
1.96196044629864e-06 0.8848798336526329 1.961962413590838e-06 0.8860652157953401 1.961964590094435e-06 0.8871729764751287 1.961966862249877e-06 0.8881691778223457 \
1.961969135754955e-06 0.8889896378135498 1.961971087665695e-06 0.8895771814349003 1.961973972100292e-06 0.8902862350409186 1.961976831036635e-06 0.8908501300162286 \
1.961979913323748e-06 0.8913157385816455 1.96199173167453e-06 0.8922670755128276 1.961994058318612e-06 0.8924600956555456 1.962000939517426e-06 0.8933233934443291 \
1.962002931772883e-06 0.8936033182227321 1.962007596963998e-06 0.8943294235126149 1.962009934973581e-06 0.894763749611499 1.96201243532077e-06 0.8952990768365913 \
1.962014909223274e-06 0.8959385502707948 1.962017035318026e-06 0.8965630758105964 1.962019624621494e-06 0.8973958942958599 1.962022048641129e-06 0.8982427248493853 \
1.962024940455552e-06 0.8993469797885378 1.962027450127073e-06 0.9003588137389537 1.962030788570323e-06 0.9017079510157455 1.962033867543754e-06 0.9029423170929788 \
1.962037060622869e-06 0.9042497182071535 1.962039656279508e-06 0.9052493492427333 1.962041664531596e-06 0.9059572885738179 1.962043772760483e-06 0.9066594295388942 \
1.962046461477418e-06 0.907478492737931 1.962048917070081e-06 0.9081366525620301 1.962051281590183e-06 0.9087089258990763 1.962053876154591e-06 0.9092804446275633 \
1.962056243869825e-06 0.9097121154337445 1.962063636309535e-06 0.9105880439508957 1.96206694738543e-06 0.9108097973553667 1.962090631104211e-06 0.9099572430838525 \
1.962093524994069e-06 0.9096028008700563 1.962099633721785e-06 0.9087795762164674 1.962102664784937e-06 0.9083311497095887 1.962109022442901e-06 0.9073557537429059 \
1.962112916389034e-06 0.906719613226565 1.962116289356866e-06 0.9061475060281556 1.96211937491473e-06 0.9055946669458763 1.962123120629278e-06 0.9048996522446952 \
1.962126487017035e-06 0.9043394102803256 1.962134077462241e-06 0.9034499723753743 1.962137953472778e-06 0.9031904105967781 1.962165717708862e-06 0.9022140906736803 \
1.962169493868779e-06 0.902100877529562 1.962200910100546e-06 0.9011025155537421 1.962207545190393e-06 0.9009020504869808 2.000110550805801e-06 0.8999193627810952 \
2.00011071848179e-06 0.8998913840591389 2.000113467033027e-06 0.8989010293823864 2.000113523573982e-06 0.8988795941121664 2.000114768178511e-06 0.8998357618405769 \
2.000114847007516e-06 0.9000722811707415 2.000115028967664e-06 0.9007374088026997 2.00011513130788e-06 0.9011852075627013 2.000115324284061e-06 0.9021545909398002 \
2.000115412645943e-06 0.9026487433775175 2.000115571157197e-06 0.9036053969378676 2.000115683054863e-06 0.9043311123122415 2.000115823971993e-06 0.9052897461292233 \
2.000115929405144e-06 0.9060407976354218 2.000116042282183e-06 0.9068700067857125 2.000116156714019e-06 0.9077320749581511 2.000116277994793e-06 0.9086625635419388 \
2.000116407030339e-06 0.9096610759972766 2.000116529569199e-06 0.9106054665418637 2.000116653924139e-06 0.9115433813509556 2.000116768824237e-06 0.912370851358936 \
2.000116872924634e-06 0.9130668181210778 2.000116980506906e-06 0.9137127811079708 2.000117148007135e-06 0.914504286313051 2.000117619367398e-06 0.9145217838087505 \
2.000117817316352e-06 0.9131640269569251 2.000117978090595e-06 0.9113346267648944 2.000118066395334e-06 0.910041664336402 2.000118153928761e-06 0.908567258693449 \
2.000118246820307e-06 0.9067913249607207 2.000118320262759e-06 0.9052411278657534 2.000118409009881e-06 0.9032017134587504 2.000118546653074e-06 0.8996915735089056 \
2.000118658994696e-06 0.8965314120175644 2.000118782291718e-06 0.892778172623249 2.000118938496376e-06 0.8876402979533503 2.000119062012361e-06 0.8833010177194197 \
2.000119232383792e-06 0.8769686903427227 2.000119380003419e-06 0.8711968848515086 2.000119531854558e-06 0.8650238565011712 2.000119667983612e-06 0.8593172646418706 \
2.000119810047228e-06 0.8532105227807962 2.000119945331887e-06 0.8472784593397693 2.000120083991258e-06 0.8411010749315838 2.00012023129828e-06 0.8344514077702887 \
2.000120377865128e-06 0.8277635723525925 2.000120539944527e-06 0.8202964899226535 2.000120687311172e-06 0.8134532267615989 2.00012085882447e-06 0.8054479178086997 \
2.000121042247436e-06 0.7968539002302991 2.000121244752722e-06 0.7873346372610658 2.000121456402384e-06 0.7773555108975432 2.000121677392943e-06 0.7669228693561837 \
2.00012190658697e-06 0.7561055044419139 2.000122183106921e-06 0.743046509132553 2.000122468593645e-06 0.7295848836660939 2.000122789908539e-06 0.7144535604611002 \
2.00012307937846e-06 0.7008559708795014 2.000123398648317e-06 0.6858669291494816 2.000123719663687e-06 0.6708097907125149 2.000124061099719e-06 0.654842287100785 \
2.000124453723407e-06 0.6364912117266992 2.000124808317996e-06 0.6199451687359452 2.000125173105078e-06 0.602895395464039 2.00012557692179e-06 0.5840362041416589 \
2.000125940450357e-06 0.56705803755797 2.000126371026893e-06 0.546963725974103 2.000126727188766e-06 0.5303181638661557 2.000127100198166e-06 0.5128834705750704 \
2.000127442383275e-06 0.4969084729771704 2.000127762124839e-06 0.4820272854775881 2.000128079868868e-06 0.4673068400017517 2.00012837572031e-06 0.453709089639897 \
2.000128703744139e-06 0.4388357619204879 2.000129013234577e-06 0.4250513307906954 2.000129299733975e-06 0.412542701771394 2.000129612088515e-06 0.3991541929604193 \
2.000129902199714e-06 0.3870087322563178 2.000130215665733e-06 0.3741657412501236 2.000130493028614e-06 0.3630444214925196 2.000130774126111e-06 0.3519744117192101 \
2.000131005607364e-06 0.3430374849397334 2.000131234174756e-06 0.3343354151638595 2.00013147406666e-06 0.3253394991495989 2.000131731848444e-06 0.3158318026516087 \
2.000131981218358e-06 0.3067925439309827 2.000132239531266e-06 0.297589150170473 2.000132486062287e-06 0.2889540805256016 2.000132773357043e-06 0.2790758510850415 \
2.000132996736124e-06 0.2715471379396955 2.000133217531486e-06 0.2642409610398131 2.00013341340532e-06 0.2578652581015776 2.0001336001294e-06 0.2519000449202701 \
2.000133771320538e-06 0.2465102462678049 2.000133946364063e-06 0.2410522141953559 2.000134109381927e-06 0.236036359124031 2.000134270786368e-06 0.2311389431166576 \
2.000134424603758e-06 0.2265774065811171 2.00013457654048e-06 0.2221477024102725 2.000134730763452e-06 0.2177012931700853 2.000134904399052e-06 0.2127672920349684 \
2.000135054516093e-06 0.2085590788965803 2.000135188967813e-06 0.2048346911951331 2.000135333880152e-06 0.2008962005616911 2.000135495414782e-06 0.1965999354189458 \
2.000135644303198e-06 0.1927083727438147 2.000135788543376e-06 0.1889957157254755 2.000135913586713e-06 0.1858267544518093 2.000136010653492e-06 0.183392498065703 \
2.000136145647889e-06 0.1800503036180525 2.00013625516225e-06 0.1773760505692391 2.000136393137778e-06 0.1740872877198338 2.000136513150413e-06 0.1712726271080235 \
2.00013663003209e-06 0.1685704901364905 2.000136756660935e-06 0.1656849030049582 2.000136892675268e-06 0.1626308514974385 2.00013702606177e-06 0.1596764551685698 \
2.000137153003704e-06 0.1569158519548911 2.000137281621738e-06 0.1541678007478876 2.000137395548178e-06 0.1517740356345986 2.000137505859117e-06 0.149496521787741 \
2.00013761900036e-06 0.1472133997668396 2.000137732479436e-06 0.1449590740078549 2.000137857844221e-06 0.1425075003983929 2.000138003638108e-06 0.1397077962434051 \
2.000138186780095e-06 0.1362681166668699 2.0001383353875e-06 0.1335395672637218 2.000138447639322e-06 0.1315146079855561 2.000138576992755e-06 0.1292194206906994 \
2.000138670528911e-06 0.1275846423925092 2.00013877932072e-06 0.1257099890290588 2.000138873074832e-06 0.1241165438085202 2.000138956682436e-06 0.1227229754719547 \
2.0001390763363e-06 0.1207568051616409 2.000139205425261e-06 0.1186746054627577 2.000139322279497e-06 0.1168252031377112 2.000139453368507e-06 0.1147891811469644 \
2.000139598723523e-06 0.1125787883659796 2.000139764133423e-06 0.110121919024741 2.00013993287367e-06 0.1076798417306999 2.000140125753816e-06 0.1049622523271389 \
2.000140299731943e-06 0.1025767092705754 2.000140487918313e-06 0.1000644866129177 2.000140670319411e-06 0.09769892895340802 2.000140849911024e-06 0.09544952095403336 \
2.000141026408427e-06 0.09330553315647841 2.000141210964178e-06 0.09112768523704891 2.000141396209645e-06 0.08900465024544718 2.000141578281057e-06 0.0869768268327742 \
2.000141774345804e-06 0.08485812802288394 2.000141944746222e-06 0.08306894814141007 2.000142122986993e-06 0.08125105909257219 2.000142298679519e-06 0.07951206376949813 \
2.000142499080023e-06 0.07758728548656671 2.000142695934063e-06 0.07575734486890456 2.000142865868499e-06 0.07422427017287291 2.00014303651775e-06 0.07272580243814712 \
2.000143219642496e-06 0.07116311580983979 2.000143413259743e-06 0.06956233824397716 2.000143594846706e-06 0.06811311716920317 2.000143793421027e-06 0.06657819701521293 \
2.000143949952299e-06 0.06540254085633944 2.000144133522745e-06 0.06406078399206196 2.000144306484986e-06 0.06283331112669251 2.000144471995363e-06 0.06169268945721457 \
2.00014462033141e-06 0.06069691796619666 2.000144757229627e-06 0.05979937680937147 2.000144904867328e-06 0.05885633029244827 2.000145037955006e-06 0.05802735218158511 \
2.000145161474142e-06 0.05727448785321319 2.000145277510429e-06 0.05658054160001152 2.000145391123697e-06 0.05591352504042409 2.000145515745172e-06 0.05519553885869784 \
2.000145636542111e-06 0.05451306145814139 2.00014579648583e-06 0.0536298481755812 2.000145931832912e-06 0.05289991373180127 2.000146032152412e-06 0.05236888834064994 \
2.000146132622372e-06 0.05184552065910697 2.000146231565458e-06 0.05133799434906983 2.000146410070021e-06 0.05044349321929222 2.000146509870119e-06 0.04995513630881745 \
2.000146710035568e-06 0.04899962929156078 2.000146800952851e-06 0.04857581029502876 2.000147007746298e-06 0.04763487432244629 2.000147112976431e-06 0.0471681110353394 \
2.000147309354923e-06 0.04631787013837765 2.000147394633218e-06 0.04595693884580357 2.000147575095581e-06 0.04521002446657041 2.000147650260171e-06 0.04490525014776706 \
2.00014786811757e-06 0.0440422972058082 2.000147951636165e-06 0.04372097365614635 2.000148141571271e-06 0.04300637120866019 2.00014826631761e-06 0.04254845761102347 \
2.000148451543579e-06 0.0418846242551883 2.000148554382137e-06 0.04152415866453074 2.000148843894811e-06 0.04053983903151908 2.000148932816407e-06 0.04024621147044882 \
2.000149241486761e-06 0.03925784365481538 2.000149297645764e-06 0.03908306666491448 2.000149611207865e-06 0.03813491809530275 2.000149667163848e-06 0.037970533835152 \
2.000149994078164e-06 0.03703805601095747 2.000150047341397e-06 0.03689043863681411 2.000150353265485e-06 0.03606517121743442 2.000150453429214e-06 0.0358032254974586 \
2.000150772044909e-06 0.03499570355391716 2.000150861523872e-06 0.03477583942316619 2.000151259364459e-06 0.03383675925705845 2.000151377245794e-06 0.03357186655877694 \
2.000151789247958e-06 0.03268299960645597 2.000151949610851e-06 0.03235094877383871 2.000152320629234e-06 0.03161177976826059 2.000152540382686e-06 0.03119164460703521 \
2.000152983766919e-06 0.03038142203317581 2.00015323281055e-06 0.0299476098095271 2.0001537326667e-06 0.02912178892962563 2.000153951558277e-06 0.02877747133829427 \
2.000154434672084e-06 0.02805819238630505 2.000154723499337e-06 0.02765301209416409 2.000155410247302e-06 0.02674723311374961 2.000155699762857e-06 0.02638861276123805 \
2.000156475736135e-06 0.02548835782609031 2.000156647189526e-06 0.02530065249352256 2.00015743327132e-06 0.02449144648051316 2.000157637300354e-06 0.02429465554580218 \
2.000158746898316e-06 0.02329883562822865 2.000158847813389e-06 0.02321388155873386 2.000160039404086e-06 0.02227529349501467 2.000160244312294e-06 0.0221260927003824 \
2.000161697508364e-06 0.02113958380755909 2.000161932492782e-06 0.02098788030205876 2.000163439760696e-06 0.02004942094855779 2.000163760061111e-06 0.01985604392354444 \
2.000164974239457e-06 0.01910354072181233 2.000165447544128e-06 0.01879991394003632 2.000166748677981e-06 0.01794965119692995 2.000167138470568e-06 0.01770179815419311 \
2.000168537018733e-06 0.01679702456340363 2.000168863768813e-06 0.01658609683275075 2.00016998110407e-06 0.01586843585740347 2.000170689790368e-06 0.01544169959229912 \
2.000172422376366e-06 0.01449858640399567 2.000172671838817e-06 0.01436065672582198 2.000174469435716e-06 0.01337694399212387 2.000174812129382e-06 0.01319104500849105 \
2.000176988462895e-06 0.01225973435293598 2.00017727331928e-06 0.01213579497780986 2.000179172162672e-06 0.01126438850740638 2.00017965502513e-06 0.01103474467122418 \
2.000181927520555e-06 0.01014901321627989 2.000182315058726e-06 0.01002270433864562 2.000184966564885e-06 0.009023867700259034 2.000185262768817e-06 0.00890332747207802 \
2.000187604606991e-06 0.00793111507746596 2.000187858191315e-06 0.007825942613114227 2.000190880361057e-06 0.006881067894167194 2.00019112999456e-06 0.006804700431426973 \
2.000195007891808e-06 0.005817006850260108 2.000195235071384e-06 0.005760637946475626 2.00019804618962e-06 0.00490690852483563 2.000198480606374e-06 0.004760206508803379 \
2.000201010366652e-06 0.003858115577918713 2.000201428863181e-06 0.003712016323791173 2.000204453534309e-06 0.00274875962184498 2.000204733759441e-06 0.002664158024812898 \
2.000208530584646e-06 0.001697446565651876 2.000208884963991e-06 0.001621705150764489 2.000214411478996e-06 0.0006347476112661908 2.000214708963482e-06 0.0005888553763099016 \
2.000222216727447e-06 -0.0003928413941844093 2.000222438401114e-06 -0.0004189941252107796 2.000236530784873e-06 -0.001410461992184868 2.000236889612591e-06 -0.001430649730572865 \
2.000250237245412e-06 -0.0004514903228812461 2.000250464642513e-06 -0.0004111859973536986 2.000255915612065e-06 0.0005614551864591434 2.000256178897484e-06 0.0006110884748384679 \
2.000260810837492e-06 0.001592952619583714 2.000261118869639e-06 0.001665522059460669 2.00026495308288e-06 0.002626457037572999 2.000265337382884e-06 0.002733556882532277 \
2.000269071576166e-06 0.003682507088408038 2.000269273441449e-06 0.00374945551670179 2.000272897693538e-06 0.004734851451646972 2.000273092622753e-06 0.004780391513086043 \
2.000276479822177e-06 0.005766866152453508 2.000276671910697e-06 0.005810149709068801 2.000280887542283e-06 0.006750994364636406 2.000281221079492e-06 0.006821678237255247 \
2.000305948540302e-06 0.005867117768706426 2.000306261817208e-06 0.005806676405157672 2.000310893192981e-06 0.004863125825100585 2.000311165044221e-06 0.004806306550559217 \
2.000316109688101e-06 0.003825328200913169 2.000316576141932e-06 0.003739629632037282 2.00032248240585e-06 0.002770751168227681 2.000322776130159e-06 0.002729631326985271 \
2.000331621359071e-06 0.001738601807147118 2.000331808126426e-06 0.001722695496451883 2.000352036959148e-06 0.0007253105668073048 2.000353471598443e-06 0.0006873447391178559 \
2.058990000000011e-06 3.130932490801775e-06 2.061883407830385e-06 -0.0008819623910157972 2.061883643879234e-06 -0.001161970612476729 2.061884102325562e-06 -0.001847355627596629 \
2.061884345612697e-06 -0.002293620068582415 2.061884595896665e-06 -0.00281405583725217 2.061884846702668e-06 -0.003393671496214343 2.06188515952233e-06 -0.004199192998005251 \
2.061885397732202e-06 -0.004872003934560885 2.061885644182635e-06 -0.005621391842385397 2.061885875927131e-06 -0.006370319304257691 2.061886183112249e-06 -0.007411941938624838 \
2.061886448406181e-06 -0.008326397880259807 2.061886693685807e-06 -0.009131457988769647 2.061887058417362e-06 -0.01007334593757064 2.061887286488539e-06 -0.01033898456945748 \
2.061887610128182e-06 -0.009994868194499993 2.061887810544735e-06 -0.009187286872421443 2.061888045349532e-06 -0.007487931918614563 2.061888226424988e-06 -0.005544847192362645 \
2.061888332865277e-06 -0.004119573247771668 2.061888471151424e-06 -0.001940540768574745 2.061888582177386e-06 7.563183370691832e-05 2.061888702798821e-06 0.002536824544301687 \
2.061888805864002e-06 0.004857398676819782 2.061888944571287e-06 0.008289235792766818 2.061889065680578e-06 0.01156496544863939 2.06188921588438e-06 0.01596809792775087 \
2.06188939752999e-06 0.02176080367268303 2.06188954996521e-06 0.02698454055473338 2.061889726115454e-06 0.03339084366291074 2.0618899251156e-06 0.04103368087207344 \
2.061890094787538e-06 0.04784290449723066 2.061890273981514e-06 0.05527749234857952 2.061890434397879e-06 0.06211990493347131 2.061890596191838e-06 0.06916698107316244 \
2.061890754742719e-06 0.07620053909780501 2.061890921935392e-06 0.08372027851346725 2.061891092293318e-06 0.09147114401158042 2.061891271730565e-06 0.0997240648901548 \
2.061891461853091e-06 0.1085375718081032 2.061891661092053e-06 0.1178373860957827 2.061891865069359e-06 0.1274102212870429 2.06189208614423e-06 0.1378300800073513 \
2.0618923318008e-06 0.1494365474357121 2.061892589151043e-06 0.1616443690283554 2.061892871842139e-06 0.1750899465505063 2.06189316989355e-06 0.1892663579759593 \
2.061893516170121e-06 0.2057792515135755 2.06189388288524e-06 0.2232517522030736 2.061894278797486e-06 0.2421754728923703 2.061894713908854e-06 0.2629945242020292 \
2.06189519371884e-06 0.2859861135989593 2.0618957190371e-06 0.3113450809673837 2.061896243573264e-06 0.3367514755549041 2.061896840892739e-06 0.3658546932050024 \
2.061897607717859e-06 0.4033613755922033 2.061898046206797e-06 0.4246376380793622 2.061898522720377e-06 0.4473946242989675 2.061898972555967e-06 0.4684360091747882 \
2.061899525240159e-06 0.4936960927629759 2.061900223236364e-06 0.5245486808074998 2.061900837638476e-06 0.5507582774516211 2.061901405608978e-06 0.5741722555225199 \
2.061901935862247e-06 0.5952266004882081 2.061902394831628e-06 0.6128068198589096 2.061902977999792e-06 0.6341908714213341 2.061903551157707e-06 0.6541368834277531 \
2.061904141842032e-06 0.6735006351351156 2.061904810515341e-06 0.6939224431220803 2.061905465000487e-06 0.7123419857223411 2.06190621863161e-06 0.7316435145596337 \
2.061907138111349e-06 0.7524771687756806 2.061907807118464e-06 0.7658582308664672 2.061908502684848e-06 0.7783426900018873 2.061909224721799e-06 0.7898435797332509 \
2.061909871505064e-06 0.7989777190578581 2.061910686398373e-06 0.809051394855074 2.061911344291083e-06 0.8161084932798452 2.061912109055577e-06 0.8232971874420545 \
2.061912705588939e-06 0.8281915934352191 2.061913333612095e-06 0.8327857747397983 2.061913964004405e-06 0.8368636793792511 2.06191494962664e-06 0.8423301485602825 \
2.061915705380697e-06 0.8458701801587535 2.061916468671131e-06 0.8489683054605098 2.061917277011917e-06 0.8518111549479527 2.061918265903365e-06 0.8547854532963984 \
2.061919008958979e-06 0.8567085856698495 2.061919831636168e-06 0.8585940601366741 2.061920612856223e-06 0.8601698380186774 2.061921416459391e-06 0.8616111415036141 \
2.061922203727638e-06 0.8628649505886673 2.061923395730052e-06 0.8644986110026872 2.061924318352036e-06 0.8655887935537701 2.061925377279772e-06 0.8666437563732095 \
2.061926250370494e-06 0.8673888282159752 2.061927019427764e-06 0.8679394432393451 2.061932776083201e-06 0.8675354626998435 2.061933384736608e-06 0.8669285211992742 \
2.061934348633067e-06 0.8661637309277684 2.061934697027123e-06 0.8657877651307159 2.061935865736297e-06 0.8648718022682493 2.061936507439083e-06 0.8645495171393598 \
2.061937723779243e-06 0.8636149212264693 2.061938210995997e-06 0.8633315979857124 2.061941995751513e-06 0.8637879096652611 2.061942803560594e-06 0.8644940879742092 \
2.061943676731311e-06 0.8654118536506241 2.06194452584852e-06 0.8664722967159353 2.061945394320663e-06 0.8676408136092975 2.061946220799482e-06 0.8688316482847912 \
2.061947067273748e-06 0.8700680498371385 2.061947993731666e-06 0.8714353201417473 2.061948922751738e-06 0.8727967357236968 2.061949890373816e-06 0.874169309418928 \
2.061950892855429e-06 0.8755268793700145 2.061951975786211e-06 0.8769279254876977 2.061953154258897e-06 0.8783524184654903 2.061954367359833e-06 0.8797057189093218 \
2.061955697820692e-06 0.8810544625232946 2.061957146531982e-06 0.8823882385150326 2.061958814266774e-06 0.8837386794148741 2.061960446298639e-06 0.8848798336526329 \
2.061962413590837e-06 0.8860652157953401 2.061964590094435e-06 0.8871729764751287 2.061966862249877e-06 0.8881691778223457 2.061969135754954e-06 0.8889896378135498 \
2.061971087665695e-06 0.8895771814349003 2.061973972100292e-06 0.8902862350409186 2.061976831036635e-06 0.8908501300162286 2.061979913323748e-06 0.8913157385816455 \
2.06199173167453e-06 0.8922670755128276 2.061994058318612e-06 0.8924600956555456 2.062000939517426e-06 0.8933233934443291 2.062002931772882e-06 0.8936033182227321 \
2.062007596963998e-06 0.8943294235126149 2.062009934973581e-06 0.894763749611499 2.06201243532077e-06 0.8952990768365913 2.062014909223274e-06 0.8959385502707948 \
2.062017035318026e-06 0.8965630758105964 2.062019624621494e-06 0.8973958942958599 2.062022048641129e-06 0.8982427248493853 2.062024940455552e-06 0.8993469797885378 \
2.062027450127073e-06 0.9003588137389537 2.062030788570323e-06 0.9017079510157455 2.062033867543754e-06 0.9029423170929788 2.062037060622869e-06 0.9042497182071535 \
2.062039656279508e-06 0.9052493492427333 2.062041664531596e-06 0.9059572885738179 2.062043772760483e-06 0.9066594295388942 2.062046461477418e-06 0.907478492737931 \
2.062048917070081e-06 0.9081366525620301 2.062051281590183e-06 0.9087089258990763 2.062053876154591e-06 0.9092804446275633 2.062056243869825e-06 0.9097121154337445 \
2.062063636309535e-06 0.9105880439508957 2.06206694738543e-06 0.9108097973553667 2.062090631104211e-06 0.9099572430838525 2.062093524994068e-06 0.9096028008700563 \
2.062099633721785e-06 0.9087795762164674 2.062102664784937e-06 0.9083311497095887 2.062109022442901e-06 0.9073557537429059 2.062112916389034e-06 0.906719613226565 \
2.062116289356866e-06 0.9061475060281556 2.062119374914729e-06 0.9055946669458763 2.062123120629277e-06 0.9048996522446952 2.062126487017035e-06 0.9043394102803256 \
2.062134077462241e-06 0.9034499723753743 2.062137953472777e-06 0.9031904105967781 2.062165717708862e-06 0.9022140906736803 2.062169493868779e-06 0.902100877529562 \
2.062200910100546e-06 0.9011025155537421 2.062207545190393e-06 0.9009020504869808 2.100110550805801e-06 0.8999193627810952 2.10011071848179e-06 0.8998913840591389 \
2.100113467033027e-06 0.8989010293823864 2.100113523573982e-06 0.8988795941121664 2.100114768178511e-06 0.8998357618405769 2.100114847007516e-06 0.9000722811707415 \
2.100115028967664e-06 0.9007374088026997 2.10011513130788e-06 0.9011852075627013 2.100115324284061e-06 0.9021545909398002 2.100115412645943e-06 0.9026487433775175 \
2.100115571157197e-06 0.9036053969378676 2.100115683054863e-06 0.9043311123122415 2.100115823971993e-06 0.9052897461292233 2.100115929405144e-06 0.9060407976354218 \
2.100116042282183e-06 0.9068700067857125 2.100116156714019e-06 0.9077320749581511 2.100116277994792e-06 0.9086625635419388 2.100116407030339e-06 0.9096610759972766 \
2.100116529569199e-06 0.9106054665418637 2.100116653924139e-06 0.9115433813509556 2.100116768824237e-06 0.912370851358936 2.100116872924634e-06 0.9130668181210778 \
2.100116980506906e-06 0.9137127811079708 2.100117148007135e-06 0.914504286313051 2.100117619367398e-06 0.9145217838087505 2.100117817316352e-06 0.9131640269569251 \
2.100117978090595e-06 0.9113346267648944 2.100118066395334e-06 0.910041664336402 2.100118153928761e-06 0.908567258693449 2.100118246820306e-06 0.9067913249607207 \
2.100118320262759e-06 0.9052411278657534 2.100118409009881e-06 0.9032017134587504 2.100118546653074e-06 0.8996915735089056 2.100118658994696e-06 0.8965314120175644 \
2.100118782291717e-06 0.892778172623249 2.100118938496376e-06 0.8876402979533503 2.100119062012361e-06 0.8833010177194197 2.100119232383792e-06 0.8769686903427227 \
2.100119380003419e-06 0.8711968848515086 2.100119531854558e-06 0.8650238565011712 2.100119667983611e-06 0.8593172646418706 2.100119810047228e-06 0.8532105227807962 \
2.100119945331887e-06 0.8472784593397693 2.100120083991258e-06 0.8411010749315838 2.10012023129828e-06 0.8344514077702887 2.100120377865128e-06 0.8277635723525925 \
2.100120539944527e-06 0.8202964899226535 2.100120687311172e-06 0.8134532267615989 2.10012085882447e-06 0.8054479178086997 2.100121042247436e-06 0.7968539002302991 \
2.100121244752722e-06 0.7873346372610658 2.100121456402384e-06 0.7773555108975432 2.100121677392943e-06 0.7669228693561837 2.10012190658697e-06 0.7561055044419139 \
2.100122183106921e-06 0.743046509132553 2.100122468593645e-06 0.7295848836660939 2.100122789908539e-06 0.7144535604611002 2.100123079378459e-06 0.7008559708795014 \
2.100123398648317e-06 0.6858669291494816 2.100123719663687e-06 0.6708097907125149 2.100124061099719e-06 0.654842287100785 2.100124453723406e-06 0.6364912117266992 \
2.100124808317996e-06 0.6199451687359452 2.100125173105078e-06 0.602895395464039 2.10012557692179e-06 0.5840362041416589 2.100125940450357e-06 0.56705803755797 \
2.100126371026893e-06 0.546963725974103 2.100126727188766e-06 0.5303181638661557 2.100127100198166e-06 0.5128834705750704 2.100127442383275e-06 0.4969084729771704 \
2.100127762124838e-06 0.4820272854775881 2.100128079868868e-06 0.4673068400017517 2.10012837572031e-06 0.453709089639897 2.100128703744139e-06 0.4388357619204879 \
2.100129013234577e-06 0.4250513307906954 2.100129299733975e-06 0.412542701771394 2.100129612088515e-06 0.3991541929604193 2.100129902199714e-06 0.3870087322563178 \
2.100130215665733e-06 0.3741657412501236 2.100130493028614e-06 0.3630444214925196 2.100130774126111e-06 0.3519744117192101 2.100131005607363e-06 0.3430374849397334 \
2.100131234174756e-06 0.3343354151638595 2.10013147406666e-06 0.3253394991495989 2.100131731848444e-06 0.3158318026516087 2.100131981218358e-06 0.3067925439309827 \
2.100132239531266e-06 0.297589150170473 2.100132486062287e-06 0.2889540805256016 2.100132773357043e-06 0.2790758510850415 2.100132996736124e-06 0.2715471379396955 \
2.100133217531486e-06 0.2642409610398131 2.10013341340532e-06 0.2578652581015776 2.1001336001294e-06 0.2519000449202701 2.100133771320538e-06 0.2465102462678049 \
2.100133946364063e-06 0.2410522141953559 2.100134109381927e-06 0.236036359124031 2.100134270786368e-06 0.2311389431166576 2.100134424603758e-06 0.2265774065811171 \
2.10013457654048e-06 0.2221477024102725 2.100134730763452e-06 0.2177012931700853 2.100134904399052e-06 0.2127672920349684 2.100135054516093e-06 0.2085590788965803 \
2.100135188967813e-06 0.2048346911951331 2.100135333880152e-06 0.2008962005616911 2.100135495414782e-06 0.1965999354189458 2.100135644303198e-06 0.1927083727438147 \
2.100135788543376e-06 0.1889957157254755 2.100135913586713e-06 0.1858267544518093 2.100136010653492e-06 0.183392498065703 2.100136145647889e-06 0.1800503036180525 \
2.10013625516225e-06 0.1773760505692391 2.100136393137778e-06 0.1740872877198338 2.100136513150413e-06 0.1712726271080235 2.10013663003209e-06 0.1685704901364905 \
2.100136756660935e-06 0.1656849030049582 2.100136892675268e-06 0.1626308514974385 2.10013702606177e-06 0.1596764551685698 2.100137153003704e-06 0.1569158519548911 \
2.100137281621737e-06 0.1541678007478876 2.100137395548178e-06 0.1517740356345986 2.100137505859117e-06 0.149496521787741 2.10013761900036e-06 0.1472133997668396 \
2.100137732479436e-06 0.1449590740078549 2.100137857844221e-06 0.1425075003983929 2.100138003638108e-06 0.1397077962434051 2.100138186780095e-06 0.1362681166668699 \
2.1001383353875e-06 0.1335395672637218 2.100138447639322e-06 0.1315146079855561 2.100138576992755e-06 0.1292194206906994 2.100138670528911e-06 0.1275846423925092 \
2.10013877932072e-06 0.1257099890290588 2.100138873074831e-06 0.1241165438085202 2.100138956682436e-06 0.1227229754719547 2.1001390763363e-06 0.1207568051616409 \
2.100139205425261e-06 0.1186746054627577 2.100139322279497e-06 0.1168252031377112 2.100139453368507e-06 0.1147891811469644 2.100139598723523e-06 0.1125787883659796 \
2.100139764133423e-06 0.110121919024741 2.10013993287367e-06 0.1076798417306999 2.100140125753815e-06 0.1049622523271389 2.100140299731943e-06 0.1025767092705754 \
2.100140487918313e-06 0.1000644866129177 2.100140670319411e-06 0.09769892895340802 2.100140849911024e-06 0.09544952095403336 2.100141026408427e-06 0.09330553315647841 \
2.100141210964177e-06 0.09112768523704891 2.100141396209645e-06 0.08900465024544718 2.100141578281057e-06 0.0869768268327742 2.100141774345804e-06 0.08485812802288394 \
2.100141944746222e-06 0.08306894814141007 2.100142122986993e-06 0.08125105909257219 2.100142298679519e-06 0.07951206376949813 2.100142499080023e-06 0.07758728548656671 \
2.100142695934063e-06 0.07575734486890456 2.100142865868499e-06 0.07422427017287291 2.10014303651775e-06 0.07272580243814712 2.100143219642496e-06 0.07116311580983979 \
2.100143413259743e-06 0.06956233824397716 2.100143594846706e-06 0.06811311716920317 2.100143793421027e-06 0.06657819701521293 2.100143949952299e-06 0.06540254085633944 \
2.100144133522745e-06 0.06406078399206196 2.100144306484986e-06 0.06283331112669251 2.100144471995362e-06 0.06169268945721457 2.10014462033141e-06 0.06069691796619666 \
2.100144757229627e-06 0.05979937680937147 2.100144904867328e-06 0.05885633029244827 2.100145037955006e-06 0.05802735218158511 2.100145161474142e-06 0.05727448785321319 \
2.100145277510429e-06 0.05658054160001152 2.100145391123697e-06 0.05591352504042409 2.100145515745172e-06 0.05519553885869784 2.100145636542111e-06 0.05451306145814139 \
2.10014579648583e-06 0.0536298481755812 2.100145931832912e-06 0.05289991373180127 2.100146032152412e-06 0.05236888834064994 2.100146132622372e-06 0.05184552065910697 \
2.100146231565458e-06 0.05133799434906983 2.10014641007002e-06 0.05044349321929222 2.100146509870119e-06 0.04995513630881745 2.100146710035568e-06 0.04899962929156078 \
2.100146800952851e-06 0.04857581029502876 2.100147007746298e-06 0.04763487432244629 2.100147112976431e-06 0.0471681110353394 2.100147309354922e-06 0.04631787013837765 \
2.100147394633218e-06 0.04595693884580357 2.100147575095581e-06 0.04521002446657041 2.100147650260171e-06 0.04490525014776706 2.10014786811757e-06 0.0440422972058082 \
2.100147951636165e-06 0.04372097365614635 2.100148141571271e-06 0.04300637120866019 2.10014826631761e-06 0.04254845761102347 2.100148451543578e-06 0.0418846242551883 \
2.100148554382137e-06 0.04152415866453074 2.100148843894811e-06 0.04053983903151908 2.100148932816406e-06 0.04024621147044882 2.10014924148676e-06 0.03925784365481538 \
2.100149297645764e-06 0.03908306666491448 2.100149611207865e-06 0.03813491809530275 2.100149667163848e-06 0.037970533835152 2.100149994078164e-06 0.03703805601095747 \
2.100150047341397e-06 0.03689043863681411 2.100150353265485e-06 0.03606517121743442 2.100150453429214e-06 0.0358032254974586 2.100150772044909e-06 0.03499570355391716 \
2.100150861523872e-06 0.03477583942316619 2.100151259364459e-06 0.03383675925705845 2.100151377245794e-06 0.03357186655877694 2.100151789247958e-06 0.03268299960645597 \
2.10015194961085e-06 0.03235094877383871 2.100152320629234e-06 0.03161177976826059 2.100152540382686e-06 0.03119164460703521 2.100152983766918e-06 0.03038142203317581 \
2.10015323281055e-06 0.0299476098095271 2.1001537326667e-06 0.02912178892962563 2.100153951558277e-06 0.02877747133829427 2.100154434672084e-06 0.02805819238630505 \
2.100154723499337e-06 0.02765301209416409 2.100155410247302e-06 0.02674723311374961 2.100155699762857e-06 0.02638861276123805 2.100156475736135e-06 0.02548835782609031 \
2.100156647189526e-06 0.02530065249352256 2.10015743327132e-06 0.02449144648051316 2.100157637300353e-06 0.02429465554580218 2.100158746898316e-06 0.02329883562822865 \
2.100158847813389e-06 0.02321388155873386 2.100160039404086e-06 0.02227529349501467 2.100160244312293e-06 0.0221260927003824 2.100161697508364e-06 0.02113958380755909 \
2.100161932492782e-06 0.02098788030205876 2.100163439760696e-06 0.02004942094855779 2.100163760061111e-06 0.01985604392354444 2.100164974239457e-06 0.01910354072181233 \
2.100165447544128e-06 0.01879991394003632 2.100166748677981e-06 0.01794965119692995 2.100167138470568e-06 0.01770179815419311 2.100168537018732e-06 0.01679702456340363 \
2.100168863768812e-06 0.01658609683275075 2.10016998110407e-06 0.01586843585740347 2.100170689790367e-06 0.01544169959229912 2.100172422376366e-06 0.01449858640399567 \
2.100172671838817e-06 0.01436065672582198 2.100174469435716e-06 0.01337694399212387 2.100174812129382e-06 0.01319104500849105 2.100176988462895e-06 0.01225973435293598 \
2.10017727331928e-06 0.01213579497780986 2.100179172162672e-06 0.01126438850740638 2.10017965502513e-06 0.01103474467122418 2.100181927520555e-06 0.01014901321627989 \
2.100182315058726e-06 0.01002270433864562 2.100184966564885e-06 0.009023867700259034 2.100185262768817e-06 0.00890332747207802 2.100187604606991e-06 0.00793111507746596 \
2.100187858191315e-06 0.007825942613114227 2.100190880361057e-06 0.006881067894167194 2.10019112999456e-06 0.006804700431426973 2.100195007891808e-06 0.005817006850260108 \
2.100195235071384e-06 0.005760637946475626 2.100198046189619e-06 0.00490690852483563 2.100198480606374e-06 0.004760206508803379 2.100201010366652e-06 0.003858115577918713 \
2.100201428863181e-06 0.003712016323791173 2.100204453534309e-06 0.00274875962184498 2.100204733759441e-06 0.002664158024812898 2.100208530584646e-06 0.001697446565651876 \
2.100208884963991e-06 0.001621705150764489 2.100214411478996e-06 0.0006347476112661908 2.100214708963482e-06 0.0005888553763099016 2.100222216727447e-06 -0.0003928413941844093 \
2.100222438401114e-06 -0.0004189941252107796 2.100236530784873e-06 -0.001410461992184868 2.100236889612591e-06 -0.001430649730572865 2.100250237245412e-06 -0.0004514903228812461 \
2.100250464642513e-06 -0.0004111859973536986 2.100255915612065e-06 0.0005614551864591434 2.100256178897484e-06 0.0006110884748384679 2.100260810837492e-06 0.001592952619583714 \
2.100261118869639e-06 0.001665522059460669 2.10026495308288e-06 0.002626457037572999 2.100265337382884e-06 0.002733556882532277 2.100269071576166e-06 0.003682507088408038 \
2.100269273441448e-06 0.00374945551670179 2.100272897693538e-06 0.004734851451646972 2.100273092622753e-06 0.004780391513086043 2.100276479822177e-06 0.005766866152453508 \
2.100276671910697e-06 0.005810149709068801 2.100280887542283e-06 0.006750994364636406 2.100281221079492e-06 0.006821678237255247 2.100305948540302e-06 0.005867117768706426 \
2.100306261817208e-06 0.005806676405157672 2.10031089319298e-06 0.004863125825100585 2.100311165044221e-06 0.004806306550559217 2.100316109688101e-06 0.003825328200913169 \
2.100316576141932e-06 0.003739629632037282 2.10032248240585e-06 0.002770751168227681 2.100322776130159e-06 0.002729631326985271 2.100331621359071e-06 0.001738601807147118 \
2.100331808126426e-06 0.001722695496451883 2.100352036959148e-06 0.0007253105668073048 2.100353471598443e-06 0.0006873447391178559 2.158990000000011e-06 3.130932490801775e-06 \
2.161883407830385e-06 -0.0008819623910157972 2.161883643879234e-06 -0.001161970612476729 2.161884102325562e-06 -0.001847355627596629 2.161884345612697e-06 -0.002293620068582415 \
2.161884595896665e-06 -0.00281405583725217 2.161884846702668e-06 -0.003393671496214343 2.16188515952233e-06 -0.004199192998005251 2.161885397732201e-06 -0.004872003934560885 \
2.161885644182635e-06 -0.005621391842385397 2.161885875927131e-06 -0.006370319304257691 2.161886183112249e-06 -0.007411941938624838 2.161886448406181e-06 -0.008326397880259807 \
2.161886693685807e-06 -0.009131457988769647 2.161887058417362e-06 -0.01007334593757064 2.161887286488539e-06 -0.01033898456945748 2.161887610128182e-06 -0.009994868194499993 \
2.161887810544735e-06 -0.009187286872421443 2.161888045349532e-06 -0.007487931918614563 2.161888226424988e-06 -0.005544847192362645 2.161888332865277e-06 -0.004119573247771668 \
2.161888471151423e-06 -0.001940540768574745 2.161888582177386e-06 7.563183370691832e-05 2.161888702798821e-06 0.002536824544301687 2.161888805864002e-06 0.004857398676819782 \
2.161888944571287e-06 0.008289235792766818 2.161889065680578e-06 0.01156496544863939 2.16188921588438e-06 0.01596809792775087 2.16188939752999e-06 0.02176080367268303 \
2.161889549965209e-06 0.02698454055473338 2.161889726115454e-06 0.03339084366291074 2.1618899251156e-06 0.04103368087207344 2.161890094787538e-06 0.04784290449723066 \
2.161890273981514e-06 0.05527749234857952 2.161890434397879e-06 0.06211990493347131 2.161890596191838e-06 0.06916698107316244 2.161890754742719e-06 0.07620053909780501 \
2.161890921935392e-06 0.08372027851346725 2.161891092293318e-06 0.09147114401158042 2.161891271730565e-06 0.0997240648901548 2.161891461853091e-06 0.1085375718081032 \
2.161891661092053e-06 0.1178373860957827 2.161891865069358e-06 0.1274102212870429 2.16189208614423e-06 0.1378300800073513 2.1618923318008e-06 0.1494365474357121 \
2.161892589151043e-06 0.1616443690283554 2.161892871842139e-06 0.1750899465505063 2.16189316989355e-06 0.1892663579759593 2.161893516170121e-06 0.2057792515135755 \
2.16189388288524e-06 0.2232517522030736 2.161894278797486e-06 0.2421754728923703 2.161894713908853e-06 0.2629945242020292 2.16189519371884e-06 0.2859861135989593 \
2.1618957190371e-06 0.3113450809673837 2.161896243573264e-06 0.3367514755549041 2.161896840892738e-06 0.3658546932050024 2.161897607717859e-06 0.4033613755922033 \
2.161898046206797e-06 0.4246376380793622 2.161898522720377e-06 0.4473946242989675 2.161898972555967e-06 0.4684360091747882 2.161899525240159e-06 0.4936960927629759 \
2.161900223236364e-06 0.5245486808074998 2.161900837638476e-06 0.5507582774516211 2.161901405608978e-06 0.5741722555225199 2.161901935862247e-06 0.5952266004882081 \
2.161902394831628e-06 0.6128068198589096 2.161902977999792e-06 0.6341908714213341 2.161903551157707e-06 0.6541368834277531 2.161904141842032e-06 0.6735006351351156 \
2.161904810515341e-06 0.6939224431220803 2.161905465000486e-06 0.7123419857223411 2.16190621863161e-06 0.7316435145596337 2.161907138111349e-06 0.7524771687756806 \
2.161907807118464e-06 0.7658582308664672 2.161908502684848e-06 0.7783426900018873 2.161909224721799e-06 0.7898435797332509 2.161909871505064e-06 0.7989777190578581 \
2.161910686398373e-06 0.809051394855074 2.161911344291083e-06 0.8161084932798452 2.161912109055577e-06 0.8232971874420545 2.161912705588939e-06 0.8281915934352191 \
2.161913333612095e-06 0.8327857747397983 2.161913964004405e-06 0.8368636793792511 2.16191494962664e-06 0.8423301485602825 2.161915705380697e-06 0.8458701801587535 \
2.161916468671131e-06 0.8489683054605098 2.161917277011917e-06 0.8518111549479527 2.161918265903365e-06 0.8547854532963984 2.161919008958979e-06 0.8567085856698495 \
2.161919831636168e-06 0.8585940601366741 2.161920612856223e-06 0.8601698380186774 2.161921416459391e-06 0.8616111415036141 2.161922203727637e-06 0.8628649505886673 \
2.161923395730052e-06 0.8644986110026872 2.161924318352036e-06 0.8655887935537701 2.161925377279772e-06 0.8666437563732095 2.161926250370494e-06 0.8673888282159752 \
2.161927019427764e-06 0.8679394432393451 2.161932776083201e-06 0.8675354626998435 2.161933384736608e-06 0.8669285211992742 2.161934348633067e-06 0.8661637309277684 \
2.161934697027122e-06 0.8657877651307159 2.161935865736297e-06 0.8648718022682493 2.161936507439083e-06 0.8645495171393598 2.161937723779243e-06 0.8636149212264693 \
2.161938210995997e-06 0.8633315979857124 2.161941995751513e-06 0.8637879096652611 2.161942803560593e-06 0.8644940879742092 2.161943676731311e-06 0.8654118536506241 \
2.16194452584852e-06 0.8664722967159353 2.161945394320663e-06 0.8676408136092975 2.161946220799482e-06 0.8688316482847912 2.161947067273748e-06 0.8700680498371385 \
2.161947993731666e-06 0.8714353201417473 2.161948922751738e-06 0.8727967357236968 2.161949890373816e-06 0.874169309418928 2.161950892855429e-06 0.8755268793700145 \
2.161951975786211e-06 0.8769279254876977 2.161953154258897e-06 0.8783524184654903 2.161954367359833e-06 0.8797057189093218 2.161955697820691e-06 0.8810544625232946 \
2.161957146531982e-06 0.8823882385150326 2.161958814266774e-06 0.8837386794148741 2.161960446298639e-06 0.8848798336526329 2.161962413590837e-06 0.8860652157953401 \
2.161964590094435e-06 0.8871729764751287 2.161966862249876e-06 0.8881691778223457 2.161969135754954e-06 0.8889896378135498 2.161971087665695e-06 0.8895771814349003 \
2.161973972100291e-06 0.8902862350409186 2.161976831036635e-06 0.8908501300162286 2.161979913323748e-06 0.8913157385816455 2.16199173167453e-06 0.8922670755128276 \
2.161994058318611e-06 0.8924600956555456 2.162000939517426e-06 0.8933233934443291 2.162002931772882e-06 0.8936033182227321 2.162007596963998e-06 0.8943294235126149 \
2.162009934973581e-06 0.894763749611499 2.16201243532077e-06 0.8952990768365913 2.162014909223274e-06 0.8959385502707948 2.162017035318026e-06 0.8965630758105964 \
2.162019624621494e-06 0.8973958942958599 2.162022048641129e-06 0.8982427248493853 2.162024940455552e-06 0.8993469797885378 2.162027450127073e-06 0.9003588137389537 \
2.162030788570323e-06 0.9017079510157455 2.162033867543754e-06 0.9029423170929788 2.162037060622869e-06 0.9042497182071535 2.162039656279508e-06 0.9052493492427333 \
2.162041664531596e-06 0.9059572885738179 2.162043772760482e-06 0.9066594295388942 2.162046461477418e-06 0.907478492737931 2.162048917070081e-06 0.9081366525620301 \
2.162051281590183e-06 0.9087089258990763 2.162053876154591e-06 0.9092804446275633 2.162056243869825e-06 0.9097121154337445 2.162063636309534e-06 0.9105880439508957 \
2.16206694738543e-06 0.9108097973553667 2.16209063110421e-06 0.9099572430838525 2.162093524994068e-06 0.9096028008700563 2.162099633721785e-06 0.9087795762164674 \
2.162102664784937e-06 0.9083311497095887 2.162109022442901e-06 0.9073557537429059 2.162112916389034e-06 0.906719613226565 2.162116289356866e-06 0.9061475060281556 \
2.162119374914729e-06 0.9055946669458763 2.162123120629277e-06 0.9048996522446952 2.162126487017035e-06 0.9043394102803256 2.162134077462241e-06 0.9034499723753743 \
2.162137953472777e-06 0.9031904105967781 2.162165717708862e-06 0.9022140906736803 2.162169493868778e-06 0.902100877529562 2.162200910100546e-06 0.9011025155537421 \
2.162207545190393e-06 0.9009020504869808 2.200110550805801e-06 0.8999193627810952 2.20011071848179e-06 0.8998913840591389 2.200113467033027e-06 0.8989010293823864 \
2.200113523573982e-06 0.8988795941121664 2.200114768178511e-06 0.8998357618405769 2.200114847007516e-06 0.9000722811707415 2.200115028967664e-06 0.9007374088026997 \
2.20011513130788e-06 0.9011852075627013 2.200115324284061e-06 0.9021545909398002 2.200115412645943e-06 0.9026487433775175 2.200115571157197e-06 0.9036053969378676 \
2.200115683054862e-06 0.9043311123122415 2.200115823971993e-06 0.9052897461292233 2.200115929405144e-06 0.9060407976354218 2.200116042282183e-06 0.9068700067857125 \
2.200116156714019e-06 0.9077320749581511 2.200116277994792e-06 0.9086625635419388 2.200116407030339e-06 0.9096610759972766 2.200116529569199e-06 0.9106054665418637 \
2.200116653924139e-06 0.9115433813509556 2.200116768824237e-06 0.912370851358936 2.200116872924634e-06 0.9130668181210778 2.200116980506906e-06 0.9137127811079708 \
2.200117148007135e-06 0.914504286313051 2.200117619367398e-06 0.9145217838087505 2.200117817316352e-06 0.9131640269569251 2.200117978090595e-06 0.9113346267648944 \
2.200118066395334e-06 0.910041664336402 2.200118153928761e-06 0.908567258693449 2.200118246820306e-06 0.9067913249607207 2.200118320262759e-06 0.9052411278657534 \
2.200118409009881e-06 0.9032017134587504 2.200118546653074e-06 0.8996915735089056 2.200118658994696e-06 0.8965314120175644 2.200118782291717e-06 0.892778172623249 \
2.200118938496375e-06 0.8876402979533503 2.200119062012361e-06 0.8833010177194197 2.200119232383792e-06 0.8769686903427227 2.200119380003419e-06 0.8711968848515086 \
2.200119531854558e-06 0.8650238565011712 2.200119667983611e-06 0.8593172646418706 2.200119810047228e-06 0.8532105227807962 2.200119945331887e-06 0.8472784593397693 \
2.200120083991258e-06 0.8411010749315838 2.20012023129828e-06 0.8344514077702887 2.200120377865128e-06 0.8277635723525925 2.200120539944527e-06 0.8202964899226535 \
2.200120687311172e-06 0.8134532267615989 2.20012085882447e-06 0.8054479178086997 2.200121042247435e-06 0.7968539002302991 2.200121244752722e-06 0.7873346372610658 \
2.200121456402384e-06 0.7773555108975432 2.200121677392943e-06 0.7669228693561837 2.20012190658697e-06 0.7561055044419139 2.200122183106921e-06 0.743046509132553 \
2.200122468593644e-06 0.7295848836660939 2.200122789908538e-06 0.7144535604611002 2.200123079378459e-06 0.7008559708795014 2.200123398648317e-06 0.6858669291494816 \
2.200123719663687e-06 0.6708097907125149 2.200124061099718e-06 0.654842287100785 2.200124453723406e-06 0.6364912117266992 2.200124808317996e-06 0.6199451687359452 \
2.200125173105078e-06 0.602895395464039 2.200125576921789e-06 0.5840362041416589 2.200125940450356e-06 0.56705803755797 2.200126371026893e-06 0.546963725974103 \
2.200126727188766e-06 0.5303181638661557 2.200127100198165e-06 0.5128834705750704 2.200127442383275e-06 0.4969084729771704 2.200127762124838e-06 0.4820272854775881 \
2.200128079868868e-06 0.4673068400017517 2.20012837572031e-06 0.453709089639897 2.200128703744139e-06 0.4388357619204879 2.200129013234576e-06 0.4250513307906954 \
2.200129299733975e-06 0.412542701771394 2.200129612088515e-06 0.3991541929604193 2.200129902199714e-06 0.3870087322563178 2.200130215665733e-06 0.3741657412501236 \
2.200130493028613e-06 0.3630444214925196 2.200130774126111e-06 0.3519744117192101 2.200131005607363e-06 0.3430374849397334 2.200131234174756e-06 0.3343354151638595 \
2.20013147406666e-06 0.3253394991495989 2.200131731848444e-06 0.3158318026516087 2.200131981218358e-06 0.3067925439309827 2.200132239531266e-06 0.297589150170473 \
2.200132486062287e-06 0.2889540805256016 2.200132773357043e-06 0.2790758510850415 2.200132996736124e-06 0.2715471379396955 2.200133217531486e-06 0.2642409610398131 \
2.20013341340532e-06 0.2578652581015776 2.2001336001294e-06 0.2519000449202701 2.200133771320538e-06 0.2465102462678049 2.200133946364063e-06 0.2410522141953559 \
2.200134109381927e-06 0.236036359124031 2.200134270786368e-06 0.2311389431166576 2.200134424603758e-06 0.2265774065811171 2.200134576540479e-06 0.2221477024102725 \
2.200134730763452e-06 0.2177012931700853 2.200134904399052e-06 0.2127672920349684 2.200135054516093e-06 0.2085590788965803 2.200135188967813e-06 0.2048346911951331 \
2.200135333880152e-06 0.2008962005616911 2.200135495414781e-06 0.1965999354189458 2.200135644303198e-06 0.1927083727438147 2.200135788543376e-06 0.1889957157254755 \
2.200135913586713e-06 0.1858267544518093 2.200136010653492e-06 0.183392498065703 2.200136145647889e-06 0.1800503036180525 2.20013625516225e-06 0.1773760505692391 \
2.200136393137778e-06 0.1740872877198338 2.200136513150413e-06 0.1712726271080235 2.200136630032089e-06 0.1685704901364905 2.200136756660935e-06 0.1656849030049582 \
2.200136892675268e-06 0.1626308514974385 2.20013702606177e-06 0.1596764551685698 2.200137153003704e-06 0.1569158519548911 2.200137281621737e-06 0.1541678007478876 \
2.200137395548178e-06 0.1517740356345986 2.200137505859117e-06 0.149496521787741 2.20013761900036e-06 0.1472133997668396 2.200137732479435e-06 0.1449590740078549 \
2.200137857844221e-06 0.1425075003983929 2.200138003638108e-06 0.1397077962434051 2.200138186780095e-06 0.1362681166668699 2.2001383353875e-06 0.1335395672637218 \
2.200138447639322e-06 0.1315146079855561 2.200138576992754e-06 0.1292194206906994 2.20013867052891e-06 0.1275846423925092 2.20013877932072e-06 0.1257099890290588 \
2.200138873074831e-06 0.1241165438085202 2.200138956682436e-06 0.1227229754719547 2.2001390763363e-06 0.1207568051616409 2.200139205425261e-06 0.1186746054627577 \
2.200139322279497e-06 0.1168252031377112 2.200139453368507e-06 0.1147891811469644 2.200139598723523e-06 0.1125787883659796 2.200139764133423e-06 0.110121919024741 \
2.20013993287367e-06 0.1076798417306999 2.200140125753815e-06 0.1049622523271389 2.200140299731943e-06 0.1025767092705754 2.200140487918313e-06 0.1000644866129177 \
2.20014067031941e-06 0.09769892895340802 2.200140849911024e-06 0.09544952095403336 2.200141026408427e-06 0.09330553315647841 2.200141210964177e-06 0.09112768523704891 \
2.200141396209645e-06 0.08900465024544718 2.200141578281057e-06 0.0869768268327742 2.200141774345804e-06 0.08485812802288394 2.200141944746222e-06 0.08306894814141007 \
2.200142122986992e-06 0.08125105909257219 2.200142298679518e-06 0.07951206376949813 2.200142499080023e-06 0.07758728548656671 2.200142695934063e-06 0.07575734486890456 \
2.200142865868499e-06 0.07422427017287291 2.20014303651775e-06 0.07272580243814712 2.200143219642496e-06 0.07116311580983979 2.200143413259743e-06 0.06956233824397716 \
2.200143594846706e-06 0.06811311716920317 2.200143793421027e-06 0.06657819701521293 2.200143949952299e-06 0.06540254085633944 2.200144133522745e-06 0.06406078399206196 \
2.200144306484986e-06 0.06283331112669251 2.200144471995362e-06 0.06169268945721457 2.20014462033141e-06 0.06069691796619666 2.200144757229627e-06 0.05979937680937147 \
2.200144904867328e-06 0.05885633029244827 2.200145037955006e-06 0.05802735218158511 2.200145161474142e-06 0.05727448785321319 2.200145277510429e-06 0.05658054160001152 \
2.200145391123697e-06 0.05591352504042409 2.200145515745172e-06 0.05519553885869784 2.200145636542111e-06 0.05451306145814139 2.20014579648583e-06 0.0536298481755812 \
2.200145931832912e-06 0.05289991373180127 2.200146032152412e-06 0.05236888834064994 2.200146132622372e-06 0.05184552065910697 2.200146231565458e-06 0.05133799434906983 \
2.20014641007002e-06 0.05044349321929222 2.200146509870119e-06 0.04995513630881745 2.200146710035568e-06 0.04899962929156078 2.200146800952851e-06 0.04857581029502876 \
2.200147007746298e-06 0.04763487432244629 2.20014711297643e-06 0.0471681110353394 2.200147309354922e-06 0.04631787013837765 2.200147394633218e-06 0.04595693884580357 \
2.200147575095581e-06 0.04521002446657041 2.200147650260171e-06 0.04490525014776706 2.20014786811757e-06 0.0440422972058082 2.200147951636165e-06 0.04372097365614635 \
2.200148141571271e-06 0.04300637120866019 2.20014826631761e-06 0.04254845761102347 2.200148451543578e-06 0.0418846242551883 2.200148554382137e-06 0.04152415866453074 \
2.200148843894811e-06 0.04053983903151908 2.200148932816406e-06 0.04024621147044882 2.20014924148676e-06 0.03925784365481538 2.200149297645764e-06 0.03908306666491448 \
2.200149611207865e-06 0.03813491809530275 2.200149667163848e-06 0.037970533835152 2.200149994078164e-06 0.03703805601095747 2.200150047341397e-06 0.03689043863681411 \
2.200150353265485e-06 0.03606517121743442 2.200150453429213e-06 0.0358032254974586 2.200150772044909e-06 0.03499570355391716 2.200150861523872e-06 0.03477583942316619 \
2.200151259364458e-06 0.03383675925705845 2.200151377245794e-06 0.03357186655877694 2.200151789247958e-06 0.03268299960645597 2.20015194961085e-06 0.03235094877383871 \
2.200152320629234e-06 0.03161177976826059 2.200152540382686e-06 0.03119164460703521 2.200152983766918e-06 0.03038142203317581 2.20015323281055e-06 0.0299476098095271 \
2.2001537326667e-06 0.02912178892962563 2.200153951558277e-06 0.02877747133829427 2.200154434672084e-06 0.02805819238630505 2.200154723499336e-06 0.02765301209416409 \
2.200155410247302e-06 0.02674723311374961 2.200155699762857e-06 0.02638861276123805 2.200156475736135e-06 0.02548835782609031 2.200156647189525e-06 0.02530065249352256 \
2.20015743327132e-06 0.02449144648051316 2.200157637300353e-06 0.02429465554580218 2.200158746898316e-06 0.02329883562822865 2.200158847813389e-06 0.02321388155873386 \
2.200160039404086e-06 0.02227529349501467 2.200160244312293e-06 0.0221260927003824 2.200161697508364e-06 0.02113958380755909 2.200161932492781e-06 0.02098788030205876 \
2.200163439760696e-06 0.02004942094855779 2.20016376006111e-06 0.01985604392354444 2.200164974239457e-06 0.01910354072181233 2.200165447544128e-06 0.01879991394003632 \
2.200166748677981e-06 0.01794965119692995 2.200167138470568e-06 0.01770179815419311 2.200168537018732e-06 0.01679702456340363 2.200168863768812e-06 0.01658609683275075 \
2.200169981104069e-06 0.01586843585740347 2.200170689790367e-06 0.01544169959229912 2.200172422376366e-06 0.01449858640399567 2.200172671838817e-06 0.01436065672582198 \
2.200174469435716e-06 0.01337694399212387 2.200174812129382e-06 0.01319104500849105 2.200176988462895e-06 0.01225973435293598 2.200177273319279e-06 0.01213579497780986 \
2.200179172162672e-06 0.01126438850740638 2.200179655025129e-06 0.01103474467122418 2.200181927520555e-06 0.01014901321627989 2.200182315058726e-06 0.01002270433864562 \
2.200184966564885e-06 0.009023867700259034 2.200185262768816e-06 0.00890332747207802 2.200187604606991e-06 0.00793111507746596 2.200187858191315e-06 0.007825942613114227 \
2.200190880361057e-06 0.006881067894167194 2.20019112999456e-06 0.006804700431426973 2.200195007891808e-06 0.005817006850260108 2.200195235071384e-06 0.005760637946475626 \
2.200198046189619e-06 0.00490690852483563 2.200198480606374e-06 0.004760206508803379 2.200201010366652e-06 0.003858115577918713 2.200201428863181e-06 0.003712016323791173 \
2.200204453534309e-06 0.00274875962184498 2.200204733759441e-06 0.002664158024812898 2.200208530584646e-06 0.001697446565651876 2.200208884963991e-06 0.001621705150764489 \
2.200214411478996e-06 0.0006347476112661908 2.200214708963481e-06 0.0005888553763099016 2.200222216727447e-06 -0.0003928413941844093 2.200222438401114e-06 -0.0004189941252107796 \
2.200236530784872e-06 -0.001410461992184868 2.200236889612591e-06 -0.001430649730572865 2.200250237245411e-06 -0.0004514903228812461 2.200250464642512e-06 -0.0004111859973536986 \
2.200255915612065e-06 0.0005614551864591434 2.200256178897484e-06 0.0006110884748384679 2.200260810837491e-06 0.001592952619583714 2.200261118869639e-06 0.001665522059460669 \
2.20026495308288e-06 0.002626457037572999 2.200265337382884e-06 0.002733556882532277 2.200269071576165e-06 0.003682507088408038 2.200269273441448e-06 0.00374945551670179 \
2.200272897693538e-06 0.004734851451646972 2.200273092622753e-06 0.004780391513086043 2.200276479822177e-06 0.005766866152453508 2.200276671910697e-06 0.005810149709068801 \
2.200280887542283e-06 0.006750994364636406 2.200281221079492e-06 0.006821678237255247 2.200305948540302e-06 0.005867117768706426 2.200306261817208e-06 0.005806676405157672 \
2.20031089319298e-06 0.004863125825100585 2.200311165044221e-06 0.004806306550559217 2.200316109688101e-06 0.003825328200913169 2.200316576141932e-06 0.003739629632037282 \
2.200322482405849e-06 0.002770751168227681 2.200322776130158e-06 0.002729631326985271 2.200331621359071e-06 0.001738601807147118 2.200331808126426e-06 0.001722695496451883 \
2.200352036959148e-06 0.0007253105668073048 2.200353471598443e-06 0.0006873447391178559 2.258990000000011e-06 3.130932490801775e-06 2.259e-06 3.130932490801775e-06 \
]
VCLOCK (CLK 0) vsource type=pwl wave=[ \
0 3.149426381262906e-06 1.027466670270133e-07 -0.0009024818035526668 1.027467394426295e-07 -0.001022682652537627 1.027471754673471e-07 -0.001858525046639076 \
1.027472623617301e-07 -0.002046124893065343 1.027476170650434e-07 -0.00288168582347465 1.027477166116442e-07 -0.003135075204051477 1.027479768813486e-07 -0.003828199033013717 \
1.027481172037501e-07 -0.004216406518003108 1.027483446898323e-07 -0.004856871791621592 1.027484818972713e-07 -0.005239031028659006 1.0274886679612e-07 -0.006187559915121 \
1.027489988933069e-07 -0.006423332025500122 1.027496873363354e-07 -0.005917035979538006 1.027498442650689e-07 -0.005202654566481615 1.027499719142314e-07 -0.004414133290428114 \
1.027500994560215e-07 -0.003433350487145549 1.027502171302335e-07 -0.002355902309038119 1.027503162699201e-07 -0.001320627313728655 1.027504216526298e-07 -9.507383675133965e-05 \
1.027505355599331e-07 0.001369964538583592 1.027506666153286e-07 0.003229572948258866 1.027507919785475e-07 0.005172303930030842 1.027509838204114e-07 0.008432154569684791 \
1.027511274902044e-07 0.01107975669588844 1.027512854720174e-07 0.01417105828876112 1.027514340716643e-07 0.01723098336859398 1.02751587122593e-07 0.02051714008521248 \
1.027517461875693e-07 0.02405720796424875 1.02751899257778e-07 0.02756764950178633 1.027520476048421e-07 0.03105219347129199 1.027521967112842e-07 0.03462388853332505 \
1.027523512757131e-07 0.03838854885099419 1.027525119616768e-07 0.04235886888523473 1.027526766408632e-07 0.04647718198980624 1.027528531638066e-07 0.05093664320808645 \
1.027530321756059e-07 0.05549818742091989 1.027532229484479e-07 0.0603932190016783 1.027534277958001e-07 0.06567927942044927 1.027536482930531e-07 0.07139554989571946 \
1.027538812110213e-07 0.07745499876455469 1.027541304587992e-07 0.08395499695136356 1.027544033803266e-07 0.09108394918256098 1.027547001733835e-07 0.09884095133633181 \
1.027550276098956e-07 0.1073964775374675 1.027553974236946e-07 0.1170487607486894 1.027557923699755e-07 0.1273407304921971 1.027562504585284e-07 0.1392499850125259 \
1.027567825583881e-07 0.1530377249371455 1.027574081103967e-07 0.169180864038255 1.027580941024627e-07 0.1867931863309214 1.027588969458782e-07 0.2072766958045763 \
1.027597962582096e-07 0.2300508264895909 1.027606966983226e-07 0.2526618731709107 1.027614985898552e-07 0.2726215666318766 1.027621940969962e-07 0.2897857674353052 \
1.027628269312821e-07 0.3052728323588638 1.027634223397735e-07 0.3197161646377594 1.027639693828152e-07 0.3328722959176427 1.027645031431617e-07 0.3455929446372428 \
1.027650223825863e-07 0.3578476146335662 1.027655297740487e-07 0.3697097539883151 1.027660333952181e-07 0.3813674725871593 1.027665451381145e-07 0.3930934709428262 \
1.027670522991229e-07 0.404595334768291 1.027675825951367e-07 0.4164962117964878 1.027680687086257e-07 0.4272847049163567 1.027685468169473e-07 0.437781779057129 \
1.027689862490711e-07 0.4473362978389137 1.027691094085349e-07 0.4500002106608159 1.027693557274626e-07 0.4553046876287923 1.027696989994585e-07 0.4626558934952216 \
1.02770010436459e-07 0.4692815017887791 1.027702611477243e-07 0.4745855323881177 1.027705319768677e-07 0.480281321066213 1.02770868458777e-07 0.4873122872019196 \
1.027712244673881e-07 0.4946959640027882 1.027715417375557e-07 0.5012322602315481 1.027717806181048e-07 0.506122906570856 1.027720216462867e-07 0.5110269393752048 \
1.027722735779908e-07 0.5161276795544476 1.027725137318346e-07 0.5209621749612534 1.027727364832964e-07 0.5254248476203834 1.027729250409435e-07 0.5291850880529715 \
1.027731397909867e-07 0.5334523706207774 1.027733543393784e-07 0.5376948565446859 1.027736131036701e-07 0.5427871977552768 1.027738639312417e-07 0.5477009885064807 \
1.027741193501039e-07 0.5526782776843104 1.027744703926295e-07 0.5594898819265107 1.027747350009544e-07 0.5645984056527484 1.027750014175097e-07 0.569709962982798 \
1.027752619318197e-07 0.5746801970751495 1.027755290218824e-07 0.5797469183389945 1.027757721599625e-07 0.5843213438768613 1.02776027852189e-07 0.5890994944692448 \
1.027762556711592e-07 0.5933243819692556 1.027764932159793e-07 0.5976999800355528 1.027767046064655e-07 0.6015679915939678 1.027769167472246e-07 0.6054277082074113 \
1.027771059366022e-07 0.6088479815213901 1.027772370949197e-07 0.6112112531841202 1.027773693914781e-07 0.6135871094428261 1.02777554614204e-07 0.6169015645304802 \
1.027777166365907e-07 0.6197943209800671 1.027778750557552e-07 0.6226100751126036 1.027780091676215e-07 0.6249846001944386 1.027781814887287e-07 0.6280247049765127 \
1.027783104275314e-07 0.6302937061188456 1.027784308050438e-07 0.6324061607157294 1.027785713339149e-07 0.634864734791624 1.027787644194074e-07 0.6382321981637986 \
1.027789142301853e-07 0.6408363654380513 1.027790815377796e-07 0.6437327988167145 1.027792625920029e-07 0.6468572757970242 1.027794659184327e-07 0.6503523798695617 \
1.027796487715879e-07 0.6534819287355287 1.027798193958343e-07 0.6563879501053153 1.027799968600742e-07 0.6594029650344411 1.027801628390247e-07 0.6622113135173925 \
1.027803200758144e-07 0.6648594636266301 1.02780460561866e-07 0.6672075432495704 1.027806042919945e-07 0.6695987751186935 1.027807373389854e-07 0.6718055529208897 \
1.02780879311128e-07 0.6741523780906628 1.027809993716612e-07 0.6761293215200647 1.027811443097483e-07 0.6785098354674278 1.027812603067977e-07 0.6804095298668216 \
1.027813798866854e-07 0.6823647593763783 1.027814788466604e-07 0.68397755359623 1.027815973550785e-07 0.6859039329668146 1.027816843993602e-07 0.6873150904607619 \
1.027818064101795e-07 0.6892866586554622 1.027819053327908e-07 0.6908817703737582 1.027819972281661e-07 0.6923536807698466 1.027820971967054e-07 0.6939486118486815 \
1.02782195442366e-07 0.6955126686751646 1.027822871561283e-07 0.6969676095571918 1.027823912890697e-07 0.698613189139943 1.02782527015812e-07 0.7007470979739818 \
1.027826816242742e-07 0.7031613517373301 1.027828167319862e-07 0.7052558942641604 1.027829630685319e-07 0.7075085519458914 1.027830915360735e-07 0.7094732734147607 \
1.02783215720207e-07 0.7113609898537658 1.027833256245073e-07 0.7130225953369277 1.027834422075759e-07 0.7147759898693785 1.027835423854067e-07 0.7162749667021007 \
1.027836794742156e-07 0.7183149847558421 1.027837994632423e-07 0.7200901405411056 1.027839185766902e-07 0.7218426783097279 1.02784045072077e-07 0.723693513465353 \
1.027841709394491e-07 0.7255245570057045 1.027842935604676e-07 0.7272980597885179 1.027844211779915e-07 0.7291334326655684 1.027845514267828e-07 0.7309957624152177 \
1.02784673019733e-07 0.73272442801297 1.027848117884253e-07 0.7346853525547948 1.02784912196869e-07 0.7360963845229137 1.027850155842573e-07 0.7375412410987998 \
1.027851092446997e-07 0.7388443755773992 1.027852208662967e-07 0.7403895158541485 1.027853073348996e-07 0.7415798421827293 1.027854081980104e-07 0.7429609798983192 \
1.027855402947324e-07 0.7447573558536402 1.027856494960337e-07 0.7462323422761349 1.027857540276639e-07 0.747635567415085 1.027858776741446e-07 0.7492836897664436 \
1.027860263705797e-07 0.7512497161812216 1.027861482512389e-07 0.7528480713857697 1.02786261855803e-07 0.7543274008692354 1.027864023754882e-07 0.7561429069656862 \
1.027865435649301e-07 0.7579511824827749 1.027866613111062e-07 0.7594470562859095 1.027867900007657e-07 0.7610693809796742 1.027869325554127e-07 0.7628512182523866 \
1.027870484119641e-07 0.7642872416835913 1.027871941752297e-07 0.7660789429779771 1.02787316007677e-07 0.7675637574673733 1.02787434476374e-07 0.7689965471136999 \
1.02787557264006e-07 0.7704700089613156 1.027876834168886e-07 0.7719718272910862 1.027877937859393e-07 0.7732757954107932 1.02787919217035e-07 0.7747465774777432 \
1.027880246987464e-07 0.775974259539018 1.027881578651758e-07 0.7775122819577122 1.02788280546631e-07 0.7789173428708996 1.027884153096743e-07 0.7804473432620218 \
1.027885259809625e-07 0.7816923373676121 1.027886353025911e-07 0.7829118427552927 1.027887704350256e-07 0.7844048889494442 1.027889212140504e-07 0.7860523747618094 \
1.027890615829581e-07 0.7875692293014268 1.027891812944828e-07 0.7888502570533434 1.027893195488235e-07 0.7903153082715967 1.027894429191593e-07 0.7916096503654788 \
1.027895880177844e-07 0.7931164937536124 1.027897277580435e-07 0.7945521172774316 1.027898549394667e-07 0.7958455533278409 1.027899739792201e-07 0.7970449251022731 \
1.027900863374111e-07 0.7981670522831598 1.027901905661906e-07 0.79919939674296 1.027902859050021e-07 0.8001364844871954 1.027904221931122e-07 0.8014634245741865 \
1.027905390856557e-07 0.8025894467082511 1.02790658725145e-07 0.8037305025474466 1.027907806067166e-07 0.8048811831579785 1.027909029850537e-07 0.8060245537852575 \
1.027910310137332e-07 0.8072081965553952 1.027911556585317e-07 0.8083483262222385 1.027912861572795e-07 0.8095291977395493 1.027914126177069e-07 0.8106611567088965 \
1.027915397436747e-07 0.8117869190804841 1.027916448611513e-07 0.8127087429624065 1.027917501113405e-07 0.8136235164943317 1.027918412515906e-07 0.8144090748259969 \
1.027919646696249e-07 0.8154632009865571 1.027920517482738e-07 0.8162003374872545 1.02792151070959e-07 0.8170344894488412 1.027922959927027e-07 0.8182390501293432 \
1.027924322612063e-07 0.8193582434421302 1.027925417234847e-07 0.8202477434185359 1.027926878435863e-07 0.8214214001843773 1.02792839202198e-07 0.8226208465286928 \
1.027929650061201e-07 0.8236052915965452 1.027931094167794e-07 0.824721541823094 1.027932340177296e-07 0.8256729463037898 1.027933847297913e-07 0.8268094083523665 \
1.0279352010105e-07 0.8278169867326588 1.027936453039791e-07 0.8287379047458127 1.027937629733617e-07 0.829593908450195 1.027939088013387e-07 0.8306418458276996 \
1.027940752973201e-07 0.8318207857986918 1.027942061544082e-07 0.8327345044534114 1.027943796038485e-07 0.833928356718921 1.027945477223224e-07 0.8350667646575466 \
1.027947175961246e-07 0.8361988603660855 1.027948984507537e-07 0.8373843006762304 1.027950416331349e-07 0.8383085120571983 1.027951557464787e-07 0.8390361588138326 \
1.027952858124697e-07 0.8398559950134801 1.027953876877057e-07 0.8404909448220066 1.027955045669982e-07 0.8412116130393378 1.027956416789287e-07 0.8420465258793415 \
1.027958395595721e-07 0.843231707656198 1.027960313457652e-07 0.8443585547012582 1.027962407088286e-07 0.8455646258450146 1.027964228224064e-07 0.846593677725298 \
1.027966199171782e-07 0.8476867969181797 1.02796793185875e-07 0.8486305714188691 1.02796976264561e-07 0.8496104335327738 1.027971474015872e-07 0.8505103231661706 \
1.027973220804384e-07 0.8514128411730317 1.02797497318728e-07 0.8523022053693007 1.027976734583675e-07 0.8531802340241421 1.027978638096238e-07 0.8541115036082744 \
1.027980543867704e-07 0.855025905954957 1.027982548181929e-07 0.8559685891497206 1.027984474106693e-07 0.8568563992305701 1.027986582738064e-07 0.8578086227668252 \
1.027988861871822e-07 0.8588150784816577 1.027991522177188e-07 0.8599606428795262 1.027994507388009e-07 0.8612090806949765 1.027997266924816e-07 0.8623286542354505 \
1.028000109545961e-07 0.8634483918036945 1.028002851030458e-07 0.8644969441068078 1.02800557392313e-07 0.8655088801415273 1.028008275580888e-07 0.8664846790737442 \
1.028010847361862e-07 0.8673881555543895 1.028013572993529e-07 0.868319368003445 1.02801633304697e-07 0.8692355072818493 1.028019034186287e-07 0.870106770567397 \
1.028022032450018e-07 0.8710447971670072 1.028025742222908e-07 0.8721640818024149 1.028028691540118e-07 0.8730224021943973 1.028031234323761e-07 0.873740732376842 \
1.028034216772072e-07 0.8745584461000401 1.028036952852192e-07 0.8752856917963749 1.028039314154438e-07 0.8758961959341748 1.028041717609793e-07 0.8765017794770257 \
1.028043940971677e-07 0.8770481951318053 1.028045881024505e-07 0.8775144010549708 1.028049178237936e-07 0.8782846129827527 1.028050729968195e-07 0.8786376896881318 \
1.028053907524076e-07 0.8793424631377607 1.028055696169827e-07 0.8797286397841958 1.028059120784622e-07 0.8804474051285093 1.028060962178168e-07 0.880822800830328 \
1.028065711184754e-07 0.881756283451624 1.028067385131538e-07 0.8820737784441692 1.028072043462e-07 0.8829272622221894 1.028073851704931e-07 0.8832470363605239 \
1.028078792047929e-07 0.8840891816604841 1.028080205486687e-07 0.8843218944112644 1.028086269405857e-07 0.8852805359894154 1.028087790117662e-07 0.8855111592597558 \
1.028094256914359e-07 0.8864506941541785 1.028095539876422e-07 0.8866295550025313 1.028102021648149e-07 0.8874976172723908 1.028103319236755e-07 0.8876644392549727 \
1.028111001444974e-07 0.8886037370453904 1.02811229881009e-07 0.8887539063021698 1.028120833066544e-07 0.8896836309705964 1.028122265650877e-07 0.8898301468060963 \
1.02813212785821e-07 0.890764641901611 1.02813434267227e-07 0.8909571971396437 1.028145773086277e-07 0.8918770673440963 1.028147072981167e-07 0.8919774876506176 \
1.028160589233886e-07 0.8929731820841386 1.028162092835701e-07 0.89307657739048 1.028176899161688e-07 0.8939986636922405 1.028179288179339e-07 0.8941315911431026 \
1.028196933116327e-07 0.894999985510941 1.028200009949781e-07 0.8951330875684044 1.028225222661808e-07 0.8960612226716312 1.02822959317422e-07 0.8961978289811912 \
1.028268627296431e-07 0.8971619289239613 1.028271095114498e-07 0.8972094058147089 1.028346860012845e-07 0.8981998139535015 1.028348019130314e-07 0.8982099955090975 \
1.028539004457353e-07 0.8992062631372056 1.028542978885091e-07 0.8992194728667773 1.030047133235903e-07 0.9002121614362558 1.03004979381947e-07 0.9002436812458944 \
1.030102475320153e-07 0.8993470931706574 1.030104539029324e-07 0.899191170936528 1.030119320157425e-07 0.8982046351054961 1.030121124663985e-07 0.8981003355419954 \
1.030143349480612e-07 0.8971299612768925 1.030145410405757e-07 0.897079983173831 1.030249493066813e-07 0.8980580240048047 1.03025087164257e-07 0.8980839755683444 \
1.030318845132984e-07 0.8990685088718567 1.030320700847659e-07 0.8990874390200084 1.035282992589679e-07 0.9000706848616691 1.03528359054814e-07 0.9000975977971888 \
1.035296126054321e-07 0.9010828413531861 1.035297182980354e-07 0.9012097231395001 1.035303764287524e-07 0.9021613947651476 1.035305136110213e-07 0.9023918767045529 \
1.035310366376409e-07 0.9033649777562528 1.035310995012334e-07 0.9034908765919824 1.035315720967825e-07 0.904476514442582 1.035316234105955e-07 0.9045863669199017 \
1.035320893739314e-07 0.9055619780118375 1.035321215783922e-07 0.9056252631670594 1.035328386771295e-07 0.9066212416280413 1.035329231134019e-07 0.9066528951765993 \
1.035335231797814e-07 0.9059679814895146 1.035336430373927e-07 0.9055903401525059 1.03533774200172e-07 0.9050640446667092 1.035339090199249e-07 0.9043926011431642 \
1.035340571549842e-07 0.9034897747335404 1.035341947143354e-07 0.902493211317788 1.035343349260954e-07 0.9013135799985507 1.035344335882047e-07 0.9003872218501816 \
1.035345192720141e-07 0.8995148096066522 1.035346018362134e-07 0.8986166894493001 1.035347166188419e-07 0.8972773101170661 1.03534797717086e-07 0.8962642459447687 \
1.03534877134364e-07 0.8952218112132616 1.035349825888917e-07 0.8937633947192651 1.035351052301954e-07 0.8919606744930825 1.035352049542744e-07 0.890414036797163 \
1.035353751486854e-07 0.8876203405523397 1.035355213337767e-07 0.8850727273800474 1.035356895519253e-07 0.8819879035815887 1.035358617130214e-07 0.8786780617039783 \
1.035360460991142e-07 0.8749807502679057 1.035362306654577e-07 0.8711418063496947 1.035364149129437e-07 0.8671917613865908 1.035366002486073e-07 0.8631174608718694 \
1.035367746363354e-07 0.8592060069639053 1.035369573402717e-07 0.8550405244181323 1.035371326873658e-07 0.8509893565349284 1.035373150168772e-07 0.8467313026054767 \
1.035375053303062e-07 0.8422468264612591 1.035376756604352e-07 0.838204894125699 1.035378421840737e-07 0.8342320488410089 1.035380047549371e-07 0.830337741667393 \
1.035381546161599e-07 0.8267359097041467 1.035383057921791e-07 0.8230937075736249 1.035384949376529e-07 0.8185270080344306 1.035386406557074e-07 0.8150026134285653 \
1.035388156466743e-07 0.8107652770601156 1.035389641182175e-07 0.807166938184282 1.035391360056828e-07 0.8029987283123258 1.035393050739223e-07 0.7988973224349885 \
1.035394692526316e-07 0.7949140139776875 1.035396285801687e-07 0.7910485911592836 1.035397890297763e-07 0.7871568543472617 1.035399908491574e-07 0.7822630953020117 \
1.035401392968917e-07 0.7786646206504594 1.03540293464276e-07 0.77492821376164 1.035404305476362e-07 0.7716074476660475 1.035405399330824e-07 0.7689587163513494 \
1.035406458665383e-07 0.7663946531324515 1.035407728808854e-07 0.7633217481666642 1.035408872438541e-07 0.7605561828888391 1.035409900916761e-07 0.7580702160470256 \
1.035411116819926e-07 0.7551325442760125 1.035412224592673e-07 0.7524575925939972 1.035413393080924e-07 0.7496376180588871 1.035414500928178e-07 0.7469652567786068 \
1.035415684589191e-07 0.7441116745915923 1.035416932860144e-07 0.7411038668912771 1.035418458478099e-07 0.7374292753756717 1.035419797447979e-07 0.7342062928952946 \
1.035421007762374e-07 0.7312947572377408 1.035422649737523e-07 0.7273475399259534 1.035424423346988e-07 0.7230877912371642 1.035426245451075e-07 0.7187161681757385 \
1.035428055423726e-07 0.7143786395952922 1.035429862063158e-07 0.7100537072471783 1.035431763578828e-07 0.7055071781827296 1.035433641177769e-07 0.7010230964996226 \
1.035435646508815e-07 0.696237807975249 1.035437733363431e-07 0.6912646166759551 1.035439809799078e-07 0.6863227581165517 1.03544208547776e-07 0.6809140411171237 \
1.035444008226102e-07 0.6763521085712711 1.035446380878582e-07 0.6707310800019505 1.035448313661221e-07 0.6661595641347996 1.035450640988686e-07 0.6606646229758047 \
1.035452696563363e-07 0.6558174602470968 1.035455020097575e-07 0.6503484594495911 1.035456970117276e-07 0.6457674053103037 1.035459002403362e-07 0.6410004262200759 \
1.035460800928814e-07 0.6367906205544323 1.035462591993119e-07 0.6326052789263827 1.035464225765258e-07 0.628795088826817 1.035465946259304e-07 0.6247880828503264 \
1.035467581187693e-07 0.6209892715878097 1.035469339085876e-07 0.6169100951581823 1.035471158475732e-07 0.6126978430086294 1.035473043313055e-07 0.6083422542008314 \
1.035475107637274e-07 0.6035858951323969 1.035476900783897e-07 0.5994633272559844 1.035478872572566e-07 0.5949432360761027 1.035480963453974e-07 0.5901646611556908 \
1.035483020946604e-07 0.5854760387944159 1.035485426053479e-07 0.5800160304866983 1.035487157334496e-07 0.5760958285528379 1.035488806274519e-07 0.5723746772837877 \
1.035490614880267e-07 0.5683014035092815 1.035492187741233e-07 0.5647722902613652 1.035493877569178e-07 0.5609879409349005 1.03549567863379e-07 0.5569709657351898 \
1.03549720846506e-07 0.5535669615732179 1.035498525609507e-07 0.5506462283231492 1.035499999486508e-07 0.5473865746199473 1.035500873742421e-07 0.5454560063082221 \
1.035501722454816e-07 0.5435860258811447 1.03550270874694e-07 0.5414171943998213 1.035503429668553e-07 0.5398340751058975 1.035504400578744e-07 0.5377039800781129 \
1.035505256482577e-07 0.5358302678688993 1.035505907291341e-07 0.5344081412607664 1.03550714329502e-07 0.5317121235594142 1.035508087537724e-07 0.52965475734789 \
1.035509062769941e-07 0.5275349985745696 1.035510791376451e-07 0.5237893654184622 1.035512141331662e-07 0.5208709659121862 1.035513683166277e-07 0.5175498113398643 \
1.03551542781984e-07 0.5138002600288881 1.035516945879704e-07 0.510550000123414 1.03551840818953e-07 0.5074290310664136 1.035519847178261e-07 0.5043644611166801 \
1.035521277396695e-07 0.5013276181140283 1.035522233495175e-07 0.499301733014788 1.035523177934733e-07 0.4973032961550828 1.035524388494141e-07 0.4947494705229025 \
1.035525337277099e-07 0.4927525559781179 1.035526495585533e-07 0.4903172469328811 1.035527368224019e-07 0.4884854516151125 1.035528192528481e-07 0.4867593351188191 \
1.035529146608016e-07 0.484765406725184 1.035530153710815e-07 0.4826639978995959 1.035531122314731e-07 0.4806459052877932 1.035532509612246e-07 0.4777646955734051 \
1.035533866660861e-07 0.4749532752442271 1.035535871508094e-07 0.4708139964547478 1.035538024649621e-07 0.4663911383470885 1.03553984040267e-07 0.462674698484628 \
1.035541830122363e-07 0.4586189944293299 1.035543535777573e-07 0.455154096457448 1.035545279314447e-07 0.4516251957269069 1.035546968646987e-07 0.4482170126441485 \
1.035548694618603e-07 0.4447467276163349 1.035550520681902e-07 0.4410867902598327 1.035552406170555e-07 0.4373240875354826 1.035554340845929e-07 0.4334777823509549 \
1.035556424052318e-07 0.4293535036700135 1.035558567504624e-07 0.4251286740881063 1.035560824557922e-07 0.4207018662297695 1.035563089991605e-07 0.4162771402745992 \
1.035565711759108e-07 0.4111844468197049 1.035568202097347e-07 0.4063709766754009 1.035571213084326e-07 0.4005865607947761 1.035574107292502e-07 0.3950673729298416 \
1.035577182435291e-07 0.3892455819062323 1.035580404399245e-07 0.3831936848847286 1.035583681704072e-07 0.3770882112794804 1.035587006001628e-07 0.3709500980558715 \
1.035590303291706e-07 0.3649083177186754 1.035593515587582e-07 0.3590729273462687 1.03559682375082e-07 0.3531219177045733 1.035600247306453e-07 0.3470224718704957 \
1.035603243716774e-07 0.3417374346434491 1.035606541592421e-07 0.3359723367088904 1.035609810531852e-07 0.3303128110141857 1.03561319032532e-07 0.3245206193888226 \
1.035616280036957e-07 0.3192755432624759 1.035619528016686e-07 0.31382336954194 1.035622684318663e-07 0.3085864885517507 1.035625734190322e-07 0.3035810258414895 \
1.035628287576776e-07 0.2994330834535801 1.03563093620834e-07 0.295170851203172 1.035633807035187e-07 0.2905978071194348 1.035636036732975e-07 0.2870801635277143 \
1.035638032125666e-07 0.2839591363066187 1.035640128685797e-07 0.2807045410859125 1.035641931251209e-07 0.2779290029372279 1.035643554698416e-07 0.2754463208250681 \
1.035645059048156e-07 0.2731629026725527 1.035646569101242e-07 0.2708866524077067 1.035648538007149e-07 0.2679392949564011 1.035649849454786e-07 0.2659970646012914 \
1.035651096820175e-07 0.2641561221543183 1.035652612740599e-07 0.2619266655689588 1.03565357242231e-07 0.2605306204207966 1.035654537935996e-07 0.2591282589302421 \
1.035655784133887e-07 0.2573209601776467 1.035657209899234e-07 0.255257422470362 1.035658799234579e-07 0.25296979123958 1.035660125895253e-07 0.251062957019046 \
1.03566196158294e-07 0.2484301322588876 1.035663773934597e-07 0.2458327969660818 1.035665889075646e-07 0.2428051031600066 1.035667914973991e-07 0.2399069804317323 \
1.035669580538467e-07 0.2375282895552967 1.03567168273059e-07 0.2345337828133105 1.035673416909451e-07 0.2320692345528927 1.035675705336728e-07 0.2288260787734411 \
1.035677911684244e-07 0.2257162440502939 1.035679668301377e-07 0.2232503232699662 1.035681472906433e-07 0.2207258962977968 1.035683180470208e-07 0.2183528725291195 \
1.035684982432872e-07 0.2158619697278009 1.035686649739047e-07 0.2135675266585953 1.035688140953261e-07 0.2115251542210239 1.035689699053442e-07 0.2094125291275523 \
1.035691050857695e-07 0.2075875692769576 1.035692551671966e-07 0.2055694209972212 1.035693876128229e-07 0.2037957203154137 1.035695281573595e-07 0.2019220745191926 \
1.035696452261239e-07 0.2003748851744883 1.035697749337302e-07 0.1986681706274326 1.035698969911991e-07 0.1970700654731777 1.035700195346348e-07 0.1954731161836187 \
1.035701375539584e-07 0.1939418157697267 1.035702725767313e-07 0.1921981789937757 1.03570417201182e-07 0.1903420634523806 1.035705455516813e-07 0.1887049708672087 \
1.03570669186156e-07 0.1871351133418249 1.035707667362788e-07 0.1859021016257166 1.035708818092082e-07 0.1844539912642748 1.035709755078879e-07 0.1832809848801438 \
1.035710742920116e-07 0.1820493959460708 1.035711972265529e-07 0.1805230483556907 1.035712929805559e-07 0.1793400249325384 1.035714220681073e-07 0.177753298391591 \
1.035715245334772e-07 0.1764993061988986 1.035716227869744e-07 0.1753029542432101 1.035717428741866e-07 0.1738483570896001 1.03571845423405e-07 0.1726127298531683 \
1.035719558810642e-07 0.1712877101305652 1.035720843709282e-07 0.1697552709290656 1.035721758557694e-07 0.1686698090598139 1.035722803403581e-07 0.1674358120019214 \
1.035723552770942e-07 0.1665544493622226 1.03572444845591e-07 0.1655049734124585 1.035724954106002e-07 0.164914347906921 1.035725453889764e-07 0.1643318187475747 \
1.03572610358061e-07 0.163576534137217 1.035726458720287e-07 0.1631646263336159 1.035727180712023e-07 0.162329174921529 1.035727852002975e-07 0.1615546732967998 \
1.035728444300318e-07 0.160873195114598 1.035728881756305e-07 0.1603710314414745 1.035729358224586e-07 0.1598254649913795 1.03573006202993e-07 0.1590230739426561 \
1.03573088541159e-07 0.1580883269013631 1.035731667127594e-07 0.1572048664554128 1.035732487657085e-07 0.1562816770844126 1.035733414693307e-07 0.1552436243401225 \
1.035734642494946e-07 0.153877370231325 1.035735633955882e-07 0.1527810927807017 1.035736648959355e-07 0.1516651170047695 1.035737661711265e-07 0.1505582666538253 \
1.035738626629107e-07 0.1495093242781697 1.035739620809455e-07 0.1484346886615803 1.03574046381569e-07 0.1475281828465028 1.035741393202594e-07 0.1465342051547719 \
1.035742219212e-07 0.1456551508734999 1.035743306872851e-07 0.1445034822456445 1.035744363302651e-07 0.1433917535370727 1.035745179898545e-07 0.1425365900703354 \
1.03574611735024e-07 0.1415598856352903 1.03574705302971e-07 0.1405903867550886 1.035747881874616e-07 0.139735765814107 1.035748763466362e-07 0.1388313836440244 \
1.035749561327222e-07 0.1380170907865772 1.035750497281217e-07 0.1370669869522621 1.035751396606459e-07 0.1361590166429519 1.035752102110423e-07 0.1354501541392388 \
1.035752799712188e-07 0.1347521119166949 1.035753941201259e-07 0.1336164586193709 1.035754760987401e-07 0.1328058651355588 1.035755637040425e-07 0.1319440719770354 \
1.035756632052385e-07 0.1309710196939938 1.035757723852409e-07 0.1299110174488692 1.03575874550573e-07 0.1289256009328031 1.035759820107789e-07 0.1278959836800649 \
1.035761020450569e-07 0.1267549558890445 1.035761962530915e-07 0.1258657925752028 1.03576327232195e-07 0.1246390638240933 1.035764266598965e-07 0.1237164070883829 \
1.035765357815822e-07 0.1227104370444639 1.035766446347502e-07 0.1217138859540913 1.035767369441536e-07 0.120874257454373 1.035768497844844e-07 0.1198547128626846 \
1.035769467965243e-07 0.118986084968971 1.035770510628723e-07 0.1180628196869088 1.035771600298026e-07 0.1171053395831002 1.035772595693683e-07 0.1162371554254778 \
1.035773765620782e-07 0.1152245300989246 1.035774636628686e-07 0.1144761644999183 1.035775729545201e-07 0.1135478691973115 1.035776544795827e-07 0.1128618460838699 \
1.035777542545759e-07 0.1120273350449922 1.03577871679726e-07 0.1110526766231405 1.035779734648438e-07 0.1102143708571793 1.035780612037922e-07 0.1094962336869811 \
1.035781420032999e-07 0.1088432886892514 1.035782289543192e-07 0.1081456845520918 1.035783097409448e-07 0.1075007757815706 1.035783999475114e-07 0.1067842832273628 \
1.03578490898266e-07 0.1060655611559195 1.035785795687901e-07 0.1053685613006139 1.035786785836107e-07 0.1045946508745568 1.035787722897869e-07 0.1038723470842792 \
1.035788661490627e-07 0.1031520741219857 1.035789669765109e-07 0.1023817709659086 1.035790716074088e-07 0.1015861061604995 1.035791955701651e-07 0.1006484085638475 \
1.035792929694782e-07 0.09991551135558702 1.035794132274253e-07 0.09901872452754552 1.035795240953005e-07 0.09819831936474602 1.035796285683363e-07 0.09742874659471555 \
1.035797458050452e-07 0.09656937225591002 1.035798475993662e-07 0.09582695326576983 1.035799455749168e-07 0.09511577589263259 1.035800860794065e-07 0.09410164141823299 \
1.035801911572026e-07 0.09334832721827611 1.035802897700187e-07 0.09264549593674179 1.035803824848273e-07 0.09198739948435641 1.035804686832124e-07 0.09137785861853052 \
1.035805625961876e-07 0.09071637432184691 1.035806596969337e-07 0.09003559055802626 1.035807691179881e-07 0.08927317549644689 1.035808701015371e-07 0.08857281843916648 \
1.035809637594832e-07 0.08792605868920525 1.035810379341552e-07 0.08741581771673042 1.03581175834007e-07 0.08647193599618339 1.035812481910108e-07 0.08597917321277694 \
1.035813835122141e-07 0.08506274029062395 1.035814694238195e-07 0.08448410751389913 1.03581614152054e-07 0.08351486081643937 1.035817103826189e-07 0.0828744112740944 \
1.035817982183981e-07 0.08229260392026354 1.035819140173063e-07 0.08152964121883956 1.035820291457576e-07 0.08077575264951149 1.0358214291219e-07 0.08003553900012179 \
1.035822831696828e-07 0.0791300282244784 1.035824245457162e-07 0.07822490276368012 1.035825741817577e-07 0.07727536491519127 1.035827186706132e-07 0.07636690312463701 \
1.035828698447241e-07 0.07542565384097814 1.035830192155436e-07 0.07450459906593411 1.03583168562251e-07 0.0735926433331697 1.035833285177668e-07 0.07262574717347114 \
1.035834846646777e-07 0.07169171823582712 1.035836591531124e-07 0.07065947636250877 1.035838288622191e-07 0.0696671357044583 1.035840140413029e-07 0.0685979885997255 \
1.035842107623799e-07 0.06747763456279594 1.035844212801998e-07 0.06629631776014881 1.03584643312255e-07 0.06507007089066431 1.035848735242764e-07 0.0638195278444372 \
1.035851160353819e-07 0.06252626147401 1.035853766894672e-07 0.06116236403900636 1.035856565885314e-07 0.05972739422233359 1.035859501722554e-07 0.05825544847408989 \
1.035862651082393e-07 0.05671370145268265 1.035866079141644e-07 0.05507846134953124 1.035869573807585e-07 0.0534565727116736 1.035873662849152e-07 0.05161746230842366 \
1.035877129499425e-07 0.05010669351290297 1.035881003649955e-07 0.04846839895323611 1.035884445827877e-07 0.04705645202362623 1.035887680090468e-07 0.04576625679949029 \
1.035890730548091e-07 0.04458093278443617 1.035893659168059e-07 0.04347099288378908 1.035896500577229e-07 0.04242242262004604 1.03589926078015e-07 0.04142902112907627 \
1.03590192930566e-07 0.04049015932812138 1.035904618227892e-07 0.03956531631184226 1.035907378832112e-07 0.03863769040165695 1.035910254787821e-07 0.03769451689421055 \
1.035912650444083e-07 0.03692662498323904 1.03591554211835e-07 0.03602084344675294 1.03591770003438e-07 0.03535960341037672 1.035919577204764e-07 0.03479599077274986 \
1.035921558495825e-07 0.03421285035004928 1.03592518724446e-07 0.03317032497347058 1.03592776866276e-07 0.03244834222605905 1.0359308657919e-07 0.0316030971185694 \
1.035933520493286e-07 0.03089664771451467 1.035936201684082e-07 0.03019941363307669 1.03593899042439e-07 0.02949128999862272 1.035941452288756e-07 0.02888043298519722 \
1.035943758602853e-07 0.02832033800396738 1.035946141502041e-07 0.02775711540944564 1.035948491575685e-07 0.02721270742060762 1.03595076940031e-07 0.02669509678424227 \
1.035954855523029e-07 0.02579039168486155 1.03595661854632e-07 0.02540904040268441 1.03596016332316e-07 0.02465798827491217 1.035962002032883e-07 0.02427641469830137 \
1.035965351520103e-07 0.02359448510613503 1.035966990607275e-07 0.02326678168937357 1.035970913313036e-07 0.02249905491676728 1.035972473220689e-07 0.02220010404946675 \
1.035976789254264e-07 0.02138321689778962 1.035978163148065e-07 0.0211255367654138 1.03598333123589e-07 0.02017559010600388 1.035984586594829e-07 0.01995091418019728 \
1.035989159010076e-07 0.01915998482559782 1.035990750469891e-07 0.01889493739859509 1.035996822854669e-07 0.01793263500095189 1.03599816822955e-07 0.01772934138481063 \
1.036004800869477e-07 0.01678091027541291 1.036006734103789e-07 0.01651856846389665 1.036013410670396e-07 0.01565087920017967 1.03601502655887e-07 0.01544858341705342 \
1.0360225789114e-07 0.01454101846553843 1.036024074521069e-07 0.01436800730673201 1.036032977899311e-07 0.01338293844200974 1.036033964478169e-07 0.01327873262558703 \
1.03604353121314e-07 0.01230993787860994 1.036044742310216e-07 0.01219243157195396 1.036054657237297e-07 0.01126376273051215 1.036056292524602e-07 0.01111855113153209 \
1.036067591745355e-07 0.01018247077230436 1.036068716217739e-07 0.01009565848301377 1.036082494452622e-07 0.009103273453806031 1.036083883905334e-07 0.009009747578659758 \
1.036099427888684e-07 0.008018073335410726 1.0361005485534e-07 0.00794673960805117 1.036116998381698e-07 0.006958154532207958 1.036118070906645e-07 0.006899512253112593 \
1.036137515841525e-07 0.005937533026687714 1.036139584821097e-07 0.005843834961138424 1.036162973698526e-07 0.00487227039639981 1.036167213562637e-07 0.004712306502041247 \
1.036194935894604e-07 0.003780857497341114 1.036199418985521e-07 0.003647790772321777 1.03623582397237e-07 0.00272553831825111 1.036240790530716e-07 0.002619503085887757 \
1.036298301734959e-07 0.001650572925599863 1.036301169553825e-07 0.001609446887446839 1.036354719440668e-07 0.0006353228983793809 1.036356773006917e-07 0.0005920420449145349 \
1.062827120745074e-07 -0.0002718533828215428 1.062828679501107e-07 -0.0004579010352009555 1.062834162652028e-07 -0.001326296959495401 1.062835290488787e-07 -0.001543805653187533 \
1.062839635410185e-07 -0.002491429791030493 1.062840393661749e-07 -0.002673591589873599 1.062843960167732e-07 -0.003590195133438418 1.062845230658532e-07 -0.003936807634339821 \
1.062848015662471e-07 -0.004716444651655622 1.062849096507305e-07 -0.005020876868076652 1.06285253249855e-07 -0.00592430224391268 1.062853602437202e-07 -0.006162325733041658 \
1.062862596141159e-07 -0.005653094509861465 1.062864380475456e-07 -0.004687598829536962 1.062865437709605e-07 -0.003940993102967527 1.062866688337378e-07 -0.002883597584075996 \
1.062867624178337e-07 -0.001971418478057775 1.062868402573964e-07 -0.001132968824455395 1.062869203293945e-07 -0.0001977429743171 1.062870427022047e-07 0.001370578777960296 \
1.062871609580771e-07 0.003041212838230153 1.062872796071873e-07 0.004860750887681821 1.06287393089626e-07 0.006730904986417607 1.062874965327645e-07 0.008536402178002854 \
1.062876111920181e-07 0.01064190690353853 1.062878017758113e-07 0.0143607330143792 1.062879355659492e-07 0.01711819191720031 1.062880858195149e-07 0.02033933849841947 \
1.062882409887625e-07 0.02378599874269359 1.062883963808114e-07 0.0273434151175349 1.062885440880426e-07 0.03080849965087477 1.062886930776679e-07 0.03437359286003162 \
1.06288848068751e-07 0.03814545786868043 1.062890074393648e-07 0.04208062121327779 1.062891723727756e-07 0.04620305710844342 1.062893473191046e-07 0.0506208066052034 \
1.062895264491763e-07 0.05518387280380205 1.062897162384316e-07 0.06005265756871143 1.062899199354002e-07 0.06530840376289772 1.062901397459318e-07 0.07100650943730057 \
1.062903714973765e-07 0.07703584544314998 1.062906193226736e-07 0.08349927754587044 1.062908906436034e-07 0.09058756662233436 1.062911853563813e-07 0.09829181712822582 \
1.062915106140293e-07 0.106792896697727 1.062918768597349e-07 0.1163551101154179 1.062922701564477e-07 0.1266079356677421 1.062927228093435e-07 0.1383809089651769 \
1.062932485245108e-07 0.1520098384503803 1.062938677380491e-07 0.1679979965193872 1.062945484823656e-07 0.1854865650013753 1.062953421573204e-07 0.2057488551561759 \
1.062962309229534e-07 0.2282732214494322 1.062970443122153e-07 0.2487218262351868 1.062977660617924e-07 0.2667261628598245 1.062984017258005e-07 0.282460740414376 \
1.062989734425617e-07 0.2965101025186013 1.062995089968458e-07 0.3095696210007924 1.063000123552588e-07 0.3217495654069301 1.063004886827015e-07 0.3331878525640654 \
1.063009626063057e-07 0.3444754071334732 1.063014200780245e-07 0.3552759747331513 1.06301886058294e-07 0.3661792384270033 1.063023350461038e-07 0.376592601923634 \
1.063028311526457e-07 0.3879857357798637 1.063033509145082e-07 0.3998002499051578 1.063037303191525e-07 0.4083447473225827 1.063041703278757e-07 0.4181679450526055 \
1.063046400968136e-07 0.4285466970600206 1.063051256177522e-07 0.4391589006481625 1.063055650658585e-07 0.4486701556983262 1.063056268188069e-07 0.4500002248264944 \
1.063057503247038e-07 0.4526540461147197 1.063059973364976e-07 0.4579447795386873 1.063062499314088e-07 0.463325462421476 1.063064475025244e-07 0.467511453725808 \
1.063066730742715e-07 0.4722681264242033 1.06306994642268e-07 0.4790073975813253 1.063072634214966e-07 0.4846013351959894 1.063074820729701e-07 0.4891262574467725 \
1.063076921769364e-07 0.4934547887280634 1.063079185824616e-07 0.4980921872304203 1.063081276876522e-07 0.5023516957637455 1.063083170899107e-07 0.5061927337048852 \
1.06308441251129e-07 0.5086969563931187 1.063085680062259e-07 0.5112441466129884 1.06308728004704e-07 0.5144514110933732 1.063089756476561e-07 0.5193914248715521 \
1.063091542341148e-07 0.5229351592435862 1.063093251876918e-07 0.5263079149198099 1.063095865372878e-07 0.5314455197962068 1.063098126088702e-07 0.5358634945234868 \
1.063100157405374e-07 0.5398188128751134 1.063101809712675e-07 0.5430252218652345 1.063103377582878e-07 0.5460612552756139 1.063105269149053e-07 0.5497137532216215 \
1.063107287826585e-07 0.5535976061995346 1.063109529339811e-07 0.5578986282275192 1.063111913163462e-07 0.5624617013850463 1.06311426077985e-07 0.566941985223824 \
1.063116563486904e-07 0.5713275351537204 1.063118621413239e-07 0.5752375533958141 1.063120671255381e-07 0.5791255875933676 1.063123099407797e-07 0.5837094709690289 \
1.063125646983618e-07 0.588493349632063 1.063127929267933e-07 0.5927514274590796 1.063130307656652e-07 0.5971656109489694 1.063132430431008e-07 0.6010807441713891 \
1.063134548365055e-07 0.6049674646600495 1.06313708720774e-07 0.6095919957414236 1.063139133143013e-07 0.6132953190650409 1.063141650376543e-07 0.6178178328453598 \
1.063143528271744e-07 0.6211736970442716 1.063146057002513e-07 0.6256587164710262 1.063148041096133e-07 0.6291560967673944 1.06314983842284e-07 0.6323071487074056 \
1.063152541130913e-07 0.6370161336915187 1.063154713968567e-07 0.6407803561788556 1.063156519232363e-07 0.6438916924996977 1.063158530841308e-07 0.6473460740030906 \
1.063160216675126e-07 0.650231451944099 1.063162260257198e-07 0.6537144072723954 1.063163716887783e-07 0.6561873372238678 1.063165362473771e-07 0.6589728476742622 \
1.063167057165935e-07 0.6618316558839334 1.063168592566751e-07 0.664412775690417 1.06317000490202e-07 0.6667750288922751 1.063171440660136e-07 0.6691685747430841 \
1.06317277296139e-07 0.6713840140331436 1.063174191964594e-07 0.6737368819239464 1.063175394300862e-07 0.6757233098298149 1.063176840811384e-07 0.6781085120392751 \
1.063178002998436e-07 0.6800197521569988 1.063179193821632e-07 0.6819757159594566 1.063180179604767e-07 0.6835903813535821 1.063181355581833e-07 0.6855122399681081 \
1.063182229941461e-07 0.6869376986921233 1.063183477402322e-07 0.6889650632873403 1.063184475472963e-07 0.6905825000046129 1.063185400370926e-07 0.6920753042469043 \
1.063186413211772e-07 0.6937043390836264 1.063187391142832e-07 0.695273833970533 1.063188303850746e-07 0.6967333967490603 1.063189328429049e-07 0.6983656370917724 \
1.063190657521356e-07 0.7004728611232253 1.063192207675414e-07 0.7029137789397926 1.063193556492269e-07 0.7050222373350452 1.063195011450183e-07 0.7072806469370021 \
1.063196289996853e-07 0.709252249158637 1.063197534579806e-07 0.7111597484283609 1.063198647836849e-07 0.7128563623504806 1.063199788137127e-07 0.7145852226468989 \
1.063200793249296e-07 0.7161013069709498 1.063202165260769e-07 0.7181590832501857 1.063203364719788e-07 0.7199473375636642 1.06320455641778e-07 0.7217141075019444 \
1.063205825867917e-07 0.7235855504531626 1.063207073542094e-07 0.7254141264975077 1.063208308495973e-07 0.7272133847865295 1.063209576308702e-07 0.7290498056238117 \
1.063210882203554e-07 0.730930225429108 1.063212104322583e-07 0.7326797786847141 1.063213474902716e-07 0.7346298644824388 1.063214487056265e-07 0.7360619656663578 \
1.063215536745619e-07 0.7375401619041119 1.063216451659951e-07 0.7388229997694907 1.06321758241356e-07 0.7404001534680551 1.063218455422403e-07 0.7416107338190071 \
1.063219500055706e-07 0.7430512000342341 1.063220807687029e-07 0.7448411286358657 1.063221906822003e-07 0.7463352048609909 1.063222953419585e-07 0.7477488743938407 \
1.0632241917362e-07 0.7494094725133206 1.063225679269713e-07 0.751387874302702 1.06322689842132e-07 0.7529958494242643 1.063228036963925e-07 0.7544867042370438 \
1.0632294419585e-07 0.7563117925204224 1.063230855193645e-07 0.7581313010100689 1.063232032989716e-07 0.7596352654099263 1.063233316974594e-07 0.7612620174900669 \
1.06323474021161e-07 0.7630496612437514 1.063235904103157e-07 0.7644991888858087 1.063237361339775e-07 0.7662987831554334 1.063238579138671e-07 0.7677897310961733 \
1.06323976478797e-07 0.7692300520321635 1.063240990922458e-07 0.7707078417740018 1.063242255436292e-07 0.77221964326554 1.06324335666584e-07 0.7735261258099556 \
1.063244611887263e-07 0.7750039859681491 1.06324566849672e-07 0.7762386743660952 1.063247020268293e-07 0.7778058706872942 1.063248256373457e-07 0.7792267957652825 \
1.06324955634725e-07 0.7807078764205345 1.06325068606223e-07 0.7819831642610904 1.063251765001111e-07 0.7831908181350914 1.063253130307933e-07 0.7847046126527283 \
1.063254631517019e-07 0.7863508260127218 1.063256054160057e-07 0.7878933964149381 1.063257249975189e-07 0.7891771019825847 1.06325861808649e-07 0.7906313890246753 \
1.063259843124129e-07 0.7919206245676671 1.063261289843411e-07 0.7934276941869095 1.063262697694143e-07 0.794878360380241 1.063263965852094e-07 0.796171745508174 \
1.063265156326018e-07 0.7973744708066829 1.063266278955628e-07 0.7984986270115709 1.063267322833333e-07 0.7995352562746869 1.063268275603949e-07 0.8004739840425704 \
1.063269639028913e-07 0.8018044219089175 1.063270807679598e-07 0.8029326473252685 1.063272003644895e-07 0.8040757482679398 1.063273222502994e-07 0.8052288531124292 \
1.063274448385593e-07 0.8063765489401953 1.06327572579618e-07 0.8075599074701925 1.06327697362526e-07 0.8087035441861687 1.063278278629006e-07 0.8098867241643505 \
1.063279542295969e-07 0.8110199871086299 1.06328081578389e-07 0.8121498004723215 1.063281867911793e-07 0.8130740322933268 1.063282914951838e-07 0.8139855427426806 \
1.063283830253901e-07 0.8147757515715357 1.063285063983601e-07 0.8158311616195392 1.063285933524084e-07 0.8165684017534872 1.063286922082447e-07 0.8173999442793862 \
1.063288367108844e-07 0.8186029267949408 1.063289730365726e-07 0.8197243345631372 1.063290824450085e-07 0.8206145128367788 1.06329228461948e-07 0.821788834531623 \
1.063293802030074e-07 0.8229927727264784 1.063295061195854e-07 0.8239792970156907 1.063296505686489e-07 0.8250971468990039 1.063297752648172e-07 0.8260503472050121 \
1.063299258788342e-07 0.8271873005969326 1.063300612493023e-07 0.8281959289694237 1.063301864729373e-07 0.8291179217777711 1.063303041288969e-07 0.8299746468143927 \
1.063304499105104e-07 0.8310230722388168 1.063306163942599e-07 0.8322027532553667 1.063307472150236e-07 0.8331167337813133 1.063309206750455e-07 0.834311196379941 \
1.063310887878414e-07 0.8354501125721271 1.063312586689692e-07 0.8365827385393307 1.063314395126276e-07 0.8377685497174457 1.063315827046921e-07 0.8386931238161603 \
1.063316968221893e-07 0.8394210074154138 1.063318268737995e-07 0.8402408682651782 1.063319287535162e-07 0.8408758513273116 1.063320456411389e-07 0.841596551294542 \
1.063321827868591e-07 0.8424315815669623 1.063323806960722e-07 0.8436167827761205 1.063325725154114e-07 0.8447436440637145 1.063327818661576e-07 0.8459494874145237 \
1.06332964017768e-07 0.8469786287449077 1.063331611039906e-07 0.8480715276019779 1.063333343567189e-07 0.8490148531186206 1.063335174509634e-07 0.8499943787178993 \
1.063336885824299e-07 0.8508936588199895 1.063338632702719e-07 0.8517955326875627 1.063340385042873e-07 0.8526841769874772 1.063342146411542e-07 0.8535614892404448 \
1.063344050084938e-07 0.8544920815553035 1.063345955808447e-07 0.8554057038167108 1.063347959768378e-07 0.8563474066245403 1.063349885664635e-07 0.8572344253714166 \
1.06335199466375e-07 0.858185963363946 1.063354273418618e-07 0.8591913103610016 1.063356934247181e-07 0.8603357477151101 1.063359919268544e-07 0.8615822374427254 \
1.063362678163234e-07 0.8627000332972231 1.063365520834927e-07 0.8638181192989086 1.063368262214432e-07 0.8648650323418529 1.06337098522366e-07 0.8658754039994767 \
1.063373686785625e-07 0.8668495780678541 1.063376258626989e-07 0.8677515347235455 1.063378984216134e-07 0.8686810999091764 1.063381744693316e-07 0.8695957110915412 \
1.063384445895985e-07 0.8704649939918846 1.063387444494889e-07 0.8714007440816277 1.063391154301144e-07 0.8725171209518352 1.063394103525362e-07 0.8733732402027278 \
1.063396646282709e-07 0.8740897163373675 1.06339962841735e-07 0.8749052413925265 1.063402364113466e-07 0.8756305047096297 1.063404725347486e-07 0.8762394088953867 \
1.063407128598864e-07 0.8768433401198644 1.063409351938211e-07 0.8773882060838187 1.063411292002539e-07 0.8778530214284207 1.063414589096812e-07 0.8786208714695904 \
1.063416140810901e-07 0.87897283049042 1.063419317234907e-07 0.8796750328643211 1.063421106040349e-07 0.8800599154915705 1.063424530647979e-07 0.8807759898408113 \
1.063426372672098e-07 0.8811501695110489 1.063431122965131e-07 0.8820806183873429 1.06343279683462e-07 0.8823969901232691 1.063437454598435e-07 0.8832471741583867 \
1.063439262991872e-07 0.8835657112976044 1.063444203088053e-07 0.8844044135654346 1.063445616237109e-07 0.8846360992458032 1.063451678673266e-07 0.8855901496945974 \
1.063453199425258e-07 0.8858196526512701 1.06345966662599e-07 0.8867549368993356 1.063460949492666e-07 0.8869330782847171 1.063467431586864e-07 0.8877977435561634 \
1.06346872882985e-07 0.8879638504720397 1.063476413020527e-07 0.8888993076310558 1.063477710739033e-07 0.8890488273083775 1.063486247365088e-07 0.8899738047157748 \
1.063487677615613e-07 0.8901192131187072 1.06349754067048e-07 0.8910487927319016 1.063499755535999e-07 0.8912403904783051 1.063511183781385e-07 0.8921548233216382 \
1.063512482580762e-07 0.8922544308366913 1.063526007584981e-07 0.8932425879319322 1.063527510414313e-07 0.8933452769452155 1.063542315756977e-07 0.8942627870546499 \
1.063544704854918e-07 0.8943950258099049 1.063562525184327e-07 0.8952625983306248 1.063566382658602e-07 0.895426813549116 1.063590404240788e-07 0.8963023915260389 \
1.063595153600487e-07 0.8964490046842035 1.063634332871647e-07 0.8974035634625627 1.063639032474093e-07 0.8974927205890085 1.063722720353868e-07 0.8984807567386782 \
1.063724925457144e-07 0.8984960697096243 1.064170720742927e-07 0.8994905034760702 1.064182734601916e-07 0.8995076493514624 1.065540832686943e-07 0.9004821828323031 \
1.065542622454192e-07 0.9005421539807538 1.065577071203374e-07 0.8996085030263692 1.065578799041918e-07 0.8994755022453073 1.065592062238996e-07 0.8985168769831137 \
1.06559392989208e-07 0.8983970610744239 1.065611771942332e-07 0.8974304740967198 1.065613893245152e-07 0.8973403978332656 1.065747300202991e-07 0.8983331062395279 \
1.065748433081446e-07 0.8983517458922662 1.065835466612414e-07 0.8993273409280406 1.0658409447182e-07 0.8993637478389299 1.070766218437148e-07 0.9003542216796759 \
1.070767175825666e-07 0.9004233209197793 1.070776601319424e-07 0.9014023545001312 1.070778225852538e-07 0.9016297223302431 1.070783892915005e-07 0.9025464066367429 \
1.070784964622122e-07 0.9027401250447874 1.07078889770564e-07 0.9035002370985188 1.07079022567928e-07 0.9037710185404622 1.070794021690344e-07 0.9045728679206633 \
1.070795323837805e-07 0.9048512534150681 1.070799937900729e-07 0.9057878278182891 1.070801130371311e-07 0.9060008176934132 1.070815426461655e-07 0.9050557440230738 \
1.070816263162926e-07 0.9046580283931719 1.070817516221221e-07 0.9039622140338933 1.070818594362906e-07 0.9032622438705011 1.070819784306371e-07 0.9023800387125585 \
1.070820938028541e-07 0.9014106868475621 1.070821838997509e-07 0.900578017289966 1.070822953474549e-07 0.8994526603282017 1.070823814266029e-07 0.8985125975436928 \
1.070824873922515e-07 0.8972736935213672 1.070825871606176e-07 0.8960214106762436 1.070826681562277e-07 0.8949470092681954 1.070827778041954e-07 0.8934133399212493 \
1.070828633916057e-07 0.8921520042367302 1.070829555142149e-07 0.8907345325087322 1.07083043733598e-07 0.8893220116766375 1.070831525083507e-07 0.8875100775672261 \
1.070832354013856e-07 0.8860780350921965 1.070833439750574e-07 0.8841400608632336 1.070834362012525e-07 0.8824412727986957 1.070835208217502e-07 0.8808423775446282 \
1.0708360666218e-07 0.8791839877465467 1.0708368587706e-07 0.8776224824828824 1.070837619650304e-07 0.8760960492665846 1.070838543013988e-07 0.874210837196514 \
1.070839141777347e-07 0.8729702140710593 1.070839715660192e-07 0.8717685933706794 1.070840335611921e-07 0.8704574090763495 1.070840968400435e-07 0.8691057216070059 \
1.070841469113811e-07 0.8680269866686803 1.070841963535335e-07 0.8669542389500936 1.070842600232402e-07 0.8655623656543436 1.070843359706592e-07 0.8638877358586781 \
1.070843848016709e-07 0.8628032002737418 1.070844333256242e-07 0.8617197496806845 1.07084509037347e-07 0.8600184098866027 1.070845762461248e-07 0.8584975010852487 \
1.070846189526312e-07 0.8575263577286506 1.070846628552044e-07 0.8565244243916033 1.070847506603509e-07 0.8545103166059256 1.070848135135196e-07 0.8530605771626394 \
1.070848721831768e-07 0.8517018597088126 1.070849083617785e-07 0.8508614974547222 1.070849431802581e-07 0.8500510151036469 1.070849782062432e-07 0.8492340038666518 \
1.070850482582133e-07 0.8475953578585981 1.07085096728698e-07 0.8464581214772323 1.070851406734992e-07 0.8454248116355969 1.070851861912554e-07 0.8443523575543517 \
1.070852500921664e-07 0.8428433081697474 1.070853162185396e-07 0.8412777165526386 1.07085421348608e-07 0.8387809254526315 1.070855092832832e-07 0.8366857089760468 \
