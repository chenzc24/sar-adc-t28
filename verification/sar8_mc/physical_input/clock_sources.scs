1.070855882285649e-07 0.834800137446173 1.070856763936023e-07 0.8326899670047023 1.070857632095989e-07 0.8306078985741704 1.070858511012833e-07 0.8284959280419055 \
1.070859423503732e-07 0.8262996967350639 1.070860451122409e-07 0.8238226494465998 1.070861436157165e-07 0.8214450402687625 1.070862559486315e-07 0.8187302447322098 \
1.070863689227678e-07 0.8159967029774419 1.070864902106627e-07 0.8130591602364435 1.070866207178167e-07 0.8098958628758253 1.070867497637196e-07 0.8067658935936169 \
1.070869032393199e-07 0.8030416153605923 1.070870685235405e-07 0.799029304640783 1.070872362647447e-07 0.7949567682299736 1.070874327883338e-07 0.7901857478752816 \
1.07087637550659e-07 0.7852160332972318 1.070878502277154e-07 0.7800563994093253 1.070880508476619e-07 0.7751902022758907 1.070882517063895e-07 0.7703212856706637 \
1.070884017284074e-07 0.766686939713112 1.070885322635739e-07 0.7635264252913375 1.070886666810141e-07 0.7602735436595947 1.070887728765446e-07 0.7577048602246427 \
1.070889061828774e-07 0.754482067181252 1.070890132158029e-07 0.7518959494812111 1.070891562917044e-07 0.7484409822837247 1.07089320797846e-07 0.7444713482725677 \
1.070894416150925e-07 0.74155777711076 1.070896127217565e-07 0.7374334100931738 1.070897736123089e-07 0.733558046396253 1.070899902049297e-07 0.7283457217000903 \
1.070901834606309e-07 0.7236999380850822 1.07090362395765e-07 0.7194029726762079 1.070905292123874e-07 0.7154015770462002 1.070907154183522e-07 0.7109395231330657 \
1.070909033515935e-07 0.7064416825495208 1.070910692736986e-07 0.7024749886985119 1.07091261631787e-07 0.6978803202016938 1.07091402988682e-07 0.6945068232011449 \
1.070915599964439e-07 0.6907636199298515 1.07091755976089e-07 0.6860965106368763 1.070919184101942e-07 0.6822325558671515 1.070920795863762e-07 0.6784034260021697 \
1.070922718945739e-07 0.6738409413562468 1.070924895564538e-07 0.6686845685784016 1.070927375777557e-07 0.6628199086538362 1.07092915635219e-07 0.6586162961343578 \
1.070931641790282e-07 0.6527567611811057 1.070933667862709e-07 0.6479896840619462 1.070935365969381e-07 0.6440011601507294 1.07093695213124e-07 0.6402799599229552 \
1.070938337435587e-07 0.637035894415233 1.070939699513215e-07 0.6338503464729111 1.070940962626978e-07 0.6309003762865483 1.070942257219331e-07 0.6278810604265532 \
1.070943540536725e-07 0.6248911458464299 1.070944853836027e-07 0.6218374290191309 1.070946174102147e-07 0.6187713222160208 1.070947615700952e-07 0.6154276788919771 \
1.070949057786871e-07 0.6120888358645944 1.070950534337911e-07 0.6086753592300279 1.070952004901491e-07 0.6052842859263143 1.070953583041757e-07 0.6016504852589418 \
1.070954909098278e-07 0.5986039825107707 1.070956223747947e-07 0.5955897059985247 1.070957418045935e-07 0.5928552647156846 1.070958778732863e-07 0.5897484304797134 \
1.070959928015483e-07 0.5871283594046445 1.070961439122689e-07 0.5836892419704927 1.070962585613368e-07 0.5810871834776226 1.070963764990064e-07 0.5784138884735546 \
1.070964662802944e-07 0.576381560286313 1.070965565996887e-07 0.5743415774978985 1.070966232905592e-07 0.5728373329037385 1.070966888523724e-07 0.5713590910263378 \
1.070967398944957e-07 0.5702089751121119 1.070968015962151e-07 0.5688198806440578 1.070968646860707e-07 0.5674025889664359 1.070969290444246e-07 0.5659586381304559 \
1.070969824382236e-07 0.5647616504486359 1.070970750808062e-07 0.5626864159088959 1.070971516880785e-07 0.5609719030357503 1.070972075131406e-07 0.5597256439368602 \
1.070972765672667e-07 0.5581857825097393 1.070973834553926e-07 0.5558054549196561 1.070974611990176e-07 0.5540764009223496 1.070975620491174e-07 0.5518382286767042 \
1.070976877299716e-07 0.5490568313009737 1.070977879716568e-07 0.5468419758621708 1.070978998893402e-07 0.5443739014182352 1.070980031552469e-07 0.5421024366463116 \
1.070981229045887e-07 0.5394737463112931 1.07098224637469e-07 0.5372436950013484 1.070983401572132e-07 0.5347185748314579 1.070984551922987e-07 0.5322102907975605 \
1.07098581673211e-07 0.529456475824718 1.070987070470086e-07 0.5267350629320526 1.070988538629319e-07 0.5235577714138258 1.070989894263807e-07 0.5206304261698983 \
1.070991471246342e-07 0.5172373565578411 1.070993094436886e-07 0.5137528589513558 1.070994902675847e-07 0.5098871206809381 1.070996827159054e-07 0.5057874350093188 \
1.070998956212086e-07 0.5012700264709963 1.071001278026081e-07 0.4963634062180514 1.071003850931867e-07 0.4909555076455908 1.071006247190101e-07 0.4859407514401474 \
1.071009264344461e-07 0.479662588092526 1.071012143537997e-07 0.4737079198104491 1.071015272426189e-07 0.4672821326282255 1.071018469808238e-07 0.4607585360408045 \
1.071021865759847e-07 0.4538766993710576 1.071025134784829e-07 0.4472977926730654 1.071028490368641e-07 0.4405887635920606 1.071031661327868e-07 0.4342949501181722 \
1.071035003705415e-07 0.4277061431972559 1.071038518016635e-07 0.4208322784122511 1.071041663278176e-07 0.4147233751108969 1.07104489505308e-07 0.4084912998479469 \
1.071049306200656e-07 0.400057814108821 1.071052727361035e-07 0.3935812134363078 1.071055726806328e-07 0.3879522399691127 1.071059478116385e-07 0.3809760137481454 \
1.071062775558777e-07 0.3749002425561211 1.071065607988036e-07 0.3697269896098562 1.071068609450588e-07 0.3642865787664632 1.071071405472531e-07 0.3592589179584539 \
1.071073643233647e-07 0.3552676761685443 1.071075761036954e-07 0.3515151294490645 1.071077785371594e-07 0.3479514629380864 1.071079796284271e-07 0.3444362246481504 \
1.071081853428453e-07 0.3408632458568372 1.071084529657171e-07 0.3362478643926977 1.071086918970113e-07 0.3321601360780691 1.07108925403074e-07 0.3281974319442653 \
1.071091388684736e-07 0.3246000376975314 1.071093602460465e-07 0.3208952602338652 1.071095602096931e-07 0.3175728982722026 1.071097644820061e-07 0.3142073831356898 \
1.071099618288778e-07 0.3109812293225088 1.071101472014048e-07 0.3079732989686547 1.071103433077958e-07 0.3048147723336881 1.071105455849362e-07 0.3015820927993307 \
1.071107212432327e-07 0.2988007390096292 1.0711090711339e-07 0.295878328903569 1.071111140927825e-07 0.2926488196724605 1.071112994143739e-07 0.2897857719971084 \
1.071114946411816e-07 0.2867989994419413 1.07111650415531e-07 0.28443329608414 1.071118291723129e-07 0.2817356906084737 1.071120102032329e-07 0.2790344478478936 \
1.071121601003467e-07 0.2768142575519123 1.071123611437744e-07 0.273859574769726 1.071125102589039e-07 0.2716833853889438 1.071126487983335e-07 0.2696726034832688 \
1.071128006734089e-07 0.2674956304896134 1.071129151475376e-07 0.2658586287383957 1.071130466774683e-07 0.2639823142040156 1.071131724359563e-07 0.2622048582339201 \
1.071132767763623e-07 0.2607341604582348 1.071133897557217e-07 0.2591418073851619 1.071135060842464e-07 0.2575033437579446 1.071136490116675e-07 0.2554974228347739 \
1.071137622731725e-07 0.2539102348881249 1.071138964299053e-07 0.2520298733123076 1.071140069027097e-07 0.2504818583075984 1.071141623352847e-07 0.2483006006477398 \
1.071143032203835e-07 0.2463217957442577 1.071144546129539e-07 0.2441928603691365 1.071146097750346e-07 0.2420086586735095 1.071147391842834e-07 0.2401849910837116 \
1.071148738963765e-07 0.2382868210192302 1.071150115942015e-07 0.2363478190565156 1.071151293462172e-07 0.2346905900295477 1.071152886704099e-07 0.2324499447852502 \
1.071154259326364e-07 0.2305210708572645 1.071155666789934e-07 0.2285488733964877 1.071156724701667e-07 0.2270688194984586 1.071158024115646e-07 0.2252532503786337 \
1.071159029480282e-07 0.2238506847401111 1.071160052817357e-07 0.2224250970611539 1.071160790103172e-07 0.2214012665004395 1.071161582442603e-07 0.2203047212273054 \
1.071162292155075e-07 0.2193236206014474 1.071162806785351e-07 0.218612902325451 1.071163336269882e-07 0.2178825126218075 1.071164127819908e-07 0.2167921001391954 \
1.071164550546259e-07 0.2162104926182252 1.071164948991708e-07 0.2156628374086678 1.071165381228204e-07 0.2150692779925967 1.071165790298225e-07 0.2145080585354088 \
1.071166491522843e-07 0.2135474129702876 1.071166828372557e-07 0.2130867492099046 1.071167276666377e-07 0.212477723463 1.071167865237998e-07 0.2116792343136102 \
1.071168513092605e-07 0.2108017053965978 1.071169087900245e-07 0.2100241135398916 1.071169692190328e-07 0.209207737948094 1.071170662554631e-07 0.2078991976528634 \
1.07117150945123e-07 0.2067595417901527 1.071172598558851e-07 0.2052972881712416 1.071173562566921e-07 0.2040065614180294 1.071174512733294e-07 0.2027428333585779 \
1.071175547051275e-07 0.2013717100485363 1.071176496344728e-07 0.2001158751783069 1.071177526548994e-07 0.198757993281026 1.071178577373321e-07 0.1973779917312911 \
1.071179670461462e-07 0.1959482000350934 1.071180774896281e-07 0.1945091075764383 1.071181937799036e-07 0.1929996650696684 1.071183037098964e-07 0.1915811184357085 \
1.071184133723204e-07 0.1901717999899754 1.071185150889654e-07 0.1888694322720079 1.071186080436791e-07 0.1876837490531375 1.07118700772569e-07 0.1865049219968967 \
1.07118774458125e-07 0.1855719169757668 1.071188572993399e-07 0.1845269810791141 1.071189318853365e-07 0.1835895008849975 1.071190016086783e-07 0.1827150226754214 \
1.071190683270854e-07 0.1818808699270075 1.071191641704113e-07 0.1806871657728035 1.071192468771839e-07 0.1796611249561687 1.071193404410076e-07 0.1785035608809835 \
1.07119435337095e-07 0.1773351434884491 1.071195467074053e-07 0.1759704596301353 1.071196883497589e-07 0.1742450478777388 1.071198035966122e-07 0.1728486436789435 \
1.071199481442513e-07 0.1711076225712051 1.071200597399285e-07 0.1697708811114609 1.071202009589021e-07 0.1680898955975501 1.071203166961755e-07 0.1667201145354908 \
1.071204226568608e-07 0.1654722325850081 1.071205214164775e-07 0.164314417410061 1.071206177596498e-07 0.1631901152369615 1.071207064174022e-07 0.1621596955203892 \
1.071208317516728e-07 0.1607099933926625 1.071209262770884e-07 0.1596224416957933 1.071210240160401e-07 0.1585042187118262 1.071211321109172e-07 0.1572745454417887 \
1.071212267786047e-07 0.1562036643369483 1.071213342264514e-07 0.1549951394274829 1.071214253154951e-07 0.1539767092330788 1.071215320872068e-07 0.1527896463435911 \
1.071216354804728e-07 0.1516469620792683 1.071217465609577e-07 0.1504267727114754 1.071218357869395e-07 0.1494522115900035 1.071219212668682e-07 0.1485231035185812 \
1.071220051920549e-07 0.1476157397758405 1.071220748986192e-07 0.1468658175993407 1.071221535366968e-07 0.1460232248551682 1.071222318479542e-07 0.1451880611912267 \
1.071223024838273e-07 0.1444378248611795 1.071223879746948e-07 0.1435337156153706 1.071224753636722e-07 0.1426139614481139 1.071225569511858e-07 0.1417594571206545 \
1.071226542701372e-07 0.1407454482154784 1.071227349596596e-07 0.139910090776864 1.071228257446906e-07 0.1389752404035735 1.07122947088963e-07 0.1377336220260025 \
1.071230361386038e-07 0.13682812281983 1.07123134655454e-07 0.1358318692385875 1.071232217417229e-07 0.1349560640726983 1.071233321526109e-07 0.1338550874529322 \
1.071234206114333e-07 0.1329791517134813 1.071235213400266e-07 0.1319874611681985 1.071236261295802e-07 0.1309622419763913 1.071237205198131e-07 0.1300442429014473 \
1.07123817024605e-07 0.1291112112475518 1.071239165112583e-07 0.1281591654439075 1.071240029124292e-07 0.1273384721630967 1.071240978925599e-07 0.1264411177628728 \
1.071242020813879e-07 0.1254629331099751 1.071243112001386e-07 0.124445178694 1.071244055505945e-07 0.1235704029653004 1.07124517846343e-07 0.1225411084520107 \
1.071246133096967e-07 0.1216733466577494 1.071247175205873e-07 0.1207311846737792 1.071248068659445e-07 0.1199276649878674 1.071248772532175e-07 0.1192980345746366 \
1.071249526392512e-07 0.1186268760051257 1.071250287714207e-07 0.1179522201461119 1.071250977489184e-07 0.1173458504859956 1.071251802680909e-07 0.1166263596898966 \
1.071252522115779e-07 0.1160015972854393 1.071253342903043e-07 0.1152916772467617 1.071254186247801e-07 0.1145654108773922 1.07125496418619e-07 0.113898375935255 \
1.071255891835211e-07 0.1131065723182637 1.071257047873425e-07 0.1121254933399327 1.071258106929114e-07 0.1112341778178403 1.071258883498312e-07 0.1105854195321705 \
1.071259766463023e-07 0.1098504899494786 1.071260567033545e-07 0.1091866403929743 1.071261536294793e-07 0.1083861389179563 1.07126248864964e-07 0.1076031391441806 \
1.071263374361587e-07 0.1068780200140514 1.071264387442599e-07 0.1060523297458165 1.071265442899473e-07 0.1051963702337609 1.071266534843119e-07 0.1043160928234657 \
1.071267616019328e-07 0.1034503663302994 1.071268815196938e-07 0.1024949450012773 1.071269828815214e-07 0.1016914181115986 1.071270888911509e-07 0.100855068690839 \
1.071272146827803e-07 0.09986840123414902 1.071273442400857e-07 0.09885896724496235 1.071274799154405e-07 0.09780904711780367 1.071276559873037e-07 0.09645781830037269 \
1.071278197878238e-07 0.09521257997344186 1.071279826125652e-07 0.09398642071914091 1.071280677512003e-07 0.09334985726464029 1.07128137589223e-07 0.09282999162688726 \
1.071282070848284e-07 0.09231474740697931 1.071282810434879e-07 0.09176875214326782 1.071283771983755e-07 0.09106241641841166 1.071284516137408e-07 0.09051841344162129 \
1.071285296033096e-07 0.08995079828656057 1.071286060521396e-07 0.08939693755534793 1.071286935462239e-07 0.08876614459792892 1.071287957229341e-07 0.08803382885421264 \
1.071288842873223e-07 0.08740269463919083 1.071289939528099e-07 0.08662585268124241 1.071291100092175e-07 0.08580942306245626 1.07129251558034e-07 0.0848216759818637 \
1.071293844270176e-07 0.08390253510334872 1.071295251873282e-07 0.08293727564630923 1.071296748969478e-07 0.08192024575105315 1.071298106088348e-07 0.08100683753927941 \
1.071299521257171e-07 0.08006309454860433 1.071300872475907e-07 0.07917070961097784 1.071302285200282e-07 0.07824718349428782 1.071303756129204e-07 0.07729532867436953 \
1.07130527122786e-07 0.07632524417621221 1.071306924984999e-07 0.07527819040792309 1.071308562596902e-07 0.07425356708383206 1.071310323896319e-07 0.07316505371836476 \
1.071312215286099e-07 0.07201151367936541 1.071314322022337e-07 0.07074528708793332 1.071316517688556e-07 0.06944624562626683 1.071318865352622e-07 0.06808094281860989 \
1.071321449277003e-07 0.06660616301228137 1.071324395923605e-07 0.06496103773121734 1.071327436716829e-07 0.06330286177969326 1.071331045821629e-07 0.06138472526627536 \
1.071334404990352e-07 0.05964719353945821 1.071338806764061e-07 0.05743991201668189 1.071342590438092e-07 0.05560437501227136 1.071347015027716e-07 0.05352996728430704 \
1.071350555229165e-07 0.05192508193542229 1.071354420396718e-07 0.05022502935509546 1.07135786643729e-07 0.04875485597254389 1.071361086186649e-07 0.04741934964807833 \
1.07136412152492e-07 0.04619304551845941 1.071367070734883e-07 0.04503122626702559 1.071369895557667e-07 0.04394770877170886 1.071372666361775e-07 0.04291147062934708 \
1.071375323636684e-07 0.04194013461971725 1.071378035943552e-07 0.0409708748276704 1.071380798533722e-07 0.04000619535229137 1.071383697525942e-07 0.03901828782233653 \
1.071385981289875e-07 0.03825741181922668 1.071389030130544e-07 0.03726495139513845 1.071391196849105e-07 0.03657573971894532 1.071393110416374e-07 0.03597943984071691 \
1.071395096361558e-07 0.03537298232318693 1.071398395514967e-07 0.03438820140908775 1.071400814971701e-07 0.03368375433354889 1.071403968092223e-07 0.03278771666975258 \
1.071406669292072e-07 0.03203957074185158 1.071409233008807e-07 0.03134567005659093 1.071412033128806e-07 0.03060515313352298 1.071414489686567e-07 0.02997014710356035 \
1.071416817043018e-07 0.02938120249260199 1.07141924434299e-07 0.02878348292867495 1.071421611615635e-07 0.02821317433052753 1.071423898079744e-07 0.0276732289298247 \
1.071428070936345e-07 0.02671456010533928 1.071430022743284e-07 0.02627749693639509 1.071433834414109e-07 0.02544369227895442 1.071435606942329e-07 0.02506446942885681 \
1.071439031456878e-07 0.02434654114125227 1.071440564141201e-07 0.02403127656358269 1.071444314325841e-07 0.02327616399748992 1.071445690667252e-07 0.02300530455388665 \
1.071450533333593e-07 0.02207084195640928 1.071451729527604e-07 0.02184403312078184 1.071455899915636e-07 0.02106026682208277 1.07145733393791e-07 0.02079332360769017 \
1.071462546051726e-07 0.01984598817089831 1.071463823790427e-07 0.0196205814374062 1.071469667914167e-07 0.01863359713481367 1.071471392268229e-07 0.01835589372257288 \
1.071477433235728e-07 0.01743644241612937 1.071479047552142e-07 0.01720262545858322 1.071485447014338e-07 0.01631831686205014 1.071487230176005e-07 0.016083210242981 \
1.071493710016487e-07 0.01526127675881721 1.071495362552397e-07 0.01505930898173208 1.071502725571753e-07 0.01419381259610907 1.071504068332255e-07 0.01404154276213586 \
1.071512039327433e-07 0.01317592498067951 1.071513445303545e-07 0.01302934089458718 1.071523098735771e-07 0.0120661300044765 1.071524742123827e-07 0.01190857475316222 \
1.071534749435119e-07 0.01099048917119646 1.07153612213369e-07 0.01087009009405628 1.071547509078863e-07 0.009949273443646761 1.071548650857872e-07 0.009863136028526375 \
1.071562457306217e-07 0.008889755784408603 1.071564000878327e-07 0.00878832203975914 1.071579465820612e-07 0.00781340401000951 1.071580309437644e-07 0.007760176032106158 \
1.071597163710821e-07 0.006770348169342283 1.071598398995725e-07 0.00670487246831437 1.071618897141387e-07 0.005720970231232756 1.071620861142965e-07 0.005634691917282852 \
1.071644047936537e-07 0.004698942116576918 1.071648654079885e-07 0.004530544077955615 1.071676055035305e-07 0.003639937533647344 1.071681236485673e-07 0.00349159181499799 \
1.071722742898753e-07 0.002502201117031859 1.071728121398825e-07 0.002396807933581942 1.0717889437533e-07 0.001421603691354927 1.071791533557405e-07 0.001378272220758726 \
1.071844761190904e-07 0.0003814093765652445 1.071845892761344e-07 0.0003711807182531981 1.098307063923701e-07 -0.0004615907568095335 1.098308688313385e-07 -0.0006852153244161934 \
1.098313698328069e-07 -0.001554404032531494 1.098314540153697e-07 -0.001725199767551738 1.098318555381938e-07 -0.002626792336557519 1.098319448731607e-07 -0.002845673237760077 \
1.098322314649697e-07 -0.0035898660494722 1.098323590334993e-07 -0.003937855927128601 1.098326777451613e-07 -0.004830400105952924 1.098327919463135e-07 -0.00515011308870196 \
1.098330743466382e-07 -0.005887653497963378 1.098332045728569e-07 -0.006177415671381139 1.098341829257541e-07 -0.005220113099403402 1.098343702332871e-07 -0.004004368716724641 \
1.098345016776888e-07 -0.002901539130564616 1.098346071052425e-07 -0.001869327786897239 1.098346928227261e-07 -0.0009323217369615201 1.098347747492128e-07 4.151965372454519e-05 \
1.098348957860361e-07 0.001618129410352471 1.098349947146829e-07 0.003024565667809575 1.098351531113568e-07 0.005482561958548801 1.098353705585867e-07 0.00923691162542661 \
1.098355517808096e-07 0.0126653356758144 1.098357638749061e-07 0.01697021734206094 1.098359268985627e-07 0.02046388365739064 1.098360875209785e-07 0.02403759527126768 \
1.09836241061221e-07 0.02755862871109176 1.098363891179022e-07 0.031036270750196 1.098365381988111e-07 0.03460722192241437 1.098366927287225e-07 0.03837091703902212 \
1.098368533795379e-07 0.04234026030123839 1.098370180342186e-07 0.04645786783841532 1.098371945751169e-07 0.05091770581196236 1.098373735379688e-07 0.05547793877747508 \
1.098375642811338e-07 0.0603721650098247 1.09837769062163e-07 0.06565647483694508 1.098379895344492e-07 0.07137203566208646 1.098382223941741e-07 0.0774299331224613 \
1.098384715816505e-07 0.08392829098722057 1.098387444237776e-07 0.09105513637423955 1.098390411275777e-07 0.09880974921055499 1.098393684539683e-07 0.1073623706929605 \
1.098397381053549e-07 0.11701033799881 1.09840132977169e-07 0.1273002725707723 1.098405908154097e-07 0.1392030195235975 1.098411226222497e-07 0.1529832553757746 \
1.09841747860046e-07 0.1691182447448397 1.098424336075175e-07 0.1867241161332086 1.098432360033912e-07 0.2071957342970069 1.09844134802183e-07 0.2299563735557614 \
1.098449404156324e-07 0.2501946571168963 1.098456541669658e-07 0.2679877251922811 1.098462837288478e-07 0.2835633151515627 1.098468540922982e-07 0.2975737963344939 \
1.098473850476804e-07 0.3105173405876944 1.098478868351306e-07 0.3226580892822354 1.098483661296844e-07 0.3341673054699896 1.098488316851033e-07 0.3452566901045974 \
1.098492954815109e-07 0.3562094254686541 1.098497512295407e-07 0.3668794056881832 1.098502114496752e-07 0.3775613305945491 1.098507497336462e-07 0.3899285626759094 \
1.098512505841796e-07 0.4013172511919189 1.098516508068632e-07 0.4103337945930838 1.098521576676441e-07 0.421642452039157 1.098526436338564e-07 0.4323669409017459 \
1.098530431485677e-07 0.4410997362599856 1.098534537606271e-07 0.4500002277813482 1.098538826870602e-07 0.4592207708982954 1.098542842014423e-07 0.4677760623951868 \
1.098545915918887e-07 0.4742753916877908 1.098549418336473e-07 0.4816249679276425 1.098552950738506e-07 0.4889795533930016 1.0985554824443e-07 0.4942125642332652 \
1.098557811883199e-07 0.4989990073547648 1.098560228316108e-07 0.5039392821429431 1.098562478222295e-07 0.5085102868389438 1.098564398583375e-07 0.5123881070394828 \
1.098566246700343e-07 0.5161059569497825 1.098568469603498e-07 0.5205538992744256 1.098570136717574e-07 0.5238726938135662 1.098572308883525e-07 0.5281726418673847 \
1.098574339672442e-07 0.5321820613122353 1.098576113786994e-07 0.5356681922482178 1.098577994510863e-07 0.5393528234657015 1.098580354832656e-07 0.5439555888699217 \
1.098583013652896e-07 0.5491186112539347 1.098585231271783e-07 0.5534070305875756 1.098588031850331e-07 0.5588091140818973 1.098590461848179e-07 0.5634839438879177 \
1.09859321538161e-07 0.5687575845994758 1.098595665335016e-07 0.5734440561015828 1.098598068277205e-07 0.5780305526007354 1.098600478670234e-07 0.5826153106864888 \
1.09860305457841e-07 0.5874946531182738 1.098605408246178e-07 0.5919209497705462 1.09860772126727e-07 0.5962518282209535 1.098609946534482e-07 0.6003950532231523 \
1.098612030130559e-07 0.6042587207462122 1.098614408548706e-07 0.6086392006348278 1.098616517150854e-07 0.612499186772883 1.09861907322267e-07 0.617151767543529 \
1.098621060500327e-07 0.620751700070918 1.098623816826772e-07 0.6257066023742009 1.098626044387981e-07 0.6296824120643636 1.098628978099216e-07 0.6348814180513288 \
1.098631305799232e-07 0.6389753720667986 1.098633507813092e-07 0.6428252659334456 1.098635520519211e-07 0.6463216644290061 1.098637693407936e-07 0.6500784077528632 \
1.098639440567036e-07 0.6530842133917786 1.098641303213334e-07 0.6562672470877895 1.098643090603859e-07 0.6593113758161715 1.098644717643993e-07 0.6620700940033843 \
1.098646370334099e-07 0.6648583661366954 1.098647803012238e-07 0.6672607123132118 1.09864919531648e-07 0.669583864918244 1.098650593322146e-07 0.6719085596965743 \
1.098651941074223e-07 0.6741424479378803 1.098653216016633e-07 0.6762463034350935 1.098654545557747e-07 0.6784344250006583 1.098655761601249e-07 0.680430207161383 \
1.098657045733663e-07 0.6825336955632141 1.098658203404209e-07 0.6844241240890321 1.098659183815937e-07 0.686020684362688 1.098660190776997e-07 0.687656981754083 \
1.098661288314626e-07 0.689434454762776 1.098662455994179e-07 0.6913211166705923 1.098663368261916e-07 0.6927889453402305 1.098664460316049e-07 0.6945396927028351 \
1.098665471403262e-07 0.6961566646470493 1.098666425406182e-07 0.6976767415743361 1.098667520226426e-07 0.6994136821864276 1.098668864742773e-07 0.7015344809028976 \
1.098670354932137e-07 0.7038694457768003 1.098671644232324e-07 0.7058755144243859 1.09867311083691e-07 0.7081418729260142 1.098674378680718e-07 0.7100885084081828 \
1.098675624659611e-07 0.7119899232102255 1.098676743197281e-07 0.7136874821928206 1.098677872756922e-07 0.7153928249203609 1.098678878290893e-07 0.716903336497302 \
1.098680251105924e-07 0.7189542886859326 1.098681449794518e-07 0.7207346491296758 1.09868264162204e-07 0.7224952472954583 1.098683911643136e-07 0.7243608783177121 \
1.098685157126648e-07 0.726179956024653 1.098686393836757e-07 0.7279757435764195 1.09868765971953e-07 0.7298035010246171 1.098688965411881e-07 0.7316777339938921 \
1.098690190562223e-07 0.7334262671520465 1.098691552997129e-07 0.7353588786631546 1.098692567424861e-07 0.7367901064855561 1.09869362765969e-07 0.7382789144707947 \
1.098694532971524e-07 0.7395446819117977 1.098695671233782e-07 0.7411267287627761 1.098696547849604e-07 0.742338113895605 1.098697606802377e-07 0.7437932991468792 \
1.098698910335325e-07 0.7455718205320391 1.098700016011403e-07 0.7470699275523445 1.098701062716115e-07 0.7484790865773925 1.09870230233143e-07 0.7501360792234356 \
1.09870378790597e-07 0.752105598322839 1.098705004731933e-07 0.7537054667443914 1.098706145848825e-07 0.7551949470168074 1.098707550054835e-07 0.7570132059451244 \
1.098708965335436e-07 0.7588296197226846 1.098710143228134e-07 0.7603289862386273 1.098711425226351e-07 0.7619481626911874 1.098712845904683e-07 0.7637269294216019 \
1.098714014655762e-07 0.7651780119234867 1.098715471393621e-07 0.7669714049983392 1.098716688778096e-07 0.7684572223066155 1.098717875183015e-07 0.7698939375992205 \
1.098719099845946e-07 0.7713653733660819 1.098720367016846e-07 0.7728756341192486 1.098721466036788e-07 0.7741754302862822 1.098722722190223e-07 0.7756497674172792 \
1.098723780294307e-07 0.7768823528242577 1.098725141995534e-07 0.7784559787239111 1.098726385466015e-07 0.7798807766277074 1.098727659718769e-07 0.7813271999647126 \
1.098728805279564e-07 0.7826155184370988 1.098729872082259e-07 0.7838050786084815 1.098731251508229e-07 0.785328674235108 1.098732746003193e-07 0.7869612315653352 \
1.098734194525364e-07 0.7885256944569791 1.098735388882871e-07 0.7898026796320731 1.0987367431316e-07 0.7912364721526877 1.09873795807481e-07 0.7925100718437531 \
1.098739391665555e-07 0.7939977458315933 1.09874082600237e-07 0.7954699260458764 1.098742084112467e-07 0.7967479640295563 1.098743274579285e-07 0.7979459892863545 \
1.098744394715731e-07 0.7990632136113104 1.098745442634543e-07 0.8000996927221937 1.098746394563032e-07 0.8010335634530776 1.098747758668286e-07 0.8023587211299719 \
1.098748926790049e-07 0.8034813603122919 1.098750121402484e-07 0.8046180202255495 1.098751341806002e-07 0.8057672874017472 1.098752570806969e-07 0.8069126780167393 \
1.098753842000533e-07 0.8080849010520604 1.098755093419151e-07 0.8092265787736463 1.098756398931422e-07 0.8104047139317369 1.09875765969389e-07 0.811530109085512 \
1.098758939660489e-07 0.8126603425876329 1.098759994272971e-07 0.8135823118114501 1.098761026965977e-07 0.814477091043954 1.098761953499458e-07 0.8152732203909091 \
1.098763190441811e-07 0.8163262937528154 1.098764066640956e-07 0.8170655553659417 1.098765053301514e-07 0.8178914289762149 1.098766488771539e-07 0.819080619224994 \
1.098767844633066e-07 0.8201904093102529 1.098768936532881e-07 0.8210742465492874 1.098770411027471e-07 0.8222539401850584 1.09877191506449e-07 0.8234410273756358 \
1.098773169754118e-07 0.8244188977545531 1.098774611413952e-07 0.8255287290252299 1.098775854299599e-07 0.8264738611628292 1.098777359002563e-07 0.8276038147969816 \
1.098778715066145e-07 0.8286089145501508 1.09877996601616e-07 0.8295251220930787 1.098781143174533e-07 0.8303776282987162 1.098782602030521e-07 0.8314210189912619 \
1.098784266961482e-07 0.8325942517713072 1.098785575628508e-07 0.833503494447128 1.098787310074617e-07 0.8346911703335461 1.098788991402022e-07 0.8358239212093587 \
1.098790689939496e-07 0.8369500705213252 1.098792498869552e-07 0.838129582835239 1.098793930212163e-07 0.8390486258646698 1.098795071191619e-07 0.8397723391454259 \
1.098796372463218e-07 0.8405879656882547 1.098797391021787e-07 0.8412191375388212 1.098798559475988e-07 0.8419354178465567 1.098799929193963e-07 0.84276453896487 \
1.098801907591422e-07 0.843942473808897 1.098803824446297e-07 0.8450620046306492 1.09880591850993e-07 0.8462610422160779 1.098807738618767e-07 0.8472832413425977 \
1.098809709773334e-07 0.8483697584184032 1.098811442904469e-07 0.8493077402131245 1.098813273256562e-07 0.8502809338042043 1.098814984787832e-07 0.8511747489972419 \
1.098816731317363e-07 0.8520708361396651 1.098818483828913e-07 0.8529540285731302 1.098820245303913e-07 0.8538259128238825 1.098822148367787e-07 0.8547503816925358 \
1.098824054277479e-07 0.8556583881771193 1.098826059797908e-07 0.8565949481971697 1.098827985825885e-07 0.8574764650234362 1.098830093312883e-07 0.8584213553684483 \
1.098832373621857e-07 0.8594210644592908 1.098835032419522e-07 0.8605573106989262 1.098838018200941e-07 0.8617960322792503 1.098840779837292e-07 0.8629075153790151 \
1.098843622302292e-07 0.8640180616030438 1.098846364142308e-07 0.8650581816846495 1.098849086694401e-07 0.8660616517296992 1.098851788589146e-07 0.8670295451208139 \
1.098854360232381e-07 0.8679256252637404 1.098857085969722e-07 0.8688492356117473 1.098859846024351e-07 0.8697577927663542 1.09886254710518e-07 0.8706213441784563 \
1.098865545689379e-07 0.8715508809746347 1.098869255828164e-07 0.8726599440782473 1.098872205155291e-07 0.873510245983525 1.098874748008955e-07 0.8742218447789023 \
1.098877730441708e-07 0.8750318897722944 1.098880466409288e-07 0.8757523113099853 1.098882827679075e-07 0.8763571312809064 1.098885231072055e-07 0.876957042728428 \
1.098887454408612e-07 0.8774982514557473 1.098889394467937e-07 0.8779599514934209 1.098892691652286e-07 0.8787226653583874 1.098894243380191e-07 0.8790722725343518 \
1.098897420714095e-07 0.8797700114458387 1.098899209390604e-07 0.880152324917399 1.09890263400534e-07 0.8808637455080008 1.098904475523683e-07 0.8812353200296749 \
1.098909224784184e-07 0.8821594045029107 1.098910898716537e-07 0.8824737723885729 1.098915556929605e-07 0.8833186808430151 1.098917365204472e-07 0.883635209600208 \
1.098922305497857e-07 0.8844687288968743 1.098923718877729e-07 0.8846990198924604 1.098929782491027e-07 0.8856473543416146 1.098931303209552e-07 0.8858754372639542 \
1.098937770089477e-07 0.8868048391838264 1.098939053031091e-07 0.8869818633102416 1.098945534965822e-07 0.8878410756373726 1.098946832451334e-07 0.8880061989117775 \
1.09895451498601e-07 0.8889361126992519 1.098955812406254e-07 0.8890847997417872 1.098964346975575e-07 0.8900046759307325 1.098965779246734e-07 0.8901495209380393 \
1.098975641580769e-07 0.8910738355210844 1.09897785636141e-07 0.8912643084423501 1.098989286536885e-07 0.8921737958641509 1.098990586319894e-07 0.8922730011388891 \
1.099004103389882e-07 0.8932565980587214 1.099005606923423e-07 0.8933589605607284 1.09902041315768e-07 0.8942730372387374 1.0990228021907e-07 0.8944047337041336 \
1.099040613442277e-07 0.8952702388217941 1.099044473255946e-07 0.8954343910560414 1.099068488716345e-07 0.896309305076933 1.099073238084202e-07 0.8964562995603377 \
1.099111419701395e-07 0.8973944547681553 1.099116244593365e-07 0.897487269196476 1.099195104748494e-07 0.898471373493449 1.099201266375397e-07 0.8985180228791175 \
1.100152826123789e-07 0.899508178894561 1.100167732145567e-07 0.8995204306067698 1.101280612887407e-07 0.9005118233983579 1.101282376257435e-07 0.9005706457326812 \
1.10131860757067e-07 0.8996048713171836 1.101320419550936e-07 0.8994654179496379 1.101333530765704e-07 0.8985275682722235 1.101335349539762e-07 0.8984123497545736 \
1.101353579441702e-07 0.8974436520388238 1.101355178574244e-07 0.8973766233009967 1.101486686887231e-07 0.8983720910457982 1.101487796702765e-07 0.8983905835035384 \
1.101576012543832e-07 0.8993863063850064 1.101581480238467e-07 0.8994226481040219 1.106507199766805e-07 0.9003987622903815 1.106507897691656e-07 0.9004496773542636 \
1.106516224219291e-07 0.9012853800543292 1.106517484680941e-07 0.9014513953152168 1.106523289889575e-07 0.9023435091985418 1.106524699532118e-07 0.9025895326188698 \
1.106528690912908e-07 0.9033428289365844 1.106530192408316e-07 0.9036449200440446 1.106534623221535e-07 0.9045762589490434 1.106536194942562e-07 0.9049121924877023 \
1.106540651209874e-07 0.9058152254958243 1.106541635773263e-07 0.9059929146639856 1.106555802587204e-07 0.9052304871087643 1.10655711415865e-07 0.904616184869324 \
1.106558804230411e-07 0.9036290332250884 1.106560457149166e-07 0.9024406226812831 1.106561519806978e-07 0.9015554774641358 1.106562554175281e-07 0.9006052096506509 \
1.106563411842469e-07 0.8997486040545581 1.106564306782332e-07 0.8987887485205278 1.106565549226324e-07 0.8973492764100613 1.106566730035805e-07 0.8958624931586439 \
1.106567602196721e-07 0.8946938835082598 1.106568845267161e-07 0.8929289312882503 1.106569915106439e-07 0.8913158670103165 1.106570913423478e-07 0.8897378501708729 \
1.106572176331742e-07 0.8876466417139378 1.106573858217853e-07 0.884705368138502 1.106575415215381e-07 0.8818365157686672 1.106577381263672e-07 0.8780362649814708 \
1.106579217476167e-07 0.8743271923380105 1.106581332550105e-07 0.8698916163736473 1.106583140648106e-07 0.8659808238081558 1.106584986458582e-07 0.8618945354625286 \
1.106586716498537e-07 0.8579913311618118 1.106588570505038e-07 0.8537436868396935 1.106590361336512e-07 0.8495884889292737 1.106592197227131e-07 0.8452850234109005 \
1.106593864844183e-07 0.8413449312544377 1.10659554574996e-07 0.8373487193315756 1.10659717684167e-07 0.8334514816705533 1.106598728704027e-07 0.829729402178684 \
1.10660045969282e-07 0.8255639501984255 1.106602319597377e-07 0.8210763864673301 1.106603965802216e-07 0.8170961425007568 1.106605614501323e-07 0.8131038678717658 \
1.106607367821645e-07 0.8088537582860886 1.106609012086681e-07 0.8048648186953292 1.106610698442787e-07 0.8007719922541914 1.106612606476452e-07 0.7961398815555145 \
1.106614461718184e-07 0.7916360074082958 1.106616551006281e-07 0.7865651471012967 1.10661879917618e-07 0.7811107659751856 1.106620697327054e-07 0.77650678233121 \
1.106622715901883e-07 0.7716133355283564 1.106624158608269e-07 0.76811790639139 1.106625575043926e-07 0.7646880872338248 1.106626852021022e-07 0.7615975116975136 \
1.106627962479435e-07 0.7589113686396982 1.106629248105796e-07 0.7558028559024855 1.10663057376087e-07 0.7525995467138866 1.106631706977832e-07 0.7498629233610832 \
1.106633070324095e-07 0.7465723252212872 1.106634134316607e-07 0.7440058350410135 1.106635726504468e-07 0.7401674766516904 1.106637450281421e-07 0.7360137588823189 \
1.10663907275386e-07 0.7321074183421575 1.106640796243437e-07 0.7279612819449855 1.106642390105271e-07 0.7241302920521341 1.106644468157139e-07 0.7191408067115369 \
1.106646073553789e-07 0.7152908836069264 1.106647998447152e-07 0.7106793324906435 1.10664985361064e-07 0.7062404417184839 1.106651552371093e-07 0.7021802791355866 \
1.106653471069473e-07 0.6975984806629684 1.106654933309623e-07 0.6941099299715526 1.106656536173094e-07 0.6902897983225644 1.10665856006145e-07 0.6854719661536142 \
1.10666037294609e-07 0.681161582477689 1.106662061160357e-07 0.6771536053116509 1.106663919619109e-07 0.6727470762459599 1.106665978927512e-07 0.6678715161770782 \
1.10666765819558e-07 0.6639016226084196 1.106669260812615e-07 0.6601182542089066 1.106671649337354e-07 0.65448589698252 1.106673326948486e-07 0.6505369020837752 \
1.106675137682881e-07 0.6462813620835641 1.106676749231988e-07 0.642499550819208 1.106678211904597e-07 0.6390715923276049 1.106679598785689e-07 0.6358268652274862 \
1.106680892356149e-07 0.6328040340451749 1.106682186201702e-07 0.6297855584526113 1.106683469414899e-07 0.6267952385336898 1.106684771436295e-07 0.6237652412672913 \
1.106686061600736e-07 0.6207683673242944 1.106687447356331e-07 0.6175525629501428 1.106688928112201e-07 0.6141227553162802 1.106690791385052e-07 0.60981438109949 \
1.106692268222044e-07 0.6064079319686639 1.106694619864099e-07 0.600995965122186 1.106696544341406e-07 0.5965821560879089 1.106698950039548e-07 0.5910808370261941 \
1.106700640513256e-07 0.587228367631822 1.106702017177501e-07 0.5840969866928536 1.106703298227265e-07 0.581191110277254 1.10670443409422e-07 0.5786182870235701 \
1.106705347742257e-07 0.5765512826027382 1.106706241961132e-07 0.5745328691003393 1.106706914578463e-07 0.573016830490748 1.106707574780489e-07 0.5715297341779608 \
1.106708095317241e-07 0.5703577032508095 1.106708737705932e-07 0.5689124506700958 1.106709353071159e-07 0.5675311492520995 1.106709995886598e-07 0.5660899724818867 \
1.106710527797555e-07 0.5648985048860162 1.106711451255398e-07 0.5628316153148989 1.106712217014409e-07 0.5611191615154557 1.106712775450911e-07 0.5598732849310241 \
1.106713468881998e-07 0.5583285932816697 1.106714527394756e-07 0.5559733466166974 1.1067153043128e-07 0.5542469170533902 1.106716310298676e-07 0.5520159549745236 \
1.106717590630782e-07 0.5491849411292137 1.106718585604598e-07 0.5469885705929382 1.106719711258113e-07 0.544508366501287 1.106720741701315e-07 0.5422442603473754 \
1.106721942190172e-07 0.5396115972585003 1.106722958334261e-07 0.5373863339265779 1.10672411457693e-07 0.5348611538529422 1.106725265738742e-07 0.5323536236546169 \
1.106726530109181e-07 0.529604142030661 1.106727785251858e-07 0.5268822104345234 1.106729252048618e-07 0.5237112381511962 1.106730608755698e-07 0.5207845659358002 \
1.106732186414087e-07 0.5173942078023266 1.106733810633495e-07 0.5139116507621072 1.106735619718178e-07 0.5100482739823553 1.106737545639722e-07 0.5059503908118104 \
1.106739675557428e-07 0.5014368974673542 1.106741999884595e-07 0.4965308659362653 1.106744575093732e-07 0.49112491222925 1.106746974735513e-07 0.4861095397820235 \
1.106749986779057e-07 0.4798501326413723 1.106752869755342e-07 0.4738957353990632 1.106756000618611e-07 0.4674739717793394 1.106759195881407e-07 0.4609631488871989 \
1.106762590854062e-07 0.4540919149088484 1.106765852755184e-07 0.4475353831519197 1.106769217567802e-07 0.4408159131180407 1.106772384675873e-07 0.4345373385230166 \
1.106775725526604e-07 0.4279587671099637 1.106779242615287e-07 0.4210864038135054 1.106782387463783e-07 0.4149846225409808 1.106785621928357e-07 0.4087533091618546 \
1.106790031209485e-07 0.400331870031168 1.106793449160247e-07 0.3938679283557566 1.106796443500686e-07 0.3882534014213259 1.10680018872672e-07 0.3812944595528024 \
1.106803482503896e-07 0.375233915169682 1.10680631354694e-07 0.3700684563936956 1.106809310997049e-07 0.3646408765157301 1.106812105955488e-07 0.3596219010422631 \
1.10681434267487e-07 0.3556377385586224 1.106816459791946e-07 0.3518907610576284 1.106818484819268e-07 0.3483292724130969 1.10682049543475e-07 0.3448190020587957 \
1.106822552213837e-07 0.3412518188287665 1.106824735968598e-07 0.3374887625241871 1.106827173592566e-07 0.3333167726275162 1.106829441158294e-07 0.3294678078423895 \
1.106831640268007e-07 0.3257615367192951 1.106833824514083e-07 0.3221060038181086 1.106835864764178e-07 0.318715141566024 1.106837883342076e-07 0.3153870758963987 \
1.106839886575955e-07 0.3121102802474151 1.106841752715021e-07 0.309079115007194 1.106843725731086e-07 0.3058982938882217 1.10684581156335e-07 0.3025606704206737 \
1.106847867910569e-07 0.2992974534031506 1.106850115231368e-07 0.2957609785165763 1.106852284189794e-07 0.2923771984023277 1.106854360983307e-07 0.2891642611511841 \
1.106856671491776e-07 0.2856239464683982 1.10685841949429e-07 0.2829684481899911 1.10686021147604e-07 0.2802647299798244 1.106861900221201e-07 0.2777348429135014 \
1.106864183453934e-07 0.274348458173166 1.106865950826614e-07 0.2717528218126659 1.106867633653918e-07 0.2693020894036587 1.106869358321621e-07 0.2668230333489093 \
1.106870699344411e-07 0.264903804409765 1.10687215894446e-07 0.2628277003548514 1.106873545899465e-07 0.2608803500812688 1.106874768715512e-07 0.2591684246570544 \
1.106876109903814e-07 0.2572942758553639 1.106877400914859e-07 0.2554978336754472 1.106878595252204e-07 0.2538430842138498 1.106879863604196e-07 0.2520939183506197 \
1.106881060014414e-07 0.2504447954274527 1.106882556176353e-07 0.2483797066042054 1.106883904811462e-07 0.2465170278296022 1.106885200385602e-07 0.2447289494531232 \
1.10688677103379e-07 0.2425624627506451 1.106888010990138e-07 0.2408491463446025 1.106889412471492e-07 0.2389135279283614 1.106890711400503e-07 0.2371200701944942 \
1.106891917576705e-07 0.2354534357320198 1.106893542306008e-07 0.2332087289724075 1.106895002846996e-07 0.2311905595759856 1.106896386054839e-07 0.2292825126447264 \
1.106897465327019e-07 0.2277949627009887 1.106898773176093e-07 0.225993474229161 1.106899758236256e-07 0.22463752857886 1.106900799069717e-07 0.2232056532573264 \
1.106901527838364e-07 0.2222046546567725 1.10690234937313e-07 0.2210804129356655 1.10690302346398e-07 0.2201585377209549 1.106903490506606e-07 0.2195201149856669 \
1.106903984680203e-07 0.2188449488487562 1.10690489422163e-07 0.2176035744446363 1.106905558165761e-07 0.2166983392055156 1.106906027798693e-07 0.2160586379972232 \
1.106906530910749e-07 0.2153737902794619 1.106907122404248e-07 0.2145693142997165 1.106907550863284e-07 0.2139870779821451 1.10690798893629e-07 0.2133941263688522 \
1.106908684238941e-07 0.2124566309962414 1.106909553407082e-07 0.2112864027023158 1.106910365295633e-07 0.2101949018929156 1.106911224290264e-07 0.2090416531541652 \
1.106912165752074e-07 0.2077796428137634 1.106913083290811e-07 0.2065517647617813 1.106914036255171e-07 0.2052788208685862 1.106915001042083e-07 0.2039945431316728 \
1.106916009294901e-07 0.2026602783061639 1.106916968855022e-07 0.2013924147365721 1.10691799571213e-07 0.2000377255165624 1.106919026075665e-07 0.1986831378210229 \
1.10692012697906e-07 0.1972405340748948 1.106921214497938e-07 0.1958206085628783 1.106922411717489e-07 0.1942631948714586 1.106923516146512e-07 0.1928328887741874 \
1.106924596174588e-07 0.1914411844406488 1.10692584973803e-07 0.1898318066870429 1.106926779079788e-07 0.1886434908940876 1.106927562787551e-07 0.1876443873000938 \
1.10692832918829e-07 0.1866698667869858 1.106929154301432e-07 0.1856249297118943 1.106929849397592e-07 0.1847473639743596 1.106930508953873e-07 0.1839166514106665 \
1.106931151627221e-07 0.1831089953192083 1.106932271462069e-07 0.1817072258029639 1.106933212001737e-07 0.1805353135896268 1.106934288419354e-07 0.1791985758407087 \
1.106935353149934e-07 0.1778827552324552 1.106936553069199e-07 0.1764073736674057 1.106937933595456e-07 0.174720142305475 1.106939095201005e-07 0.1733081217455876 \
1.106940716169029e-07 0.1713503924599185 1.106941867054196e-07 0.1699688234017716 1.106943266910192e-07 0.1682987764548305 1.106944438970947e-07 0.1669083002780509 \
1.106945548164474e-07 0.1655990025649634 1.106946524449328e-07 0.1644521190704843 1.106947472954813e-07 0.1633427224865242 1.106948633498935e-07 0.161991523106341 \
1.106949548984438e-07 0.1609305136382055 1.106950510074198e-07 0.1598214181625073 1.106951452255534e-07 0.1587403933520305 1.106952387261563e-07 0.1576732160104884 \
1.106953323234783e-07 0.1566104070550305 1.106954280050165e-07 0.1555300824433628 1.106955185929212e-07 0.1545132165873678 1.106956096060781e-07 0.1534969984004868 \
1.106957051545556e-07 0.1524358767948732 1.106957958202681e-07 0.1514342506187442 1.106958988926308e-07 0.1503020548964867 1.106959713440797e-07 0.1495100717445464 \
1.106960504448726e-07 0.148649146151682 1.106961249930915e-07 0.1478424742503694 1.106961960245005e-07 0.1470770917224498 1.106962687889816e-07 0.1462962409077327 \
1.106963434061567e-07 0.1454990959398698 1.106964133891184e-07 0.1447543557055888 1.106964875500381e-07 0.143968261688537 1.106965412953772e-07 0.1434005634796054 \
1.106965945789319e-07 0.1428396203849428 1.106966597746903e-07 0.1421555039833398 1.106967310807313e-07 0.141411576573238 1.106967954507931e-07 0.1407432786314442 \
1.106968688027537e-07 0.1399847409254479 1.106969294203207e-07 0.1393607073002494 1.106970154538046e-07 0.1384787080092832 1.106970914048206e-07 0.1377037134581418 \
1.106971813727262e-07 0.1367902106004182 1.106972630996836e-07 0.1359645165492482 1.106973457896615e-07 0.1351360437760365 1.106974283459693e-07 0.1343145513298757 \
1.106975339081247e-07 0.1332698421778018 1.106976157754082e-07 0.1324642397250402 1.106977131428679e-07 0.1315110876582503 1.106978031437286e-07 0.130634908321232 \
1.106978911139876e-07 0.1297829978838479 1.106979740438426e-07 0.1289892226181523 1.106980482809344e-07 0.1282822873521282 1.106981479319927e-07 0.1273377645104763 \
1.106982436870518e-07 0.1264350619688987 1.106983305344566e-07 0.1256206895242312 1.106984205359939e-07 0.1247808744623497 1.106985008686745e-07 0.1240346855852102 \
1.106985875627031e-07 0.1232365419604467 1.106986863930319e-07 0.1223331159004786 1.106987764751698e-07 0.1215131568528167 1.106988867184272e-07 0.1205141992263624 \
1.106989739498662e-07 0.1197275966302077 1.106990425230003e-07 0.1191120727131645 1.106991271853926e-07 0.1183553887582162 1.106991936928737e-07 0.1177634990399222 \
1.106992651487993e-07 0.1171309945267847 1.106993348226041e-07 0.1165184920865242 1.106994121596921e-07 0.1158409171037389 1.106995079029745e-07 0.1150054407698888 \
1.10699579157887e-07 0.1143861389207103 1.106996465274204e-07 0.1138025718558601 1.106997149641909e-07 0.113211685696446 1.106997905545423e-07 0.1125613765304429 \
1.106998812963886e-07 0.1117840233035959 1.106999640001163e-07 0.1110788257213999 1.107000775991873e-07 0.1101151050704521 1.107001874748992e-07 0.1091895325357105 \
1.107002796742132e-07 0.1084169374841771 1.107004036235445e-07 0.1073835127717347 1.107004919878672e-07 0.1066505015902263 1.107006314468373e-07 0.1055001025916527 \
1.107007307435382e-07 0.1046863788921388 1.107008233935897e-07 0.1039306459201802 1.10700933598102e-07 0.1030359883605075 1.107010188925422e-07 0.1023467905686673 \
1.107011037933452e-07 0.101663637589173 1.107011867443086e-07 0.1009989740617136 1.107013092542103e-07 0.1000225794851696 1.107014311960626e-07 0.09905761200121259 \
1.10701557818349e-07 0.09806258992746317 1.107016706304718e-07 0.09718220909187772 1.107018152059564e-07 0.09606278874246346 1.107019529198845e-07 0.09500564015228773 \
1.107020696106743e-07 0.09411672853020667 1.107021973542416e-07 0.0931507147971556 1.107022970187578e-07 0.09240236948627445 1.107023764526375e-07 0.09180921593916676 \
1.107024751879354e-07 0.09107599640376031 1.10702553063239e-07 0.09050081472416407 1.107026345291548e-07 0.08990210528957472 1.107027092464628e-07 0.0893557072655629 \
1.107027897762006e-07 0.08876971652456604 1.107029086085259e-07 0.08791061481419053 1.107029982690622e-07 0.08726673116015753 1.107031031831091e-07 0.08651800316437093 \
1.107032346576667e-07 0.08558693768262025 1.107033957658019e-07 0.08445695903909305 1.107035359474973e-07 0.08348350561263763 1.107036844501031e-07 0.08246223579158835 \
1.10703821170292e-07 0.08153124812726546 1.107039611820024e-07 0.08058696725890066 1.10704098179202e-07 0.07967195061625794 1.107042367898133e-07 0.07875532825288725 \
1.107043812626999e-07 0.07780967510081127 1.107045288089374e-07 0.07685421131041187 1.107046863126477e-07 0.07584560580436887 1.107048507078841e-07 0.07480523464991846 \
1.107050187999819e-07 0.07375451744755303 1.10705199799341e-07 0.07263751640721161 1.107053985126234e-07 0.07142823309373261 1.10705611921415e-07 0.07014922396308329 \
1.107058380853001e-07 0.06881630383186611 1.107060786456226e-07 0.06742468841361035 1.107063562065355e-07 0.06585179211508728 1.107066534109385e-07 0.06420523370201831 \
1.107069717116618e-07 0.06248365192299224 1.10707361695962e-07 0.06043183534616462 1.107077605227481e-07 0.05839861031494715 1.10708202994687e-07 0.05621846258761681 \
1.107085879755898e-07 0.05438828987170503 1.107090000221824e-07 0.05249218901100536 1.10709351759698e-07 0.05092353490091287 1.107096872643497e-07 0.04946969867921969 \
1.107099977632446e-07 0.04816021644386199 1.107102917000643e-07 0.04695194805701195 1.107105844309969e-07 0.04577883625507727 1.107108592742044e-07 0.04470700909733757 \
1.107111331179271e-07 0.04366353526031765 1.107113988076876e-07 0.04267398813878486 1.107116741167033e-07 0.04167180388267511 1.107119586736207e-07 0.04066026046469497 \
1.107122549717362e-07 0.03963283340811159 1.107125138471216e-07 0.03875659098599576 1.107127418035276e-07 0.03800131046948733 1.107129605287219e-07 0.03729095380188759 \
1.107131803834489e-07 0.03659437723507575 1.107135212495136e-07 0.03554043311314246 1.107137972903943e-07 0.03470953269536187 1.107140907211692e-07 0.03384790442147732 \
1.107143732890922e-07 0.03303898052111545 1.107146281985287e-07 0.03232625790162248 1.107149088829884e-07 0.03155947796597136 1.107151547163818e-07 0.03090318379665042 \
1.107153868776701e-07 0.03029616297556957 1.10715627215008e-07 0.02968398395812225 1.107158628518432e-07 0.02909722707395018 1.107160910630208e-07 0.0285403787496557 \
1.107165078357495e-07 0.02755138287878544 1.10716702361127e-07 0.02710176794309662 1.107170886015322e-07 0.02623051698020805 1.10717267770925e-07 0.0258356865503758 \
1.107176189981086e-07 0.02507792837274256 1.107177869041566e-07 0.0247229612172224 1.107181711668123e-07 0.02392944198669211 1.107182864485406e-07 0.02369675911063252 \
1.107187284963783e-07 0.02282172072611499 1.107189503116517e-07 0.02239223679446916 1.107194739313108e-07 0.02139838041889957 1.107196292938196e-07 0.02110714647916685 \
1.107201469998876e-07 0.02015295207761772 1.10720272033152e-07 0.01992792118872039 1.10720796234659e-07 0.01901759738223179 1.107209324540342e-07 0.01879045572456909 \
1.107215387304897e-07 0.01783210191617334 1.107217057396231e-07 0.01758082406519646 1.107223489472666e-07 0.01666064795441237 1.107225280915353e-07 0.0164167113061686 \
1.107232182502689e-07 0.01551958953683085 1.107233818701531e-07 0.01531511209162885 1.107241423508398e-07 0.01440332854054019 1.107242893929629e-07 0.01423371673427115 \
1.107251072646214e-07 0.01333087949608782 1.107252268131343e-07 0.01320411419549955 1.107261426746556e-07 0.01227329163592313 1.107262840275722e-07 0.01213544173166964 \
1.107272325031483e-07 0.01124488043697059 1.107273911425863e-07 0.01110230805801717 1.1072857354363e-07 0.01011356759191894 1.107286716440201e-07 0.01003725601038859 \
1.1072993325548e-07 0.009120360285939955 1.107300676693304e-07 0.009028655389366201 1.107316082406548e-07 0.008043892937307966 1.107316892739987e-07 0.007992925041580451 \
1.107332778679313e-07 0.007023242357651564 1.10733410759078e-07 0.006948518507451114 1.107353874624203e-07 0.005952856104192286 1.107355692005682e-07 0.005869662958407677 \
1.107376715542283e-07 0.004980929874643355 1.107381123459968e-07 0.004810448874467742 1.107407675608552e-07 0.003892108290451164 1.107412441403943e-07 0.003745909362026665 \
1.107448822226149e-07 0.00279447349697209 1.107454077460605e-07 0.002678838783887205 1.107510138108453e-07 0.001700248310874221 1.107513248985468e-07 0.001653333728976835 \
1.107564592262458e-07 0.0006858192122199529 1.107566532060193e-07 0.0006440832883579712 1.134045769148618e-07 -0.0002037173203380238 1.134047411152831e-07 -0.0003889174928863678 \
1.134053144580912e-07 -0.001270938904608877 1.134053893922784e-07 -0.001411855863724778 1.134058499760551e-07 -0.002393592696522268 1.134059619168068e-07 -0.002660411672198376 \
1.134062151887948e-07 -0.003300974950034667 1.134063815720996e-07 -0.003745951779090856 1.134066765678696e-07 -0.004566571567208835 1.134067880554425e-07 -0.00488071790655901 \
1.134070674282164e-07 -0.005641221413069743 1.134071883865554e-07 -0.005938820066262044 1.134082823393885e-07 -0.005180465225493313 1.13408406471631e-07 -0.004410796826645887 \
1.134085308790492e-07 -0.003456122327429311 1.134086504354286e-07 -0.002364170815481491 1.13408748579805e-07 -0.001341064316055312 1.13408855004127e-07 -0.0001052154991983786 \
1.134089672399721e-07 0.001336046702817826 1.134091021958209e-07 0.003249882807978809 1.134092247823306e-07 0.005149402351921401 1.134094136442457e-07 0.008353592055059769 \
1.134095548265785e-07 0.01094873860302964 1.134097081879224e-07 0.01393943619118621 1.134098515614267e-07 0.01687898420971235 1.13410005752867e-07 0.02017576688295359 \
1.134101618928252e-07 0.02363796584892512 1.134103176188778e-07 0.02719811802828209 1.134104651125568e-07 0.03065407560139007 1.134106137843234e-07 0.03420778369279751 \
1.134107691144076e-07 0.03798436241030867 1.134109277402875e-07 0.04189786275883118 1.134110926734479e-07 0.0460171220807938 1.134112670963364e-07 0.05041857973200652 \
1.134114460857363e-07 0.05497510627343041 1.134116353855968e-07 0.05982852266675163 1.134118383936028e-07 0.06506368941101938 1.134120578706689e-07 0.07075025585284363 \
1.134122889353305e-07 0.07675903373893865 1.134125359956494e-07 0.08319974270080552 1.134128064206373e-07 0.0902619122132732 1.134130999843244e-07 0.09793335781011638 \
1.13413424033306e-07 0.1064001814721126 1.134137882548562e-07 0.1159066558703892 1.134141808063258e-07 0.1261372395632307 1.134146303042508e-07 0.1378252442462487 \
1.134151530964837e-07 0.1513754922073403 1.134157666942192e-07 0.1672157090591849 1.134164444550933e-07 0.184625848284817 1.134172327202124e-07 0.2047487967247964 \
1.134181155530716e-07 0.22712469896725 1.134189338390288e-07 0.2476994923478653 1.13419661268608e-07 0.2658503723959502 1.134203013816358e-07 0.2817009601644404 \
1.134208756853502e-07 0.2958213763442377 1.134214132513172e-07 0.3089396094373287 1.134219172487762e-07 0.3211464104224903 1.1342239337143e-07 0.3325930942309646 \
1.134228712594449e-07 0.3439912352478621 1.134233245925507e-07 0.3547121966731367 1.134237958852587e-07 0.3657614311162562 1.134242385610847e-07 0.3760518588326446 \
1.13424757059872e-07 0.3879885572071845 1.134252842219919e-07 0.3999987293386327 1.134256631316234e-07 0.4085537955782026 1.134261930471663e-07 0.4204060347738258 \
1.13426622963746e-07 0.429919877745455 1.134270766645209e-07 0.4398653393542544 1.134275433780368e-07 0.4500002271552926 1.134279810592672e-07 0.4594210430579985 \
1.134283890215308e-07 0.468120704286539 1.134287084545646e-07 0.4748816926501604 1.134290805898366e-07 0.4826992142337162 1.134293155719776e-07 0.4876010339127531 \
1.13429549178225e-07 0.4924491904621348 1.134297971906479e-07 0.4975647713404599 1.134300955920778e-07 0.5036796627825791 1.134303519484798e-07 0.5088948470128004 \
1.134305642417897e-07 0.5131878547336713 1.134307582598616e-07 0.5170959594548015 1.134309052463942e-07 0.5200432695146362 1.134310592244046e-07 0.523118600542271 \
1.134312771061538e-07 0.5274469616807909 1.134315302104803e-07 0.5324525256580425 1.134317400493245e-07 0.5365797337241586 1.134319515026335e-07 0.5407247601751553 \
1.134322337095338e-07 0.5462280430697679 1.134324632548168e-07 0.5506821559930507 1.134326791510236e-07 0.5548604062613707 1.134329613725408e-07 0.560308769190463 \
1.134332126802682e-07 0.5651538146135803 1.134335103411598e-07 0.5708625224168123 1.134337605680607e-07 0.5756519166658941 1.134340169315557e-07 0.5805516059354519 \
1.134342573415699e-07 0.585116682128892 1.134345155213862e-07 0.5900038400537884 1.134347391135916e-07 0.5942175703762435 1.134349776231628e-07 0.5986919452581434 \
1.134351852078615e-07 0.6025689278491061 1.134354017304866e-07 0.6065904171332736 1.134356510330919e-07 0.6111939272561876 1.134358561065347e-07 0.6149609706257601 \
1.134361073788606e-07 0.6195555361399968 1.13436310600886e-07 0.6232455818254186 1.134365074727914e-07 0.6267987644955494 1.134367007643072e-07 0.630267737067843 \
1.134369555427623e-07 0.6348113783570861 1.13437185753374e-07 0.638887973644319 1.134374031071848e-07 0.6427143472883045 1.134377015129076e-07 0.6479268061885751 \
1.134379169157571e-07 0.6516657345437264 1.134381181394757e-07 0.6551344108237934 1.134382930609835e-07 0.6581323437428509 1.13438458126254e-07 0.6609495238976936 \
1.134386275947746e-07 0.6638251431769452 1.134387797316125e-07 0.666392827642013 1.134389176422984e-07 0.6687037209181631 1.134390664784122e-07 0.6711867545200138 \
1.134391945930143e-07 0.6733159837320549 1.134393378158276e-07 0.6756849429836936 1.134394590900776e-07 0.6776819274526149 1.134395966887617e-07 0.6799401191146522 \
1.134397160692161e-07 0.6818929034138137 1.134398631769624e-07 0.6842914131385206 1.134399803786278e-07 0.6861933934268433 1.13440073884205e-07 0.6877071857403232 \
1.13440164873897e-07 0.6891752279197846 1.134402676159613e-07 0.6908280855439021 1.134403691335249e-07 0.6924555900607121 1.134404875166309e-07 0.6943444167618776 \
1.134405996372169e-07 0.6961264383846065 1.134407171927181e-07 0.6979868779962457 1.134409023430049e-07 0.7008959348649784 1.134410335352131e-07 0.7029413755586562 \
1.134411697037528e-07 0.7050491462541959 1.134412912224561e-07 0.7069171228306749 1.134414311454679e-07 0.7090538254196674 1.134415350881169e-07 0.7106315721465845 \
1.134416462491007e-07 0.712309798010818 1.134417505089649e-07 0.7138759052437967 1.134418801470564e-07 0.7158124745844324 1.134419770777692e-07 0.7172526339884565 \
1.134421160000042e-07 0.7193052800722975 1.134422355492927e-07 0.7210612846995991 1.134423551218654e-07 0.7228080613301419 1.134424808972429e-07 0.7246353354365959 \
1.134426076155857e-07 0.7264656873164689 1.134427296554369e-07 0.728218443613998 1.134428578038805e-07 0.7300486655261287 1.13442987872205e-07 0.7318956587421809 \
1.134431088632273e-07 0.7336041830685722 1.134432496338107e-07 0.7355801168346318 1.1344335060338e-07 0.7369898206659778 1.134434522042367e-07 0.7384020079314992 \
1.13443548224548e-07 0.7397310783624924 1.134436591374029e-07 0.7412570822736337 1.134437467850298e-07 0.7424563811251772 1.134438466394007e-07 0.7438154404043728 \
1.134439814045385e-07 0.7456370856934184 1.13444097699018e-07 0.747198032089633 1.13444201190815e-07 0.7485782798032956 1.134443254462628e-07 0.7502239458264747 \
1.13444470359203e-07 0.7521280942578691 1.134445883397714e-07 0.753666143975803 1.134447072708787e-07 0.7552056331692281 1.134448468504184e-07 0.7569980918234445 \
1.134449912028081e-07 0.7588357421297242 1.134451092636163e-07 0.7603265096672839 1.134452340853355e-07 0.7618908200857619 1.134453739165311e-07 0.7636286950759973 \
1.134454986794279e-07 0.7651662633748356 1.134456421928987e-07 0.7669199865864609 1.134457628783765e-07 0.7683824344671055 1.13445883722124e-07 0.7698356273746885 \
1.134460033670484e-07 0.7712633747646481 1.134461330746874e-07 0.7727989859455529 1.134462418184901e-07 0.7740766298596218 1.134463644662266e-07 0.7755070372682662 \
1.134464742429112e-07 0.7767778749889983 1.13446603267025e-07 0.7782599816788072 1.134467350433437e-07 0.7797610257751375 1.134468483559198e-07 0.7810403609326458 \
1.134469694418617e-07 0.7823954393038701 1.134470733144949e-07 0.7835479431998941 1.134472155975174e-07 0.785111775748914 1.134473638006659e-07 0.7867227488076519 \
1.134475226942012e-07 0.7884297907063792 1.134476428872234e-07 0.7897074707829422 1.134477924539297e-07 0.7912811323018302 1.134479165691468e-07 0.7925734175081853 \
1.134480422734439e-07 0.7938699048627912 1.134481452190109e-07 0.7949224966762399 1.134482595901654e-07 0.7960823495211882 1.134483720644089e-07 0.7972131756542409 \
1.134484623369833e-07 0.7981137961420948 1.134485516778793e-07 0.7989989930139054 1.134486769038167e-07 0.800229513878344 1.134487846751798e-07 0.8012785338618679 \
1.134489143429785e-07 0.8025281307685926 1.134490357222573e-07 0.8036855380110038 1.134491522780568e-07 0.8047859282369955 1.134492730834528e-07 0.80591497746663 \
1.134494057087579e-07 0.8071413435168892 1.134495275023783e-07 0.8082555056211007 1.13449654106103e-07 0.8094015704683005 1.134497797196214e-07 0.8105266036187198 \
1.13449899211046e-07 0.8115857443778658 1.134500374092988e-07 0.8127973981963581 1.134501469085475e-07 0.8137473213416323 1.134502310566626e-07 0.8144713378799666 \
1.134503518607202e-07 0.8155017394983226 1.134504473695572e-07 0.8163089346032877 1.134505836603603e-07 0.8174496006492775 1.13450726424414e-07 0.8186303638797883 \
1.13450860857535e-07 0.8197292014569521 1.134509707295191e-07 0.8206175763825388 1.134511146291367e-07 0.8217677661037901 1.134512679567201e-07 0.8229768690765377 \
1.134513958055741e-07 0.8239722812379519 1.134515362029048e-07 0.8250521595273246 1.13451662107844e-07 0.8260088941474263 1.134518167240102e-07 0.8271688948348412 \
1.134519490793395e-07 0.8281489842609937 1.134520753461681e-07 0.8290730392392056 1.134521930066954e-07 0.8299245984162376 1.134523414090921e-07 0.8309852945996649 \
1.134525086032604e-07 0.8321626230293395 1.134526413805716e-07 0.8330844501529713 1.134528142817687e-07 0.8342675727345584 1.134529826990627e-07 0.8354015168591284 \
1.134531521935363e-07 0.8365246342267009 1.134533336304179e-07 0.8377070668209077 1.134534761865593e-07 0.8386219603417975 1.134535900974499e-07 0.8393441765511721 \
1.134537209736586e-07 0.8401643924869071 1.134538225966329e-07 0.8407940582489307 1.134539390368715e-07 0.8415078269750864 1.134540743300576e-07 0.8423269142909066 \
1.134542715951592e-07 0.8435017451489455 1.134544621144827e-07 0.844614933042255 1.13454672039296e-07 0.8458175693076773 1.134548528178267e-07 0.8468334846981137 \
1.134550501858462e-07 0.8479221976595614 1.134552240443405e-07 0.8488638701886076 1.134554065585834e-07 0.8498353939890455 1.134555779026936e-07 0.8507314120859523 \
1.13455752248258e-07 0.8516272398309612 1.134559276512583e-07 0.8525125793730954 1.134561038964483e-07 0.8533864315694911 1.134562936653265e-07 0.8543099749208749 \
1.134564844233442e-07 0.8552205033559714 1.134566862125501e-07 0.8561646193034282 1.134568789161161e-07 0.8570482883232282 1.134570883567927e-07 0.8579892478796384 \
1.134573180985592e-07 0.8589986827500428 1.134575835675109e-07 0.8601360945383778 1.134578822138556e-07 0.8613786760148464 1.134581606012222e-07 0.8625023989005415 \
1.134584447911769e-07 0.8636161469557806 1.13458719285784e-07 0.8646608622318305 1.134589913772806e-07 0.8656672252055042 1.134592615937268e-07 0.8666387059277968 \
1.134595187619146e-07 0.8675381145236246 1.134597913209795e-07 0.8684653318325959 1.1346006734232e-07 0.8693777905953765 1.13460337484171e-07 0.8702455402709716 \
1.134606372319547e-07 0.8711796653984102 1.134610081058124e-07 0.872294745819888 1.134613030287967e-07 0.8731503023941 1.134615572848448e-07 0.8738665406311316 \
1.134618555155772e-07 0.8746822274488602 1.134621291339016e-07 0.8754080260278182 1.134623652695491e-07 0.8760175227551726 1.134626056214059e-07 0.876622281264788 \
1.134628279637853e-07 0.8771680781109068 1.134630219681285e-07 0.8776338860468618 1.134633516912075e-07 0.8784037109613512 1.1346350686397e-07 0.8787567114621292 \
1.134638246164967e-07 0.879461652496718 1.134640034818579e-07 0.8798480920375044 1.134643459433238e-07 0.8805675499479563 1.134645300848474e-07 0.8809434933546246 \
1.134650049902839e-07 0.8818790560183651 1.134651723847029e-07 0.8821975058309585 1.134656382161285e-07 0.8830540251881659 1.134658190409674e-07 0.8833751042472839 \
1.134663130743469e-07 0.8842212008576973 1.134664544170557e-07 0.884455124402366 1.13467060806836e-07 0.8854193259359495 1.134672128789829e-07 0.8856514227360587 \
1.134678595574705e-07 0.8865980751852495 1.134679878538246e-07 0.8867785329419297 1.134686359799261e-07 0.8876550049536978 1.134687657724472e-07 0.8878236738033012 \
1.134695440340947e-07 0.8887860366092379 1.134696590259732e-07 0.8889208282599539 1.134705147583919e-07 0.8898661633196656 1.134706600215368e-07 0.8900169066926564 \
1.134716457777221e-07 0.8909664261264102 1.134718668828627e-07 0.8911622482549515 1.134730119973067e-07 0.8921020388386462 1.134731432072641e-07 0.8922053928944147 \
1.134743308657994e-07 0.8931033243919096 1.134744844860915e-07 0.8932130731307282 1.13475894522803e-07 0.8941348173026452 1.13476117329622e-07 0.8942660193790342 \
1.134777980203304e-07 0.8951452796684343 1.134781256415096e-07 0.8952966652167414 1.134803555826309e-07 0.8961896554712738 1.134809084965924e-07 0.8963788593752812 \
1.134844767111233e-07 0.8973573335043913 1.134848002235382e-07 0.8974284307984646 1.134911566318259e-07 0.8984120886469452 1.134917055346727e-07 0.8984686671268907 \
1.13544207609024e-07 0.8994658645395698 1.135448506378865e-07 0.8994692460188505 1.137369893085195e-07 0.9004073346715066 1.137371907224907e-07 0.9004708280105613 \
1.137411505004318e-07 0.8995366825576255 1.137413345272296e-07 0.8993953949813248 1.137426511245044e-07 0.8984641879157507 1.137428231683587e-07 0.8983566564859006 \
1.137447195446537e-07 0.8973720929359315 1.137448932508418e-07 0.897304621671452 1.137574671778748e-07 0.8982933655523699 1.137575523681118e-07 0.8983081509245614 \
1.137658192411513e-07 0.8993078551592517 1.137662939605718e-07 0.8993433667976791 1.142597948700116e-07 0.9002974142054325 1.142599143497356e-07 0.9003767372269074 \
1.142608071727864e-07 0.9012336455299185 1.142609534294226e-07 0.901423267690772 1.142615483221009e-07 0.9023325668564308 1.142616832929176e-07 0.9025673929107925 \
1.14262187968707e-07 0.9035294259428087 1.142623205796079e-07 0.9038000271808221 1.142627212069726e-07 0.9046475051114249 1.142628655723708e-07 0.9049556543240072 \
1.142632886935802e-07 0.9058123566484279 1.142633841506385e-07 0.9059850892484415 1.142648087094547e-07 0.9052205906349737 1.142649337473088e-07 0.9046352442223391 \
1.142650601578981e-07 0.9039223775493039 1.142651628066418e-07 0.9032486771507763 1.142652900219319e-07 0.9022944222362175 1.142654088677579e-07 0.9012801950564071 \
1.142655065202371e-07 0.9003603330664713 1.142655885222584e-07 0.8995243596151602 1.142656681858213e-07 0.8986589236008835 1.142657789639895e-07 0.8973708307079206 \
1.142658801400036e-07 0.8961049472956977 1.142659630844751e-07 0.8950067229086057 1.142660715298925e-07 0.8934921260891034 1.142661799938501e-07 0.8918872687155874 \
1.14266275049989e-07 0.8904106867557802 1.142663959226416e-07 0.8884444419111864 1.14266516699262e-07 0.8863849482818795 1.142666297444327e-07 0.8843763393508186 \
1.142667329151817e-07 0.8824794505619851 1.142668185153382e-07 0.8808620855018965 1.142668929893991e-07 0.8794251273161163 1.142669873129417e-07 0.8775673968166831 \
1.142670757738577e-07 0.8757888800524039 1.142671548468696e-07 0.8741711975775893 1.142672488342247e-07 0.872216793437976 1.142673301795293e-07 0.8704993514258973 \
1.14267425093555e-07 0.8684673705816817 1.14267518136275e-07 0.8664480751909672 1.142676149220692e-07 0.8643215060814092 1.142677382174414e-07 0.8615778533848952 \
1.142678516644525e-07 0.859022019682563 1.142679775164913e-07 0.8561558571929792 1.142681008446355e-07 0.8533196845306243 1.142682300229265e-07 0.850323637950593 \
1.142683706197831e-07 0.8470370034914 1.142684793995045e-07 0.8444782910716596 1.142686144592575e-07 0.8412850455921466 1.14268724119566e-07 0.8386804253780991 \
1.142688532993454e-07 0.8356002443501571 1.14268979483175e-07 0.8325812421138936 1.142691065735304e-07 0.8295317031556502 1.142692355958039e-07 0.826427745883674 \
1.142693446760448e-07 0.8237985689995477 1.142694845267009e-07 0.8204223029647078 1.142696239548932e-07 0.8170507778356514 1.142697567085239e-07 0.8138366863616762 \
1.142698867771992e-07 0.8106848159989707 1.142700104726457e-07 0.8076853837479523 1.142701474270357e-07 0.8043627031572629 1.142702611388824e-07 0.8016030849198694 \
1.142703886159226e-07 0.7985086235398901 1.142704994169941e-07 0.7958187897651571 1.142706186034522e-07 0.7929254985494992 1.142707319825085e-07 0.7901733724735396 \
1.142708662929012e-07 0.7869138859547327 1.142709733871687e-07 0.7843152933129034 1.142710894043117e-07 0.7815009627552112 1.142712185952754e-07 0.778367508739124 \
1.142713162077106e-07 0.7760002683782802 1.142714217871509e-07 0.773440790716327 1.142715304693199e-07 0.7708069008430674 1.142716328855832e-07 0.7683258101021144 \
1.142717262792412e-07 0.7660641808432364 1.142718458350171e-07 0.7631702213567544 1.142719383073787e-07 0.7609327305817616 1.14272030945494e-07 0.7586922094322426 \
1.142721293703097e-07 0.7563124992069843 1.142722373479617e-07 0.7537030947613649 1.142723336164742e-07 0.7513778334636231 1.142724198728768e-07 0.7492952979736797 \
1.142725227366661e-07 0.7468128004450286 1.14272601580994e-07 0.744910856519283 1.142727023870358e-07 0.7424801602439853 1.142728369152764e-07 0.7392377693660663 \
1.142729741401358e-07 0.7359316755186537 1.142731176199873e-07 0.7324773442723981 1.142732660441767e-07 0.7289066083419234 1.142734093054719e-07 0.7254625447335662 \
1.142735493824514e-07 0.7220977259655398 1.142737058083174e-07 0.7183435968963056 1.142738302100673e-07 0.715360858370426 1.14273951271848e-07 0.7124600029613375 \
1.1427410478411e-07 0.7087850045121084 1.142742395660554e-07 0.7055614325718365 1.142743656650877e-07 0.7025479112911024 1.142745088393713e-07 0.6991289103945657 \
1.142746289211628e-07 0.6962626602560111 1.142747581554914e-07 0.6931807499479741 1.142748646405391e-07 0.6906432840523983 1.142749769163615e-07 0.6879696524977363 \
1.142750732516477e-07 0.6856773754336868 1.142751760613402e-07 0.683232326200841 1.14275270865193e-07 0.6809792012818872 1.142753761871231e-07 0.6784784437814733 \
1.14275484625777e-07 0.6759058899658261 1.142755836350576e-07 0.673558569590366 1.142757003916503e-07 0.6707929011939652 1.142758084769278e-07 0.6682347329991606 \
1.142759184831366e-07 0.6656332609774134 1.142760045709787e-07 0.6635992664604092 1.142761341661182e-07 0.6605400273835189 1.142762267673659e-07 0.6583552307294462 \
1.142763225550924e-07 0.6560965362104854 1.142764075070784e-07 0.6540950852804182 1.142765268016021e-07 0.6512869789851043 1.142766140715399e-07 0.6492343850333612 \
1.142767047785614e-07 0.6471030993779646 1.14276805943536e-07 0.6447280068361273 1.142768857743593e-07 0.6428551652550211 1.142769745601937e-07 0.6407732405330839 \
1.142770522504205e-07 0.6389536101386547 1.142771140193684e-07 0.6375081226244841 1.142771777840134e-07 0.6360167668935747 1.142772410182332e-07 0.634538653569437 \
1.142772802588059e-07 0.6336218002627473 1.142773208978281e-07 0.6326726453797233 1.142774009823624e-07 0.6308039353694699 1.142774708865426e-07 0.6291742390428672 \
1.142775215232567e-07 0.6279942052995945 1.142775602728994e-07 0.6270914175114127 1.142775992678787e-07 0.6261832343283663 1.142776438826267e-07 0.6251445623164014 \
1.142776867390832e-07 0.6241478292286105 1.142777370536867e-07 0.6229782634938205 1.142777889908641e-07 0.6217719122409077 1.142778740584487e-07 0.6197972300178722 \
1.142779340388659e-07 0.6184052992407258 1.142780238260749e-07 0.61632338076978 1.142781002901565e-07 0.6145529519516876 1.142781798544472e-07 0.6127119801362371 \
1.142782608910593e-07 0.6108383709630588 1.142783501053817e-07 0.6087775861620425 1.142784409653938e-07 0.6066826282541496 1.142785281841023e-07 0.6046739453334793 \
1.142786219572931e-07 0.6025158549334848 1.142787236427565e-07 0.6001788642681311 1.142788232408485e-07 0.5978941858483342 1.142789350958888e-07 0.5953317151711254 \
1.14279051129026e-07 0.5926772450523136 1.142791727501318e-07 0.5899020947998995 1.142792771339459e-07 0.5875236635596754 1.142794219241658e-07 0.5842296531729801 \
1.142795345841267e-07 0.5816734289694181 1.14279643596094e-07 0.5792035939892568 1.142797360755373e-07 0.5771100174076607 1.142798295261766e-07 0.5749994714793375 \
1.142799218520404e-07 0.5729181236728181 1.142799944387413e-07 0.571283073141143 1.142800503929671e-07 0.5700232888304386 1.142801114612485e-07 0.5686498830286455 \
1.142802099507645e-07 0.5664400707212188 1.142802731622084e-07 0.5650238531380825 1.14280333588177e-07 0.5636708824310654 1.142804105365601e-07 0.5619492451093103 \
1.142804736951014e-07 0.5605380106414651 1.142805620087099e-07 0.558569506627369 1.14280633210033e-07 0.5569845302974165 1.14280719745787e-07 0.555060151797141 \
1.142808410985601e-07 0.5523665438352664 1.142809690278082e-07 0.5495364947125975 1.142810671584392e-07 0.5473694328713704 1.142811802824346e-07 0.5448752016832871 \
1.14281282350254e-07 0.5426314425864434 1.142814012991245e-07 0.5400217272291628 1.142815043868322e-07 0.5377630705755105 1.142816185939865e-07 0.5352670017334624 \
1.142817320096582e-07 0.532794946211756 1.14281859080713e-07 0.5300302694710822 1.14281982900802e-07 0.5273426867079006 1.142821276896071e-07 0.5242103332418484 \
1.142822635131097e-07 0.5212782585303676 1.142824185679684e-07 0.5179428401013338 1.142825794198528e-07 0.5144913885072363 1.142827581493005e-07 0.5106699876709851 \
1.1428294832834e-07 0.5066200804011861 1.142831582303623e-07 0.5021665212646098 1.142833869363468e-07 0.4973332357952056 1.142836408642853e-07 0.4919960258408594 \
1.142838817977506e-07 0.4869529241725989 1.142841779602358e-07 0.4807889695952298 1.142844679576231e-07 0.4747910561470179 1.142847742009558e-07 0.4684976697011882 \
1.142850948768875e-07 0.4619520863481486 1.142854227440541e-07 0.4553041925245184 1.142857629891091e-07 0.4484521981997251 1.142860884146545e-07 0.4419418052309769 \
1.142864103218022e-07 0.4355465312739703 1.142867405359073e-07 0.4290298934287748 1.142870965284996e-07 0.4220583188787752 1.142874154069286e-07 0.4158579595363656 \
1.14287752858691e-07 0.4093433989943853 1.142881807254075e-07 0.4011531841887147 1.142885294373556e-07 0.3945419525178304 1.142888370733194e-07 0.388759214407489 \
1.142892168998106e-07 0.3816861832573664 1.142895480893721e-07 0.3755780492082042 1.142898316974524e-07 0.370391509977049 1.142901425163967e-07 0.3647512908748707 \
1.142904218330045e-07 0.3597258263082204 1.142906483291526e-07 0.3556836811642302 1.142908640115379e-07 0.3518598964090484 1.142910612955428e-07 0.3483842179544538 \
1.142912662800023e-07 0.3447988491770444 1.142914785019664e-07 0.3411119200457455 1.142917338071541e-07 0.33670771290924 1.142919753294027e-07 0.3325734463267218 \
1.14292206706731e-07 0.3286464933807047 1.142924215592308e-07 0.3250253651850565 1.142926421183882e-07 0.3213332986541765 1.142928435443551e-07 0.3179852906236645 \
1.142930466126061e-07 0.3146379646143546 1.142932445082156e-07 0.3114011111455273 1.142934314693022e-07 0.3083651674074345 1.142936252695217e-07 0.3052406640298299 \
1.142938291861339e-07 0.3019773030815858 1.142940082554678e-07 0.2991336297844484 1.142942438463241e-07 0.2954229173226265 1.142944446504233e-07 0.2922868215109002 \
1.142946458293147e-07 0.2891696385850206 1.142948696390574e-07 0.2857334090862961 1.142950342018033e-07 0.2832271910241367 1.142952111291889e-07 0.2805503385691353 \
1.14295396922194e-07 0.2777610713150803 1.142955787376702e-07 0.2750538970423583 1.142957577624632e-07 0.2724132377985424 1.142959251076164e-07 0.2699606650006489 \
1.142960855365337e-07 0.2676371805838822 1.142962081102854e-07 0.2658719571410424 1.14296357874814e-07 0.2637236906090554 1.142964855719403e-07 0.2619099339733745 \
1.142965928803121e-07 0.2603957336038235 1.142967088809744e-07 0.2587625259947361 1.142968191895705e-07 0.2572125806747212 1.142969450687671e-07 0.2554509781935611 \
1.142970605506183e-07 0.2538402638894013 1.142971951315211e-07 0.2519757335310172 1.142973071947753e-07 0.2504255755821768 1.142974575341346e-07 0.2483447107137444 \
1.142975971599893e-07 0.2464124269747185 1.142977430518096e-07 0.2444035064209518 1.142978760124476e-07 0.2425734862730615 1.14297999574161e-07 0.2408709992523319 \
1.142981467838532e-07 0.2388417729476062 1.142982633706824e-07 0.2372355665500016 1.142984028258316e-07 0.23532008003217 1.142985370003013e-07 0.2334768281602104 \
1.142986629767575e-07 0.2317465561243653 1.142987823761605e-07 0.2301094434087779 1.142988772305854e-07 0.2288105340759602 1.142989903681845e-07 0.2272617792622066 \
1.142990706846421e-07 0.2261626001158484 1.142991582496986e-07 0.2249657246820506 1.142992837868356e-07 0.2232507767215072 1.142993894805428e-07 0.2218101326756785 \
1.142994791350539e-07 0.2205921574607158 1.14299549986253e-07 0.2196300825522397 1.142995930147827e-07 0.2190460135436258 1.142996353053263e-07 0.2184724035808872 \
1.142996776470424e-07 0.2178984240735344 1.142997498424616e-07 0.2169203674089526 1.142997922358174e-07 0.2163464205126744 1.14299827490656e-07 0.2158693585303403 \
1.142998716822395e-07 0.2152716287340076 1.142999412904665e-07 0.2143309212991285 1.142999756337965e-07 0.2138672544767182 1.143000200933248e-07 0.2132698436071631 \
1.143000877718062e-07 0.2123628126304402 1.143001741990649e-07 0.2112058698236149 1.143002488356675e-07 0.2102078598594563 1.143003301376756e-07 0.2091219706754807 \
1.143004270150594e-07 0.2078300362310651 1.143005529985482e-07 0.2061528795789772 1.143006555333841e-07 0.2047906894256944 1.143007570169014e-07 0.2034500128132261 \
1.143008580825969e-07 0.202119416354989 1.143009546968166e-07 0.2008491615811921 1.143010566612396e-07 0.1995112314821507 1.143011633834836e-07 0.1981153840927639 \
1.143012717886237e-07 0.1967018790395962 1.143013837827796e-07 0.1952465002768531 1.14301496249907e-07 0.1937897263683151 1.143016083232463e-07 0.1923454332378671 \
1.143017162157206e-07 0.1909603537828802 1.143018175986494e-07 0.1896629368444172 1.143019092360985e-07 0.1884941330679491 1.143020032117073e-07 0.1872990757663449 \
1.143020744780721e-07 0.1863957871745983 1.1430215115336e-07 0.1854271890400033 1.143022548124749e-07 0.184122202819407 1.143023284795955e-07 0.1831974022686171 \
1.143024018254956e-07 0.1822796569444652 1.143025152158449e-07 0.1808667181969195 1.143026030744852e-07 0.1797760932362061 1.143026869231622e-07 0.1787387947787487 \
1.143028158855897e-07 0.1771515524267008 1.143029177720844e-07 0.1759040172436072 1.143030234727908e-07 0.1746156056808686 1.143031251208657e-07 0.1733818993219825 \
1.143032559825841e-07 0.1718019019596718 1.143033631792215e-07 0.1705140034701537 1.14303492508118e-07 0.168969083715685 1.143036042046102e-07 0.167642098072289 \
1.143037045351887e-07 0.1664555496840579 1.143038003357432e-07 0.1653276075899142 1.143039111480153e-07 0.1640289617085985 1.143039985482962e-07 0.1630090521997956 \
1.143041098694134e-07 0.1617156184952586 1.143042028212722e-07 0.1606409001560029 1.143042903941502e-07 0.1596330843918451 1.143043920250233e-07 0.1584700928658864 \
1.143044764790781e-07 0.1575086241734052 1.143045515834575e-07 0.1566573095634876 1.143046294056999e-07 0.1557789554714152 1.143047097635688e-07 0.1548759612316424 \
1.143048108183989e-07 0.1537464547857493 1.143048932519626e-07 0.1528311848879565 1.143049855565143e-07 0.1518114053368895 1.143050624909871e-07 0.150965812476358 \
1.143051454135576e-07 0.1500585909391909 1.143052169442981e-07 0.1492793026301012 1.143053133277974e-07 0.1482344968214558 1.143053835562832e-07 0.1474766665551334 \
1.143054665365612e-07 0.1465853655470201 1.143055279788246e-07 0.1459298106834085 1.143055996612094e-07 0.1451677491870439 1.14305668289752e-07 0.1444408762699853 \
1.143057185582615e-07 0.1439102090153988 1.143057661380673e-07 0.143409423336876 1.14305820187418e-07 0.1428423132663369 1.143058795295158e-07 0.1422216078256897 \
1.143059475649228e-07 0.1415124633834424 1.14306023828345e-07 0.1407207186008814 1.143060921081446e-07 0.1400161356079559 1.143061868943229e-07 0.1390460813732662 \
1.143062764481352e-07 0.1381341561933974 1.143063481336088e-07 0.1374075731330657 1.143064320850176e-07 0.1365606113096345 1.143064973974727e-07 0.1359045398875483 \
1.143065588405982e-07 0.1352895588344758 1.143066331170967e-07 0.1345490408254265 1.143066953273574e-07 0.1339328028964004 1.143067632983657e-07 0.133265236037424 \
1.143068225054055e-07 0.1326856657519672 1.143068951778785e-07 0.1319767402814105 1.143069701979877e-07 0.1312477270463112 1.143070556514107e-07 0.1304208267333309 \
1.143071417517503e-07 0.1295914604616623 1.143072418772051e-07 0.1286317929389105 1.143073231668748e-07 0.127857435971709 1.143074249342228e-07 0.1268981149578782 \
1.143075091821821e-07 0.1261072369695883 1.143076079989111e-07 0.1251836587365037 1.143076808394557e-07 0.1245055382686853 1.143077608655429e-07 0.1237631876254407 \
1.14307831351338e-07 0.1231117958237987 1.143079038817606e-07 0.1224439308288319 1.143079813507563e-07 0.1217331219782777 1.143080887021039e-07 0.1207554316575004 \
1.143081893401196e-07 0.1198442997624752 1.143082619276736e-07 0.1191899427853172 1.143083307595138e-07 0.1185715582611356 1.143083965463339e-07 0.1179824683205609 \
1.143084661751317e-07 0.1173610347366148 1.143085365588769e-07 0.1167350538439435 1.143086117372496e-07 0.1160688810594495 1.143087159914846e-07 0.1151493019715505 \
1.143087911261386e-07 0.114489769343061 1.143088600412231e-07 0.1138870655592168 1.143089232460945e-07 0.1133369146236164 1.143089927874599e-07 0.1127339156958381 \
1.14309050088964e-07 0.1122385190692166 1.14309121730019e-07 0.1116210355509516 1.143091795650925e-07 0.1111240709857579 1.143092516865272e-07 0.1105063809580559 \
1.1430931410261e-07 0.1099736279351742 1.143093984241316e-07 0.1092565349771765 1.143094660201e-07 0.1086842173446869 1.143095748160323e-07 0.1077671916889585 \
1.143096791265639e-07 0.1068924975608609 1.14309758614772e-07 0.1062289053282379 1.143098461831825e-07 0.1055008617114655 1.143099096395349e-07 0.1049752776433979 \
1.143099713506517e-07 0.10446579874651 1.14310075190416e-07 0.103612238268202 1.143101578711175e-07 0.1029362225408096 1.143102563391439e-07 0.1021348761715451 \
1.14310340785582e-07 0.101450818648051 1.143104572630618e-07 0.1005121841703865 1.143105919965077e-07 0.09943411943161744 1.143107280660444e-07 0.0983541971400249 \
1.143108423854515e-07 0.09745369041838402 1.143109278525961e-07 0.09678457778867394 1.143110381342688e-07 0.09592640631053104 1.143111189226223e-07 0.09530159220710262 \
1.143112184734934e-07 0.09453592511176086 1.143113084215428e-07 0.09384821103094763 1.14311380924943e-07 0.09329669945188329 1.143114626670093e-07 0.09267796846073476 \
1.143115907872446e-07 0.09171467366828615 1.143116721993079e-07 0.09110674702409056 1.143117466312153e-07 0.09055373306570065 1.143118216050993e-07 0.08999936228352182 \
1.143119010240745e-07 0.08941505746347288 1.143120096849318e-07 0.08862052380504259 1.143121040449035e-07 0.08793517800096999 1.143121934400264e-07 0.08728987318634121 \
1.143123002057426e-07 0.086524181682867 1.143124187081826e-07 0.08568073755029131 1.143125602332527e-07 0.08468224831562859 1.143126933716762e-07 0.08375174214918565 \
1.143128342170073e-07 0.08277682112810406 1.143129832689884e-07 0.08175525972387458 1.143131190667176e-07 0.08083369778093191 1.143132605232322e-07 0.0798830809748103 \
1.143133957831475e-07 0.07898330517332906 1.143135371649882e-07 0.07805242629322809 1.143136842327613e-07 0.07709434677344783 1.143138359609018e-07 0.07611680364043326 \
1.143140013092032e-07 0.07506403321855706 1.143141651767209e-07 0.07403332863189842 1.143143414906487e-07 0.07293832728335037 1.143145309257506e-07 0.07177777688466977 \
1.143147416924551e-07 0.07050569389938771 1.143149614649522e-07 0.06920150027616521 1.143151964331044e-07 0.06783224552442871 1.14315455333654e-07 0.06635227408830123 \
1.14315750264117e-07 0.06470266364809808 1.143160546101784e-07 0.06304001691994518 1.143164165564573e-07 0.06111393619706453 1.143167326842125e-07 0.05947639552636011 \
1.143171740066774e-07 0.0572596911373907 1.143174875727196e-07 0.05573556853365672 1.14317911072189e-07 0.0537382660685313 1.143182550240426e-07 0.05216649213267931 \
1.143185952653102e-07 0.05065508790922631 1.143189061028998e-07 0.04931137323461653 1.143192005748017e-07 0.04807062469528345 1.143194942742994e-07 0.04686392507224969 \
1.143197691455356e-07 0.04576537019482012 1.143200446857014e-07 0.04468949010490332 1.143203097762298e-07 0.04367785045825667 1.143205865333108e-07 0.04264571401740119 \
1.143208698014357e-07 0.04161414314527601 1.143211677947347e-07 0.04055545327485047 1.143214272801311e-07 0.03965542606183669 1.143216573035691e-07 0.03887446236327848 \
1.143218769951559e-07 0.03814321686473518 1.14322101935296e-07 0.0374128399305801 1.1432242218897e-07 0.0363978329183388 1.143227099868201e-07 0.03550963653148703 \
1.143229863821537e-07 0.03467738358988744 1.143232702012828e-07 0.03384352473043348 1.143235083105866e-07 0.03315996078327022 1.143237926213707e-07 0.03236211345273886 \
1.143240345332207e-07 0.03169864947531036 1.143242696733945e-07 0.03106710921041438 1.143245113809233e-07 0.03043352335444016 1.143247483338566e-07 0.02982731501219571 \
1.14324978676274e-07 0.02925002048968134 1.143251924268523e-07 0.02872465224286764 1.143253982738151e-07 0.02822791768061097 1.143257906108381e-07 0.02730524204782691 \
1.143259790028487e-07 0.02687312495148303 1.143263546143073e-07 0.02603163971789 1.143265290810819e-07 0.02564950258131362 1.143269530155409e-07 0.02474274850847508 \
1.14327073769958e-07 0.02449086781212801 1.143275440207215e-07 0.02353384026002922 1.143276932357865e-07 0.02323677291035493 1.143280868679981e-07 0.02246740853134286 \
1.143282578943424e-07 0.02213909006726131 1.143287451732745e-07 0.02121869533024997 1.143288872209832e-07 0.02095326544309953 1.143294202372519e-07 0.01997576278857772 \
1.14329542401289e-07 0.01975737097014436 1.143300645590335e-07 0.01885981776906158 1.143302351373363e-07 0.01857989792133653 1.143307224503994e-07 0.01781360777737795 \
1.143308939733227e-07 0.01755501440977742 1.143315137600803e-07 0.01666567753024489 1.143316846844061e-07 0.0164316648397145 1.143323902353964e-07 0.01551160061118263 \
1.14332552852409e-07 0.01530799450170666 1.143333097458994e-07 0.01439879525764199 1.143334506625442e-07 0.01423641007536438 1.143343506613842e-07 0.01324361033368418 \
1.143344380106346e-07 0.01315122959105692 1.14335342363989e-07 0.01223321097894121 1.14335479555938e-07 0.01209984223734439 1.14336450212214e-07 0.01118944790767422 \
1.14336578130092e-07 0.01107451071402888 1.143377285400387e-07 0.01011008206277823 1.143378223420747e-07 0.01003687265682024 1.143390783878875e-07 0.009120584045805383 \
1.143392159292007e-07 0.009026502753623255 1.14340774683602e-07 0.008029670037698805 1.143408584862873e-07 0.007977066150721189 1.143424638651059e-07 0.00699828665725172 \
1.143425747634502e-07 0.006935886594503895 1.143445070098238e-07 0.005959177461785255 1.143446867147596e-07 0.005876661013304485 1.143467985058761e-07 0.004981749118765498 \
1.143471412910116e-07 0.004848482978762325 1.143496544570453e-07 0.003966891390423618 1.143501241787149e-07 0.003819799497680527 1.143537644949897e-07 0.002847564273158896 \
1.143542802321751e-07 0.002731633924241866 1.143596220620139e-07 0.001773027297371861 1.14359907382299e-07 0.001729522787584184 1.143651360301289e-07 0.0007540451492352357 \
1.143653101766958e-07 0.0007162692714263865 1.170136987690021e-07 -0.0001123232525192561 1.170138717942903e-07 -0.0002901710972538241 1.170144915460445e-07 -0.001202022686018724 \
1.170145801152216e-07 -0.001365806793032466 1.170149410863549e-07 -0.002110727959526865 1.1701506578065e-07 -0.002395793696299351 1.170154296225314e-07 -0.003299857180474864 \
1.170156008981996e-07 -0.003758114451912169 1.170158948960377e-07 -0.004576312838821549 1.170160051044431e-07 -0.004886880824040592 1.170162833584409e-07 -0.005643955697619643 \
1.1701640463225e-07 -0.00594200199557267 1.17017498254348e-07 -0.00517389603226481 1.170176213582281e-07 -0.004409713243767066 1.170177448263029e-07 -0.003462788751204457 \
1.170178649920999e-07 -0.002366010162083454 1.170179628537677e-07 -0.001346276287748183 1.170180695561039e-07 -0.0001076498664581183 1.170181813974884e-07 0.001328007358939307 \
1.170183173718548e-07 0.003256083960376262 1.170184394010113e-07 0.00514709866632534 1.170186278172891e-07 0.008343062029134115 1.170187688058191e-07 0.01093380316938193 \
1.170189215775226e-07 0.01391176330477175 1.170190642801506e-07 0.01683596409946878 1.170192186323876e-07 0.02013443377634912 1.170193744260432e-07 0.02358734537610087 \
1.170195304833402e-07 0.02715365164079262 1.170196778877403e-07 0.03060642997674319 1.170198265044852e-07 0.03415780069914553 1.170199819257017e-07 0.03793559522944389 \
1.170201403115322e-07 0.04184227512730877 1.170203052511541e-07 0.04596085539464361 1.170204795004229e-07 0.05035714787605008 1.170206584435392e-07 0.05491177248689325 \
1.170208475830321e-07 0.0597604232635115 1.170210503636104e-07 0.06498910043066243 1.170212697356369e-07 0.07067233091134768 1.170215005721334e-07 0.07667464705993039 \
1.170217473839693e-07 0.0831083675499642 1.1702201751608e-07 0.09016243555275107 1.170223107041881e-07 0.0978236474935409 1.170226343596258e-07 0.1062798466079799 \
1.170229979269121e-07 0.1157689210849182 1.170233902204302e-07 0.1259925151671456 1.170238386999148e-07 0.1376538644086695 1.170243603994004e-07 0.1511757390224034 \
1.170249727720439e-07 0.1669844191341421 1.170256494173592e-07 0.1843663871188266 1.170264363276496e-07 0.2044554566749352 1.170273175487439e-07 0.2267919980918504 \
1.170281372923844e-07 0.2474048556006221 1.170288657453285e-07 0.2655829647002126 1.17029507221317e-07 0.2814688958417333 1.170300831444854e-07 0.2956305456066151 \
1.170306204013019e-07 0.3087428400511723 1.17031124292597e-07 0.3209487846516751 1.17031601896145e-07 0.3324328152479784 1.170320800193789e-07 0.343838772307344 \
1.170325321182285e-07 0.3545331600964184 1.170330038845194e-07 0.365596737404158 1.170334475813599e-07 0.3759140547845509 1.170339695498976e-07 0.3879344734281669 \
1.170344970878305e-07 0.399956933836353 1.170348766025744e-07 0.4085271910771138 1.170354055641746e-07 0.4203606102508351 1.170358748832554e-07 0.4307444005277802 \
1.170363100387911e-07 0.4402814026247405 1.170367575161174e-07 0.4500002273945978 1.170371975395924e-07 0.4594737646471725 1.170376008413354e-07 0.4680814138276727 \
1.170379192411013e-07 0.4748254127722248 1.170382892190148e-07 0.4826007100982719 1.17038525472097e-07 0.4875314737878706 1.170387605434932e-07 0.4924129045770672 \
1.170390118828312e-07 0.4975994385012801 1.170393182698655e-07 0.5038799449729535 1.170395752283189e-07 0.5091120301871851 1.170397837026154e-07 0.5133309170973237 \
1.170399840849048e-07 0.5173683849445317 1.170401264786059e-07 0.5202244049244739 1.170402754030717e-07 0.5231993726577677 1.170404869493287e-07 0.5274019882470222 \
1.170407130069516e-07 0.5318780389403845 1.170409075493335e-07 0.5357103559602913 1.170410966812289e-07 0.539423417888626 1.170413261282768e-07 0.5439012399750046 \
1.170415086340828e-07 0.5474563135343053 1.170417459969519e-07 0.5520623276458133 1.170420149912601e-07 0.5572695987004129 1.170422639017101e-07 0.5620706638085723 \
1.170425079185314e-07 0.5667633705755619 1.170427802737438e-07 0.5719926523718327 1.170430416698736e-07 0.5769928369418796 1.170432993012793e-07 0.5819084237686675 \
1.17043546144628e-07 0.586601202059797 1.170437918903539e-07 0.5912552023551558 1.170440184678743e-07 0.5955288021520931 1.170442496200641e-07 0.5998646534936181 \
1.170444559004441e-07 0.6037202012184053 1.170446840212041e-07 0.6079592993751251 1.170449064011853e-07 0.6120725203834017 1.17045133377667e-07 0.6162454422471376 \
1.170453484306168e-07 0.6201823359462864 1.170455778001903e-07 0.6243500782103125 1.170458468230649e-07 0.6292041961704016 1.170460698367118e-07 0.6331993632081415 \
1.170462820912892e-07 0.6369772451758789 1.170464934888789e-07 0.6407176358819484 1.17046693558109e-07 0.644236566349866 1.170469231519586e-07 0.6482486956559365 \
1.170471639888863e-07 0.6524328529570182 1.170473457382733e-07 0.6555667906748446 1.170475342865e-07 0.6588018260593631 1.170476873661394e-07 0.6614154033769962 \
1.170478593744213e-07 0.6643352515471471 1.170480095472396e-07 0.6668697017322168 1.170481460645294e-07 0.6691578850264722 1.170482956937163e-07 0.6716547631652277 \
1.170484234340851e-07 0.673777752640997 1.170485630202226e-07 0.6760856948620949 1.170486872589102e-07 0.6781310478824312 1.170488184087496e-07 0.6802827752320969 \
1.170489428500932e-07 0.6823179209931315 1.170490800809157e-07 0.6845542421253382 1.170492003290863e-07 0.6865048414796368 1.170493416605295e-07 0.6887891282595083 \
1.170494419916407e-07 0.6904033553735033 1.170495631093427e-07 0.6923460943304175 1.170496538868777e-07 0.6937948943079848 1.170497511453436e-07 0.6953408241330762 \
1.170498473532237e-07 0.6968660703265798 1.170499359670681e-07 0.6982647859968389 1.170500332550912e-07 0.6997938110311075 1.170501657237294e-07 0.7018622871835729 \
1.170503209139279e-07 0.7042674555997347 1.170504587918793e-07 0.7063866855441746 1.170506036461533e-07 0.7085960165693863 1.170507307079098e-07 0.7105202221428537 \
1.170508553934701e-07 0.7123960184768648 1.170509680988463e-07 0.7140814553427599 1.170510798891907e-07 0.7157437310299281 1.170511806678399e-07 0.7172341607972841 \
1.170513179462954e-07 0.7192525454101454 1.170514376303672e-07 0.7210013704967912 1.170515570598379e-07 0.7227365757678518 1.170516839430602e-07 0.7245692610776365 \
1.170518083607121e-07 0.7263556789600311 1.170519320935366e-07 0.728121726658988 1.170520586890634e-07 0.7299181396522603 1.170521890744641e-07 0.7317573312219798 \
1.170523118842844e-07 0.7334798522758219 1.170524473200596e-07 0.7353678990088863 1.170525486098379e-07 0.7367723836293941 1.170526562323338e-07 0.7382576460517265 \
1.170527457604157e-07 0.7394878879617913 1.170528603087849e-07 0.7410528648863303 1.170529483370413e-07 0.7422487366778059 1.170530554151068e-07 0.7436953530868765 \
1.170531854801004e-07 0.7454403311053276 1.170532967597954e-07 0.7469230742113165 1.170534013783548e-07 0.7483084058091373 1.170535254613402e-07 0.7499400420429273 \
1.170536737621685e-07 0.7518749696944975 1.170537951620328e-07 0.7534462209622173 1.170539096027802e-07 0.7549170836379747 1.170540499400977e-07 0.7567069362027918 \
1.170541917029811e-07 0.7584995177563068 1.170543095039188e-07 0.759977341175643 1.170544374807853e-07 0.761570846386187 1.170545791832092e-07 0.7633205808366864 \
1.170546966945227e-07 0.7647599110190483 1.170548422997917e-07 0.7665289162262866 1.170549639940994e-07 0.7679951561698679 1.170550827247088e-07 0.7694149786178283 \
1.170552050113037e-07 0.7708662727382939 1.170553320558197e-07 0.77236234268503 1.170554416997921e-07 0.7736439866494906 1.170555673867047e-07 0.7751025186690397 \
1.170556734018052e-07 0.776323977486031 1.170558089877718e-07 0.7778743028704433 1.170559339507686e-07 0.7792913979962601 1.17056059856921e-07 0.7807070123991936 \
1.17056175124167e-07 0.7819915514687489 1.170562814286401e-07 0.7831664991275713 1.17056419833432e-07 0.7846822315516878 1.170565691298821e-07 0.7862997378875561 \
1.170567146373276e-07 0.7878588534534761 1.170568340418389e-07 0.7891257303126159 1.170569691346634e-07 0.7905455128963393 1.170570903878263e-07 0.7918076974797237 \
1.170572333811048e-07 0.7932816011184505 1.170573775854105e-07 0.7947523458802197 1.170575031222391e-07 0.7960199014141693 1.170576221686118e-07 0.7972110037065316 \
1.170577341044954e-07 0.7983213107123885 1.170578389760474e-07 0.7993531099923881 1.170579342264591e-07 0.8002831901653534 1.170580705697047e-07 0.8016020813281191 \
1.170581873938354e-07 0.8027203407102198 1.170583067984452e-07 0.803852171037294 1.170584289052493e-07 0.8049980820693966 1.170585518602505e-07 0.8061401395390313 \
1.17058678828951e-07 0.8073073595000361 1.170588040685604e-07 0.8084467645495962 1.17058934640955e-07 0.8096220968518901 1.170590606314733e-07 0.8107441738369082 \
1.170591888173857e-07 0.8118738099374113 1.170592943471138e-07 0.8127947795787664 1.170593972188869e-07 0.8136847278655364 1.17059490214057e-07 0.8144826950388273 \
1.170596140106596e-07 0.8155354283166244 1.170597019789174e-07 0.8162769513478326 1.170598007099885e-07 0.8171027376706747 1.170599439751418e-07 0.8182889948057973 \
1.170600792538271e-07 0.8193962136425846 1.170601883684495e-07 0.8202800249700468 1.17060336451758e-07 0.8214657808291811 1.170604862226849e-07 0.8226492530953341 \
1.170606114572855e-07 0.8236267526687548 1.170607554487032e-07 0.8247372275730155 1.170608795047738e-07 0.8256825756473101 1.170610299680322e-07 0.8268152483647575 \
1.17061165678884e-07 0.8278240064655301 1.170612906973921e-07 0.828742521381556 1.170614084523219e-07 0.8295983347934622 1.170615544291349e-07 0.8306466023667578 \
1.170617209384522e-07 0.8318251482734692 1.170618518610282e-07 0.8327390940956469 1.170620252884658e-07 0.8339327615268647 1.170621934353481e-07 0.8350717495747054 \
1.170623632702773e-07 0.8362042975620877 1.170625441950479e-07 0.8373912937861997 1.170626872933069e-07 0.8383160748488641 1.170628013791983e-07 0.8390446117604563 \
1.170629315531841e-07 0.8398665237782376 1.170630333942664e-07 0.8405024977857931 1.170631502136154e-07 0.8412243379523001 1.170632870780449e-07 0.8420597162999857 \
1.170634848766686e-07 0.8432475311273343 1.170636764807398e-07 0.8443767279905872 1.170638859212216e-07 0.8455874169714939 1.170640678468519e-07 0.8466193100105236 \
1.170642649799575e-07 0.8477171434207121 1.170644383298479e-07 0.8486653666163242 1.170646213292318e-07 0.8496493024239481 1.17064792495495e-07 0.8505537352954988 \
1.170649671272818e-07 0.8514606693963016 1.170651423896692e-07 0.8523550102558151 1.170653185417845e-07 0.8532381479010797 1.170655088128238e-07 0.8541746551565574 \
1.170656994147745e-07 0.85509499218684 1.170659000624008e-07 0.8560449689899254 1.170660926729659e-07 0.8569390259424264 1.170663033306522e-07 0.8578972157030333 \
1.170665314560509e-07 0.8589122247267402 1.170667972133685e-07 0.8600655879592763 1.17067095837813e-07 0.8613244245924475 1.170673721693318e-07 0.862454900702886 \
1.170676564023905e-07 0.8635842083919951 1.17067930614306e-07 0.8646423892283146 1.170682028423722e-07 0.8656634505877856 1.170684730511913e-07 0.8666487272755322 \
1.170687302040671e-07 0.8675609437488442 1.170690027863351e-07 0.868501515423508 1.170692787713349e-07 0.8694269133137555 1.170695488729115e-07 0.8703069289141475 \
1.170698487348628e-07 0.8712546000783432 1.170702197689933e-07 0.8723856543073821 1.170705147067536e-07 0.8732530157608677 1.170707689975357e-07 0.8739790309043101 \
1.170710672549513e-07 0.8748056771600844 1.170713408634847e-07 0.8755409825400007 1.170715769915496e-07 0.8761583495732972 1.170718173369303e-07 0.876770807053994 \
1.170720396702121e-07 0.8773233906735478 1.170722336759598e-07 0.8777948466981503 1.17072563398506e-07 0.8785737911727464 1.170727185719444e-07 0.8789308835864816 \
1.17073036347473e-07 0.8796437246174529 1.170732152091701e-07 0.8800342982281311 1.170735576710472e-07 0.8807611334253193 1.170737417995192e-07 0.8811407335605206 \
1.170742166778565e-07 0.8820849466541889 1.170743840740528e-07 0.8824061830950772 1.170748499154564e-07 0.8832696475595492 1.170750307376651e-07 0.8835931319180218 \
1.170755247759143e-07 0.8844450822729043 1.170756661243274e-07 0.8846804878101884 1.170762724573853e-07 0.8856498028150036 1.170764245267248e-07 0.8858829444029697 \
1.170770712152002e-07 0.8868329272509302 1.170771995097231e-07 0.8870138524519416 1.170778476269279e-07 0.8878919388991984 1.170779774257916e-07 0.8880607713689423 \
1.17078755627481e-07 0.8890227771434612 1.170788706844142e-07 0.8891574578072456 1.170797263428482e-07 0.8901003239091128 1.170798717076157e-07 0.8902505899439886 \
1.1708085746403e-07 0.8911948786459364 1.170810785690402e-07 0.8913892999646706 1.170822236960192e-07 0.8923206810037944 1.170823549126186e-07 0.892422953350996 \
1.170836961242674e-07 0.8934189515818408 1.170838475232108e-07 0.8935240845833778 1.170853289614591e-07 0.8944568913393511 1.170855678408922e-07 0.8945912088657246 \
1.170873371610739e-07 0.8954685138428928 1.170877263108405e-07 0.895637400736999 1.170901199766276e-07 0.896526474291006 1.170905956894499e-07 0.8966764365754722 \
1.17094011699057e-07 0.8975478548673914 1.170946588490717e-07 0.8976786076740833 1.171021370136781e-07 0.8986646932675814 1.171028095907965e-07 0.8987192862546014 \
1.171952539953667e-07 0.8997188196574962 1.171959172280509e-07 0.8997241906476866 1.17385126389945e-07 0.900686595210158 1.173852884627892e-07 0.9007292695325627 \
1.173879339836764e-07 0.8998161167154269 1.173881025331539e-07 0.8996881690130656 1.173893792855451e-07 0.8987393243250013 1.173895814518808e-07 0.8986030018074492 \
1.173911895612674e-07 0.8976721249252815 1.173913816671926e-07 0.8975774045828077 1.174064950498388e-07 0.8985726115129884 1.174066831087563e-07 0.8986004060702872 \
1.174179880377677e-07 0.8995874924221801 1.174183614235164e-07 0.8996034751727418 1.17907373786698e-07 0.9005892719715856 1.179074845548976e-07 0.9006868984798269 \
1.179082372272589e-07 0.9015617873136611 1.179083390219455e-07 0.9017086238768567 1.179088744204902e-07 0.9025814930725723 1.179089769296628e-07 0.9027670217776843 \
1.179093691484817e-07 0.9035254014384071 1.17909509991429e-07 0.9038129158713877 1.179099510288813e-07 0.9047472953155866 1.179101365144842e-07 0.9051402477015744 \
1.179106528276013e-07 0.9061269394579334 1.17910737502694e-07 0.9062564181617988 1.179119721747438e-07 0.9053011091537977 1.179121293881559e-07 0.9045688862145235 \
1.179123212048176e-07 0.9034162411061901 1.179124880453484e-07 0.9021712267446264 1.179126350037463e-07 0.9008824031243315 1.179127491199425e-07 0.8997575350477262 \
1.179128789920323e-07 0.8983446880789033 1.179129901095502e-07 0.8970273815442567 1.179130829140294e-07 0.8958483937359277 1.17913171236719e-07 0.8946639786015808 \
1.179132744174779e-07 0.8932058048613533 1.179133666254135e-07 0.8918333298588224 1.179134541956103e-07 0.8904732289418564 1.179135681890766e-07 0.8886245408236838 \
1.179137299935004e-07 0.8858564722885236 1.179139149921176e-07 0.8825005184224666 1.179141071517853e-07 0.8788219124347386 1.179143085991386e-07 0.874780227084481 \
1.179145150097281e-07 0.8704697801294994 1.179147001816807e-07 0.8664790122147591 1.179148846894051e-07 0.862405115500708 1.179150578412964e-07 0.8585071391690239 \
1.179152428873213e-07 0.8542751393552932 1.179154202615245e-07 0.8501657390392787 1.179155970079552e-07 0.8460284987362284 1.179157631666058e-07 0.8421077870518131 \
1.179159252110445e-07 0.8382599993991456 1.179160917839251e-07 0.8342839555277276 1.179162504376618e-07 0.8304816347052207 1.179164413136869e-07 0.8258903812682129 \
1.179166162972586e-07 0.8216694867670907 1.179167862433926e-07 0.8175615830390965 1.179169514195676e-07 0.8135626411663678 1.179171246116744e-07 0.8093650119631921 \
1.179172956738769e-07 0.8052155696745213 1.179174637749139e-07 0.801136095357175 1.179176541098628e-07 0.7965156511928794 1.179178376918066e-07 0.7920591698039 \
1.179180456827317e-07 0.7870113041480956 1.179182682592422e-07 0.7816114142545842 1.17918457674258e-07 0.7770174196885687 1.17918650984654e-07 0.7723312127316435 \
1.179187944302406e-07 0.7688556734481145 1.179189438535907e-07 0.7652374066097742 1.179190630060629e-07 0.7623536300085233 1.179191757225445e-07 0.7596269484184472 \
1.179192849974512e-07 0.7569846861296079 1.179194210272094e-07 0.753697254849378 1.179195338230239e-07 0.750972995067179 1.179196560209801e-07 0.7480232093637929 \
1.179197676057526e-07 0.7453311011793381 1.179198923122156e-07 0.7423241425761796 1.179200466941669e-07 0.7386034578119585 1.179202134782327e-07 0.7345862494782525 \
1.179204306429213e-07 0.7293605768817599 1.179206252035101e-07 0.7246835946359503 1.179207855343955e-07 0.7208333202545074 1.179209609599985e-07 0.7166251500492028 \
1.179211507235729e-07 0.7120779400724765 1.179213394518974e-07 0.7075610435995559 1.179215212732644e-07 0.7032145396962334 1.179217058706759e-07 0.6988062725207448 \
1.179218429538112e-07 0.6955348514212173 1.179219962420495e-07 0.6918805091472418 1.179221916137951e-07 0.6872279990818534 1.179223477705467e-07 0.6835136309588888 \
1.179225057227664e-07 0.6797605476340507 1.179227039740297e-07 0.6750570282453686 1.179228973199279e-07 0.6704763548785364 1.17923133825274e-07 0.6648822204491218 \
1.179233200303777e-07 0.6604858901039825 1.179235576526979e-07 0.6548824851665868 1.179237444514522e-07 0.6504854738275335 1.179239250092116e-07 0.6462424706993735 \
1.179240880851561e-07 0.6424159959781919 1.179242326967206e-07 0.6390271817202816 1.179243732990706e-07 0.6357379642635244 1.179245001086569e-07 0.632774906490579 \
1.179246322451931e-07 0.6296924762754078 1.179247584891446e-07 0.6267508340255646 1.179248897527744e-07 0.6236963630311418 1.179250188505141e-07 0.6206978048938425 \
1.179251582761788e-07 0.6174624210713571 1.179253066461711e-07 0.6140261568477932 1.179255012030603e-07 0.6095278574984737 1.179256446489368e-07 0.6062198040692683 \
1.179258791091827e-07 0.6008245134060309 1.179260510074948e-07 0.5968818013610552 1.179262639280334e-07 0.5920102583789468 1.179264363946513e-07 0.5880775912131976 \
1.179265667191976e-07 0.5851108450968721 1.179266982755174e-07 0.5821241897920357 1.179268085055992e-07 0.5796262478458715 1.179269041598466e-07 0.5774603558442819 \
1.179270033938061e-07 0.5752182923213994 1.179270863119075e-07 0.5733484809858778 1.179271652275343e-07 0.5715706040143225 1.179272281563093e-07 0.5701535626562365 \
1.179272936647862e-07 0.5686800671140783 1.179273741508387e-07 0.5668736364148982 1.179274240168465e-07 0.5657560592102344 1.179274732056154e-07 0.5646541775062763 \
1.179275346754008e-07 0.5632780399140616 1.179275825969294e-07 0.5622058085646952 1.179276334416479e-07 0.5610687758404553 1.179276925419032e-07 0.5597501790023616 \
1.1792775115623e-07 0.5584442118409422 1.179278267823233e-07 0.5567607189607793 1.17927897341035e-07 0.5551915720267918 1.17927986471042e-07 0.5532116467156011 \
1.1792807569462e-07 0.5512351177508077 1.179281609982305e-07 0.5493490637975145 1.17928248625197e-07 0.5474138635528197 1.179283456271202e-07 0.545274424894262 \
1.179284499728913e-07 0.5429792414815097 1.179285662643155e-07 0.5404269323775457 1.17928672601932e-07 0.5380963700835184 1.179287843108152e-07 0.5356536306660374 \
1.179288966052949e-07 0.5332047801427824 1.179290238028543e-07 0.5304364255197962 1.17929146572528e-07 0.5277698476303582 1.179292887969246e-07 0.5246912237717902 \
1.179294251600566e-07 0.5217463069543907 1.179295773811234e-07 0.5184691491721333 1.179297370173294e-07 0.5150420887864461 1.179299129925215e-07 0.5112761258030903 \
1.179301015011087e-07 0.5072591542828934 1.179303085676898e-07 0.5028616940969075 1.179305335096624e-07 0.4981043078903621 1.179307849056189e-07 0.4928144328841237 \
1.179310213311851e-07 0.4878598554762091 1.179313184949192e-07 0.4816683149127979 1.179316091722113e-07 0.4756487143466775 1.17931917027196e-07 0.469313240945046 \
1.179322308529534e-07 0.4628991126846517 1.179325599943131e-07 0.4562163541974347 1.179328933724197e-07 0.4494927613461197 1.179332249990283e-07 0.4428490490857003 \
1.179335465484253e-07 0.4364504708187015 1.179338742242378e-07 0.4299742838549845 1.179342218438604e-07 0.4231546934710667 1.179345550651743e-07 0.4166645133789623 \
1.179349009744022e-07 0.4099771621835854 1.179353463882216e-07 0.4014400148089548 1.179357041780923e-07 0.3946500490499754 1.179360183349117e-07 0.3887397205534429 \
1.179364027453916e-07 0.3815756289527631 1.179367327200365e-07 0.3754830843203271 1.179370179301253e-07 0.3702633801070484 1.179373262203822e-07 0.3646649204592909 \
1.179376060174434e-07 0.3596257204303125 1.179378320117929e-07 0.3555880084110294 1.179380468497475e-07 0.3517755993421203 1.179382452848198e-07 0.3482769933469286 \
1.179384492243371e-07 0.3447071465415313 1.179386597603963e-07 0.3410461989361561 1.179389167345215e-07 0.3366091000429626 1.179391579951288e-07 0.3324763702393667 \
1.179393895688451e-07 0.3285420159269506 1.179396042222912e-07 0.3249208057821749 1.17939825046275e-07 0.3212218866489027 1.179400262928671e-07 0.3178749657716667 \
1.179402293821204e-07 0.3145250552959265 1.179404272269915e-07 0.3112865758726304 1.179406140799367e-07 0.3082497660855442 1.179408080166626e-07 0.3051208532403978 \
1.179410117613171e-07 0.30185834615803 1.179411904885829e-07 0.2990186060348319 1.179414281343783e-07 0.2952727068736475 1.179416278966111e-07 0.2921508861588616 \
1.179418295254275e-07 0.2890253490052915 1.179420549918856e-07 0.285561995332 1.17942221086285e-07 0.2830312764183137 1.179423997053871e-07 0.2803277612349699 \
1.179425814095885e-07 0.2775983111934518 1.179427700433049e-07 0.2747882307029562 1.17942947466508e-07 0.2721695222189568 1.179431246596456e-07 0.2695724116247911 \
1.179432847315606e-07 0.2672552081803913 1.179434051322386e-07 0.2655193337608355 1.179435529583031e-07 0.2633957862580221 1.179436815880755e-07 0.2615692882062232 \
1.179437837936585e-07 0.2601227034409412 1.179439020289393e-07 0.2584516051170885 1.179440224822997e-07 0.2567534139348401 1.179441461906177e-07 0.2550183706610066 \
1.179442644426428e-07 0.2533694204037282 1.179443922957733e-07 0.2515887492000971 1.179445125816039e-07 0.249915736161692 1.179446652612099e-07 0.2477917697339537 \
1.179448001739884e-07 0.2459264316518071 1.1794492881341e-07 0.2441493177932957 1.17945086528788e-07 0.2419705448111171 1.179452132100908e-07 0.2402201997919771 \
1.179453485361585e-07 0.2383592392624043 1.179454874487268e-07 0.2364550510890953 1.179456052210313e-07 0.2348405558720491 1.179457644918496e-07 0.2326580599570062 \
1.179459010137043e-07 0.2307878375452989 1.179460422456504e-07 0.2288626996658652 1.179461480586929e-07 0.2274220928889542 1.179462784016402e-07 0.2256484734765637 \
1.17946378112453e-07 0.2242944442559471 1.179464809338881e-07 0.2228991027388591 1.179465543495424e-07 0.2219046249368765 1.179466341811041e-07 0.2208265149641777 \
1.179467042283352e-07 0.2198809561195558 1.179467546314264e-07 0.2192009305305119 1.179468068832254e-07 0.2184966408607167 1.179468861207429e-07 0.2174292050927151 \
1.179469279646958e-07 0.2168658036437602 1.179469673046481e-07 0.216336351877609 1.179470103400575e-07 0.2157575332679269 1.179470545074838e-07 0.2151638767852215 \
1.179471282732236e-07 0.2141731338947761 1.179471637852207e-07 0.2136967174286463 1.179472115000211e-07 0.2130606706933813 1.17947272229561e-07 0.2122518321687151 \
1.179473404867867e-07 0.2113438957752176 1.179474130085659e-07 0.2103801801047663 1.179474856831929e-07 0.2094152724966429 1.179475939991808e-07 0.2079788886429202 \
1.179476916703231e-07 0.20668564243436 1.179478032218192e-07 0.2052110974836689 1.179479017572532e-07 0.2039136008387587 1.179480052503929e-07 0.2025572972554956 \
1.179481011521277e-07 0.2013021587886929 1.17948203780057e-07 0.1999606878451601 1.179483066031699e-07 0.1986207062101238 1.179484167227972e-07 0.1971897063011611 \
1.179485254183531e-07 0.1957815523781236 1.179486450955818e-07 0.1942360962608612 1.179487553732606e-07 0.192818053470401 1.179488634364806e-07 0.1914343471929882 \
1.179489885351485e-07 0.1898375077741012 1.179490785049817e-07 0.1886931806549971 1.179491571919347e-07 0.1876950225942949 1.17949234476806e-07 0.1867173468865102 \
1.179493209853825e-07 0.1856271834369256 1.179494199345929e-07 0.1843848109964498 1.179494904434582e-07 0.1835017733581451 1.179495618945114e-07 0.1826096997732476 \
1.179496670398458e-07 0.1813018727451555 1.179497462794755e-07 0.1803200401832796 1.179498273633695e-07 0.1793174195483187 1.179499208553101e-07 0.1781663090788374 \
1.179500216312847e-07 0.1769308188703378 1.179501713433884e-07 0.175105380089017 1.179502871327037e-07 0.1737009932372819 1.179504381380806e-07 0.1718807311127691 \
1.179505492465001e-07 0.1705485445502526 1.179506913729584e-07 0.168854666407182 1.179508090313791e-07 0.167460358327668 1.179509139359749e-07 0.1662230887079887 \
1.179510089985733e-07 0.1651069099307241 1.179511024298279e-07 0.1640147999883682 1.179512034764903e-07 0.1628388413495604 1.179512998233979e-07 0.1617223204899406 \
1.179513969756437e-07 0.1606011553546776 1.179514800242163e-07 0.1596469772300165 1.179515900618698e-07 0.1583897228513109 1.179516723644316e-07 0.1574542248873526 \
1.179517773641412e-07 0.156267858580057 1.179518550602102e-07 0.1553950893374849 1.179519378796887e-07 0.1544690878994293 1.179520195415937e-07 0.1535604570452941 \
1.179521088908844e-07 0.152571060794856 1.1795218460332e-07 0.1517364980793458 1.179522671659343e-07 0.1508307726525361 1.179523437473671e-07 0.1499942554682341 \
1.179524120352535e-07 0.1492531084507001 1.179525054022655e-07 0.1482449401818621 1.179525745556768e-07 0.1475015570698688 1.179526501800083e-07 0.1466917482325688 \
1.179527117291286e-07 0.1460354497178591 1.179527789778923e-07 0.1453208357145237 1.179528500398917e-07 0.1445684785944268 1.179529255373203e-07 0.143772322008306 \
1.179529844488598e-07 0.1431546944759192 1.179530611224699e-07 0.1423563022825049 1.179531414432115e-07 0.1415233898163201 1.179532145945195e-07 0.1407682091691316 \
1.179533087509408e-07 0.139800669784813 1.179533803551248e-07 0.1390684367429364 1.179534538159005e-07 0.1383201464810226 1.179535373276515e-07 0.1374732033664194 \
1.179536268067954e-07 0.1365744208092838 1.179536918717003e-07 0.1359252211013016 1.179538039977229e-07 0.1348115665849295 1.179538691838635e-07 0.1341670699454539 \
1.179539392221084e-07 0.1334770515823289 1.179539995271633e-07 0.1328849371768329 1.179540545379868e-07 0.1323464455745446 1.17954142654965e-07 0.1314871014507438 \
1.179541834412595e-07 0.131090685705856 1.179542871440105e-07 0.1300923774523848 1.179543304565801e-07 0.1296773144713907 1.17954391675178e-07 0.1290920262082728 \
1.179544365118974e-07 0.1286643765206081 1.179545241079233e-07 0.127831527987147 1.179545656618794e-07 0.1274377589706847 1.179546255233895e-07 0.1268718307679372 \
1.179546973671149e-07 0.1261946708524367 1.179547535798413e-07 0.1256664967939027 1.179548160673402e-07 0.125081039250218 1.179548902953232e-07 0.1243877959456236 \
1.179549649763284e-07 0.1236954937854857 1.179550521595408e-07 0.1228905551604285 1.179551205580918e-07 0.1222610287411191 1.17955201128775e-07 0.1215216597888775 \
1.179552824242559e-07 0.120778012781285 1.179553493407808e-07 0.1201677797529914 1.179554321577256e-07 0.1194156054679852 1.179554913464481e-07 0.1188799972037829 \
1.179555572674477e-07 0.1182853617472536 1.179556371414917e-07 0.1175675408705869 1.179557136372899e-07 0.1168828806096336 1.179557950994005e-07 0.1161574242846086 \
1.179558935702815e-07 0.1152852106851665 1.179559686806303e-07 0.114622623867465 1.179560716684202e-07 0.1137180076826871 1.179561458523715e-07 0.1130691786503039 \
1.179562434718251e-07 0.1122190343868764 1.179563392827804e-07 0.1113890351962442 1.179564351312053e-07 0.110562946039519 1.179565160694118e-07 0.1098685209805978 \
1.179566044526832e-07 0.1091134439098378 1.179567030526616e-07 0.108274944429282 1.179567758368656e-07 0.1076586405352824 1.17956865109775e-07 0.1069058608836731 \
1.179569270917884e-07 0.1063852406583179 1.179569896849557e-07 0.1058613310701875 1.179570749071042e-07 0.105150777260444 1.179571803694782e-07 0.1042758147594986 \
1.179572601999606e-07 0.1036167065755082 1.179573409142144e-07 0.1029530974056021 1.179574235279495e-07 0.1022768941101355 1.179574939725617e-07 0.1017026162492672 \
1.179575972319282e-07 0.1008648142128753 1.179576700720535e-07 0.1002767039768694 1.179577557123351e-07 0.09958839426015198 1.179578745140727e-07 0.09863954321822334 \
1.179579421518979e-07 0.09810250133474645 1.179580119020204e-07 0.09755100310752296 1.17958089237e-07 0.09694230106952094 1.179581816572539e-07 0.09621870517595056 \
1.17958253354782e-07 0.09566033062548993 1.179583391719417e-07 0.09499542738017568 1.17958441597192e-07 0.09420660575030523 1.17958534892083e-07 0.09349264652734962 \
1.179586312085565e-07 0.09276005482712441 1.179587081108176e-07 0.09217843893134048 1.179588015908053e-07 0.09147541043939374 1.179588808332317e-07 0.09088281005358793 \
1.17958995455426e-07 0.0900310686188453 1.179591250636858e-07 0.08907580221142102 1.179592583208766e-07 0.08810234090122065 1.179594023507657e-07 0.08705990691030199 \
1.179595595189096e-07 0.08593388720602639 1.179597092953871e-07 0.08487214151476249 1.179598717629786e-07 0.08373303262435308 1.179600149429843e-07 0.08273971668837025 \
1.17960167622107e-07 0.0816913199659166 1.179603018918778e-07 0.08077856892457436 1.179604436441555e-07 0.07982444400446118 1.179605786438163e-07 0.07892500874648442 \
1.179607206012136e-07 0.07798882638923543 1.179608674486441e-07 0.07703088995320664 1.17961019894053e-07 0.07604750978240994 1.179611851127758e-07 0.07499422991502351 \
1.179613492506213e-07 0.07396067809208305 1.17961526112024e-07 0.07286119333145537 1.179617164535802e-07 0.07169407515132428 1.179619274100931e-07 0.07042030845332216 \
1.179621478192316e-07 0.0691121699798517 1.17962383344393e-07 0.06773900533435212 1.179626437937674e-07 0.0662496528900723 1.179629394591772e-07 0.06459579389282195 \
1.179632445814628e-07 0.06292902455725519 1.179636095760241e-07 0.06098725515092194 1.179640044568393e-07 0.05894944116461652 1.179644108474933e-07 0.05692211719668253 \
1.179648265730353e-07 0.05491854459141238 1.179651893793582e-07 0.0532251207245777 1.179655339806477e-07 0.05166301626031383 1.179658491605098e-07 0.05027284652491828 \
1.179661446898748e-07 0.04900240867073854 1.179664426703825e-07 0.04775344010203557 1.179667184691725e-07 0.04662857640242725 1.179669972437684e-07 0.04551884372531381 \
1.179672611786382e-07 0.04449205559535935 1.179675372013766e-07 0.04344260531795661 1.179678161576298e-07 0.04240676967887352 1.179681298509633e-07 0.04127097799875453 \
1.179683658512502e-07 0.04043636567030678 1.179686216459875e-07 0.03955075129286261 1.17968881769487e-07 0.03867033103466553 1.179691519047594e-07 0.03778142289416799 \
1.179694311247467e-07 0.03688501536902895 1.179697129633963e-07 0.03600226561751176 1.17969989839066e-07 0.03515600409566183 1.179702689326649e-07 0.03432349610146775 \
1.179705018102725e-07 0.03364444121149882 1.179707856469894e-07 0.03283527291840588 1.179710257519236e-07 0.03216626441466421 1.179712655507464e-07 0.0315119836023277 \
1.179715048279204e-07 0.03087436846876356 1.179717400849421e-07 0.03026290129608995 1.17971971011964e-07 0.02967475842909434 1.17972186001007e-07 0.02913788335257221 \
1.179725881554596e-07 0.02816043724496065 1.179727868782784e-07 0.02768988489927659 1.179731605612946e-07 0.0268265706552881 1.179733473596173e-07 0.02640514011949098 \
1.179736949193039e-07 0.02563810810034544 1.179738168487671e-07 0.0253740445387235 1.179741993202075e-07 0.02456430406701914 1.179743700282368e-07 0.02421180751242828 \
1.179748271256211e-07 0.02328894863848502 1.179750127580069e-07 0.0229225623309489 1.179753762152598e-07 0.02221803970155307 1.179755965826125e-07 0.02179832126591805 \
1.179760543089696e-07 0.02093867417890744 1.179761897285988e-07 0.02068687731869814 1.179767196240474e-07 0.01972418011126781 1.17976838945017e-07 0.01951377505543128 \
1.179774047306961e-07 0.01856069823426573 1.17977569110437e-07 0.0182962226476828 1.179781876557339e-07 0.01735107502432094 1.179783577099333e-07 0.01710418363667701 \
1.179788898421661e-07 0.01636278834442301 1.179790869261418e-07 0.01610013864443424 1.179798100452149e-07 0.01517806887136661 1.179799746753809e-07 0.01497647803580381 \
1.179807238007678e-07 0.01409711804523418 1.179808571001203e-07 0.01394643716836554 1.179817173537587e-07 0.01301449210748497 1.179818524573794e-07 0.01287422877142914 \
1.179827950348197e-07 0.01193816285908547 1.179829586305738e-07 0.01178202925388569 1.179839599872008e-07 0.0108653384673985 1.179840975299883e-07 0.01074500730514941 \
1.179853196363713e-07 0.009765086624518643 1.179854265890839e-07 0.00968516078425012 1.179868307805774e-07 0.008707372520026449 1.179869356112841e-07 0.008639312158696611 \
1.179884704482461e-07 0.00767719340797631 1.179885657315476e-07 0.007617466071856052 1.179901745288685e-07 0.006680264535635283 1.179903086056077e-07 0.006609506832171614 \
1.179924056185594e-07 0.005610918814474722 1.179926361631908e-07 0.005510783990371394 1.179949591584347e-07 0.004586584533412417 1.179954404886379e-07 0.004413562233393853 \
1.179982780502688e-07 0.003511943147855551 1.179988229699549e-07 0.003360532104877318 1.180029471783516e-07 0.002408309874554541 1.180034909020111e-07 0.002305347543005144 \
1.180093621912368e-07 0.001333291345955189 1.180096050564212e-07 0.001286469439319215 1.180239329487719e-07 0.0002880570268237783 1.180240775074142e-07 0.0002853642807229123 \
1.206613564285128e-07 -0.0006859155495331031 1.206614959836499e-07 -0.000901903561740745 1.206620050775826e-07 -0.001859438188174024 1.206620945650851e-07 -0.002052812934985279 \
1.206624579599451e-07 -0.00291126965001638 1.206625489820155e-07 -0.003143482006111167 1.206629144200523e-07 -0.004127275145644371 1.206630246806195e-07 -0.004436819103926468 \
1.206633367277739e-07 -0.005309594399865315 1.206634394426211e-07 -0.005584800160857357 1.206638032904768e-07 -0.006384516484886619 1.206639680812086e-07 -0.006586298968823262 \
1.206645476774082e-07 -0.005791490933239759 1.206647227875511e-07 -0.004914057272375438 1.206648394794853e-07 -0.004132845175365214 1.206649660640906e-07 -0.003100877896798674 \
1.206650678730126e-07 -0.002132773363901063 1.206651883617228e-07 -0.0008283127610571584 1.206652788087988e-07 0.0002599396317828252 1.206653766989305e-07 0.001541559978017447 \
1.206654757632395e-07 0.002943971508909197 1.206656465705158e-07 0.005594911825788154 1.206658683385388e-07 0.00944046646559993 1.206660642423845e-07 0.01317281463966807 \
1.206662231237664e-07 0.01639870563256729 1.206663875522633e-07 0.01989779506365397 1.206665419182936e-07 0.02331070396473752 1.20666700690818e-07 0.02693200463312963 \
1.20666847428777e-07 0.03036422445567413 1.206669960527481e-07 0.0339113704936035 1.20667151667245e-07 0.03768995713197771 1.206673089092589e-07 0.04156499463828727 \
1.206674738020577e-07 0.04567927910670353 1.206676472215784e-07 0.05005184210758699 1.20667825915293e-07 0.05459761989277153 1.206680145311307e-07 0.05943075613080645 \
1.206682154312736e-07 0.06460909294799391 1.206684348880646e-07 0.0702927970720964 1.206686644343515e-07 0.07626037976612585 1.20668910133291e-07 0.08266408948881369 \
1.206691786982297e-07 0.08967663153997742 1.206694700401445e-07 0.09728936802005522 1.206697917081718e-07 0.1056939239977524 1.20670152022263e-07 0.1150987971742611 \
1.206705430017012e-07 0.1252892839303718 1.206709864165172e-07 0.1368209045172546 1.206715027296046e-07 0.1502062239570841 1.206721089348208e-07 0.16586000516691 \
1.206727801918478e-07 0.1831102247110778 1.206735596915048e-07 0.20301830483439 1.206744320013886e-07 0.2251413938832897 1.206752623367137e-07 0.2460320778586349 \
1.206759936670634e-07 0.264292249712138 1.206766416128433e-07 0.280346965484095 1.206772249233171e-07 0.29469740877147 1.20677760655584e-07 0.3077798509628869 \
1.20678263914169e-07 0.3199778888071559 1.2067874911767e-07 0.3316516836183861 1.206792280403756e-07 0.3430829066939081 1.20679674471008e-07 0.3536501814456421 \
1.206801488007181e-07 0.3647819492304352 1.206805979917124e-07 0.3752331958288908 1.206810884639696e-07 0.3865396207984229 1.206816170367226e-07 0.3985997842463301 \
1.206819881810625e-07 0.4069920784971888 1.206825159354181e-07 0.4188173133762567 1.206829782921778e-07 0.4290642331729484 1.206834506243179e-07 0.4394285229343968 \
1.206839324090407e-07 0.4498981261869666 1.206839654481592e-07 0.4506126593745911 1.206840032071518e-07 0.45142837879914 1.20684078725137e-07 0.4530572051633331 \
1.206842297611073e-07 0.4563088938659436 1.206844372803726e-07 0.460764549126051 1.206846253191843e-07 0.4647825567212808 1.206848443283984e-07 0.469441659996985 \
1.206850871594094e-07 0.4745824626509371 1.206853869350375e-07 0.4808894567257585 1.206856247281872e-07 0.4858624696070272 1.206858879495879e-07 0.4913374535260851 \
1.206861488471327e-07 0.4967277906005185 1.206863784012197e-07 0.5014431429135263 1.206866014614136e-07 0.506003872007333 1.206868030374043e-07 0.5100983586086808 \
1.206869518674631e-07 0.51310967141356 1.206871961785157e-07 0.5180317772556589 1.206873287837491e-07 0.5206893064287169 1.206874681403308e-07 0.5234717264876519 \
1.206876791057242e-07 0.5276623644271943 1.206878539796058e-07 0.5311266030493931 1.206881220278524e-07 0.5364094032095129 1.206883170535098e-07 0.5402319029111832 \
1.206884966150174e-07 0.5437361368949839 1.206887475711459e-07 0.5486228351952749 1.20689024979257e-07 0.5540035987981641 1.20689308928559e-07 0.5594901708581531 \
1.206895645658505e-07 0.5644152233389156 1.206898555480696e-07 0.570006772487656 1.20690115853754e-07 0.5749917787111524 1.206903842978737e-07 0.5801232573974072 \
1.206906270630043e-07 0.5847450403362237 1.206908835942051e-07 0.5896146675871002 1.206911097576483e-07 0.59388771440121 1.206913470991427e-07 0.5983512154742827 \
1.206915564878602e-07 0.6022720321566808 1.206917702606284e-07 0.6062574570422776 1.206920237134688e-07 0.6109557890491497 1.206922265678164e-07 0.6146943332140289 \
1.206924193723378e-07 0.6182333111593361 1.206926096773651e-07 0.6217090173923294 1.206928003358541e-07 0.6251694921350958 1.206930029137797e-07 0.6288260100903066 \
1.206932656625422e-07 0.6335359534764116 1.206934946302321e-07 0.6376100987349322 1.206937145778672e-07 0.6414991146358265 1.206939402625401e-07 0.6454625140719233 \
1.206941491499662e-07 0.6491091855837361 1.206943708035853e-07 0.652957810138281 1.206945556930106e-07 0.6561429680377227 1.206947457075645e-07 0.6594017273991298 \
1.206948958626861e-07 0.6619630641908443 1.206950707405929e-07 0.6649292185271485 1.206952164613095e-07 0.6673855496832628 1.206953524938417e-07 0.6696641287411549 \
1.206955008561211e-07 0.672138295335571 1.206956303038336e-07 0.6742883907026684 1.206957641695307e-07 0.6764996355878535 1.206958925139303e-07 0.6786115243545502 \
1.206960179020585e-07 0.6806677490053815 1.20696147367755e-07 0.6827843190971332 1.206962783489702e-07 0.6849171426143115 1.206964267220724e-07 0.6873221141612875 \
1.206965347848267e-07 0.6890667486235877 1.206966633164996e-07 0.6911333958680312 1.206967987562836e-07 0.6933004139195943 1.206969236906072e-07 0.6952876996714908 \
1.206970494478751e-07 0.6972799977491608 1.206971559637663e-07 0.6989584331773744 1.20697273081655e-07 0.7007929859467624 1.206973916214008e-07 0.7026383448210159 \
1.206975149247975e-07 0.704545102273978 1.206976180976957e-07 0.7061304255463237 1.206977690688591e-07 0.7084341141567283 1.206978853230653e-07 0.7101955266062138 \
1.206980158834539e-07 0.7121605601685687 1.206981344459821e-07 0.7139335830373704 1.206982405198518e-07 0.7155108922888329 1.206983405447916e-07 0.716990346352101 \
1.206984778700066e-07 0.719009255813789 1.206985965313623e-07 0.7207429633399333 1.20698718230586e-07 0.7225107522614664 1.206988434131515e-07 0.7243181860083944 \
1.206989654329653e-07 0.7260693242762759 1.206990934647187e-07 0.7278954552757622 1.20699217946458e-07 0.7296603419865877 1.206993462457807e-07 0.7314685590147565 \
1.206994733395841e-07 0.7332489547570846 1.206995993644231e-07 0.7350034830462163 1.2069970210311e-07 0.7364262918236342 1.206998167758557e-07 0.7380063527755659 \
1.206998981819179e-07 0.7391232259175492 1.207000173814378e-07 0.7407496908814458 1.207001100237781e-07 0.7420059782745783 1.207002481828348e-07 0.7438668850244906 \
1.207003792383344e-07 0.7456179978167152 1.207005093705019e-07 0.7473439783685625 1.207006143445769e-07 0.7487266533969134 1.207007534844189e-07 0.7505456565005918 \
1.207009074287187e-07 0.7525407731682957 1.207010293729987e-07 0.7541080835708853 1.207011769193594e-07 0.7559892974429111 1.20701298924537e-07 0.7575320275232224 \
1.207014476244666e-07 0.7593968175435225 1.207015816710922e-07 0.7610632318338031 1.207017039243472e-07 0.7625711443351471 1.207018167902567e-07 0.763953046884334 \
1.207019596412247e-07 0.7656882893306027 1.207020863641194e-07 0.7672149413549471 1.207022021689945e-07 0.7685995877768005 1.207023319108228e-07 0.7701390587657672 \
1.207024476492106e-07 0.7715019052061673 1.207025706016372e-07 0.7729391548276606 1.20702688317297e-07 0.7743051053122872 1.207027942872733e-07 0.7755262985206828 \
1.207029106984675e-07 0.7768586864857919 1.207030173164004e-07 0.7780703956921795 1.207031295151206e-07 0.7793369495935717 1.207032161836897e-07 0.7803089322889447 \
1.207033195691813e-07 0.7814603789665585 1.207034327334326e-07 0.7827108149434853 1.207035383807156e-07 0.783868819044773 1.207036477202729e-07 0.7850578567336689 \
1.207037548972878e-07 0.786214126597127 1.20703884303365e-07 0.7875981444497275 1.207039967207506e-07 0.7887899291890393 1.207041201084898e-07 0.7900869036018625 \
1.207042375588255e-07 0.7913106402786101 1.207043810857437e-07 0.7927918312347375 1.20704496005322e-07 0.7939667362870242 1.207046347277352e-07 0.7953719780830618 \
1.207047727598755e-07 0.7967562205547866 1.207048822530295e-07 0.7978444364842524 1.207049832714595e-07 0.7988406866985471 1.207050843594198e-07 0.7998302780396641 \
1.207052167466158e-07 0.8011146558616069 1.207053354720369e-07 0.8022550163876687 1.207054572565424e-07 0.8034134048507504 1.20705576346336e-07 0.8045351524060473 \
1.207056975508533e-07 0.8056657048884367 1.207058291946645e-07 0.8068811249615274 1.207059522127029e-07 0.8080052413861453 1.207060798230234e-07 0.8091594649786741 \
1.20706210891683e-07 0.8103325925767672 1.207063342120463e-07 0.8114249716726942 1.207064421363105e-07 0.8123719892944993 1.207065499317031e-07 0.8133095350680949 \
1.20706631652631e-07 0.8140147772069938 1.207067485202474e-07 0.815015186305849 1.207068395812563e-07 0.8157880755829442 1.207069737498876e-07 0.8169164295805346 \
1.2070711832076e-07 0.8181184617099191 1.207072518231266e-07 0.8192158725965917 1.207073617890376e-07 0.8201107352847025 1.207075056546975e-07 0.8212684563313245 \
1.207076589602621e-07 0.8224861772268215 1.207077866985553e-07 0.8234883060891934 1.207079273408909e-07 0.8245786478120171 1.207080531244556e-07 0.8255423809867173 \
1.207082077424273e-07 0.8267124309768116 1.207083401541937e-07 0.8277017767197102 1.207084664337982e-07 0.8286345641820314 1.207085840641131e-07 0.8294941055817234 \
1.207087322309758e-07 0.8305638349826423 1.207088993752207e-07 0.8317531470681401 1.207090319938809e-07 0.832683775428688 1.20709204938569e-07 0.8338803479528284 \
1.207093733252244e-07 0.8350269493631071 1.207095428597542e-07 0.8361634673386688 1.207097242289089e-07 0.8373596561587384 1.207098668614913e-07 0.8382862741713709 \
1.207099807973396e-07 0.8390176620397163 1.207101115711344e-07 0.8398476357987267 1.207102132250742e-07 0.8404856735008092 1.207103297188026e-07 0.8412091703399448 \
1.207104652363492e-07 0.8420405885319162 1.20710662580143e-07 0.8432318270427018 1.20710853245141e-07 0.8443612543037786 1.207110631019802e-07 0.8455804035625291 \
1.207112440391043e-07 0.8466117334714958 1.207114413745909e-07 0.8477160230260256 1.207116151614274e-07 0.8486711109012058 1.207117977428814e-07 0.8496572451898022 \
1.207119690624607e-07 0.850566499179887 1.207121434475075e-07 0.8514760798656241 1.207123188310518e-07 0.8523748177975867 1.207124950632094e-07 0.8532619682996843 \
1.207126849014518e-07 0.8542000584728613 1.207128756376655e-07 0.8551245802328369 1.20713077434399e-07 0.856083442102113 1.207132701277753e-07 0.8569809170305027 \
1.207134797560765e-07 0.857937542729613 1.207137091938401e-07 0.8589615588718806 1.207139749904802e-07 0.8601183337444025 1.207142735657076e-07 0.8613802063570262 \
1.207145514672209e-07 0.8625196921548358 1.207148356776949e-07 0.8636511027355716 1.207151100894824e-07 0.8647118800460076 1.207153822523641e-07 0.8657341977214618 \
1.207156524214556e-07 0.8667205537246333 1.207159096161394e-07 0.8676338760342862 1.207161821558105e-07 0.868575115807136 1.207164581902909e-07 0.8695013130444248 \
1.207167283429862e-07 0.8703818891200001 1.207170280497877e-07 0.8713292845176382 1.207173988672582e-07 0.8724597217497643 1.207176937859212e-07 0.8733269024855727 \
1.207179480301993e-07 0.8740525764960509 1.207182462541985e-07 0.8748787854419284 1.207185198789691e-07 0.8756137195941651 1.207187560179586e-07 0.8762307200963571 \
1.207189963736862e-07 0.8768427579093606 1.207192187193381e-07 0.8773949085683344 1.207194127230722e-07 0.877865919014753 1.207197424471962e-07 0.878644045115768 \
1.207198976198553e-07 0.8790007149587372 1.207202153732479e-07 0.879712598742095 1.207203942386052e-07 0.8801026384247937 1.207207367000935e-07 0.8808283583858193 \
1.207209208412927e-07 0.8812073588304842 1.207213957461144e-07 0.8821499412898334 1.207215631406012e-07 0.8824705695712217 1.207220289718891e-07 0.8833323038036038 \
1.207222097967714e-07 0.8836551183393088 1.207227038300282e-07 0.8845051821644966 1.207228451726029e-07 0.8847400410050358 1.207234515631179e-07 0.8857071861637142 \
1.207236036356849e-07 0.8859397703602404 1.207242503137577e-07 0.8868873789663725 1.207243786102467e-07 0.8870678433440622 1.207250267232453e-07 0.8879435266410994 \
1.207251565285235e-07 0.8881118897635528 1.20725934785608e-07 0.8890711781604964 1.207260497804227e-07 0.8892053868933587 1.207269055110619e-07 0.8901454611437621 \
1.207270507776287e-07 0.8902951528450479 1.207280365337324e-07 0.8912364417375994 1.207282576409459e-07 0.8914302300078862 1.207294027520271e-07 0.892358484239638 \
1.207295339601744e-07 0.8924604119362172 1.207308752633695e-07 0.8934531785430913 1.207310266510305e-07 0.8935579568409697 1.207325081098674e-07 0.8944876667405802 \
1.207327469902294e-07 0.894621531696939 1.207345164619859e-07 0.8954958910368339 1.207349055688235e-07 0.8956641700186337 1.207372993342323e-07 0.8965498195158238 \
1.207377748942228e-07 0.8966991754584082 1.207418379503871e-07 0.8976977719002629 1.20742329424408e-07 0.8977905759376156 1.207506459514872e-07 0.8987839664765119 \
1.207515658053769e-07 0.8988472044554419 1.208777709459031e-07 0.8998441026240215 1.20878784754255e-07 0.8998514601858095 1.210704973474114e-07 0.8990059056521554 \
1.210707273489741e-07 0.8988405173838494 1.210723422215349e-07 0.8978439928078279 1.210725199353886e-07 0.8977495532019018 1.210892857104286e-07 0.8987316330193963 \
1.210894216988253e-07 0.8987497732072308 1.211048844279385e-07 0.8997471920221268 1.211051522925305e-07 0.8997526389354535 1.215889776197985e-07 0.9006560548284696 \
1.215890984089986e-07 0.9007687033315858 1.215898861800374e-07 0.9017381658104292 1.215900203187565e-07 0.901943163319478 1.215905139335305e-07 0.9027850367016239 \
1.21590658833145e-07 0.9030569221572713 1.215910546405301e-07 0.9038490360455199 1.215911744361842e-07 0.9041001886668685 1.215915586097176e-07 0.9049189780371781 \
1.215916707313647e-07 0.9051556495331843 1.215921780523356e-07 0.9061253139956988 1.215922720511916e-07 0.90626859229291 1.215934307008982e-07 0.9055667778886739 \
1.215935336638317e-07 0.9051589876696525 1.215936175067007e-07 0.9047707260375384 1.215937512467522e-07 0.9040404158978201 1.215938519641334e-07 0.9033957423200318 \
1.215939595799193e-07 0.9026166239542108 1.215940771531732e-07 0.9016533104038295 1.21594165418223e-07 0.90085556431878 1.215942850516912e-07 0.8996698288011099 \
1.215943823733893e-07 0.8986166602050341 1.215944933908277e-07 0.8973222354192386 1.215945955004155e-07 0.8960407982554908 1.21594678931815e-07 0.8949326975987755 \
1.215947831128827e-07 0.8934749428758865 1.215948741996463e-07 0.8921321265381427 1.215949667404319e-07 0.8907058396397178 1.2159506189443e-07 0.8891776325191247 \
1.215951764494069e-07 0.88725933118288 1.215952652925089e-07 0.8857137884271823 1.215953635316907e-07 0.8839502506198179 1.215954489018647e-07 0.8823735982707064 \
1.215955298021067e-07 0.8808434949738935 1.215956027633997e-07 0.8794355441897157 1.215956697820454e-07 0.8781198554636557 1.215957383931237e-07 0.8767515715160701 \
1.215958218880357e-07 0.8750591081124355 1.215958840153664e-07 0.8737811510706814 1.215959469979638e-07 0.8724704924326797 1.215960421537153e-07 0.8704632161180945 \
1.215961427643535e-07 0.8683077530860182 1.215962226435446e-07 0.8665738309361769 1.215963069058141e-07 0.8647250601592834 1.215963860160737e-07 0.8629723295901451 \
1.215964488315189e-07 0.8615696597604833 1.215965362885537e-07 0.8596016864744445 1.215966021820844e-07 0.8581079708060287 1.215966702436265e-07 0.856556281928966 \
1.215967195561343e-07 0.8554267461646872 1.215967747929236e-07 0.85415654045335 1.215968155325295e-07 0.8532164928603474 1.215968618342832e-07 0.8521450198670055 \
1.21596892048343e-07 0.8514441160591502 1.215969210896253e-07 0.8507691938976955 1.215969517282201e-07 0.8500558939662993 1.215970130054097e-07 0.8486254874746039 \
1.215970660779718e-07 0.8473828229799116 1.215971197331653e-07 0.8461232012188223 1.215971823904472e-07 0.8446482873934593 1.215972456733951e-07 0.8431545995644786 \
1.21597336171269e-07 0.8410121009440262 1.215974331690495e-07 0.8387078554355326 1.215975161465499e-07 0.8367307351423475 1.215975981509054e-07 0.8347721678896715 \
1.215976872193066e-07 0.8326403548070889 1.215977717326432e-07 0.8306135893189693 1.215978625915234e-07 0.8284303722590877 1.215979545263781e-07 0.8262176456275642 \
1.215980569573085e-07 0.8237486178045141 1.215981570753404e-07 0.8213320995840899 1.215982718962233e-07 0.8185572053828121 1.215983841027604e-07 0.8158423448209959 \
1.215985090963053e-07 0.8128151787794674 1.215986403567133e-07 0.8096337870015397 1.215987856277547e-07 0.8061104108175116 1.215989401353681e-07 0.8023613213197434 \
1.215991115759889e-07 0.7981999722344618 1.215992756257814e-07 0.794217661721315 1.215994600412032e-07 0.7897413884478564 1.215996665335768e-07 0.7847307375046715 \
1.215998560274198e-07 0.7801344622909899 1.216000494211826e-07 0.775444374634302 1.216002499880375e-07 0.7705834242206392 1.21600397552439e-07 0.7670092004965298 \
1.216005275638896e-07 0.7638619034739171 1.216006624283032e-07 0.7605987503374771 1.216007689187539e-07 0.7580234999254772 1.216009006085467e-07 0.7548403390839162 \
1.216010070329759e-07 0.7522693550468039 1.21601150211605e-07 0.7488125398635642 1.216013113387162e-07 0.7449250928176189 1.216014295655331e-07 0.7420746008290786 \
1.216015997983541e-07 0.7379721584775248 1.216017657246235e-07 0.7339761998059781 1.216019852669538e-07 0.7286940862104242 1.216021784540779e-07 0.724050920820232 \
1.216023533680413e-07 0.719851304223293 1.216025203151389e-07 0.7158476177432674 1.216027078061003e-07 0.711355754450834 1.216028952345367e-07 0.7068709122373377 \
1.216030635710959e-07 0.7028473835914892 1.216032564016302e-07 0.6982428782038785 1.216033964513775e-07 0.694901318858167 1.216035527086664e-07 0.6911769338170629 \
1.216037468781132e-07 0.6865540563080536 1.216039059846016e-07 0.6827702245679255 1.216040643446318e-07 0.679008548037742 1.216042596617402e-07 0.6743756772263459 \
1.216044700905194e-07 0.6693917663527935 1.216047227926646e-07 0.6634173774538097 1.216049024606155e-07 0.6591769455535931 1.216051540374889e-07 0.6532475027332399 \
1.21605354410306e-07 0.6485340174553987 1.216055260641582e-07 0.6445032789616798 1.216056847562747e-07 0.6407814961122935 1.216058239642021e-07 0.637522316374186 \
1.216059602882518e-07 0.6343349641335875 1.216060875012759e-07 0.6313646237382058 1.216062169938336e-07 0.6283457899522861 1.216063449851212e-07 0.6253646753452949 \
1.216064760596301e-07 0.6223174651643489 1.216066067717051e-07 0.6192830747181834 1.216067493797576e-07 0.6159760732208495 1.216068921032356e-07 0.612672916206165 \
1.216070446510367e-07 0.6091471600588 1.216071891550245e-07 0.6058158037532523 1.216073531732721e-07 0.6020406322262999 1.216074906379333e-07 0.5988837056407329 \
1.21607625454949e-07 0.5957940466067043 1.216077469535923e-07 0.5930134750293682 1.216078858038966e-07 0.5898448108574432 1.216079994507128e-07 0.5872554148224447 \
1.216081508608854e-07 0.5838116422847746 1.216082645795603e-07 0.5812320812748947 1.216083839926513e-07 0.5785269636915771 1.216084726731778e-07 0.5765205397309219 \
1.216085638182694e-07 0.5744630259469776 1.216086291571447e-07 0.5729901393713442 1.216086936268468e-07 0.5715377831648228 1.21608744447459e-07 0.5703933076453638 \
1.216088034223984e-07 0.569066051987989 1.216088708671064e-07 0.5675516747474645 1.216089379592979e-07 0.5660472084764079 1.216089908797418e-07 0.5648615894615425 \
1.216090865272254e-07 0.5627204246953637 1.216091437083616e-07 0.5614413394337 1.216091975109775e-07 0.5602399192081799 1.216092592530825e-07 0.5588634520375642 \
1.216093450862141e-07 0.5569525037715509 1.216094277818617e-07 0.5551133137453282 1.21609553910589e-07 0.552313430559463 1.216096890096646e-07 0.5493247407981657 \
1.21609787329828e-07 0.5471534914294828 1.216098999078898e-07 0.5446716589975775 1.216100024523052e-07 0.5424173856211837 1.216101225611309e-07 0.5397821662853191 \
1.216102242487819e-07 0.5375541863492928 1.216103397527456e-07 0.5350300289250629 1.216104546438614e-07 0.5325260225312031 1.216105811211341e-07 0.5297740207092871 \
1.216107063383297e-07 0.5270565158317848 1.216108531843123e-07 0.5238798967507053 1.216109886424458e-07 0.5209557060405445 1.216111462030546e-07 0.5175672114705414 \
1.216113083572294e-07 0.5140875588169389 1.216114890683071e-07 0.5102248342695275 1.216116813160604e-07 0.5061308236654174 1.216118940383231e-07 0.5016182665703952 \
1.216121259434839e-07 0.4967183500883584 1.216123831371877e-07 0.4913135654247419 1.216126226904984e-07 0.4863004534671564 1.216129246203734e-07 0.4800178499336004 \
1.216132123868145e-07 0.4740665530855001 1.216135251890574e-07 0.4676409412178996 1.216138450208061e-07 0.4611139840073785 1.21614184657409e-07 0.4542292677834274 \
1.216145118732278e-07 0.4476411633207955 1.216148470347968e-07 0.4409363684817221 1.216151642914576e-07 0.4346351592989786 1.216154981114363e-07 0.4280489847791872 \
1.2161584979678e-07 0.4211625252737479 1.21616163864498e-07 0.4150547397555842 1.216164868937019e-07 0.4088175946446666 1.216169278730989e-07 0.4003732788922496 \
1.216172702759421e-07 0.3938810608698495 1.216175707238305e-07 0.3882325136127223 1.216179460534016e-07 0.3812375944419973 1.216182761286299e-07 0.3751439175705365 \
1.216185594064112e-07 0.3699597784791666 1.216188599137726e-07 0.3645020109013299 1.216191395612329e-07 0.3594637112692664 1.216193634235237e-07 0.3554634414471464 \
1.216195752745134e-07 0.35170280677964 1.216197776231135e-07 0.3481338771034005 1.216199787581392e-07 0.3446120049995081 1.216201845356566e-07 0.3410324794262659 \
1.216204455143708e-07 0.3365252478245505 1.216206850045531e-07 0.3324209773202946 1.21620917679624e-07 0.3284665339262754 1.216211317612159e-07 0.3248537323113044 \
1.216213529069831e-07 0.3211475567840967 1.21621553789873e-07 0.3178053707831449 1.216217571810749e-07 0.3144500223650613 1.216219548494876e-07 0.3112139453100684 \
1.216221410931751e-07 0.3081862077816076 1.216223360742573e-07 0.3050391973134606 1.216225395365023e-07 0.3017803754370622 1.216227174774077e-07 0.2989521325826759 \
1.216229532011123e-07 0.2952356640875101 1.216231513339656e-07 0.2921385263640672 1.216233526780327e-07 0.2890160050544278 1.216235769672297e-07 0.2855690750291008 \
1.216237418971288e-07 0.2830551950838826 1.216239195258139e-07 0.2803657404651576 1.216241039249613e-07 0.2775946687427531 1.216242877463064e-07 0.2748547260732712 \
1.216244662029787e-07 0.2722194282383935 1.216246381032459e-07 0.2696976713509589 1.216247986436534e-07 0.2673699088296289 1.216249201257116e-07 0.265617282026588 \
1.216250730472387e-07 0.2634201198254058 1.21625200480934e-07 0.2616085083773952 1.216253046546047e-07 0.2601317890528609 1.216254215590816e-07 0.2584775571399547 \
1.21625536570573e-07 0.2568557450124987 1.216256609328034e-07 0.2551103168403305 1.216257765070866e-07 0.2534925198640895 1.216259106146075e-07 0.2516172680784447 \
1.216260256018485e-07 0.2500177396912131 1.216261793514453e-07 0.2478798443778067 1.216263161546458e-07 0.2459790966208961 1.21626450740453e-07 0.2441094379339017 \
1.216266066045887e-07 0.2419575875351012 1.216267312534115e-07 0.2402378086535915 1.216268704689347e-07 0.2383186229544463 1.2162700069296e-07 0.236525770455347 \
1.216271210458007e-07 0.2348769158236033 1.216272564390845e-07 0.233027137746051 1.216274076440629e-07 0.2309620730808924 1.216275424005331e-07 0.2291249940296414 \
1.216276470867202e-07 0.2277003186426776 1.216277696228612e-07 0.2260366668203369 1.2162790456742e-07 0.2242086518061946 1.216279996831675e-07 0.2229209267876512 \
1.216281149432224e-07 0.2213657311907907 1.216281974762018e-07 0.2202562617028589 1.216282686815329e-07 0.2192992955643472 1.216283173890172e-07 0.2186449771734718 \
1.216283645839733e-07 0.2180112263680214 1.216284111327915e-07 0.2173864029843717 1.216284645213553e-07 0.2166701476649976 1.216285018980252e-07 0.2161690444847812 \
1.216285392831377e-07 0.2156680710113931 1.21628579604508e-07 0.2151283464800275 1.216286508546475e-07 0.2141753141901174 1.216286850689041e-07 0.2137180869447317 \
1.216287314635346e-07 0.2131018213873352 1.216287919072008e-07 0.2122998083652294 1.216288609101202e-07 0.2113853596849882 1.216289262050716e-07 0.210520730631805 \
1.216289941831954e-07 0.2096212333552783 1.21629110629525e-07 0.2080823984153433 1.216292005517136e-07 0.2068957989735914 1.216293082176197e-07 0.2054771097790837 \
1.216294042789353e-07 0.2042146625011118 1.216295076575089e-07 0.2028641889872041 1.216296043425437e-07 0.2016026287683381 1.216297071523967e-07 0.2002625524503448 \
1.216298079123679e-07 0.1989526210414513 1.216299190580346e-07 0.1975116692735505 1.216300260975286e-07 0.1961279675313261 1.216301440040638e-07 0.1946083430154048 \
1.216302521143875e-07 0.1932197128021231 1.216303614129877e-07 0.1918224631760269 1.216304820447392e-07 0.1902849927564414 1.216305769453309e-07 0.1890796997295432 \
1.216307055062502e-07 0.18745262875399 1.216307985410385e-07 0.1862801166370808 1.216309009375946e-07 0.1849947785893032 1.216309889048857e-07 0.1838942174288659 \
1.216310871755573e-07 0.182668828510528 1.216311837761789e-07 0.1814691026470878 1.216312704146924e-07 0.1803971466393716 1.216313568237045e-07 0.1793305247657973 \
1.216314526608142e-07 0.1781527189679156 1.216315573876885e-07 0.1768710765218302 1.216317031999754e-07 0.1750963017969037 1.216318191679069e-07 0.1736923427161618 \
1.216319756317111e-07 0.1718092975148396 1.2163208681163e-07 0.1704786474822015 1.216322270616306e-07 0.1688098560703619 1.216323500730353e-07 0.1673544160765056 \
1.216324565640335e-07 0.1661007559767333 1.216325528894916e-07 0.1649724583647661 1.216326503229586e-07 0.1638357962207703 1.216327541762373e-07 0.1626293386330815 \
1.216328459768101e-07 0.1615673458739011 1.216329443645254e-07 0.1604337426303964 1.216330272831699e-07 0.1594828374885931 1.216331226515033e-07 0.1583950132920943 \
1.216332052138516e-07 0.1574587876231885 1.216333077985372e-07 0.1563016192679324 1.21633384076854e-07 0.1554454316211293 1.216334726624788e-07 0.1544557264474612 \
1.216335448319839e-07 0.1536532700165102 1.216336265414731e-07 0.1527486200895024 1.216337002202809e-07 0.1519363404455653 1.216337804404095e-07 0.1510573496788611 \
1.216338521684844e-07 0.1502755532525617 1.216339204254628e-07 0.149534520573691 1.216340181414224e-07 0.1484788062294206 1.216340875916063e-07 0.147731872792437 \
1.216341703430852e-07 0.1468455801890639 1.216342303799948e-07 0.1462052652532956 1.216343006186586e-07 0.1454587420502366 1.216343720461929e-07 0.1447037411390827 \
1.216344525596948e-07 0.1438588888651768 1.216345158225991e-07 0.1431977449412327 1.216345934965784e-07 0.1423892845091393 1.216346828063428e-07 0.141463758692191 \
1.216347521699289e-07 0.1407479403162204 1.216348501181493e-07 0.1397418416088305 1.216349404626691e-07 0.1388188591118084 1.216350262429942e-07 0.1379520826379384 \
1.21635093896779e-07 0.1372719511642241 1.216351602046294e-07 0.1366075914250998 1.21635238824321e-07 0.1358227655030745 1.216353195192302e-07 0.135020537018139 \
1.21635377921894e-07 0.1344419857224206 1.216354386744168e-07 0.1338420332148588 1.21635532580729e-07 0.1329184183639811 1.216355749782324e-07 0.1325029080242558 \
1.216356542224261e-07 0.1317336600863391 1.216356945925846e-07 0.1313430593815061 1.216357842934634e-07 0.130477658168832 1.216358232415503e-07 0.1301029732927899 \
1.216359188572359e-07 0.1291862249441596 1.216359577410651e-07 0.1288146335111444 1.21636050975841e-07 0.1279263274670414 1.2163611931843e-07 0.1272775968534341 \
1.216361716392852e-07 0.1267823325594629 1.216362537399991e-07 0.1260075984242486 1.216363249033783e-07 0.1253406747583812 1.216364028563663e-07 0.1246136378429537 \
1.216364819761022e-07 0.1238779526756392 1.21636560619333e-07 0.1231489004754178 1.216366406542416e-07 0.122409328367501 1.216367023886578e-07 0.1218405706457005 \
1.216367759836405e-07 0.1211645344030958 1.216368593634578e-07 0.120401093559758 1.216369234601888e-07 0.1198161795466899 1.216369928987769e-07 0.119184869057559 \
1.216370659217156e-07 0.1185234239195788 1.216371507966272e-07 0.1177582144838446 1.216372301594785e-07 0.117046673033812 1.216373148931361e-07 0.1162898833629492 \
1.216374056044255e-07 0.1154830714735263 1.216374811875037e-07 0.1148135241260771 1.216375469154284e-07 0.1142333070693714 1.216376069752011e-07 0.1137047561823949 \
1.216376765809174e-07 0.1130943456353956 1.216377429999685e-07 0.1125141752866663 1.216378224112316e-07 0.1118230150855203 1.216379126741612e-07 0.1110406875128299 \
1.216379817184613e-07 0.1104447270551955 1.216380562735805e-07 0.1098035355921305 1.216381447575013e-07 0.1090456469739195 1.216382238656483e-07 0.1083709350695736 \
1.216382937340289e-07 0.1077773127978274 1.216383747433988e-07 0.1070920034756896 1.216384309482126e-07 0.106618206733547 1.216384936074922e-07 0.1060916009495399 \
1.216385587540976e-07 0.105545887371837 1.216386300897258e-07 0.1049504956797945 1.216387503861013e-07 0.1039516085561449 1.216388019396737e-07 0.103525508500865 \
1.216388570887417e-07 0.1030709598036589 1.216389477859257e-07 0.1023262935955709 1.216390301757782e-07 0.1016530765296615 1.216391257555856e-07 0.1008759670630478 \
1.216392329651519e-07 0.1000092507657299 1.216393366245585e-07 0.09917656019160864 1.216394228321611e-07 0.09848810438956324 1.216395090743862e-07 0.09780303991321163 \
1.216395886154605e-07 0.09717448010577609 1.216396686283335e-07 0.09654538840876434 1.216397599166613e-07 0.09583163072761708 1.216398416620796e-07 0.09519620281310773 \
1.216399305889172e-07 0.09450872319168514 1.216400203662242e-07 0.09381864801001834 1.216400973288722e-07 0.09323024625953365 1.216401876536891e-07 0.0925435244861572 \
1.216402514624153e-07 0.09206084550525626 1.216403239259827e-07 0.09151514907748673 1.216403880546354e-07 0.09103438864950099 1.216404663020107e-07 0.09045054736970405 \
1.216405660032922e-07 0.08971110930136832 1.216406400564437e-07 0.08916512281998501 1.216407266649787e-07 0.08852997392441805 1.216408729646849e-07 0.08746544055362569 \
1.216409836769483e-07 0.08666684197409438 1.216410939866262e-07 0.08587717033461532 1.216412361822689e-07 0.08486839672072237 1.216413762347203e-07 0.08388450488753585 \
1.216415188805343e-07 0.08289222299161547 1.21641667651249e-07 0.08186778387581196 1.216418043639349e-07 0.08093569403044946 1.21641946484565e-07 0.07997640434545976 \
1.21642081061545e-07 0.07907728405019222 1.21642221281423e-07 0.07814997945867638 1.216423690282294e-07 0.07718353387841098 1.216425189824149e-07 0.07621348085094087 \
1.216426836982467e-07 0.07516037195605636 1.216428472843634e-07 0.07412732798506308 1.216430219327157e-07 0.07303837372665309 1.216432089864081e-07 0.07188781219077654 \
1.216434189729257e-07 0.0706159374129187 1.216436370461739e-07 0.06931715807027321 1.216438703663275e-07 0.06795188046253516 1.216441248458817e-07 0.0664909822812602 \
1.2164441780254e-07 0.06484528303377844 1.21644719953089e-07 0.06318745987130532 1.216450576747916e-07 0.06138078634948794 1.216454527833931e-07 0.05932807220464856 \
1.216458202346361e-07 0.05747953410674719 1.216462378424018e-07 0.05544691527644593 1.216465828383762e-07 0.0538196438399016 1.216469333806655e-07 0.05221302159193914 \
1.21647248341029e-07 0.0508087490907442 1.216475475823956e-07 0.049508488261462 1.216478469482477e-07 0.04824029756235761 1.216481221909583e-07 0.04710512226277328 \
1.216484056545246e-07 0.04596497870754415 1.216486672549465e-07 0.04493681260994405 1.216489447070712e-07 0.04387103439794762 1.216492207665063e-07 0.04283531238677037 \
1.21649529036243e-07 0.04170718945545093 1.216497514688635e-07 0.0409114719535993 1.21650039009947e-07 0.03990505631995635 1.216502752428796e-07 0.0390969788355163 \
1.216505937045548e-07 0.03803800466874574 1.21650844115589e-07 0.03722710566490722 1.216511671003914e-07 0.03620720400565681 1.216514254364062e-07 0.03541203096995557 \
1.216517154102847e-07 0.03454066075983582 1.216519452051025e-07 0.0338658635512188 1.216522301004437e-07 0.03304787219836024 1.21652469846563e-07 0.03237513696606491 \
1.216527104811323e-07 0.03171392889024889 1.216529495996188e-07 0.03107212555077287 1.216531855385298e-07 0.03045460689686571 1.21653416367391e-07 0.02986254663395104 \
1.216536313939186e-07 0.02932175456294728 1.216540335597598e-07 0.0283374222946415 1.2165423211788e-07 0.02786401170979088 1.216546058190659e-07 0.02699470773596776 \
1.216547926322608e-07 0.02657042318767052 1.216551386335082e-07 0.02580176906824739 1.216552605769465e-07 0.02553595448027303 1.216556434299635e-07 0.02472011952872977 \
1.216558038641492e-07 0.02438657631284594 1.216562468653031e-07 0.02348572425118655 1.216564174793446e-07 0.02314627247835563 1.216567380559406e-07 0.02251902970747987 \
1.216569383408681e-07 0.0221336684630111 1.216573852788009e-07 0.02128811173678137 1.216575132229166e-07 0.02104854104185888 1.21658001100276e-07 0.02014826272243131 \
1.21658136077553e-07 0.01990454278080647 1.216586183290713e-07 0.0190640092473091 1.216587806551862e-07 0.01879235028057063 1.216592670495272e-07 0.01801148170254873 \
1.216594300771863e-07 0.01776103207540622 1.216601102988766e-07 0.01676849304257711 1.216602493826145e-07 0.01657541006259178 1.216609818771477e-07 0.01560782569993242 \
1.216611407707804e-07 0.01540693214221847 1.216619238518671e-07 0.01445869962397344 1.216620696444218e-07 0.01428952172302696 1.216629204257814e-07 0.01334248985256295 \
1.21663031529053e-07 0.01322388191882306 1.216639648234166e-07 0.0122699293983148 1.216640986614658e-07 0.01213902814618388 1.21665057199482e-07 0.01123495036716388 \
1.216651783165509e-07 0.01112486091825863 1.216663004003486e-07 0.01017270671243764 1.216664059016017e-07 0.01008921053061839 1.216677349760139e-07 0.009112307258623473 \
1.216678551802884e-07 0.009029744095492466 1.21669403542048e-07 0.008036808760534916 1.216694843298185e-07 0.007986285493236449 1.216710552093519e-07 0.007024564730313319 \
1.216711226255509e-07 0.006986095570813155 1.216730433922295e-07 0.006001386377072119 1.216732301941131e-07 0.005914747648762168 1.216755456080606e-07 0.0049318160947762 \
1.216759451349076e-07 0.004777795182599986 1.216785089444083e-07 0.003889929704329555 1.216790078153284e-07 0.003736330440833864 1.21682637539317e-07 0.002784984367379526 \
1.216831882332918e-07 0.002663729254427667 1.216885866736714e-07 0.001711392372544448 1.216888999412434e-07 0.001662511220227468 1.216938922337914e-07 0.0006970413096974805 \
1.216940762528259e-07 0.0006571176749162138 1.243425553956096e-07 -0.0002691198397987355 1.243427114545721e-07 -0.0004551674219448388 1.243432594384272e-07 -0.001322174727784445 \
1.243433723764199e-07 -0.001539785040943742 1.243438016313499e-07 -0.002474302920374066 1.24343907888515e-07 -0.002730173903076456 1.243441906906666e-07 -0.003454402452283872 \
1.243443042852103e-07 -0.003760966378165151 1.243446428397891e-07 -0.004705104513819927 1.243447552637498e-07 -0.005021586953003071 1.243450835416507e-07 -0.005887841248467669 \
1.243451910801718e-07 -0.006130875888161453 1.243460710062032e-07 -0.005789627805322099 1.243462462122502e-07 -0.004910736584223327 1.243463630430134e-07 -0.004127745010746014 \
1.243464899101376e-07 -0.00309221842859156 1.243465914428629e-07 -0.002125750314016509 1.243467128641333e-07 -0.0008095618968406578 1.243468030290462e-07 0.0002767910803854594 \
1.243469002126957e-07 0.001550247908954045 1.243469982869598e-07 0.002938803805678211 1.243471655080454e-07 0.005530627736217106 1.243473878133234e-07 0.009378371294171852 \
1.243475735517141e-07 0.01290572951649239 1.243477976330495e-07 0.01747895571448658 1.243479572777817e-07 0.02091945933227325 1.243481217671113e-07 0.02459614091902196 \
1.243482715915693e-07 0.0280452875125503 1.243484209914613e-07 0.03156498790849799 1.243485705227667e-07 0.03515592969144176 1.243487246026614e-07 0.03891669635189081 \
1.243488867868089e-07 0.0429309674228065 1.24349053210035e-07 0.0470989728378523 1.243492291435082e-07 0.05154884981278444 1.24349410271779e-07 0.05616867911875007 \
1.243496024027047e-07 0.06110225049351239 1.24349810098117e-07 0.0664648391313285 1.243500320181979e-07 0.07222051812179281 1.243502672196804e-07 0.07834079218654426 \
1.243505194059893e-07 0.08491829088081257 1.243507955452241e-07 0.09213111703448683 1.243510966667008e-07 0.1000001933597138 1.243514285865622e-07 0.1086702418150647 \
1.243518059053303e-07 0.1185147411083515 1.243522041953866e-07 0.1288888856248832 1.243526735037065e-07 0.1410822143415975 1.243532195292308e-07 0.1552200475789812 \
1.243538544895379e-07 0.1715918832733369 1.243545538901293e-07 0.1895291194622146 1.243553721290552e-07 0.2103807608661494 1.243562778230217e-07 0.2332840710921665 \
1.243570673340878e-07 0.253091928008631 1.243577710929056e-07 0.2706124241987875 1.243583889437195e-07 0.2858796548825839 1.243589545671311e-07 0.2997575097153312 \
1.243594763024047e-07 0.3124620269501652 1.243599740861211e-07 0.3244932238414255 1.243604577240811e-07 0.3360954048923613 1.243609145982154e-07 0.3469667650518959 \
1.243613874391095e-07 0.3581213589834248 1.243618270524661e-07 0.3684065070151987 1.24362314929562e-07 0.379719432411247 1.243628457299846e-07 0.3919028193132517 \
1.243633436253595e-07 0.4032143644097119 1.24363775002613e-07 0.41292177789323 1.243642618898012e-07 0.4237731225600331 1.243647619892433e-07 0.4348012155672935 \
1.243651066099338e-07 0.4423321287141763 1.243654600037777e-07 0.4500000647748709 1.243658877736169e-07 0.4592134948422093 1.243662796346881e-07 0.4675816212925634 \
1.243665799290445e-07 0.4739471552041949 1.243669218601248e-07 0.4811428413521782 1.243672651945704e-07 0.4883132334011818 1.24367525955058e-07 0.4937215836208605 \
1.243677680115876e-07 0.4987106167174703 1.243680340100557e-07 0.5041617362307154 1.243682934982395e-07 0.5094435946950286 1.243684834145397e-07 0.5132872703533161 \
1.243686986491409e-07 0.5176241792560061 1.243688371999001e-07 0.5204025546691405 1.243689820806791e-07 0.5232962183003332 1.243691954947458e-07 0.5275364624051522 \
1.243693975193605e-07 0.5315382148201082 1.243695902480239e-07 0.5353370730264509 1.243697755034039e-07 0.5389735557287745 1.243699525009277e-07 0.5424323215059959 \
1.243702617642633e-07 0.5484573594957171 1.243705229123106e-07 0.5535233414883098 1.243708247314806e-07 0.5593562770234363 1.243710801601219e-07 0.5642781701956761 \
1.243713725156194e-07 0.5698968483756405 1.243716319698133e-07 0.5748654731717864 1.243719020897901e-07 0.5800301911327002 1.243721441003479e-07 0.5846380733684551 \
1.24372401610146e-07 0.5895273573494454 1.243726280544834e-07 0.5938057549890672 1.243728649429657e-07 0.5982619499065401 1.24373074987873e-07 0.6021962733001386 \
1.243732879185847e-07 0.6061670177072124 1.243735413972821e-07 0.6108668889270118 1.24373744692931e-07 0.6146150465592417 1.243739363811142e-07 0.6181346807088086 \
1.243741250074786e-07 0.6215812235468744 1.243743123254166e-07 0.6249823889551316 1.243745179374062e-07 0.6286953279350977 1.243747677606249e-07 0.6331759959753138 \
1.243749715724035e-07 0.6368063379741715 1.243751792111212e-07 0.6404826298163093 1.24375371862737e-07 0.6438748386876914 1.243756164748105e-07 0.6481531432733096 \
1.243758643733136e-07 0.6524620620600715 1.243760442082188e-07 0.6555644139995785 1.243762349822552e-07 0.6588391718544121 1.24376388158437e-07 0.6614554104590837 \
1.243765598271469e-07 0.6643705886591137 1.243767102939677e-07 0.6669108747194671 1.243768468979714e-07 0.6692010654183506 1.243769963383726e-07 0.6716954191563786 \
1.243771240725235e-07 0.6738189269502312 1.2437726394477e-07 0.6761323074508511 1.24377388021905e-07 0.6781756764962316 1.243775193832699e-07 0.6803315871556701 \
1.243776435547311e-07 0.6823627547057004 1.243777813315919e-07 0.6846081866267727 1.243779015758123e-07 0.6865586181592046 1.243780436284175e-07 0.6888545186016138 \
1.243781438561225e-07 0.6904668682779994 1.243782651601134e-07 0.6924123325129877 1.243783561353879e-07 0.6938641504265992 1.243784535186708e-07 0.695411869780077 \
1.243785506015381e-07 0.6969507228893711 1.243786398841584e-07 0.6983595753378042 1.243787378559428e-07 0.699898781449533 1.243788681310304e-07 0.7019319515314388 \
1.243790215432551e-07 0.7043083163565919 1.243791571090672e-07 0.7063909659299702 1.24379301449562e-07 0.708591461371511 1.243794273204452e-07 0.710496752775434 \
1.243795523478311e-07 0.712376488910674 1.243796666301914e-07 0.7140841686551523 1.243797776133356e-07 0.7157331888171029 1.243798773084046e-07 0.7172065512867005 \
1.243800143526226e-07 0.7192196995505324 1.243801333798347e-07 0.7209572005600779 1.24380253677943e-07 0.7227029412191364 1.243803801768634e-07 0.7245276185835638 \
1.243805041084668e-07 0.7263044524160376 1.243806283948001e-07 0.7280754330070212 1.24380754759953e-07 0.7298652243312684 1.243808845716946e-07 0.7316925631262517 \
1.243810084102138e-07 0.7334254795816325 1.243811411911006e-07 0.735272086289578 1.243812420423058e-07 0.7366670415914529 1.243813552339755e-07 0.738224777043618 \
1.243814420199563e-07 0.7394137384482823 1.243815586452529e-07 0.7410021813026957 1.243816479345105e-07 0.7422110784210975 1.243817591113938e-07 0.7437075443329063 \
1.243818883701577e-07 0.7454347509364776 1.243820022291937e-07 0.7469455276109591 1.243821066334058e-07 0.74832188588007 1.243822310004373e-07 0.7499498655229884 \
1.243823782406159e-07 0.7518616907275563 1.243824985209068e-07 0.753411006437983 1.243826144254459e-07 0.7548933175676444 1.243827545012897e-07 0.7566706674475765 \
1.243828971129601e-07 0.7584645678799224 1.243830150672032e-07 0.7599365027959469 1.243831418837122e-07 0.7615071445339606 1.243832827668562e-07 0.7632375905494565 \
1.243834025603537e-07 0.7646969139886852 1.243835475192107e-07 0.7664484133613445 1.243836690779963e-07 0.7679052725436226 1.243837881174897e-07 0.7693214142140735 \
1.243839097488533e-07 0.7707575700077021 1.243840377178317e-07 0.772256936813787 1.243841469330139e-07 0.7735272422640712 1.243842718238923e-07 0.774969549136603 \
1.24384378939953e-07 0.7761978171588899 1.243845121931473e-07 0.7777146071439789 1.243846392965933e-07 0.7791497354387434 1.243847610475684e-07 0.7805132846941326 \
1.243848776321508e-07 0.7818078758210534 1.24384983459753e-07 0.7829735233300771 1.243851228258954e-07 0.7844949153190801 1.243852718976944e-07 0.786105286864636 \
1.24385419626362e-07 0.7876841235632186 1.243855389322397e-07 0.7889471147195867 1.243856729390521e-07 0.7903527806482344 1.243857933652268e-07 0.791604423795974 \
1.243859349104043e-07 0.7930616786923709 1.243860823364167e-07 0.7945638089648995 1.243862068109252e-07 0.7958198087139573 1.243863258549181e-07 0.7970105506108808 \
1.243864374452017e-07 0.7981174590942314 1.243865426744905e-07 0.7991530841216606 1.243866381855941e-07 0.8000862307887144 1.243867742475476e-07 0.8014036057482816 \
1.243868911236816e-07 0.8025237700417888 1.243870102773537e-07 0.8036549841722296 1.24387132589548e-07 0.8048050501807249 1.243872558616218e-07 0.8059526272620129 \
1.243873823583984e-07 0.8071184350969989 1.243875078610623e-07 0.8082633544790385 1.243876385869669e-07 0.8094437311890262 1.243877641549387e-07 0.8105658358439867 \
1.243878932098036e-07 0.8117072367686948 1.243879990659606e-07 0.8126345588578442 1.243881002348366e-07 0.8135133322873783 1.243881948546566e-07 0.8143286754242188 \
1.243883191357402e-07 0.8153900871385379 1.243884088474262e-07 0.816149614585347 1.243885078849502e-07 0.8169816577628611 1.243886456628271e-07 0.8181280288377792 \
1.243887801986773e-07 0.81923501721715 1.243888886049436e-07 0.8201180631035904 1.243890385184474e-07 0.8213254631869725 1.243891890970255e-07 0.8225223201378843 \
1.243893145921802e-07 0.8235077122548546 1.24389458438707e-07 0.8246238332260477 1.243895830219706e-07 0.8255790649890803 1.243897318751914e-07 0.8267066458678887 \
1.243898680237751e-07 0.827725029289517 1.243899930476024e-07 0.8286494160599757 1.243901107545823e-07 0.8295103773055483 1.243902563935805e-07 0.8305630309532103 \
1.243904227748753e-07 0.8317484146982921 1.243905533585646e-07 0.8326660250626342 1.243907268806749e-07 0.8338683097812621 1.243908950025776e-07 0.8350147136930499 \
1.243910648651803e-07 0.8361549927788252 1.243912457668832e-07 0.8373497079260466 1.243913888761651e-07 0.8382806519784776 1.24391502965127e-07 0.839013953006387 \
1.243916331276036e-07 0.8398410866028793 1.243917349727342e-07 0.8404811280669765 1.243918517989402e-07 0.8412075886390841 1.243919886903802e-07 0.8420483852080155 \
1.24392186497604e-07 0.843243620449199 1.243923781227506e-07 0.8443797466267589 1.24392587554618e-07 0.8455974227529048 1.243927695012999e-07 0.8466352798309468 \
1.243929666301539e-07 0.8477391449715804 1.243931399710144e-07 0.8486924050423899 1.243933229793209e-07 0.8496814535024207 1.243934941423557e-07 0.8505903669473519 \
1.243936687794506e-07 0.851501688465695 1.243938440392814e-07 0.8524001683007644 1.243940201897297e-07 0.8532872510191711 1.243942104700295e-07 0.8542278331088334 \
1.2439440106916e-07 0.8551519386507073 1.243946016923949e-07 0.8561055033533737 1.2439479430095e-07 0.8570028516027762 1.243950049816413e-07 0.8579644845832216 \
1.243952330831089e-07 0.8589827023971403 1.243954988710916e-07 0.860139640227508 1.243957974838522e-07 0.8614018215255795 1.243960737724907e-07 0.8625348754565382 \
1.243963580090103e-07 0.8636666213345715 1.243966322137804e-07 0.8647267940813509 1.243969044486385e-07 0.8657495569722869 1.243971746527799e-07 0.8667361702337206 \
1.243974318083905e-07 0.867649441901348 1.243977043886041e-07 0.8685908808535525 1.2439798037489e-07 0.8695169452638583 1.24398250477721e-07 0.870397355937691 \
1.243985503347982e-07 0.8713451925332844 1.243989213624563e-07 0.8724761722512941 1.243992162997666e-07 0.8733433185969293 1.243994705892065e-07 0.8740690226522811 \
1.243997688459906e-07 0.874895168896023 1.244000424554269e-07 0.8756299040683481 1.244002785839137e-07 0.8762466977562872 1.244005189298274e-07 0.8768585021646264 \
1.244007412634921e-07 0.8774104263690854 1.244009352691695e-07 0.8778812671168952 1.244012649918855e-07 0.8786590883967833 1.244014201653189e-07 0.8790156160651978 \
1.244017379413894e-07 0.8797272612331356 1.244019168030317e-07 0.8801171459162566 1.244022592648612e-07 0.8808425821290963 1.244024433930207e-07 0.881221400612852 \
1.244029182707539e-07 0.8821634994206867 1.244030856669651e-07 0.8824839765989225 1.244035515089056e-07 0.8833452998114757 1.244037323309576e-07 0.8836679564577563 \
1.244042263693833e-07 0.8845176198113115 1.24404367718007e-07 0.8847523712107549 1.244049740520726e-07 0.8857188576377059 1.244051261213959e-07 0.8859512996759633 \
1.244057728095585e-07 0.8868983431897121 1.2440590110417e-07 0.8870786909355212 1.244065492212318e-07 0.8879538337624689 1.244066790202949e-07 0.8881220828502663 \
1.244074572237723e-07 0.8890807033877333 1.24407572278734e-07 0.8892148977954012 1.244084279402065e-07 0.8901543051721961 1.244085733010758e-07 0.8903040038307473 \
1.244095590571273e-07 0.8912446482480114 1.244097801624957e-07 0.8914382978987679 1.244109252894234e-07 0.8923659558950503 1.244110565064392e-07 0.8924678262926897 \
1.244123977150129e-07 0.8934599079028542 1.24412549114272e-07 0.8935646301988298 1.244140305519949e-07 0.8944937559627255 1.244142694313731e-07 0.8946275407274444 \
1.244160387469791e-07 0.8955013787854181 1.244164278981914e-07 0.8956696032899972 1.244188215611418e-07 0.8965547188539188 1.244192972701398e-07 0.8967039926079825 \
1.244233604302104e-07 0.8977020505850396 1.24423851854269e-07 0.8977948037134476 1.24432168453822e-07 0.898787348739254 1.244330883529499e-07 0.8988506593152591 \
1.245765735834803e-07 0.8998476076348748 1.245776920164557e-07 0.8998537475785264 1.247827836359558e-07 0.898985773748599 1.247830107254573e-07 0.8988224379910277 \
1.247846203322555e-07 0.8978282360369357 1.247847977407988e-07 0.8977338482811539 1.248017048890996e-07 0.8987315468430059 1.248018143281978e-07 0.8987460089186867 \
1.248175950494439e-07 0.8997418097871094 1.248178913753395e-07 0.8997476966799167 1.25301325027745e-07 0.9007060148833608 1.253014540780854e-07 0.9008313386292994 \
1.253021042279306e-07 0.9016292186224167 1.253022937236614e-07 0.9019133038041363 1.253027969456399e-07 0.9027675859898705 1.253029324182996e-07 0.9030208676018907 \
1.253033328770163e-07 0.9038195223753869 1.253034648149532e-07 0.9040958310886574 1.253038660300167e-07 0.9049509627747726 1.253039642901937e-07 0.9051582028152527 \
1.253044301640043e-07 0.9060587574877488 1.253045916627274e-07 0.9063060456044927 1.253057356752505e-07 0.9055153668657776 1.253058806545959e-07 0.9049059606760256 \
1.253060592073535e-07 0.9039396653125833 1.253062394026313e-07 0.9027054491383806 1.253063820935606e-07 0.9015369228101149 1.253064992531646e-07 0.9004524619440171 \
1.253065882345255e-07 0.8995505656965809 1.253066798781777e-07 0.8985529714258781 1.253068129901104e-07 0.8969831049011855 1.253069067111929e-07 0.8957895978311226 \
1.253069978500018e-07 0.8945634483845346 1.253071111423133e-07 0.8929516940777753 1.253072142512258e-07 0.8913998138690341 1.253073105184064e-07 0.8898830246517148 \
1.253074296555229e-07 0.8879200664089764 1.253075982407716e-07 0.8849885378698126 1.253077600122728e-07 0.8820195265790133 1.253079532313317e-07 0.8782956415026882 \
1.253081387944432e-07 0.8745571577041361 1.253083490607478e-07 0.8701566079887386 1.253085313097886e-07 0.8662213066841463 1.253087161731834e-07 0.8621339172744639 \
1.253088888583302e-07 0.8582419637438897 1.253090749664034e-07 0.8539816046497358 1.253092527824914e-07 0.849858603441091 1.253094334990722e-07 0.8456251963850057 \
1.253095986373313e-07 0.8417258760277182 1.253097639114333e-07 0.837798995916667 1.253099271590959e-07 0.8339004324287677 1.253100857493696e-07 0.8300982805770993 \
1.253102626737714e-07 0.8258418712800655 1.253104591875839e-07 0.8211009660847696 1.253106267441254e-07 0.8170498602679914 1.253107934845439e-07 0.8130123908857781 \
1.253109679080616e-07 0.8087844286215062 1.253111372776842e-07 0.8046757316210446 1.253113054767786e-07 0.8005936994537799 1.25311494325046e-07 0.7960093488074458 \
1.253116851408819e-07 0.7913773844868103 1.253118935230917e-07 0.7863203192056716 1.25312119942597e-07 0.7808277108969495 1.253123091427939e-07 0.7762391340290878 \
1.253125192894832e-07 0.7711455503222944 1.253126680579875e-07 0.7675418410361046 1.253127990509761e-07 0.7643705172588006 1.25312936616212e-07 0.7610417440783073 \
1.253130423674414e-07 0.7584842184275663 1.253131771410752e-07 0.7552262509102785 1.253132889738005e-07 0.7525244432456109 1.253134184089644e-07 0.7493992292091655 \
1.253135735976883e-07 0.7456545577979357 1.253136852334407e-07 0.7429626190147979 1.253138448080549e-07 0.7391166470929011 1.253140201296882e-07 0.7348935218456193 \
1.253142325051509e-07 0.7297828120356423 1.253144253876789e-07 0.7251458607116523 1.253145820889711e-07 0.7213823872711312 1.253147687636618e-07 0.716903961299824 \
1.253149576500111e-07 0.7123775767926828 1.253151485342027e-07 0.70780884692282 1.253153352821382e-07 0.7033444557767304 1.253155183669542e-07 0.698972331957095 \
1.253156556859354e-07 0.6956951921588121 1.253158089288925e-07 0.6920418367118417 1.253160040575431e-07 0.6873949992893974 1.253161613518718e-07 0.6836535194673684 \
1.25316320746467e-07 0.6798660670227984 1.253165164902601e-07 0.6752219404489795 1.253167086893939e-07 0.6706682621108646 1.253169436410222e-07 0.6651105611269369 \
1.2531713111727e-07 0.6606839627962382 1.253173683544039e-07 0.6550894036851447 1.253175575343661e-07 0.6506361170423679 1.253177381501785e-07 0.6463915264929231 \
1.253179018447415e-07 0.6425504277539856 1.253180463961504e-07 0.6391628119244788 1.2531818686792e-07 0.6358764726647652 1.253183139687075e-07 0.6329064225879303 \
1.253184462761836e-07 0.6298198307262635 1.253185728632297e-07 0.626870110582017 1.253187034434976e-07 0.62383130535404 1.253188327128966e-07 0.6208285625908692 \
1.253189718197929e-07 0.6176004736356133 1.253191203301029e-07 0.6141606483517721 1.253193098786583e-07 0.6097777958748198 1.253194555819145e-07 0.6064170107178907 \
1.253196906324779e-07 0.601007464699683 1.253198736317494e-07 0.5968099615921 1.253200979734226e-07 0.5916778694808832 1.253202691466717e-07 0.5877753019413697 \
1.253204014804909e-07 0.5847634284691802 1.253205332770303e-07 0.5817721407249107 1.253206398209335e-07 0.5793579518205488 1.25320735711292e-07 0.5771868999037388 \
1.25320828211542e-07 0.5750974572268882 1.25320920638905e-07 0.5730134868920421 1.253209930672116e-07 0.5713818265150021 1.25321048796317e-07 0.5701269325864891 \
1.253211099054046e-07 0.5687522410723198 1.2532120667008e-07 0.5665806864277688 1.253212681615946e-07 0.5652027770813386 1.253213272142164e-07 0.5638802801505602 \
1.253214028408818e-07 0.5621878686488651 1.253214698636602e-07 0.5606896577364279 1.253215434607697e-07 0.5590483558003441 1.253216110667724e-07 0.5575429304381756 \
1.253217271358289e-07 0.5549610936632026 1.253218273422345e-07 0.5527359403974305 1.253219393494244e-07 0.5502565947066531 1.253220338414751e-07 0.5481686943853854 \
1.253221549961726e-07 0.5454955387196141 1.253222551839389e-07 0.5432910220514219 1.253223711744508e-07 0.5407443765731218 1.253224788782885e-07 0.5383833065966291 \
1.253225884569768e-07 0.5359861028148916 1.253227005784207e-07 0.5335400310751951 1.253228275156047e-07 0.5307765704644959 1.253229496651232e-07 0.5281221248815906 \
1.253230894260377e-07 0.525095489155881 1.253232265641539e-07 0.522132778766487 1.253233765292442e-07 0.5189020692106626 1.253235353022474e-07 0.5154923220538846 \
1.253237093279044e-07 0.511765695450105 1.25323896158028e-07 0.5077823379664483 1.253241011259936e-07 0.5034264211640872 1.253243238349422e-07 0.4987133299464507 \
1.253245767391391e-07 0.4933874474923696 1.253248116930461e-07 0.4884604410272814 1.253251079613079e-07 0.4822828691822955 1.253253977512662e-07 0.4762763831984252 \
1.253257040870848e-07 0.4699660956099861 1.253260164056119e-07 0.4635767846525711 1.253263549710683e-07 0.4566963260653934 1.25326678082485e-07 0.4501741115777416 \
1.253270164777878e-07 0.4433881855507311 1.253273403090534e-07 0.4369378830387565 1.253276647034741e-07 0.4305204627449936 1.253280076377603e-07 0.4237851826852676 \
1.253283469185779e-07 0.4171698123421442 1.253286863932124e-07 0.4105997181257849 1.253291295050583e-07 0.4020958655332711 1.253294915732268e-07 0.3952155038183801 \
1.253298121249644e-07 0.3891775711374149 1.253301990595345e-07 0.3819561902961204 1.253305269297949e-07 0.3758957719299574 1.253308120888516e-07 0.3706704968427373 \
1.253311304576464e-07 0.3648820026298218 1.253314132885732e-07 0.3597820188690578 1.253316419773369e-07 0.3556924369094372 1.253318598701416e-07 0.3518226517641353 \
1.253320551194862e-07 0.3483769517668343 1.253322620275857e-07 0.344751588202948 1.253324768243417e-07 0.3410137651016431 1.253327290508921e-07 0.3366564674340092 \
1.253329710462048e-07 0.3325077909124976 1.253332018984844e-07 0.3285822460490526 1.253334167466748e-07 0.3249550452085373 1.253336371033643e-07 0.3212604562488142 \
1.253338386742641e-07 0.3179050685021769 1.253340417582106e-07 0.3145531374773136 1.253342396555968e-07 0.3113121771742085 1.253344267548364e-07 0.3082694484595072 \
1.253346206551795e-07 0.3051385396431291 1.253348257035143e-07 0.3018527636900292 1.253350059382659e-07 0.2989872106339772 1.253352418362775e-07 0.2952669081535775 \
1.253354431238275e-07 0.2921198200609627 1.253356445146313e-07 0.2889965001417216 1.253358691637942e-07 0.2855437159941698 1.253360345437678e-07 0.2830223598911593 \
1.253362123481056e-07 0.280330186126118 1.253363960043191e-07 0.277570343839212 1.253365812460764e-07 0.2748090658167894 1.253367593914542e-07 0.2721781298892599 \
1.253369329835173e-07 0.2696316866093095 1.253370933483699e-07 0.267306655456324 1.253372144595526e-07 0.2655585721882695 1.253373676543406e-07 0.2633570345323199 \
1.253374949857892e-07 0.2615475749425888 1.253375983136284e-07 0.2600830587034867 1.25337715638424e-07 0.2584225376281647 1.253378334453812e-07 0.2567591557214636 \
1.253379574091473e-07 0.2550199666844239 1.253380743933138e-07 0.2533821414201824 1.253382051894417e-07 0.2515535495016885 1.253383223995523e-07 0.2499173892700276 \
1.253384756526766e-07 0.2477853623028658 1.253386111831973e-07 0.2459029165157107 1.253387428644058e-07 0.244074199323236 1.25338899457317e-07 0.2419017673596028 \
1.253390246538746e-07 0.2401755227310949 1.253391603715014e-07 0.2383060149301216 1.253392927986628e-07 0.2364844144139329 1.253394127723238e-07 0.2348355337769661 \
1.253395758201609e-07 0.232606585912384 1.253397146272525e-07 0.230713852557009 1.253398531009719e-07 0.2288300961780371 1.253399586457212e-07 0.2273962817971701 \
1.253400870074011e-07 0.2256537837490921 1.253401911350241e-07 0.2242444877898851 1.25340291651026e-07 0.222886569499566 1.253403666954022e-07 0.2218745444235658 \
1.253404440284576e-07 0.2208349692306942 1.253405187916369e-07 0.2198305887827458 1.253405967553143e-07 0.218785487158918 1.253406516218243e-07 0.2180503923904892 \
1.253407081185998e-07 0.2172938400168352 1.253407515721192e-07 0.2167123195211523 1.253407916131654e-07 0.2161767335077376 1.253408308521132e-07 0.2156521099473339 \
1.253408717263501e-07 0.2151058606261434 1.253409258788401e-07 0.2143825797409383 1.253409642959716e-07 0.2138698309421548 1.253410035846784e-07 0.2133480458229882 \
1.253410651213865e-07 0.2125332203444249 1.253411270989155e-07 0.2117131287842428 1.253411835756643e-07 0.2109664019951111 1.253412482072545e-07 0.2101124842966758 \
1.253413437158761e-07 0.2088522205996687 1.253414310316075e-07 0.207701294711168 1.253415276412079e-07 0.2064291756790013 1.253416248707623e-07 0.2051510266126755 \
1.253417257178229e-07 0.2038307158897115 1.253418263175944e-07 0.2025192706911573 1.253419228088913e-07 0.2012627769767186 1.253420249910648e-07 0.1999338657614989 \
1.253421286307215e-07 0.1985898465970496 1.253422384047343e-07 0.1971698847140261 1.253423475797596e-07 0.1957617939809042 1.253424676778517e-07 0.1942174441246506 \
1.253425776973762e-07 0.1928086337505992 1.253426858092848e-07 0.1914295694688549 1.253428088379843e-07 0.1898652723262108 1.253428989485537e-07 0.1887234630454603 \
1.253430063140445e-07 0.1873671680421656 1.253430831253526e-07 0.1864004060894758 1.253431665706207e-07 0.1853535952511875 1.253432561024323e-07 0.1842338297700716 \
1.253433406678985e-07 0.1831790839553313 1.253434203840387e-07 0.1821880912968773 1.253435217092422e-07 0.1809331989518758 1.253436300564713e-07 0.1795959386230563 \
1.253437265321694e-07 0.1784102562612937 1.25343851909986e-07 0.1768766438339704 1.253439846934562e-07 0.1752616821119887 1.253441024642794e-07 0.1738362801839788 \
1.253442481158562e-07 0.1720835746408261 1.253443587130081e-07 0.1707596463148658 1.25344500843447e-07 0.1690680578777541 1.253446165530702e-07 0.1676985735146403 \
1.253447220270832e-07 0.166456424915798 1.253448165437425e-07 0.1653485352650968 1.253449121811146e-07 0.1642320043563913 1.253450092529585e-07 0.1631032360400927 \
1.253451083042124e-07 0.161956192050434 1.253452022277692e-07 0.1608730077890209 1.253452875034443e-07 0.1598934595213354 1.253453878832364e-07 0.1587475631033795 \
1.253454721860728e-07 0.1577906478848196 1.25345574585582e-07 0.1566342854655733 1.253456519798444e-07 0.1557646215197878 1.253457443247583e-07 0.154731814591042 \
1.253458145762303e-07 0.1539498814072817 1.253459107506593e-07 0.1528844393027091 1.253459875753224e-07 0.152038051282755 1.253460663454742e-07 0.1511758489440315 \
1.253461402383946e-07 0.150370438825067 1.253462079361382e-07 0.1496353997608715 1.253463040000261e-07 0.1485973848112393 1.25346373572453e-07 0.1478489919002561 \
1.253464574616254e-07 0.1469503328160803 1.253465185934615e-07 0.146298213254472 1.253465908615431e-07 0.1455309799806117 1.253466633001063e-07 0.1447677488542132 \
1.253467442811468e-07 0.1439178685120187 1.253468103556157e-07 0.1432275520600639 1.253468877561137e-07 0.1424219220725307 1.253469771315706e-07 0.1414956876531561 \
1.253470479922163e-07 0.1407644282175171 1.253471468792833e-07 0.1397487730030469 1.253472241981923e-07 0.1389620820751095 1.253473062434185e-07 0.1381330876879582 \
1.2534739435453e-07 0.1372467208126059 1.25347461981677e-07 0.1365690714953818 1.253475422788589e-07 0.1357674830239305 1.253476170628882e-07 0.1350239185327315 \
1.253476850640654e-07 0.1343502586094245 1.253477317469739e-07 0.1338891847862563 1.253478209985674e-07 0.1330118383700247 1.253478592216168e-07 0.1326395291833771 \
1.253479282135268e-07 0.1319690872918072 1.253479809615963e-07 0.1314578750898332 1.253480639543784e-07 0.1306559489775353 1.253481041328288e-07 0.1302688434457458 \
1.253481966502028e-07 0.1293805059784019 1.253482353685699e-07 0.1290098403727171 1.253483091292851e-07 0.1283055160094505 1.253483707572868e-07 0.1277188748199021 \
1.253484427849764e-07 0.1270353589407805 1.253485109520081e-07 0.1263909833196726 1.253485855741693e-07 0.1256908956540175 1.25348667426635e-07 0.1249253613889138 \
1.253487508807973e-07 0.124147338931438 1.25348823832511e-07 0.1234692772477456 1.253488965594407e-07 0.122795332839617 1.253489565494356e-07 0.1222410931008323 \
1.253490429174471e-07 0.121445549533078 1.253491038861646e-07 0.1208856452315438 1.253491622719555e-07 0.1203507897957366 1.253492279066197e-07 0.119751336354628 \
1.253492872608612e-07 0.1192111367930785 1.253493552926419e-07 0.1185941868697126 1.25349452587012e-07 0.11771710490035 1.253495310789918e-07 0.1170124163111649 \
1.25349621315123e-07 0.1162055395685231 1.253497171618085e-07 0.1153523005684616 1.253497921195047e-07 0.1146878351828532 1.253498964789213e-07 0.1137670532163148 \
1.25349983267518e-07 0.1130053589403202 1.25350092924934e-07 0.1120476726212376 1.253501744789968e-07 0.1113387926087848 1.253502700926292e-07 0.1105114393564785 \
1.253503468048225e-07 0.10985058581598 1.253504417232868e-07 0.1090364400125625 1.253505175463918e-07 0.1083889268999046 1.253505952460493e-07 0.1077282965354292 \
1.253506775775e-07 0.1070311517075373 1.253507371427637e-07 0.1065286079538068 1.253508009005013e-07 0.1059924133642201 1.253508619951089e-07 0.1054803128126646 \
1.253509578588471e-07 0.1046801683739134 1.253510027219416e-07 0.1043071445723913 1.253510859626872e-07 0.1036173314376927 1.25351135082509e-07 0.1032117000904133 \
1.253512441312713e-07 0.1023149933518279 1.253512889673535e-07 0.1019479364619093 1.253513792285848e-07 0.1012117400678687 1.25351420105203e-07 0.1008795969612472 \
1.25351490563617e-07 0.1003088525914566 1.253515768510382e-07 0.09961307626065434 1.253516686285974e-07 0.09887705578174606 1.253517381566897e-07 0.09832225024344161 \
1.25351816683849e-07 0.09769854072774181 1.253519074125254e-07 0.09698178745350861 1.25351983228664e-07 0.09638605854785212 1.253520652414071e-07 0.09574500473888557 \
1.253521469944435e-07 0.09510943278387665 1.253522375022672e-07 0.09440967388330095 1.253523270615646e-07 0.09372126988887708 1.253524126713984e-07 0.09306698857649189 \
1.253525054508965e-07 0.09236212353634379 1.253525863388571e-07 0.0917510971760913 1.253526874678274e-07 0.09099177263830999 1.253527679613525e-07 0.09039108594384238 \
1.253528522042178e-07 0.08976589684797046 1.253529260492652e-07 0.08922077348043934 1.253530028987434e-07 0.08865632925481931 1.253530910391125e-07 0.08801255002475737 \
1.253531711034816e-07 0.08743108261130086 1.253532641396717e-07 0.08675939571108145 1.253533821403849e-07 0.08591369538214398 1.253535245136124e-07 0.08490278100234279 \
1.253536687619621e-07 0.08388867104764453 1.253538110896711e-07 0.08289807427203813 1.253539606674147e-07 0.08186746790234835 1.253540969811606e-07 0.08093761126893445 \
1.253542391015919e-07 0.0799778356000513 1.253543736550197e-07 0.07907840240745091 1.253545140077296e-07 0.07814980287393705 1.253546616898023e-07 0.0771833418413561 \
1.253548118052992e-07 0.07621180464723754 1.253549765257765e-07 0.07515824360926991 1.253551401551281e-07 0.07412455432658185 1.25355314933688e-07 0.07303438636984133 \
1.253555021863042e-07 0.07188220095900363 1.253557122313082e-07 0.07060976590783831 1.253559304415312e-07 0.06930979572898451 1.253561638986196e-07 0.06794333957253913 \
1.25356418744638e-07 0.06648001693367038 1.253567118391949e-07 0.06483321328442151 1.253570141789572e-07 0.06317411115207273 1.253573287658326e-07 0.06148945259513613 \
1.253577250265267e-07 0.05942677493938087 1.253580587436719e-07 0.05774249301432461 1.253584660545012e-07 0.05574994498853819 1.253587939392599e-07 0.05419380357502902 \
1.25359150629899e-07 0.05254809000207299 1.253594638680598e-07 0.05114243792209583 1.253597668351931e-07 0.04981740498512215 1.253600643757185e-07 0.04854875663330436 \
1.253603431552738e-07 0.04739109061078805 1.253606261551693e-07 0.04624570307560639 1.253608878954772e-07 0.04521055793698023 1.253611671343699e-07 0.04413130357485813 \
1.253614392402902e-07 0.0431040186124033 1.253617466070472e-07 0.04197194005652995 1.25361968409948e-07 0.04117329707315532 1.253622748704283e-07 0.04009446155587663 \
1.253625010598812e-07 0.03931650950691581 1.253627399772065e-07 0.03851359500741255 1.253629644010393e-07 0.03777663690506906 1.253631666633204e-07 0.03712468825868943 \
1.253633677059489e-07 0.03648814235703791 1.253637194799833e-07 0.03540095449820539 1.253639697258209e-07 0.03464776841732944 1.253642160441008e-07 0.03392252499723709 \
1.253644973769647e-07 0.03311308780599518 1.253647404679504e-07 0.03242954897046491 1.253649759417007e-07 0.03178112583711486 1.25365217601206e-07 0.03113119522156456 \
1.253654544834836e-07 0.03050988948014832 1.25365685016041e-07 0.02991733361391674 1.253658989845686e-07 0.02937801894285819 1.253661049271158e-07 0.02886851641492237 \
1.253664976516028e-07 0.02792196059063811 1.25366685729283e-07 0.02747992420741849 1.253670611682489e-07 0.02661861215736662 1.253672360424775e-07 0.02622659266649364 \
1.253676593654916e-07 0.02530049759795254 1.253677806148756e-07 0.02504150687334681 1.253682211765283e-07 0.02412433837770948 1.253683636746477e-07 0.02383402682615681 \
1.253686957281575e-07 0.02316883068419595 1.253688786936821e-07 0.02280879143785283 1.25369267997886e-07 0.02205689891561978 1.253694363435941e-07 0.02173705378531499 \
1.253699084579933e-07 0.02085107653961301 1.253700482027269e-07 0.0205916297664938 1.253705437828048e-07 0.01969297428531048 1.253706710082374e-07 0.01946923320191776 \
1.253712389173419e-07 0.01851512288677271 1.253714031712902e-07 0.0182513999453204 1.253720130430286e-07 0.0173209960017622 1.253721727282572e-07 0.01708922829277545 \
1.253726996397978e-07 0.01635462467776483 1.253729041570907e-07 0.01608193551804103 1.253736276344778e-07 0.01515939662837778 1.253737930766099e-07 0.01495683325581705 \
1.253745396363563e-07 0.01408081084911163 1.253746729395689e-07 0.01393008075245666 1.253755331241552e-07 0.01299799962960837 1.253756692055701e-07 0.01285670227674402 \
1.253766097994594e-07 0.01192267652923807 1.253767735725333e-07 0.01176632439256516 1.253777747514646e-07 0.01084959205883911 1.253779122291873e-07 0.01072929995296418 \
1.253790829267985e-07 0.009787962024485789 1.253791753231659e-07 0.009718668544398181 1.253805933990138e-07 0.008725931027897449 1.253806803751621e-07 0.00866912727384293 \
1.253822213707926e-07 0.00770199130002063 1.253823306868068e-07 0.007633428668288294 1.253839739346293e-07 0.006673746291950173 1.253841067919082e-07 0.006603544020797993 \
1.253862011722063e-07 0.005605323336654431 1.253864095769411e-07 0.00551468736035817 1.25388763913366e-07 0.004577307911602986 1.253892374721228e-07 0.004407121484391641 \
1.253921229089796e-07 0.003492041675788492 1.253926525733265e-07 0.00334538389506189 1.253968608005519e-07 0.00237996320858989 1.253973742348033e-07 0.002283557532494709 \
1.254031334854955e-07 0.001325291758975802 1.254033680667129e-07 0.001279502680325907 1.254180358940879e-07 0.0002809017338477542 1.2541814896418e-07 0.0002788534805396912 \
1.280551690439302e-07 -0.0006849217749926401 1.280553352056058e-07 -0.0009443270389602415 1.28055814074993e-07 -0.001850320037528519 1.280559067946197e-07 -0.002050462221988249 \
1.280562720196971e-07 -0.002913187630468476 1.280563636768137e-07 -0.00314709230904735 1.280567297831652e-07 -0.004133001189868674 1.280568399302907e-07 -0.004442309109773816 \
1.280571506685429e-07 -0.005311341427314526 1.280572524071878e-07 -0.005583925258601597 1.280576161113131e-07 -0.00638370916272213 1.280577809576365e-07 -0.006585924750287024 \
1.280583607549566e-07 -0.005792290386912202 1.280585355894154e-07 -0.004916934050781314 1.280586522790152e-07 -0.00413641027497409 1.280587787087077e-07 -0.00310656561120747 \
1.280588807309106e-07 -0.002137079422087956 1.28059000577393e-07 -0.0008406209844352954 1.280590912146293e-07 0.0002489246187367611 1.280591896346795e-07 0.001536790859923857 \
1.280592893583236e-07 0.002948496343048522 1.280594568423325e-07 0.005545701385567424 1.280596754209339e-07 0.009327395936412004 1.280598614912559e-07 0.0128572688386996 \
1.280600828738638e-07 0.01737012273305725 1.280602435339974e-07 0.02082840415615294 1.28060406999647e-07 0.02447866954313523 1.280605576351642e-07 0.02794359528291388 \
1.280607066909169e-07 0.03145289236167962 1.280608561536706e-07 0.03504014479003619 1.280610101846837e-07 0.03879791952579481 1.280611723009431e-07 0.04280891157365373 \
1.280613383304077e-07 0.04696567134311741 1.280615142832281e-07 0.05141478668696391 1.280616949538656e-07 0.05602187592747932 1.280618867748118e-07 0.06094655248807559 \
1.280620938803164e-07 0.06629309753158302 1.280623154520462e-07 0.07203901748582854 1.280625501862155e-07 0.07814662931008168 1.280628017257829e-07 0.08470684589377442 \
1.280630771678493e-07 0.09190125212984442 1.280633773636676e-07 0.09974607960254324 1.280637082958779e-07 0.108390578238945 1.280640839626117e-07 0.1181923833971668 \
1.280644815454798e-07 0.1285487285136021 1.280649483700824e-07 0.1406786766767902 1.280654913626172e-07 0.1547396794802719 1.2806612478764e-07 0.1710742296429572 \
1.280668207276907e-07 0.1889259607126788 1.280676362848005e-07 0.2097135943149445 1.280685463129037e-07 0.2327316641523666 1.280693395691243e-07 0.2526372689279454 \
1.280700450441999e-07 0.2702038474981599 1.280706639884678e-07 0.2855008995781749 1.280712310944079e-07 0.2994177966724069 1.280717541744141e-07 0.3121574438576628 \
1.280722531532068e-07 0.3242197130846058 1.280727371932144e-07 0.3358335658028451 1.280731924200473e-07 0.3466679577370423 1.280736669320092e-07 0.3578644504627745 \
1.280741068407172e-07 0.368158604789619 1.28074592685345e-07 0.3794271463718566 1.280751242881185e-07 0.3916316501999784 1.280756269514167e-07 0.4030538969706937 \
1.280760560236697e-07 0.4127111343288326 1.280765470403382e-07 0.4236561147984291 1.280770484704186e-07 0.434714731975362 1.280773950150088e-07 0.442288187401736 \
1.280777504243856e-07 0.4500000616404133 1.280781776521144e-07 0.4592019891792938 1.28078569851637e-07 0.4675774400278049 1.280788702333952e-07 0.4739448723400065 \
1.280792120451549e-07 0.4811381049525967 1.280795554849688e-07 0.4883107756756314 1.280798162200955e-07 0.4937186470393492 1.280800582500486e-07 0.4987071765458648 \
1.280803241952915e-07 0.5041573145298286 1.280805814645869e-07 0.509394255416739 1.280807715836905e-07 0.5132422368582924 1.280809851098511e-07 0.5175451019736222 \
1.280811248001571e-07 0.5203466115392713 1.280812710004491e-07 0.5232668091041763 1.280814849883502e-07 0.5275186200231483 1.280816930046097e-07 0.5316389396023125 \
1.280818854658791e-07 0.5354321131715788 1.280820705821105e-07 0.5390651926504321 1.280822449555568e-07 0.5424725330931349 1.280825494976334e-07 0.5484058192982523 \
1.280828100565151e-07 0.5534602958276967 1.280831114875446e-07 0.5592859190791987 1.280833658051381e-07 0.5641865993769294 1.280836586613278e-07 0.5698153316805189 \
1.280839178744799e-07 0.5747800306938655 1.280841889508119e-07 0.579963273174682 1.280844307945714e-07 0.5845680738798381 1.280846882997289e-07 0.5894577538325241 \
1.280849150436047e-07 0.5937419314630586 1.280851520444244e-07 0.5982006324572362 1.280853622309863e-07 0.6021379329905048 1.280855749915204e-07 0.6061060319396779 \
1.280858278702861e-07 0.6107954169450593 1.280860315335545e-07 0.6145509252949414 1.280862222509359e-07 0.6180531102377972 1.280864095873744e-07 0.6214768531423983 \
1.28086598465652e-07 0.6249070011644339 1.280868066654474e-07 0.6286671070650327 1.280870509975622e-07 0.6330499453121026 1.280872505640949e-07 0.6366057789565548 \
1.280874547098357e-07 0.6402215701419991 1.2808763934909e-07 0.643474671963314 1.28087908884781e-07 0.6481901084955864 1.280881365916373e-07 0.652149230294136 \
1.280883242633752e-07 0.6553888277830079 1.280885051635202e-07 0.6584949378977958 1.280886647046019e-07 0.661221510907812 1.280888351670024e-07 0.6641177016088209 \
1.280889869184432e-07 0.6666817235716488 1.280891245614551e-07 0.6689905419339194 1.280892735563186e-07 0.6714784915997724 1.280894012981823e-07 0.6736028790357499 \
1.280895442846951e-07 0.675968899142866 1.280896660677513e-07 0.6779749688503388 1.280898023511611e-07 0.6802121872853304 1.280899221800626e-07 0.682172759947357 \
1.280900687756234e-07 0.6845626218370968 1.28090187248565e-07 0.6864845934661837 1.280902831819268e-07 0.6880368302455475 1.280903757015115e-07 0.6895284278106264 \
1.280904807620225e-07 0.6912169000724893 1.280905788439078e-07 0.6927871490736753 1.280907159592253e-07 0.6949707622226827 1.28090835157868e-07 0.6968607547931925 \
1.280909450978383e-07 0.6985951241089645 1.280910825970815e-07 0.7007503743809057 1.280912140269832e-07 0.7027960765825516 1.280913462564987e-07 0.7048392108129343 \
1.280914594338973e-07 0.7065756917706891 1.280916138667517e-07 0.708927873976708 1.280917446467452e-07 0.7109048231498766 1.280918673154548e-07 0.7127465601965561 \
1.280919735837112e-07 0.7143329262278221 1.280920959637349e-07 0.7161490373358268 1.280921978172318e-07 0.7176517022913665 1.280923319551315e-07 0.7196190116794019 \
1.280924526481717e-07 0.7213783352064487 1.280925717899705e-07 0.7231049829175343 1.280926968079846e-07 0.7249059312823601 1.280928266477907e-07 0.7267645120560844 \
1.280929464599617e-07 0.7284691779696002 1.280930754532131e-07 0.730293808329565 1.280932075602774e-07 0.7321507998840678 1.280933258660953e-07 0.7338038328985433 \
1.280934691267862e-07 0.7357927618453034 1.280935715814729e-07 0.7372070005703254 1.280936677883586e-07 0.7385290937783453 1.280937728059804e-07 0.7399656334130889 \
1.280938835775113e-07 0.7414708009413548 1.280939852560522e-07 0.7428439364018735 1.280940882175066e-07 0.7442258341871242 1.280942051436606e-07 0.7457850038572696 \
1.280943339039365e-07 0.747489965072781 1.28094435062908e-07 0.7488201182152049 1.280945839319523e-07 0.7507626302114226 1.280947316114891e-07 0.75267249971878 \
1.280948509768551e-07 0.7542038164026367 1.280949974606996e-07 0.7560679527984652 1.280951206361903e-07 0.7576223900169708 1.280952614398646e-07 0.7593848990234215 \
1.280953980325311e-07 0.7610800595258669 1.280955201903812e-07 0.7625841275516777 1.280956328467787e-07 0.7639610711610054 1.280957745729197e-07 0.7656796138775311 \
1.280959007394198e-07 0.767196844592689 1.280960161567243e-07 0.768574452686535 1.28096146464904e-07 0.7701179991486644 1.280962621775718e-07 0.7714782821591826 \
1.280963850018603e-07 0.7729116492687436 1.280965028461285e-07 0.7742769236963016 1.280966084761186e-07 0.7754922619072108 1.280967238495534e-07 0.7768108638983861 \
1.280968291127158e-07 0.7780056027231214 1.28096940062529e-07 0.7792565499870431 1.280970264670306e-07 0.7802246528436213 1.280971305008506e-07 0.7813823422463088 \
1.28097244396594e-07 0.7826398494046257 1.280973474300136e-07 0.7837684443710583 1.280974555127141e-07 0.7849432998269023 1.280975637643697e-07 0.7861107422109641 \
1.280976991816164e-07 0.7875582910536544 1.280978118557238e-07 0.7887521292973186 1.280979362797841e-07 0.7900592323105087 1.28098054252648e-07 0.7912877959129118 \
1.280981987206026e-07 0.7927781272271259 1.280983163897418e-07 0.7939806363584788 1.280984522695815e-07 0.7953567374150946 1.280985870139539e-07 0.7967081403609936 \
1.280986980849332e-07 0.7978123285366109 1.280987979742732e-07 0.7987978371087655 1.280988996542306e-07 0.7997937268659365 1.280990328678971e-07 0.8010867894381996 \
1.280991512407163e-07 0.8022243628210853 1.280992727817905e-07 0.8033812848148773 1.280993921454424e-07 0.8045065422543012 1.280995132768188e-07 0.80563739819571 \
1.280996449762361e-07 0.8068544426691319 1.280997679845129e-07 0.8079795872959963 1.280998958281203e-07 0.8091371804586788 1.281000267346398e-07 0.8103101881504271 \
1.28100150327798e-07 0.8114062915203997 1.28100257500303e-07 0.8123479140825919 1.281003649295024e-07 0.8132835730547656 1.281004475986206e-07 0.8139979974227743 \
1.281005653103806e-07 0.8150069815425507 1.281006559159858e-07 0.8157770472204025 1.281007865694307e-07 0.8168774959419571 1.28100930959301e-07 0.8180800468042847 \
1.281010641337151e-07 0.8191766687328477 1.281011740251065e-07 0.8200725423139092 1.281013176239916e-07 0.8212302325252553 1.281014710146833e-07 0.8224508494407716 \
1.281015990929081e-07 0.8234574467428303 1.281017388802764e-07 0.8245431382086058 1.281018651298391e-07 0.8255122018650548 1.281020197283917e-07 0.8266841987320058 \
1.281021519393684e-07 0.8276738265999063 1.281022781661507e-07 0.8286078934539939 1.281023959138743e-07 0.8294698388787296 1.281025449866676e-07 0.8305480062617677 \
1.281027123182206e-07 0.8317406852496945 1.281028455394968e-07 0.8326770812274722 1.281030183208196e-07 0.8338744310092966 1.281031868261935e-07 0.8350236380668206 \
1.281033562054924e-07 0.8361608866600232 1.281035378407611e-07 0.8373606451951652 1.281036801740827e-07 0.8382866867625347 1.281037940110689e-07 0.8390185116470331 \
1.28103925192579e-07 0.8398522525089582 1.28104026724794e-07 0.8404903982372576 1.281041430090543e-07 0.8412135669902132 1.281042776438078e-07 0.8420406924792603 \
1.281044746666439e-07 0.8432316292878405 1.281046647721864e-07 0.8443592803112207 1.281048748954986e-07 0.8455816023960827 1.281050552136043e-07 0.8466107566581813 \
1.281052526767048e-07 0.8477171937062282 1.281054267458196e-07 0.8486750118570332 1.281056090652401e-07 0.8496608982186138 1.281057804803758e-07 0.8505716849290491 \
1.281059545936529e-07 0.8514808063694008 1.281061303246211e-07 0.8523822271368225 1.281063064363214e-07 0.8532696099472232 1.281064960541732e-07 0.8542074684498208 \
1.281066868356705e-07 0.8551330189126392 1.28106888431747e-07 0.8560917259710515 1.281070811660049e-07 0.856990088884472 1.281072900378257e-07 0.8579439907476532 \
1.281075207402632e-07 0.8589743400177088 1.281077851832273e-07 0.8601259267840322 1.281080840059149e-07 0.8613896125360476 1.281083639602159e-07 0.8625380186322354 \
1.281086480860817e-07 0.8636694076724545 1.28108922855057e-07 0.8647317823994775 1.281091947122167e-07 0.8657531067718063 1.281094650893343e-07 0.8667403371654003 \
1.281097221678556e-07 0.8676533221001362 1.281099947926866e-07 0.868594905839151 1.281102707598356e-07 0.8695208838709013 1.281105408640933e-07 0.8704012674911344 \
1.281108407401039e-07 0.8713491368600049 1.281112118011625e-07 0.8724801680184872 1.2811150674079e-07 0.8733472453740196 1.28111761036548e-07 0.8740729094291386 \
1.281120592974738e-07 0.8748989982677786 1.281123329040153e-07 0.8756336613858092 1.281125690299577e-07 0.876250392688866 1.281128093740557e-07 0.8768621356511911 \
1.281130317061818e-07 0.8774140071409635 1.28113225712247e-07 0.8778848105679672 1.281135554349973e-07 0.8786625669521169 1.281137106085256e-07 0.8790190643519731 \
1.281140283876062e-07 0.879730644938159 1.281142072488645e-07 0.8801204696806418 1.281145497107611e-07 0.8808457867651537 1.281147338373631e-07 0.8812245477320809 \
1.28115208711942e-07 0.8821665346129511 1.281153761083518e-07 0.8824869809105039 1.281158419518539e-07 0.883348261932613 1.281160227735483e-07 0.8836708855253055 \
1.281165168126507e-07 0.8845204537290557 1.281166581620591e-07 0.8847551796839913 1.281172645001219e-07 0.8857215808967022 1.281174165693362e-07 0.8859539944113424 \
1.28118063256356e-07 0.8869009218298172 1.281181915512387e-07 0.8870812460539503 1.28118839667745e-07 0.8879562712787433 1.281189694676407e-07 0.8881245027440973 \
1.281197476783404e-07 0.8890830197250962 1.281198627254718e-07 0.8892171882189283 1.281207183963142e-07 0.8901564861234483 1.281208637440773e-07 0.8903061494816453 \
1.281218494996487e-07 0.8912466483555094 1.281220706077111e-07 0.8914402669210102 1.281232157277145e-07 0.892367747196105 1.281233469391586e-07 0.8924695935232408 \
1.281246882116238e-07 0.8934615053489913 1.281248396029001e-07 0.8935661991834861 1.281263210551204e-07 0.8944951400107031 1.281265599348161e-07 0.8946288932334222 \
1.281283293566539e-07 0.895502508848118 1.281287184779452e-07 0.895670668133377 1.281311122106538e-07 0.8965556062201232 1.281315877505926e-07 0.8967047758494365 \
1.281356508198176e-07 0.8977025964496719 1.281361422956535e-07 0.8977953148389237 1.281444588927963e-07 0.8987880790885289 1.281453787942481e-07 0.8988514070442593 \
1.282992423701678e-07 0.8998485708192639 1.283028854964575e-07 0.8998628537402877 1.285296142766717e-07 0.8989664306490068 1.285298446165833e-07 0.8988008565867064 \
1.285314595368805e-07 0.897804750401333 1.285316372691665e-07 0.8977103535805105 1.285484036692715e-07 0.8986978311584225 1.285485397684025e-07 0.8987160394686986 \
1.285637106086718e-07 0.8997133888183054 1.285639877135078e-07 0.899719468756186 1.290480289064218e-07 0.9005852143835333 1.290482022410388e-07 0.9007408621809421 \
1.290488627306383e-07 0.9015135064485434 1.290490287958205e-07 0.9017527716291757 1.29049555130528e-07 0.9026184054967997 1.290497462444476e-07 0.9029704910143604 \
1.290501104654996e-07 0.9036902342402512 1.290502896649215e-07 0.9040628043424317 1.290506515515938e-07 0.9048333795345931 1.290508466611638e-07 0.9052442844328937 \
1.290513790595253e-07 0.9062266394381637 1.290515614131638e-07 0.9064623886473868 1.290525533935561e-07 0.905594670761786 1.290527149341233e-07 0.9049318860608667 \
1.290528829265756e-07 0.9040378649110347 1.290530427580612e-07 0.9029782421366458 1.29053180254799e-07 0.9018984154159868 1.290533131621115e-07 0.9007052793196499 \
1.290534395875788e-07 0.8994328447569792 1.290535469868187e-07 0.8982475863895881 1.290536514834769e-07 0.8970047013543965 1.290537655331467e-07 0.8955451342423859 \
1.290538555027343e-07 0.8943225684615312 1.290539603213726e-07 0.8928208677113324 1.290540497696119e-07 0.891473284704788 1.290541321453926e-07 0.8901820884368528 \
1.290542232383926e-07 0.8887006634027688 1.290543605744706e-07 0.8863657732814155 1.290544590674027e-07 0.8846195012157601 1.290545711411528e-07 0.8825649218508906 \
1.290547020241858e-07 0.880080778639088 1.290548384952159e-07 0.8774018563482072 1.290549919493788e-07 0.8742910281085086 1.290551510437468e-07 0.8709679977889497 \
1.290553153276494e-07 0.867445283300377 1.290554719957507e-07 0.8640104344288071 1.290556240865311e-07 0.860615744772629 1.290557778002064e-07 0.857132398554192 \
1.290559373623814e-07 0.853469801378647 1.290560924510829e-07 0.8498714074018293 1.290562661304016e-07 0.8458039138600054 1.290564291612694e-07 0.8419559450883216 \
1.29056590803684e-07 0.8381170660338335 1.290567534504206e-07 0.8342344554797501 1.290569148689274e-07 0.8303657475978833 1.29057083463406e-07 0.8263109424305363 \
1.290572663565043e-07 0.8219002364007665 1.290574341852182e-07 0.8178440888239877 1.290576024710332e-07 0.8137703061148112 1.290577732990847e-07 0.8096302849976138 \
1.290579454736422e-07 0.8054541271740473 1.290581132355611e-07 0.8013830614994394 1.290582968650184e-07 0.7969255463994016 1.290584682714963e-07 0.7927646873948894 \
1.290586537148024e-07 0.7882638003278283 1.290588203854536e-07 0.7842196820467244 1.290589892715848e-07 0.7801233737411432 1.290591734278819e-07 0.7756572567105651 \
1.290593680379105e-07 0.7709405333854473 1.290595152932414e-07 0.7673736106648734 1.29059641923832e-07 0.7643079795643375 1.290597837806443e-07 0.7608754495129878 \
1.290598881844221e-07 0.7583505812556488 1.290600205770739e-07 0.7551502542766809 1.290601301612705e-07 0.7525028097975122 1.290602633259231e-07 0.7492875979647342 \
1.290604195076852e-07 0.7455190770546114 1.290605327371121e-07 0.7427887939149777 1.290606952584764e-07 0.7388718945951063 1.290608674392915e-07 0.7347246296492568 \
1.29061063444044e-07 0.7300078517193382 1.290612278340229e-07 0.7260553905833119 1.290613802307036e-07 0.7223944885043934 1.290615439058578e-07 0.718466402706526 \
1.29061711831558e-07 0.7144406657912139 1.290618916719358e-07 0.7101336212543717 1.290620679658861e-07 0.7059164985576465 1.290622390405214e-07 0.7018286413152719 \
1.29062407358697e-07 0.6978099102718778 1.290625606248287e-07 0.6941537154717222 1.290627225083983e-07 0.6902960245155986 1.290629014599385e-07 0.6860364417190952 \
1.290630356714899e-07 0.6828448068431195 1.290631391777878e-07 0.6803854168085423 1.290632384622005e-07 0.6780286039046017 1.290633399166766e-07 0.6756220912380299 \
1.290634323732757e-07 0.6734303711245889 1.29063516962075e-07 0.6714267031582685 1.290636105394115e-07 0.6692114082407524 1.290637270816307e-07 0.6664546942583044 \
1.290638365591918e-07 0.6638675763958631 1.290639496722031e-07 0.6611971533414394 1.290640727909702e-07 0.6582923426231613 1.29064197017283e-07 0.6553636581362478 \
1.290643677774271e-07 0.6513432847262797 1.290645262260144e-07 0.6476181700514572 1.290646985138371e-07 0.6435738126612673 1.290648444919037e-07 0.6401512360303271 \
1.290649862851197e-07 0.6368325564797357 1.290651178835739e-07 0.6337564355289309 1.290652480468588e-07 0.630718219665797 1.290653735717996e-07 0.6277924818644975 \
1.290655053547071e-07 0.6247239543970449 1.290656352782026e-07 0.6217046839485236 1.290657715867779e-07 0.6185408917806742 1.290659162003453e-07 0.615188962872713 \
1.29066075692536e-07 0.611499189008522 1.290662491526524e-07 0.6074939486938447 1.290664201599544e-07 0.6035554342946753 1.290666515285226e-07 0.5982402936372396 \
1.290668949905284e-07 0.5926661367297537 1.29067069111016e-07 0.5886942528256315 1.290672153830935e-07 0.5853638081576373 1.290673497553116e-07 0.58231230528805 \
1.290674668502067e-07 0.5796585826255305 1.290675626145532e-07 0.5774900935424465 1.290676614610955e-07 0.5752566196463251 1.290677454384143e-07 0.5733628024369305 \
1.290678230524635e-07 0.571614165956722 1.290678843779373e-07 0.5702331258704825 1.290679490585756e-07 0.5687779664863769 1.290680303667114e-07 0.5669528575016536 \
1.290680804367073e-07 0.5658306078972934 1.290681297572688e-07 0.5647256890740617 1.29068191677069e-07 0.5633393552914843 1.290682395088943e-07 0.5622690492396486 \
1.290682900136796e-07 0.5611395143522533 1.290683500757169e-07 0.559799205480933 1.290684093585124e-07 0.5584782058326896 1.290684844152261e-07 0.5568072508052372 \
1.290685540978827e-07 0.5552574373576753 1.290686396864492e-07 0.5533559356568912 1.290687267538207e-07 0.5514265885063823 1.290688104163414e-07 0.5495763264044081 \
1.290688965613662e-07 0.5476734676082877 1.290689922659868e-07 0.5455621222678217 1.290690965509387e-07 0.5432673229847179 1.290692112181133e-07 0.5407497407899529 \
1.290693199365745e-07 0.5383664115638558 1.290694295088142e-07 0.5359693749054023 1.290695418135745e-07 0.5335193270114367 1.290696685891956e-07 0.530759392645703 \
1.290697908664272e-07 0.5281021910076299 1.290699309524049e-07 0.5250685463469849 1.290700679697626e-07 0.5221084647952599 1.29070218271135e-07 0.5188705764247719 \
1.290703771663761e-07 0.5154582091324615 1.290705515002589e-07 0.5117250894133971 1.29070738517481e-07 0.5077378180012799 1.290709438354859e-07 0.5033745272871338 \
1.290711556776788e-07 0.498891131759938 1.29071408479721e-07 0.4935662239713107 1.2907161056737e-07 0.4893264048484654 1.290718451606753e-07 0.4844277613141263 \
1.290720812752722e-07 0.4795194943790256 1.290723344517689e-07 0.474283574581623 1.290726449817317e-07 0.4679020429045382 1.290728630397103e-07 0.4634451779596257 \
1.290730364853444e-07 0.4599153839204358 1.290732129777809e-07 0.4563351808422506 1.290734924595775e-07 0.4506930409909046 1.290737247034844e-07 0.4460279192631412 \
1.290740117970732e-07 0.44029020239849 1.290742296431809e-07 0.435960758243863 1.290744396957687e-07 0.4318042429497612 1.290746408936045e-07 0.4278406951573778 \
1.290748233137656e-07 0.4242617300271556 1.290749972087507e-07 0.4208637793449936 1.290751620728668e-07 0.4176529694331993 1.290753208268398e-07 0.4145718140694327 \
1.290754870737866e-07 0.4113577680628809 1.290756357189934e-07 0.4084923702366076 1.290757880872491e-07 0.4055658186126443 1.290759301504318e-07 0.4028468403491589 \
1.290760995263099e-07 0.3996150665462138 1.290762199082301e-07 0.3973276483660343 1.290763298814939e-07 0.3952449223617059 1.290764448068949e-07 0.3930732253581283 \
1.290765970484751e-07 0.3902080468194818 1.290767092695403e-07 0.3881039677199808 1.290768164620408e-07 0.386098874836553 1.290769689902897e-07 0.383254723448244 \
1.290770971374193e-07 0.380874963946598 1.290772199854117e-07 0.3786015923730871 1.290773990837881e-07 0.375299968600122 1.290775481684202e-07 0.3725653942578417 \
1.290777158758077e-07 0.3695018296724824 1.290778712734425e-07 0.3666748141177644 1.290779954402882e-07 0.3644243980538668 1.290781093321555e-07 0.3623666676050148 \
1.29078230775526e-07 0.3601804966264144 1.290784109272934e-07 0.3569532670533712 1.290785774151136e-07 0.3539878629329621 1.29078767834223e-07 0.3506138544217919 \
1.290789595908186e-07 0.3472380408565978 1.290791426402121e-07 0.344035729794033 1.290792916122767e-07 0.3414435189591631 1.290794115521823e-07 0.3393660536257183 \
1.290795342136651e-07 0.3372483242714233 1.290796572441514e-07 0.3351324902755385 1.29079802148562e-07 0.3326515017845288 1.290799054613373e-07 0.3308907757076019 \
1.290799991908464e-07 0.3292979229163631 1.290800898511484e-07 0.3277620998585528 1.29080200972602e-07 0.3258853746017661 1.290803081455789e-07 0.3240820510456246 \
1.290804064202303e-07 0.3224338250618513 1.290805188247763e-07 0.3205545940512134 1.290806827646764e-07 0.3178277446588927 1.290808444025551e-07 0.3151576097143818 \
1.290809921893013e-07 0.3127316247504084 1.290811544345159e-07 0.3100832165115083 1.290813144650734e-07 0.3074868334344322 1.290814667283718e-07 0.3050304870660137 \
1.290816201002421e-07 0.3025703731928215 1.29081778808771e-07 0.3000411640344692 1.290819432578998e-07 0.297437246442505 1.290821104849764e-07 0.2948063590562646 \
1.290822635965136e-07 0.292412731930112 1.290824466944405e-07 0.2895700146919417 1.290826370021783e-07 0.2866380344427262 1.290827859052365e-07 0.2843603072871506 \
1.290829598425416e-07 0.2817165165722222 1.290831367199302e-07 0.2790484233348025 1.290832843171486e-07 0.2768363681311815 1.290834739488487e-07 0.2740172295061162 \
1.290836239507675e-07 0.2718052906662373 1.290837610609577e-07 0.2697943906627059 1.290839025914008e-07 0.2677397479842996 1.290840160502698e-07 0.2661005451260196 \
1.290841523405965e-07 0.2641384584581135 1.290842824172175e-07 0.2622807416655737 1.290844006714701e-07 0.2606037730704709 1.290845185270663e-07 0.2589348966568543 \
1.290846494208769e-07 0.2570853888657079 1.290847896596348e-07 0.2551145527343576 1.290849051542211e-07 0.2534976852533538 1.290850340055979e-07 0.2516957519945816 \
1.290851491515796e-07 0.2500885525459272 1.290853024625469e-07 0.2479513765689386 1.290854403163083e-07 0.2460367343642474 1.290855797779604e-07 0.2441002375748529 \
1.29085735245815e-07 0.2419427021952501 1.290858600284303e-07 0.2402176526454788 1.290859998933384e-07 0.2382916534360561 1.290861285955144e-07 0.2365220787132559 \
1.290862495543663e-07 0.234860341242685 1.290863665996657e-07 0.2332541163798121 1.290864926007302e-07 0.2315368940272461 1.290865893203229e-07 0.2302195772445239 \
1.290866814091961e-07 0.2289683907689286 1.290867958266674e-07 0.2274152998827935 1.290868941973141e-07 0.2260807986508055 1.290870113441077e-07 0.2244933520241092 \
1.290871144352257e-07 0.2231010305483718 1.290872199499518e-07 0.2216798666278746 1.290873008680117e-07 0.2205933880575098 1.290873745391968e-07 0.2196046443759679 \
1.290874172684338e-07 0.2190314036349237 1.29087460398579e-07 0.2184540235451489 1.290875111960607e-07 0.217774515685755 1.290875483709394e-07 0.217277430841393 \
1.29087589041954e-07 0.2167338127731004 1.290876318337555e-07 0.2161620985357572 1.290876682448971e-07 0.2156758299561118 1.290877101698878e-07 0.2151161507306283 \
1.290877647120985e-07 0.2143884526296278 1.290878031708565e-07 0.2138756926875936 1.290878427976257e-07 0.2133496230586122 1.290879046301276e-07 0.212531488259555 \
1.290879663565787e-07 0.2117156525305126 1.290880224938542e-07 0.210974237875411 1.290880861490837e-07 0.210134110843225 1.290881802401172e-07 0.2088936328424611 \
1.290882670483761e-07 0.2077505933124353 1.290883610050201e-07 0.2065146061917991 1.290884590472537e-07 0.2052266823513323 1.290885606346195e-07 0.2038976009052371 \
1.290886615435679e-07 0.2025832113009377 1.290887582793767e-07 0.2013244528083448 1.290888604043477e-07 0.1999972806373927 1.290889637359055e-07 0.1986583046056677 \
1.29089073618507e-07 0.1972379690671278 1.290891825607647e-07 0.1958337611883887 1.290893023958847e-07 0.1942937175364915 1.290894126797513e-07 0.1928822800638286 \
1.290895205584963e-07 0.191507108810815 1.290896466212543e-07 0.1899051957406391 1.290897364889608e-07 0.1887671190866151 1.290898469673e-07 0.1873723090993208 \
1.290899245002487e-07 0.1863971337376019 1.290900088239919e-07 0.1853400660204312 1.2909009641205e-07 0.1842452710069853 1.290901842046442e-07 0.18315095174413 \
1.290902659245155e-07 0.1821357652581398 1.290903634861928e-07 0.1809282658474054 1.290904701973441e-07 0.1796118512064394 1.29090570679026e-07 0.178377576484793 \
1.290906948502376e-07 0.1768595317522179 1.290908287417608e-07 0.1752320886156309 1.290909476539533e-07 0.1737937102924047 1.290910980541469e-07 0.1719851742607024 \
1.290912088892401e-07 0.1706594030660365 1.290913486559821e-07 0.168997130456427 1.290914671812902e-07 0.1675953052211382 1.29091572608521e-07 0.1663548750207849 \
1.290916673183802e-07 0.1652455210322802 1.290917606281544e-07 0.1641568522804657 1.290918615342705e-07 0.1629842804551663 1.290919569521023e-07 0.1618800504313296 \
1.290920541430255e-07 0.1607598891027116 1.290921357045071e-07 0.1598237474547246 1.290922410209519e-07 0.1586229753023833 1.290923245006587e-07 0.1576763029943549 \
1.290924260299495e-07 0.1565306813704828 1.290925032604858e-07 0.1556635090415242 1.29092594132523e-07 0.154647919213242 1.290926634838334e-07 0.1538765336840219 \
1.290927480678846e-07 0.1529397840535594 1.290928224610911e-07 0.1521208717489242 1.290929018312932e-07 0.151251902275755 1.290929764189645e-07 0.1504388356812226 \
1.290930456405212e-07 0.1496871728711989 1.290931403213281e-07 0.1486640077242138 1.29093210087093e-07 0.1479134441579097 1.290932945316558e-07 0.147008717574758 \
1.290933560970016e-07 0.1463518850554192 1.290934301394933e-07 0.1455673550676988 1.290935035250169e-07 0.1447940960774066 1.290935849602586e-07 0.1439395015691976 \
1.290936544094048e-07 0.1432139999234875 1.290937295111024e-07 0.1424323701137583 1.290938194231735e-07 0.1415006120834361 1.290938965067932e-07 0.1407052977810757 \
1.290939956173774e-07 0.1396885207473417 1.290940651574398e-07 0.138983077430453 1.290941464759156e-07 0.1381612812129989 1.290942166443247e-07 0.1374549162714094 \
1.290942956124378e-07 0.1366629455350578 1.290943745907205e-07 0.1358740351737466 1.290944469125105e-07 0.1351544405911459 1.290945162779692e-07 0.1344667589602006 \
1.290945649819766e-07 0.1339854049281765 1.290946557443483e-07 0.1330945614011112 1.290946877658758e-07 0.1327823711724506 1.290947758698441e-07 0.131925672678654 \
1.290948083638864e-07 0.1316105445757083 1.290949070315436e-07 0.1306564447580443 1.290949506875193e-07 0.130235859061297 1.290950286693357e-07 0.1294866595045693 \
1.290950660002937e-07 0.1291289430202982 1.290951681516938e-07 0.128153223240932 1.290952355956539e-07 0.1275115375392494 1.290953007486116e-07 0.1268935577290946 \
1.290953666546259e-07 0.1262729746041904 1.290954378066093e-07 0.1256052797936485 1.290955207439704e-07 0.1248293808775363 1.290956061394508e-07 0.1240331657139879 \
1.290956822268445e-07 0.1233259817834828 1.290957626875214e-07 0.1225806238777534 1.290958207714622e-07 0.1220441728027253 1.29095892104936e-07 0.1213870835332726 \
1.290959768933693e-07 0.1206085709991845 1.290960380484021e-07 0.1200487744399507 1.290961081348534e-07 0.1194096117168642 1.290961706401422e-07 0.1188419501154776 \
1.290962366450903e-07 0.1182453094891599 1.290963054178569e-07 0.1176255789053269 1.290963748744814e-07 0.1170017375875525 1.29096458038731e-07 0.1162574953874909 \
1.290965311562548e-07 0.1156056107435251 1.29096601870241e-07 0.1149774116339468 1.290966612219237e-07 0.1144518657417393 1.290967665191357e-07 0.1135239342411639 \
1.290968123866298e-07 0.1131212254602471 1.290968993406834e-07 0.1123603821649216 1.290969423544638e-07 0.1119852310621949 1.290969872212112e-07 0.1115947726395539 \
1.29097076954706e-07 0.1108164664143028 1.290971478390574e-07 0.110204256460374 1.290972266925708e-07 0.109525796983828 1.290972894703463e-07 0.1089876103666232 \
1.290973494647019e-07 0.1084750215669379 1.290974604624741e-07 0.1075310013968523 1.2909754121676e-07 0.1068475792877216 1.290976536800859e-07 0.1059005796323111 \
1.290977048246292e-07 0.1054717782906781 1.290977878097979e-07 0.1047785948356612 1.290978459745031e-07 0.1042945647727652 1.29097960212503e-07 0.1033482075721767 \
1.290980101159701e-07 0.1029366076865433 1.290980958575694e-07 0.1022320954501846 1.290981448890196e-07 0.1018307629303728 1.290982274554409e-07 0.101157455862875 \
1.290982983877772e-07 0.1005815064560546 1.290983665381274e-07 0.1000302812267231 1.290984441484433e-07 0.0994053199805509 1.290985164918144e-07 0.09882546240595018 \
1.29098594067778e-07 0.09820656846618626 1.290986827384394e-07 0.09750287271560702 1.290987565532273e-07 0.09692010793638871 1.290988381442348e-07 0.09627924899616347 \
1.290989162827031e-07 0.09566870926115327 1.290990020324936e-07 0.09500229249765579 1.290990897294021e-07 0.09432453920671229 1.290991836389668e-07 0.09360304191323381 \
1.290992800982852e-07 0.09286661217778783 1.290993587289458e-07 0.09226977907248698 1.290994614525456e-07 0.09149473120661993 1.290995452801959e-07 0.09086620530027881 \
1.290996660323777e-07 0.08996702094116031 1.29099795302029e-07 0.08901247130467421 1.290999511904932e-07 0.08787237469953549 1.291001062900762e-07 0.08675000010972149 \
1.291002633058824e-07 0.08562614142917294 1.291004433267348e-07 0.08435280068725284 1.291005938476015e-07 0.08330035525696428 1.291007422216238e-07 0.08227363395463329 \
1.291008798388548e-07 0.08133079092382095 1.291010197585049e-07 0.08038162993974078 1.291011563654934e-07 0.07946425488810546 1.291012950927908e-07 0.07854214404995859 \
1.291014404036529e-07 0.07758663187171365 1.29101588151466e-07 0.07662571164688473 1.291017467483332e-07 0.07560598447141591 1.29101911000851e-07 0.07456266320243836 \
1.291020800179273e-07 0.07350246718885647 1.29102261906921e-07 0.07237646636762114 1.291024625290194e-07 0.07115268999588262 1.291026764065622e-07 0.0698691158856425 \
1.291029040406938e-07 0.0685263410462881 1.291031456262355e-07 0.06712722147996912 1.29103427215414e-07 0.06552977831071743 1.291037243695346e-07 0.06388229915275011 \
1.291040478026115e-07 0.06213267023812474 1.29104438962031e-07 0.0600758559534558 1.29104840456333e-07 0.05803293250078725 1.291052173970595e-07 0.05617754872181892 \
1.291055845107909e-07 0.05442503025024555 1.291059346274713e-07 0.05280240270907886 1.291062539331247e-07 0.05136309724710254 1.291065582574072e-07 0.05002640192327024 \
1.291068551633126e-07 0.04875503464657577 1.291071371636386e-07 0.04757867888787161 1.291074175969433e-07 0.04643900623749339 1.291076823205669e-07 0.04538777697325767 \
1.291079582182789e-07 0.04431704973151576 1.291082326831433e-07 0.04327654260273706 1.291085311024235e-07 0.04217254828989973 1.291087576184799e-07 0.04135316230013186 \
1.291090695313176e-07 0.04025053053625379 1.291092897861088e-07 0.03948972371590862 1.291095070508635e-07 0.03875470657060948 1.291097167735126e-07 0.03806113111453101 \
1.291100269559001e-07 0.03705828856757609 1.291102495537778e-07 0.03635538859683734 1.29110496919279e-07 0.03559019656168042 1.291107693256556e-07 0.03476651972027592 \
1.291109899582094e-07 0.03411384091885184 1.291112742384598e-07 0.03329124852897781 1.291115121517525e-07 0.0326183788879464 1.291117502411637e-07 0.03195887699386461 \
1.291119854964917e-07 0.03132132139405813 1.291122142751987e-07 0.03071728735992773 1.291124470059479e-07 0.03011490821398154 1.291126663089891e-07 0.02955843195412813 \
1.291128702520595e-07 0.02905055018162466 1.291132691617956e-07 0.02808303002558106 1.291134563160508e-07 0.02764052191221165 1.29113828521772e-07 0.0267814187683372 \
1.29114015473295e-07 0.02635997027055515 1.291143848272417e-07 0.02554620807076183 1.291145384804102e-07 0.02521471147941385 1.291149546945644e-07 0.02434161493068329 \
1.291151601823807e-07 0.02392065165079968 1.291154991903413e-07 0.02323955384462723 1.291156818850694e-07 0.02287916718068597 1.291161389789784e-07 0.02199597290476789 \
1.291162687197144e-07 0.02174967209293581 1.291167221401377e-07 0.02089828923199067 1.2911686451243e-07 0.0206336680476187 1.291173940791906e-07 0.01967289368906444 \
1.291175202861975e-07 0.01945139161001456 1.291180825206354e-07 0.01850749734048266 1.29118245259022e-07 0.01824627541187189 1.291188094390872e-07 0.01738327200207762 \
1.291189611831539e-07 0.01716165742474803 1.291196628626383e-07 0.01618760396393164 1.291198329517282e-07 0.01596324388168 1.291204880096043e-07 0.01513221026437959 \
1.291206545239164e-07 0.01492874613340729 1.291213876376758e-07 0.01406966818047924 1.291215209008543e-07 0.01391906482409888 1.291223725580289e-07 0.01299647369571925 \
1.291225105004775e-07 0.01285324185793544 1.291234505599668e-07 0.0119198170026788 1.29123614321604e-07 0.01176347583728811 1.291246015550385e-07 0.01085909507266535 \
1.291247361441145e-07 0.0107410715025141 1.291258775835447e-07 0.009819907073012045 1.291259858224434e-07 0.009738548299709823 1.29127309069827e-07 0.00880579379490502 \
1.291274418155253e-07 0.008718202093769473 1.291289643166501e-07 0.007760835273143199 1.29129076858719e-07 0.007690148685505111 1.291307691503061e-07 0.00669558715138598 \
1.291309094168915e-07 0.00662113250846694 1.291329824261937e-07 0.005629132576249021 1.291331749877106e-07 0.005545002188831318 1.291353851975589e-07 0.004656096148610405 \
1.291357919842319e-07 0.004507219767123045 1.291386137242086e-07 0.003590578528330178 1.291391350199587e-07 0.00344214578404881 1.291433471210094e-07 0.002447529662748036 \
1.291438996838773e-07 0.002340875287107731 1.291497829734169e-07 0.001359168649576994 1.291500322464151e-07 0.001311490127959886 1.291631823674654e-07 0.0003136950974005476 \
1.291632991504353e-07 0.0003112730584132499 1.589900000000113e-07 3.042397160644726e-06 2.027466670270133e-07 -0.0009024818035526668 2.027467394426295e-07 -0.001022682652537627 \
2.027471754673471e-07 -0.001858525046639076 2.027472623617301e-07 -0.002046124893065343 2.027476170650434e-07 -0.00288168582347465 2.027477166116442e-07 -0.003135075204051477 \
2.027479768813486e-07 -0.003828199033013717 2.027481172037501e-07 -0.004216406518003108 2.027483446898323e-07 -0.004856871791621592 2.027484818972713e-07 -0.005239031028659006 \
2.0274886679612e-07 -0.006187559915121 2.027489988933069e-07 -0.006423332025500122 2.027496873363354e-07 -0.005917035979538006 2.027498442650689e-07 -0.005202654566481615 \
2.027499719142314e-07 -0.004414133290428114 2.027500994560215e-07 -0.003433350487145549 2.027502171302335e-07 -0.002355902309038119 2.027503162699201e-07 -0.001320627313728655 \
2.027504216526298e-07 -9.507383675133965e-05 2.027505355599331e-07 0.001369964538583592 2.027506666153286e-07 0.003229572948258866 2.027507919785475e-07 0.005172303930030842 \
2.027509838204114e-07 0.008432154569684791 2.027511274902044e-07 0.01107975669588844 2.027512854720174e-07 0.01417105828876112 2.027514340716643e-07 0.01723098336859398 \
2.02751587122593e-07 0.02051714008521248 2.027517461875693e-07 0.02405720796424875 2.02751899257778e-07 0.02756764950178633 2.027520476048421e-07 0.03105219347129199 \
2.027521967112842e-07 0.03462388853332505 2.027523512757131e-07 0.03838854885099419 2.027525119616768e-07 0.04235886888523473 2.027526766408632e-07 0.04647718198980624 \
2.027528531638066e-07 0.05093664320808645 2.027530321756059e-07 0.05549818742091989 2.027532229484479e-07 0.0603932190016783 2.027534277958001e-07 0.06567927942044927 \
2.027536482930531e-07 0.07139554989571946 2.027538812110213e-07 0.07745499876455469 2.027541304587992e-07 0.08395499695136356 2.027544033803266e-07 0.09108394918256098 \
2.027547001733835e-07 0.09884095133633181 2.027550276098956e-07 0.1073964775374675 2.027553974236946e-07 0.1170487607486894 2.027557923699755e-07 0.1273407304921971 \
2.027562504585284e-07 0.1392499850125259 2.027567825583881e-07 0.1530377249371455 2.027574081103967e-07 0.169180864038255 2.027580941024627e-07 0.1867931863309214 \
2.027588969458782e-07 0.2072766958045763 2.027597962582096e-07 0.2300508264895909 2.027606966983226e-07 0.2526618731709107 2.027614985898552e-07 0.2726215666318766 \
2.027621940969962e-07 0.2897857674353052 2.027628269312821e-07 0.3052728323588638 2.027634223397735e-07 0.3197161646377594 2.027639693828152e-07 0.3328722959176427 \
2.027645031431617e-07 0.3455929446372428 2.027650223825863e-07 0.3578476146335662 2.027655297740487e-07 0.3697097539883151 2.027660333952181e-07 0.3813674725871593 \
2.027665451381145e-07 0.3930934709428262 2.027670522991229e-07 0.404595334768291 2.027675825951367e-07 0.4164962117964878 2.027680687086257e-07 0.4272847049163567 \
2.027685468169473e-07 0.437781779057129 2.027689862490711e-07 0.4473362978389137 2.027691094085349e-07 0.4500002106608159 2.027693557274626e-07 0.4553046876287923 \
2.027696989994585e-07 0.4626558934952216 2.02770010436459e-07 0.4692815017887791 2.027702611477243e-07 0.4745855323881177 2.027705319768677e-07 0.480281321066213 \
2.02770868458777e-07 0.4873122872019196 2.027712244673881e-07 0.4946959640027882 2.027715417375557e-07 0.5012322602315481 2.027717806181048e-07 0.506122906570856 \
2.027720216462867e-07 0.5110269393752048 2.027722735779908e-07 0.5161276795544476 2.027725137318346e-07 0.5209621749612534 2.027727364832964e-07 0.5254248476203834 \
2.027729250409435e-07 0.5291850880529715 2.027731397909867e-07 0.5334523706207774 2.027733543393784e-07 0.5376948565446859 2.027736131036701e-07 0.5427871977552768 \
2.027738639312417e-07 0.5477009885064807 2.027741193501039e-07 0.5526782776843104 2.027744703926295e-07 0.5594898819265107 2.027747350009544e-07 0.5645984056527484 \
2.027750014175097e-07 0.569709962982798 2.027752619318197e-07 0.5746801970751495 2.027755290218824e-07 0.5797469183389945 2.027757721599625e-07 0.5843213438768613 \
2.02776027852189e-07 0.5890994944692448 2.027762556711592e-07 0.5933243819692556 2.027764932159793e-07 0.5976999800355528 2.027767046064655e-07 0.6015679915939678 \
2.027769167472246e-07 0.6054277082074113 2.027771059366022e-07 0.6088479815213901 2.027772370949197e-07 0.6112112531841202 2.027773693914781e-07 0.6135871094428261 \
2.02777554614204e-07 0.6169015645304802 2.027777166365907e-07 0.6197943209800671 2.027778750557552e-07 0.6226100751126036 2.027780091676215e-07 0.6249846001944386 \
2.027781814887287e-07 0.6280247049765127 2.027783104275314e-07 0.6302937061188456 2.027784308050438e-07 0.6324061607157294 2.027785713339149e-07 0.634864734791624 \
2.027787644194074e-07 0.6382321981637986 2.027789142301853e-07 0.6408363654380513 2.027790815377796e-07 0.6437327988167145 2.027792625920029e-07 0.6468572757970242 \
2.027794659184327e-07 0.6503523798695617 2.027796487715879e-07 0.6534819287355287 2.027798193958343e-07 0.6563879501053153 2.027799968600742e-07 0.6594029650344411 \
2.027801628390247e-07 0.6622113135173925 2.027803200758144e-07 0.6648594636266301 2.02780460561866e-07 0.6672075432495704 2.027806042919945e-07 0.6695987751186935 \
2.027807373389854e-07 0.6718055529208897 2.02780879311128e-07 0.6741523780906628 2.027809993716612e-07 0.6761293215200647 2.027811443097483e-07 0.6785098354674278 \
2.027812603067977e-07 0.6804095298668216 2.027813798866854e-07 0.6823647593763783 2.027814788466604e-07 0.68397755359623 2.027815973550785e-07 0.6859039329668146 \
2.027816843993602e-07 0.6873150904607619 2.027818064101795e-07 0.6892866586554622 2.027819053327908e-07 0.6908817703737582 2.027819972281661e-07 0.6923536807698466 \
2.027820971967054e-07 0.6939486118486815 2.02782195442366e-07 0.6955126686751646 2.027822871561283e-07 0.6969676095571918 2.027823912890697e-07 0.698613189139943 \
2.02782527015812e-07 0.7007470979739818 2.027826816242742e-07 0.7031613517373301 2.027828167319862e-07 0.7052558942641604 2.027829630685319e-07 0.7075085519458914 \
2.027830915360735e-07 0.7094732734147607 2.02783215720207e-07 0.7113609898537658 2.027833256245073e-07 0.7130225953369277 2.027834422075759e-07 0.7147759898693785 \
2.027835423854067e-07 0.7162749667021007 2.027836794742156e-07 0.7183149847558421 2.027837994632423e-07 0.7200901405411056 2.027839185766902e-07 0.7218426783097279 \
2.02784045072077e-07 0.723693513465353 2.027841709394491e-07 0.7255245570057045 2.027842935604676e-07 0.7272980597885179 2.027844211779915e-07 0.7291334326655684 \
2.027845514267828e-07 0.7309957624152177 2.02784673019733e-07 0.73272442801297 2.027848117884253e-07 0.7346853525547948 2.02784912196869e-07 0.7360963845229137 \
2.027850155842573e-07 0.7375412410987998 2.027851092446997e-07 0.7388443755773992 2.027852208662967e-07 0.7403895158541485 2.027853073348996e-07 0.7415798421827293 \
2.027854081980104e-07 0.7429609798983192 2.027855402947324e-07 0.7447573558536402 2.027856494960337e-07 0.7462323422761349 2.027857540276639e-07 0.747635567415085 \
2.027858776741446e-07 0.7492836897664436 2.027860263705797e-07 0.7512497161812216 2.027861482512389e-07 0.7528480713857697 2.02786261855803e-07 0.7543274008692354 \
2.027864023754882e-07 0.7561429069656862 2.027865435649301e-07 0.7579511824827749 2.027866613111062e-07 0.7594470562859095 2.027867900007657e-07 0.7610693809796742 \
2.027869325554127e-07 0.7628512182523866 2.027870484119641e-07 0.7642872416835913 2.027871941752297e-07 0.7660789429779771 2.02787316007677e-07 0.7675637574673733 \
2.02787434476374e-07 0.7689965471136999 2.02787557264006e-07 0.7704700089613156 2.027876834168886e-07 0.7719718272910862 2.027877937859393e-07 0.7732757954107932 \
2.02787919217035e-07 0.7747465774777432 2.027880246987464e-07 0.775974259539018 2.027881578651758e-07 0.7775122819577122 2.02788280546631e-07 0.7789173428708996 \
2.027884153096743e-07 0.7804473432620218 2.027885259809625e-07 0.7816923373676121 2.027886353025911e-07 0.7829118427552927 2.027887704350256e-07 0.7844048889494442 \
2.027889212140504e-07 0.7860523747618094 2.027890615829581e-07 0.7875692293014268 2.027891812944828e-07 0.7888502570533434 2.027893195488235e-07 0.7903153082715967 \
2.027894429191593e-07 0.7916096503654788 2.027895880177844e-07 0.7931164937536124 2.027897277580435e-07 0.7945521172774316 2.027898549394667e-07 0.7958455533278409 \
2.027899739792201e-07 0.7970449251022731 2.027900863374111e-07 0.7981670522831598 2.027901905661906e-07 0.79919939674296 2.027902859050021e-07 0.8001364844871954 \
2.027904221931122e-07 0.8014634245741865 2.027905390856557e-07 0.8025894467082511 2.02790658725145e-07 0.8037305025474466 2.027907806067166e-07 0.8048811831579785 \
2.027909029850537e-07 0.8060245537852575 2.027910310137332e-07 0.8072081965553952 2.027911556585317e-07 0.8083483262222385 2.027912861572795e-07 0.8095291977395493 \
2.027914126177069e-07 0.8106611567088965 2.027915397436747e-07 0.8117869190804841 2.027916448611513e-07 0.8127087429624065 2.027917501113405e-07 0.8136235164943317 \
2.027918412515906e-07 0.8144090748259969 2.027919646696249e-07 0.8154632009865571 2.027920517482738e-07 0.8162003374872545 2.02792151070959e-07 0.8170344894488412 \
2.027922959927027e-07 0.8182390501293432 2.027924322612063e-07 0.8193582434421302 2.027925417234847e-07 0.8202477434185359 2.027926878435863e-07 0.8214214001843773 \
2.02792839202198e-07 0.8226208465286928 2.027929650061201e-07 0.8236052915965452 2.027931094167794e-07 0.824721541823094 2.027932340177296e-07 0.8256729463037898 \
2.027933847297913e-07 0.8268094083523665 2.0279352010105e-07 0.8278169867326588 2.027936453039791e-07 0.8287379047458127 2.027937629733617e-07 0.829593908450195 \
2.027939088013387e-07 0.8306418458276996 2.027940752973201e-07 0.8318207857986918 2.027942061544082e-07 0.8327345044534114 2.027943796038485e-07 0.833928356718921 \
2.027945477223224e-07 0.8350667646575466 2.027947175961246e-07 0.8361988603660855 2.027948984507537e-07 0.8373843006762304 2.027950416331349e-07 0.8383085120571983 \
2.027951557464787e-07 0.8390361588138326 2.027952858124697e-07 0.8398559950134801 2.027953876877057e-07 0.8404909448220066 2.027955045669982e-07 0.8412116130393378 \
2.027956416789287e-07 0.8420465258793415 2.027958395595721e-07 0.843231707656198 2.027960313457652e-07 0.8443585547012582 2.027962407088286e-07 0.8455646258450146 \
2.027964228224064e-07 0.846593677725298 2.027966199171782e-07 0.8476867969181797 2.02796793185875e-07 0.8486305714188691 2.02796976264561e-07 0.8496104335327738 \
2.027971474015872e-07 0.8505103231661706 2.027973220804384e-07 0.8514128411730317 2.02797497318728e-07 0.8523022053693007 2.027976734583675e-07 0.8531802340241421 \
2.027978638096238e-07 0.8541115036082744 2.027980543867704e-07 0.855025905954957 2.027982548181929e-07 0.8559685891497206 2.027984474106693e-07 0.8568563992305701 \
2.027986582738064e-07 0.8578086227668252 2.027988861871822e-07 0.8588150784816577 2.027991522177188e-07 0.8599606428795262 2.027994507388009e-07 0.8612090806949765 \
2.027997266924816e-07 0.8623286542354505 2.028000109545961e-07 0.8634483918036945 2.028002851030458e-07 0.8644969441068078 2.02800557392313e-07 0.8655088801415273 \
2.028008275580888e-07 0.8664846790737442 2.028010847361862e-07 0.8673881555543895 2.028013572993529e-07 0.868319368003445 2.02801633304697e-07 0.8692355072818493 \
2.028019034186287e-07 0.870106770567397 2.028022032450018e-07 0.8710447971670072 2.028025742222908e-07 0.8721640818024149 2.028028691540118e-07 0.8730224021943973 \
2.028031234323761e-07 0.873740732376842 2.028034216772072e-07 0.8745584461000401 2.028036952852192e-07 0.8752856917963749 2.028039314154438e-07 0.8758961959341748 \
2.028041717609793e-07 0.8765017794770257 2.028043940971677e-07 0.8770481951318053 2.028045881024505e-07 0.8775144010549708 2.028049178237936e-07 0.8782846129827527 \
2.028050729968195e-07 0.8786376896881318 2.028053907524076e-07 0.8793424631377607 2.028055696169827e-07 0.8797286397841958 2.028059120784622e-07 0.8804474051285093 \
2.028060962178168e-07 0.880822800830328 2.028065711184754e-07 0.881756283451624 2.028067385131538e-07 0.8820737784441692 2.028072043462e-07 0.8829272622221894 \
2.028073851704931e-07 0.8832470363605239 2.028078792047929e-07 0.8840891816604841 2.028080205486687e-07 0.8843218944112644 2.028086269405857e-07 0.8852805359894154 \
2.028087790117662e-07 0.8855111592597558 2.028094256914359e-07 0.8864506941541785 2.028095539876422e-07 0.8866295550025313 2.028102021648149e-07 0.8874976172723908 \
2.028103319236755e-07 0.8876644392549727 2.028111001444974e-07 0.8886037370453904 2.02811229881009e-07 0.8887539063021698 2.028120833066544e-07 0.8896836309705964 \
2.028122265650877e-07 0.8898301468060963 2.02813212785821e-07 0.890764641901611 2.02813434267227e-07 0.8909571971396437 2.028145773086277e-07 0.8918770673440963 \
2.028147072981167e-07 0.8919774876506176 2.028160589233886e-07 0.8929731820841386 2.028162092835701e-07 0.89307657739048 2.028176899161688e-07 0.8939986636922405 \
2.028179288179339e-07 0.8941315911431026 2.028196933116327e-07 0.894999985510941 2.028200009949781e-07 0.8951330875684044 2.028225222661808e-07 0.8960612226716312 \
2.02822959317422e-07 0.8961978289811912 2.028268627296431e-07 0.8971619289239613 2.028271095114498e-07 0.8972094058147089 2.028346860012845e-07 0.8981998139535015 \
2.028348019130314e-07 0.8982099955090975 2.028539004457353e-07 0.8992062631372056 2.028542978885091e-07 0.8992194728667773 2.030047133235903e-07 0.9002121614362558 \
2.03004979381947e-07 0.9002436812458944 2.030102475320153e-07 0.8993470931706574 2.030104539029324e-07 0.899191170936528 2.030119320157425e-07 0.8982046351054961 \
2.030121124663985e-07 0.8981003355419954 2.030143349480612e-07 0.8971299612768925 2.030145410405757e-07 0.897079983173831 2.030249493066813e-07 0.8980580240048047 \
2.03025087164257e-07 0.8980839755683444 2.030318845132984e-07 0.8990685088718567 2.030320700847659e-07 0.8990874390200084 2.035282992589679e-07 0.9000706848616691 \
2.03528359054814e-07 0.9000975977971888 2.035296126054321e-07 0.9010828413531861 2.035297182980354e-07 0.9012097231395001 2.035303764287524e-07 0.9021613947651476 \
2.035305136110213e-07 0.9023918767045529 2.035310366376409e-07 0.9033649777562528 2.035310995012334e-07 0.9034908765919824 2.035315720967825e-07 0.904476514442582 \
2.035316234105955e-07 0.9045863669199017 2.035320893739314e-07 0.9055619780118375 2.035321215783922e-07 0.9056252631670594 2.035328386771295e-07 0.9066212416280413 \
2.035329231134019e-07 0.9066528951765993 2.035335231797814e-07 0.9059679814895146 2.035336430373927e-07 0.9055903401525059 2.03533774200172e-07 0.9050640446667092 \
2.035339090199249e-07 0.9043926011431642 2.035340571549842e-07 0.9034897747335404 2.035341947143354e-07 0.902493211317788 2.035343349260954e-07 0.9013135799985507 \
2.035344335882047e-07 0.9003872218501816 2.035345192720141e-07 0.8995148096066522 2.035346018362134e-07 0.8986166894493001 2.035347166188419e-07 0.8972773101170661 \
2.03534797717086e-07 0.8962642459447687 2.03534877134364e-07 0.8952218112132616 2.035349825888917e-07 0.8937633947192651 2.035351052301954e-07 0.8919606744930825 \
2.035352049542744e-07 0.890414036797163 2.035353751486854e-07 0.8876203405523397 2.035355213337767e-07 0.8850727273800474 2.035356895519253e-07 0.8819879035815887 \
2.035358617130214e-07 0.8786780617039783 2.035360460991142e-07 0.8749807502679057 2.035362306654577e-07 0.8711418063496947 2.035364149129437e-07 0.8671917613865908 \
2.035366002486073e-07 0.8631174608718694 2.035367746363354e-07 0.8592060069639053 2.035369573402717e-07 0.8550405244181323 2.035371326873658e-07 0.8509893565349284 \
2.035373150168772e-07 0.8467313026054767 2.035375053303062e-07 0.8422468264612591 2.035376756604352e-07 0.838204894125699 2.035378421840737e-07 0.8342320488410089 \
2.035380047549371e-07 0.830337741667393 2.035381546161599e-07 0.8267359097041467 2.035383057921791e-07 0.8230937075736249 2.035384949376529e-07 0.8185270080344306 \
2.035386406557074e-07 0.8150026134285653 2.035388156466743e-07 0.8107652770601156 2.035389641182175e-07 0.807166938184282 2.035391360056828e-07 0.8029987283123258 \
2.035393050739223e-07 0.7988973224349885 2.035394692526316e-07 0.7949140139776875 2.035396285801687e-07 0.7910485911592836 2.035397890297763e-07 0.7871568543472617 \
2.035399908491574e-07 0.7822630953020117 2.035401392968917e-07 0.7786646206504594 2.03540293464276e-07 0.77492821376164 2.035404305476362e-07 0.7716074476660475 \
2.035405399330824e-07 0.7689587163513494 2.035406458665383e-07 0.7663946531324515 2.035407728808854e-07 0.7633217481666642 2.035408872438541e-07 0.7605561828888391 \
2.035409900916761e-07 0.7580702160470256 2.035411116819926e-07 0.7551325442760125 2.035412224592673e-07 0.7524575925939972 2.035413393080924e-07 0.7496376180588871 \
2.035414500928178e-07 0.7469652567786068 2.035415684589191e-07 0.7441116745915923 2.035416932860144e-07 0.7411038668912771 2.035418458478099e-07 0.7374292753756717 \
2.035419797447979e-07 0.7342062928952946 2.035421007762374e-07 0.7312947572377408 2.035422649737523e-07 0.7273475399259534 2.035424423346988e-07 0.7230877912371642 \
2.035426245451075e-07 0.7187161681757385 2.035428055423726e-07 0.7143786395952922 2.035429862063158e-07 0.7100537072471783 2.035431763578828e-07 0.7055071781827296 \
2.035433641177769e-07 0.7010230964996226 2.035435646508815e-07 0.696237807975249 2.035437733363431e-07 0.6912646166759551 2.035439809799078e-07 0.6863227581165517 \
2.03544208547776e-07 0.6809140411171237 2.035444008226102e-07 0.6763521085712711 2.035446380878582e-07 0.6707310800019505 2.035448313661221e-07 0.6661595641347996 \
2.035450640988686e-07 0.6606646229758047 2.035452696563363e-07 0.6558174602470968 2.035455020097575e-07 0.6503484594495911 2.035456970117276e-07 0.6457674053103037 \
2.035459002403362e-07 0.6410004262200759 2.035460800928814e-07 0.6367906205544323 2.035462591993119e-07 0.6326052789263827 2.035464225765258e-07 0.628795088826817 \
2.035465946259304e-07 0.6247880828503264 2.035467581187693e-07 0.6209892715878097 2.035469339085876e-07 0.6169100951581823 2.035471158475732e-07 0.6126978430086294 \
2.035473043313055e-07 0.6083422542008314 2.035475107637274e-07 0.6035858951323969 2.035476900783897e-07 0.5994633272559844 2.035478872572566e-07 0.5949432360761027 \
2.035480963453974e-07 0.5901646611556908 2.035483020946604e-07 0.5854760387944159 2.035485426053479e-07 0.5800160304866983 2.035487157334496e-07 0.5760958285528379 \
2.035488806274519e-07 0.5723746772837877 2.035490614880267e-07 0.5683014035092815 2.035492187741233e-07 0.5647722902613652 2.035493877569178e-07 0.5609879409349005 \
2.03549567863379e-07 0.5569709657351898 2.03549720846506e-07 0.5535669615732179 2.035498525609507e-07 0.5506462283231492 2.035499999486508e-07 0.5473865746199473 \
2.035500873742421e-07 0.5454560063082221 2.035501722454816e-07 0.5435860258811447 2.03550270874694e-07 0.5414171943998213 2.035503429668553e-07 0.5398340751058975 \
2.035504400578744e-07 0.5377039800781129 2.035505256482577e-07 0.5358302678688993 2.035505907291341e-07 0.5344081412607664 2.03550714329502e-07 0.5317121235594142 \
2.035508087537724e-07 0.52965475734789 2.035509062769941e-07 0.5275349985745696 2.035510791376451e-07 0.5237893654184622 2.035512141331662e-07 0.5208709659121862 \
2.035513683166277e-07 0.5175498113398643 2.03551542781984e-07 0.5138002600288881 2.035516945879704e-07 0.510550000123414 2.03551840818953e-07 0.5074290310664136 \
2.035519847178261e-07 0.5043644611166801 2.035521277396695e-07 0.5013276181140283 2.035522233495175e-07 0.499301733014788 2.035523177934733e-07 0.4973032961550828 \
2.035524388494141e-07 0.4947494705229025 2.035525337277099e-07 0.4927525559781179 2.035526495585533e-07 0.4903172469328811 2.035527368224019e-07 0.4884854516151125 \
2.035528192528481e-07 0.4867593351188191 2.035529146608016e-07 0.484765406725184 2.035530153710815e-07 0.4826639978995959 2.035531122314731e-07 0.4806459052877932 \
2.035532509612246e-07 0.4777646955734051 2.035533866660861e-07 0.4749532752442271 2.035535871508094e-07 0.4708139964547478 2.035538024649621e-07 0.4663911383470885 \
2.03553984040267e-07 0.462674698484628 2.035541830122363e-07 0.4586189944293299 2.035543535777573e-07 0.455154096457448 2.035545279314447e-07 0.4516251957269069 \
2.035546968646987e-07 0.4482170126441485 2.035548694618603e-07 0.4447467276163349 2.035550520681902e-07 0.4410867902598327 2.035552406170555e-07 0.4373240875354826 \
2.035554340845929e-07 0.4334777823509549 2.035556424052318e-07 0.4293535036700135 2.035558567504624e-07 0.4251286740881063 2.035560824557922e-07 0.4207018662297695 \
2.035563089991605e-07 0.4162771402745992 2.035565711759108e-07 0.4111844468197049 2.035568202097347e-07 0.4063709766754009 2.035571213084326e-07 0.4005865607947761 \
2.035574107292502e-07 0.3950673729298416 2.035577182435291e-07 0.3892455819062323 2.035580404399245e-07 0.3831936848847286 2.035583681704072e-07 0.3770882112794804 \
2.035587006001628e-07 0.3709500980558715 2.035590303291706e-07 0.3649083177186754 2.035593515587582e-07 0.3590729273462687 2.03559682375082e-07 0.3531219177045733 \
2.035600247306453e-07 0.3470224718704957 2.035603243716774e-07 0.3417374346434491 2.035606541592421e-07 0.3359723367088904 2.035609810531852e-07 0.3303128110141857 \
2.03561319032532e-07 0.3245206193888226 2.035616280036957e-07 0.3192755432624759 2.035619528016686e-07 0.31382336954194 2.035622684318663e-07 0.3085864885517507 \
2.035625734190322e-07 0.3035810258414895 2.035628287576776e-07 0.2994330834535801 2.03563093620834e-07 0.295170851203172 2.035633807035187e-07 0.2905978071194348 \
2.035636036732975e-07 0.2870801635277143 2.035638032125666e-07 0.2839591363066187 2.035640128685797e-07 0.2807045410859125 2.035641931251209e-07 0.2779290029372279 \
2.035643554698416e-07 0.2754463208250681 2.035645059048156e-07 0.2731629026725527 2.035646569101242e-07 0.2708866524077067 2.035648538007149e-07 0.2679392949564011 \
2.035649849454786e-07 0.2659970646012914 2.035651096820175e-07 0.2641561221543183 2.035652612740599e-07 0.2619266655689588 2.03565357242231e-07 0.2605306204207966 \
2.035654537935996e-07 0.2591282589302421 2.035655784133887e-07 0.2573209601776467 2.035657209899234e-07 0.255257422470362 2.035658799234579e-07 0.25296979123958 \
2.035660125895253e-07 0.251062957019046 2.03566196158294e-07 0.2484301322588876 2.035663773934597e-07 0.2458327969660818 2.035665889075646e-07 0.2428051031600066 \
2.035667914973991e-07 0.2399069804317323 2.035669580538467e-07 0.2375282895552967 2.03567168273059e-07 0.2345337828133105 2.035673416909451e-07 0.2320692345528927 \
2.035675705336728e-07 0.2288260787734411 2.035677911684244e-07 0.2257162440502939 2.035679668301377e-07 0.2232503232699662 2.035681472906433e-07 0.2207258962977968 \
2.035683180470208e-07 0.2183528725291195 2.035684982432872e-07 0.2158619697278009 2.035686649739047e-07 0.2135675266585953 2.035688140953261e-07 0.2115251542210239 \
2.035689699053442e-07 0.2094125291275523 2.035691050857695e-07 0.2075875692769576 2.035692551671966e-07 0.2055694209972212 2.035693876128229e-07 0.2037957203154137 \
2.035695281573595e-07 0.2019220745191926 2.035696452261239e-07 0.2003748851744883 2.035697749337302e-07 0.1986681706274326 2.035698969911991e-07 0.1970700654731777 \
2.035700195346348e-07 0.1954731161836187 2.035701375539584e-07 0.1939418157697267 2.035702725767313e-07 0.1921981789937757 2.03570417201182e-07 0.1903420634523806 \
2.035705455516813e-07 0.1887049708672087 2.03570669186156e-07 0.1871351133418249 2.035707667362788e-07 0.1859021016257166 2.035708818092082e-07 0.1844539912642748 \
2.035709755078879e-07 0.1832809848801438 2.035710742920116e-07 0.1820493959460708 2.035711972265529e-07 0.1805230483556907 2.035712929805559e-07 0.1793400249325384 \
2.035714220681073e-07 0.177753298391591 2.035715245334772e-07 0.1764993061988986 2.035716227869744e-07 0.1753029542432101 2.035717428741866e-07 0.1738483570896001 \
2.03571845423405e-07 0.1726127298531683 2.035719558810642e-07 0.1712877101305652 2.035720843709282e-07 0.1697552709290656 2.035721758557694e-07 0.1686698090598139 \
2.035722803403581e-07 0.1674358120019214 2.035723552770942e-07 0.1665544493622226 2.03572444845591e-07 0.1655049734124585 2.035724954106002e-07 0.164914347906921 \
2.035725453889764e-07 0.1643318187475747 2.03572610358061e-07 0.163576534137217 2.035726458720287e-07 0.1631646263336159 2.035727180712023e-07 0.162329174921529 \
2.035727852002975e-07 0.1615546732967998 2.035728444300318e-07 0.160873195114598 2.035728881756305e-07 0.1603710314414745 2.035729358224586e-07 0.1598254649913795 \
2.03573006202993e-07 0.1590230739426561 2.03573088541159e-07 0.1580883269013631 2.035731667127594e-07 0.1572048664554128 2.035732487657085e-07 0.1562816770844126 \
2.035733414693307e-07 0.1552436243401225 2.035734642494946e-07 0.153877370231325 2.035735633955882e-07 0.1527810927807017 2.035736648959355e-07 0.1516651170047695 \
2.035737661711265e-07 0.1505582666538253 2.035738626629107e-07 0.1495093242781697 2.035739620809455e-07 0.1484346886615803 2.03574046381569e-07 0.1475281828465028 \
2.035741393202594e-07 0.1465342051547719 2.035742219212e-07 0.1456551508734999 2.035743306872851e-07 0.1445034822456445 2.035744363302651e-07 0.1433917535370727 \
2.035745179898545e-07 0.1425365900703354 2.03574611735024e-07 0.1415598856352903 2.03574705302971e-07 0.1405903867550886 2.035747881874616e-07 0.139735765814107 \
2.035748763466362e-07 0.1388313836440244 2.035749561327222e-07 0.1380170907865772 2.035750497281217e-07 0.1370669869522621 2.035751396606459e-07 0.1361590166429519 \
2.035752102110423e-07 0.1354501541392388 2.035752799712188e-07 0.1347521119166949 2.035753941201259e-07 0.1336164586193709 2.035754760987401e-07 0.1328058651355588 \
2.035755637040425e-07 0.1319440719770354 2.035756632052385e-07 0.1309710196939938 2.035757723852409e-07 0.1299110174488692 2.03575874550573e-07 0.1289256009328031 \
2.035759820107789e-07 0.1278959836800649 2.035761020450569e-07 0.1267549558890445 2.035761962530915e-07 0.1258657925752028 2.03576327232195e-07 0.1246390638240933 \
2.035764266598965e-07 0.1237164070883829 2.035765357815822e-07 0.1227104370444639 2.035766446347502e-07 0.1217138859540913 2.035767369441536e-07 0.120874257454373 \
2.035768497844844e-07 0.1198547128626846 2.035769467965243e-07 0.118986084968971 2.035770510628723e-07 0.1180628196869088 2.035771600298026e-07 0.1171053395831002 \
2.035772595693683e-07 0.1162371554254778 2.035773765620782e-07 0.1152245300989246 2.035774636628686e-07 0.1144761644999183 2.035775729545201e-07 0.1135478691973115 \
2.035776544795827e-07 0.1128618460838699 2.035777542545759e-07 0.1120273350449922 2.03577871679726e-07 0.1110526766231405 2.035779734648438e-07 0.1102143708571793 \
2.035780612037922e-07 0.1094962336869811 2.035781420032999e-07 0.1088432886892514 2.035782289543192e-07 0.1081456845520918 2.035783097409448e-07 0.1075007757815706 \
2.035783999475114e-07 0.1067842832273628 2.03578490898266e-07 0.1060655611559195 2.035785795687901e-07 0.1053685613006139 2.035786785836107e-07 0.1045946508745568 \
2.035787722897869e-07 0.1038723470842792 2.035788661490627e-07 0.1031520741219857 2.035789669765109e-07 0.1023817709659086 2.035790716074088e-07 0.1015861061604995 \
2.035791955701651e-07 0.1006484085638475 2.035792929694782e-07 0.09991551135558702 2.035794132274253e-07 0.09901872452754552 2.035795240953005e-07 0.09819831936474602 \
2.035796285683363e-07 0.09742874659471555 2.035797458050452e-07 0.09656937225591002 2.035798475993662e-07 0.09582695326576983 2.035799455749168e-07 0.09511577589263259 \
2.035800860794065e-07 0.09410164141823299 2.035801911572026e-07 0.09334832721827611 2.035802897700187e-07 0.09264549593674179 2.035803824848273e-07 0.09198739948435641 \
2.035804686832124e-07 0.09137785861853052 2.035805625961876e-07 0.09071637432184691 2.035806596969337e-07 0.09003559055802626 2.035807691179881e-07 0.08927317549644689 \
2.035808701015371e-07 0.08857281843916648 2.035809637594832e-07 0.08792605868920525 2.035810379341552e-07 0.08741581771673042 2.03581175834007e-07 0.08647193599618339 \
2.035812481910108e-07 0.08597917321277694 2.035813835122141e-07 0.08506274029062395 2.035814694238195e-07 0.08448410751389913 2.03581614152054e-07 0.08351486081643937 \
2.035817103826189e-07 0.0828744112740944 2.035817982183981e-07 0.08229260392026354 2.035819140173063e-07 0.08152964121883956 2.035820291457576e-07 0.08077575264951149 \
2.0358214291219e-07 0.08003553900012179 2.035822831696828e-07 0.0791300282244784 2.035824245457162e-07 0.07822490276368012 2.035825741817577e-07 0.07727536491519127 \
2.035827186706132e-07 0.07636690312463701 2.035828698447241e-07 0.07542565384097814 2.035830192155436e-07 0.07450459906593411 2.03583168562251e-07 0.0735926433331697 \
2.035833285177668e-07 0.07262574717347114 2.035834846646777e-07 0.07169171823582712 2.035836591531124e-07 0.07065947636250877 2.035838288622191e-07 0.0696671357044583 \
2.035840140413029e-07 0.0685979885997255 2.035842107623799e-07 0.06747763456279594 2.035844212801998e-07 0.06629631776014881 2.03584643312255e-07 0.06507007089066431 \
2.035848735242764e-07 0.0638195278444372 2.035851160353819e-07 0.06252626147401 2.035853766894672e-07 0.06116236403900636 2.035856565885314e-07 0.05972739422233359 \
2.035859501722554e-07 0.05825544847408989 2.035862651082393e-07 0.05671370145268265 2.035866079141644e-07 0.05507846134953124 2.035869573807585e-07 0.0534565727116736 \
2.035873662849152e-07 0.05161746230842366 2.035877129499425e-07 0.05010669351290297 2.035881003649955e-07 0.04846839895323611 2.035884445827877e-07 0.04705645202362623 \
2.035887680090468e-07 0.04576625679949029 2.035890730548091e-07 0.04458093278443617 2.035893659168059e-07 0.04347099288378908 2.035896500577229e-07 0.04242242262004604 \
2.03589926078015e-07 0.04142902112907627 2.03590192930566e-07 0.04049015932812138 2.035904618227892e-07 0.03956531631184226 2.035907378832112e-07 0.03863769040165695 \
2.035910254787821e-07 0.03769451689421055 2.035912650444083e-07 0.03692662498323904 2.03591554211835e-07 0.03602084344675294 2.03591770003438e-07 0.03535960341037672 \
2.035919577204764e-07 0.03479599077274986 2.035921558495825e-07 0.03421285035004928 2.03592518724446e-07 0.03317032497347058 2.03592776866276e-07 0.03244834222605905 \
2.0359308657919e-07 0.0316030971185694 2.035933520493286e-07 0.03089664771451467 2.035936201684082e-07 0.03019941363307669 2.03593899042439e-07 0.02949128999862272 \
2.035941452288756e-07 0.02888043298519722 2.035943758602853e-07 0.02832033800396738 2.035946141502041e-07 0.02775711540944564 2.035948491575685e-07 0.02721270742060762 \
2.03595076940031e-07 0.02669509678424227 2.035954855523029e-07 0.02579039168486155 2.03595661854632e-07 0.02540904040268441 2.03596016332316e-07 0.02465798827491217 \
2.035962002032883e-07 0.02427641469830137 2.035965351520103e-07 0.02359448510613503 2.035966990607275e-07 0.02326678168937357 2.035970913313036e-07 0.02249905491676728 \
2.035972473220689e-07 0.02220010404946675 2.035976789254264e-07 0.02138321689778962 2.035978163148065e-07 0.0211255367654138 2.03598333123589e-07 0.02017559010600388 \
2.035984586594829e-07 0.01995091418019728 2.035989159010076e-07 0.01915998482559782 2.035990750469891e-07 0.01889493739859509 2.035996822854669e-07 0.01793263500095189 \
2.03599816822955e-07 0.01772934138481063 2.036004800869477e-07 0.01678091027541291 2.036006734103789e-07 0.01651856846389665 2.036013410670396e-07 0.01565087920017967 \
2.03601502655887e-07 0.01544858341705342 2.0360225789114e-07 0.01454101846553843 2.036024074521069e-07 0.01436800730673201 2.036032977899311e-07 0.01338293844200974 \
2.036033964478169e-07 0.01327873262558703 2.03604353121314e-07 0.01230993787860994 2.036044742310216e-07 0.01219243157195396 2.036054657237297e-07 0.01126376273051215 \
2.036056292524602e-07 0.01111855113153209 2.036067591745355e-07 0.01018247077230436 2.036068716217739e-07 0.01009565848301377 2.036082494452622e-07 0.009103273453806031 \
2.036083883905334e-07 0.009009747578659758 2.036099427888684e-07 0.008018073335410726 2.0361005485534e-07 0.00794673960805117 2.036116998381698e-07 0.006958154532207958 \
2.036118070906645e-07 0.006899512253112593 2.036137515841525e-07 0.005937533026687714 2.036139584821097e-07 0.005843834961138424 2.036162973698526e-07 0.00487227039639981 \
2.036167213562637e-07 0.004712306502041247 2.036194935894604e-07 0.003780857497341114 2.036199418985521e-07 0.003647790772321777 2.03623582397237e-07 0.00272553831825111 \
2.036240790530716e-07 0.002619503085887757 2.036298301734959e-07 0.001650572925599863 2.036301169553825e-07 0.001609446887446839 2.036354719440668e-07 0.0006353228983793809 \
2.036356773006917e-07 0.0005920420449145349 2.062827120745074e-07 -0.0002718533828215428 2.062828679501107e-07 -0.0004579010352009555 2.062834162652028e-07 -0.001326296959495401 \
2.062835290488787e-07 -0.001543805653187533 2.062839635410185e-07 -0.002491429791030493 2.062840393661749e-07 -0.002673591589873599 2.062843960167732e-07 -0.003590195133438418 \
2.062845230658532e-07 -0.003936807634339821 2.062848015662471e-07 -0.004716444651655622 2.062849096507305e-07 -0.005020876868076652 2.06285253249855e-07 -0.00592430224391268 \
2.062853602437202e-07 -0.006162325733041658 2.062862596141159e-07 -0.005653094509861465 2.062864380475456e-07 -0.004687598829536962 2.062865437709605e-07 -0.003940993102967527 \
2.062866688337378e-07 -0.002883597584075996 2.062867624178337e-07 -0.001971418478057775 2.062868402573964e-07 -0.001132968824455395 2.062869203293945e-07 -0.0001977429743171 \
2.062870427022047e-07 0.001370578777960296 2.062871609580771e-07 0.003041212838230153 2.062872796071873e-07 0.004860750887681821 2.06287393089626e-07 0.006730904986417607 \
2.062874965327645e-07 0.008536402178002854 2.062876111920181e-07 0.01064190690353853 2.062878017758113e-07 0.0143607330143792 2.062879355659492e-07 0.01711819191720031 \
2.062880858195149e-07 0.02033933849841947 2.062882409887625e-07 0.02378599874269359 2.062883963808114e-07 0.0273434151175349 2.062885440880426e-07 0.03080849965087477 \
2.062886930776679e-07 0.03437359286003162 2.06288848068751e-07 0.03814545786868043 2.062890074393648e-07 0.04208062121327779 2.062891723727756e-07 0.04620305710844342 \
2.062893473191046e-07 0.0506208066052034 2.062895264491763e-07 0.05518387280380205 2.062897162384316e-07 0.06005265756871143 2.062899199354002e-07 0.06530840376289772 \
2.062901397459318e-07 0.07100650943730057 2.062903714973765e-07 0.07703584544314998 2.062906193226736e-07 0.08349927754587044 2.062908906436034e-07 0.09058756662233436 \
2.062911853563813e-07 0.09829181712822582 2.062915106140293e-07 0.106792896697727 2.062918768597349e-07 0.1163551101154179 2.062922701564477e-07 0.1266079356677421 \
2.062927228093435e-07 0.1383809089651769 2.062932485245108e-07 0.1520098384503803 2.062938677380491e-07 0.1679979965193872 2.062945484823656e-07 0.1854865650013753 \
2.062953421573204e-07 0.2057488551561759 2.062962309229534e-07 0.2282732214494322 2.062970443122153e-07 0.2487218262351868 2.062977660617924e-07 0.2667261628598245 \
2.062984017258005e-07 0.282460740414376 2.062989734425617e-07 0.2965101025186013 2.062995089968458e-07 0.3095696210007924 2.063000123552588e-07 0.3217495654069301 \
2.063004886827015e-07 0.3331878525640654 2.063009626063057e-07 0.3444754071334732 2.063014200780245e-07 0.3552759747331513 2.06301886058294e-07 0.3661792384270033 \
2.063023350461038e-07 0.376592601923634 2.063028311526457e-07 0.3879857357798637 2.063033509145082e-07 0.3998002499051578 2.063037303191525e-07 0.4083447473225827 \
2.063041703278757e-07 0.4181679450526055 2.063046400968136e-07 0.4285466970600206 2.063051256177522e-07 0.4391589006481625 2.063055650658585e-07 0.4486701556983262 \
2.063056268188069e-07 0.4500002248264944 2.063057503247038e-07 0.4526540461147197 2.063059973364976e-07 0.4579447795386873 2.063062499314088e-07 0.463325462421476 \
2.063064475025244e-07 0.467511453725808 2.063066730742715e-07 0.4722681264242033 2.06306994642268e-07 0.4790073975813253 2.063072634214966e-07 0.4846013351959894 \
2.063074820729701e-07 0.4891262574467725 2.063076921769364e-07 0.4934547887280634 2.063079185824616e-07 0.4980921872304203 2.063081276876522e-07 0.5023516957637455 \
2.063083170899107e-07 0.5061927337048852 2.06308441251129e-07 0.5086969563931187 2.063085680062259e-07 0.5112441466129884 2.06308728004704e-07 0.5144514110933732 \
2.063089756476561e-07 0.5193914248715521 2.063091542341148e-07 0.5229351592435862 2.063093251876918e-07 0.5263079149198099 2.063095865372878e-07 0.5314455197962068 \
2.063098126088702e-07 0.5358634945234868 2.063100157405374e-07 0.5398188128751134 2.063101809712675e-07 0.5430252218652345 2.063103377582878e-07 0.5460612552756139 \
2.063105269149053e-07 0.5497137532216215 2.063107287826585e-07 0.5535976061995346 2.063109529339811e-07 0.5578986282275192 2.063111913163462e-07 0.5624617013850463 \
2.06311426077985e-07 0.566941985223824 2.063116563486904e-07 0.5713275351537204 2.063118621413239e-07 0.5752375533958141 2.063120671255381e-07 0.5791255875933676 \
2.063123099407797e-07 0.5837094709690289 2.063125646983618e-07 0.588493349632063 2.063127929267933e-07 0.5927514274590796 2.063130307656652e-07 0.5971656109489694 \
2.063132430431008e-07 0.6010807441713891 2.063134548365055e-07 0.6049674646600495 2.06313708720774e-07 0.6095919957414236 2.063139133143013e-07 0.6132953190650409 \
2.063141650376543e-07 0.6178178328453598 2.063143528271744e-07 0.6211736970442716 2.063146057002513e-07 0.6256587164710262 2.063148041096133e-07 0.6291560967673944 \
2.06314983842284e-07 0.6323071487074056 2.063152541130913e-07 0.6370161336915187 2.063154713968567e-07 0.6407803561788556 2.063156519232363e-07 0.6438916924996977 \
2.063158530841308e-07 0.6473460740030906 2.063160216675126e-07 0.650231451944099 2.063162260257198e-07 0.6537144072723954 2.063163716887783e-07 0.6561873372238678 \
2.063165362473771e-07 0.6589728476742622 2.063167057165935e-07 0.6618316558839334 2.063168592566751e-07 0.664412775690417 2.06317000490202e-07 0.6667750288922751 \
2.063171440660136e-07 0.6691685747430841 2.06317277296139e-07 0.6713840140331436 2.063174191964594e-07 0.6737368819239464 2.063175394300862e-07 0.6757233098298149 \
2.063176840811384e-07 0.6781085120392751 2.063178002998436e-07 0.6800197521569988 2.063179193821632e-07 0.6819757159594566 2.063180179604767e-07 0.6835903813535821 \
2.063181355581833e-07 0.6855122399681081 2.063182229941461e-07 0.6869376986921233 2.063183477402322e-07 0.6889650632873403 2.063184475472963e-07 0.6905825000046129 \
2.063185400370926e-07 0.6920753042469043 2.063186413211772e-07 0.6937043390836264 2.063187391142832e-07 0.695273833970533 2.063188303850746e-07 0.6967333967490603 \
2.063189328429049e-07 0.6983656370917724 2.063190657521356e-07 0.7004728611232253 2.063192207675414e-07 0.7029137789397926 2.063193556492269e-07 0.7050222373350452 \
2.063195011450183e-07 0.7072806469370021 2.063196289996853e-07 0.709252249158637 2.063197534579806e-07 0.7111597484283609 2.063198647836849e-07 0.7128563623504806 \
2.063199788137127e-07 0.7145852226468989 2.063200793249296e-07 0.7161013069709498 2.063202165260769e-07 0.7181590832501857 2.063203364719788e-07 0.7199473375636642 \
2.06320455641778e-07 0.7217141075019444 2.063205825867917e-07 0.7235855504531626 2.063207073542094e-07 0.7254141264975077 2.063208308495973e-07 0.7272133847865295 \
2.063209576308702e-07 0.7290498056238117 2.063210882203554e-07 0.730930225429108 2.063212104322583e-07 0.7326797786847141 2.063213474902716e-07 0.7346298644824388 \
2.063214487056265e-07 0.7360619656663578 2.063215536745619e-07 0.7375401619041119 2.063216451659951e-07 0.7388229997694907 2.06321758241356e-07 0.7404001534680551 \
2.063218455422403e-07 0.7416107338190071 2.063219500055706e-07 0.7430512000342341 2.063220807687029e-07 0.7448411286358657 2.063221906822003e-07 0.7463352048609909 \
2.063222953419585e-07 0.7477488743938407 2.0632241917362e-07 0.7494094725133206 2.063225679269713e-07 0.751387874302702 2.06322689842132e-07 0.7529958494242643 \
2.063228036963925e-07 0.7544867042370438 2.0632294419585e-07 0.7563117925204224 2.063230855193645e-07 0.7581313010100689 2.063232032989716e-07 0.7596352654099263 \
2.063233316974594e-07 0.7612620174900669 2.06323474021161e-07 0.7630496612437514 2.063235904103157e-07 0.7644991888858087 2.063237361339775e-07 0.7662987831554334 \
2.063238579138671e-07 0.7677897310961733 2.06323976478797e-07 0.7692300520321635 2.063240990922458e-07 0.7707078417740018 2.063242255436292e-07 0.77221964326554 \
2.06324335666584e-07 0.7735261258099556 2.063244611887263e-07 0.7750039859681491 2.06324566849672e-07 0.7762386743660952 2.063247020268293e-07 0.7778058706872942 \
2.063248256373457e-07 0.7792267957652825 2.06324955634725e-07 0.7807078764205345 2.06325068606223e-07 0.7819831642610904 2.063251765001111e-07 0.7831908181350914 \
2.063253130307933e-07 0.7847046126527283 2.063254631517019e-07 0.7863508260127218 2.063256054160057e-07 0.7878933964149381 2.063257249975189e-07 0.7891771019825847 \
2.06325861808649e-07 0.7906313890246753 2.063259843124129e-07 0.7919206245676671 2.063261289843411e-07 0.7934276941869095 2.063262697694143e-07 0.794878360380241 \
2.063263965852094e-07 0.796171745508174 2.063265156326018e-07 0.7973744708066829 2.063266278955628e-07 0.7984986270115709 2.063267322833333e-07 0.7995352562746869 \
2.063268275603949e-07 0.8004739840425704 2.063269639028913e-07 0.8018044219089175 2.063270807679598e-07 0.8029326473252685 2.063272003644895e-07 0.8040757482679398 \
2.063273222502994e-07 0.8052288531124292 2.063274448385593e-07 0.8063765489401953 2.06327572579618e-07 0.8075599074701925 2.06327697362526e-07 0.8087035441861687 \
2.063278278629006e-07 0.8098867241643505 2.063279542295969e-07 0.8110199871086299 2.06328081578389e-07 0.8121498004723215 2.063281867911793e-07 0.8130740322933268 \
2.063282914951838e-07 0.8139855427426806 2.063283830253901e-07 0.8147757515715357 2.063285063983601e-07 0.8158311616195392 2.063285933524084e-07 0.8165684017534872 \
2.063286922082447e-07 0.8173999442793862 2.063288367108844e-07 0.8186029267949408 2.063289730365726e-07 0.8197243345631372 2.063290824450085e-07 0.8206145128367788 \
2.06329228461948e-07 0.821788834531623 2.063293802030074e-07 0.8229927727264784 2.063295061195854e-07 0.8239792970156907 2.063296505686489e-07 0.8250971468990039 \
2.063297752648172e-07 0.8260503472050121 2.063299258788342e-07 0.8271873005969326 2.063300612493023e-07 0.8281959289694237 2.063301864729373e-07 0.8291179217777711 \
2.063303041288969e-07 0.8299746468143927 2.063304499105104e-07 0.8310230722388168 2.063306163942599e-07 0.8322027532553667 2.063307472150236e-07 0.8331167337813133 \
2.063309206750455e-07 0.834311196379941 2.063310887878414e-07 0.8354501125721271 2.063312586689692e-07 0.8365827385393307 2.063314395126276e-07 0.8377685497174457 \
2.063315827046921e-07 0.8386931238161603 2.063316968221893e-07 0.8394210074154138 2.063318268737995e-07 0.8402408682651782 2.063319287535162e-07 0.8408758513273116 \
2.063320456411389e-07 0.841596551294542 2.063321827868591e-07 0.8424315815669623 2.063323806960722e-07 0.8436167827761205 2.063325725154114e-07 0.8447436440637145 \
2.063327818661576e-07 0.8459494874145237 2.06332964017768e-07 0.8469786287449077 2.063331611039906e-07 0.8480715276019779 2.063333343567189e-07 0.8490148531186206 \
2.063335174509634e-07 0.8499943787178993 2.063336885824299e-07 0.8508936588199895 2.063338632702719e-07 0.8517955326875627 2.063340385042873e-07 0.8526841769874772 \
2.063342146411542e-07 0.8535614892404448 2.063344050084938e-07 0.8544920815553035 2.063345955808447e-07 0.8554057038167108 2.063347959768378e-07 0.8563474066245403 \
2.063349885664635e-07 0.8572344253714166 2.06335199466375e-07 0.858185963363946 2.063354273418618e-07 0.8591913103610016 2.063356934247181e-07 0.8603357477151101 \
2.063359919268544e-07 0.8615822374427254 2.063362678163234e-07 0.8627000332972231 2.063365520834927e-07 0.8638181192989086 2.063368262214432e-07 0.8648650323418529 \
2.06337098522366e-07 0.8658754039994767 2.063373686785625e-07 0.8668495780678541 2.063376258626989e-07 0.8677515347235455 2.063378984216134e-07 0.8686810999091764 \
2.063381744693316e-07 0.8695957110915412 2.063384445895985e-07 0.8704649939918846 2.063387444494889e-07 0.8714007440816277 2.063391154301144e-07 0.8725171209518352 \
2.063394103525362e-07 0.8733732402027278 2.063396646282709e-07 0.8740897163373675 2.06339962841735e-07 0.8749052413925265 2.063402364113466e-07 0.8756305047096297 \
2.063404725347486e-07 0.8762394088953867 2.063407128598864e-07 0.8768433401198644 2.063409351938211e-07 0.8773882060838187 2.063411292002539e-07 0.8778530214284207 \
2.063414589096812e-07 0.8786208714695904 2.063416140810901e-07 0.87897283049042 2.063419317234907e-07 0.8796750328643211 2.063421106040349e-07 0.8800599154915705 \
2.063424530647979e-07 0.8807759898408113 2.063426372672098e-07 0.8811501695110489 2.063431122965131e-07 0.8820806183873429 2.06343279683462e-07 0.8823969901232691 \
2.063437454598435e-07 0.8832471741583867 2.063439262991872e-07 0.8835657112976044 2.063444203088053e-07 0.8844044135654346 2.063445616237109e-07 0.8846360992458032 \
2.063451678673266e-07 0.8855901496945974 2.063453199425258e-07 0.8858196526512701 2.06345966662599e-07 0.8867549368993356 2.063460949492666e-07 0.8869330782847171 \
2.063467431586864e-07 0.8877977435561634 2.06346872882985e-07 0.8879638504720397 2.063476413020527e-07 0.8888993076310558 2.063477710739033e-07 0.8890488273083775 \
2.063486247365088e-07 0.8899738047157748 2.063487677615613e-07 0.8901192131187072 2.06349754067048e-07 0.8910487927319016 2.063499755535999e-07 0.8912403904783051 \
2.063511183781385e-07 0.8921548233216382 2.063512482580762e-07 0.8922544308366913 2.063526007584981e-07 0.8932425879319322 2.063527510414313e-07 0.8933452769452155 \
2.063542315756977e-07 0.8942627870546499 2.063544704854918e-07 0.8943950258099049 2.063562525184327e-07 0.8952625983306248 2.063566382658602e-07 0.895426813549116 \
2.063590404240788e-07 0.8963023915260389 2.063595153600487e-07 0.8964490046842035 2.063634332871647e-07 0.8974035634625627 2.063639032474093e-07 0.8974927205890085 \
2.063722720353868e-07 0.8984807567386782 2.063724925457144e-07 0.8984960697096243 2.064170720742927e-07 0.8994905034760702 2.064182734601916e-07 0.8995076493514624 \
2.065540832686943e-07 0.9004821828323031 2.065542622454192e-07 0.9005421539807538 2.065577071203374e-07 0.8996085030263692 2.065578799041918e-07 0.8994755022453073 \
2.065592062238996e-07 0.8985168769831137 2.06559392989208e-07 0.8983970610744239 2.065611771942332e-07 0.8974304740967198 2.065613893245152e-07 0.8973403978332656 \
2.065747300202991e-07 0.8983331062395279 2.065748433081446e-07 0.8983517458922662 2.065835466612414e-07 0.8993273409280406 2.0658409447182e-07 0.8993637478389299 \
2.070766218437148e-07 0.9003542216796759 2.070767175825666e-07 0.9004233209197793 2.070776601319424e-07 0.9014023545001312 2.070778225852538e-07 0.9016297223302431 \
2.070783892915005e-07 0.9025464066367429 2.070784964622122e-07 0.9027401250447874 2.07078889770564e-07 0.9035002370985188 2.07079022567928e-07 0.9037710185404622 \
2.070794021690344e-07 0.9045728679206633 2.070795323837805e-07 0.9048512534150681 2.070799937900729e-07 0.9057878278182891 2.070801130371311e-07 0.9060008176934132 \
2.070815426461655e-07 0.9050557440230738 2.070816263162926e-07 0.9046580283931719 2.070817516221221e-07 0.9039622140338933 2.070818594362906e-07 0.9032622438705011 \
2.070819784306371e-07 0.9023800387125585 2.070820938028541e-07 0.9014106868475621 2.070821838997509e-07 0.900578017289966 2.070822953474549e-07 0.8994526603282017 \
2.070823814266029e-07 0.8985125975436928 2.070824873922515e-07 0.8972736935213672 2.070825871606176e-07 0.8960214106762436 2.070826681562277e-07 0.8949470092681954 \
2.070827778041954e-07 0.8934133399212493 2.070828633916057e-07 0.8921520042367302 2.070829555142149e-07 0.8907345325087322 2.07083043733598e-07 0.8893220116766375 \
2.070831525083507e-07 0.8875100775672261 2.070832354013856e-07 0.8860780350921965 2.070833439750574e-07 0.8841400608632336 2.070834362012525e-07 0.8824412727986957 \
2.070835208217502e-07 0.8808423775446282 2.0708360666218e-07 0.8791839877465467 2.0708368587706e-07 0.8776224824828824 2.070837619650304e-07 0.8760960492665846 \
2.070838543013988e-07 0.874210837196514 2.070839141777347e-07 0.8729702140710593 2.070839715660192e-07 0.8717685933706794 2.070840335611921e-07 0.8704574090763495 \
2.070840968400435e-07 0.8691057216070059 2.070841469113811e-07 0.8680269866686803 2.070841963535335e-07 0.8669542389500936 2.070842600232402e-07 0.8655623656543436 \
2.070843359706592e-07 0.8638877358586781 2.070843848016709e-07 0.8628032002737418 2.070844333256242e-07 0.8617197496806845 2.07084509037347e-07 0.8600184098866027 \
2.070845762461248e-07 0.8584975010852487 2.070846189526312e-07 0.8575263577286506 2.070846628552044e-07 0.8565244243916033 2.070847506603509e-07 0.8545103166059256 \
2.070848135135196e-07 0.8530605771626394 2.070848721831768e-07 0.8517018597088126 2.070849083617785e-07 0.8508614974547222 2.070849431802581e-07 0.8500510151036469 \
2.070849782062432e-07 0.8492340038666518 2.070850482582133e-07 0.8475953578585981 2.07085096728698e-07 0.8464581214772323 2.070851406734992e-07 0.8454248116355969 \
2.070851861912554e-07 0.8443523575543517 2.070852500921664e-07 0.8428433081697474 2.070853162185396e-07 0.8412777165526386 2.07085421348608e-07 0.8387809254526315 \
2.070855092832832e-07 0.8366857089760468 2.070855882285649e-07 0.834800137446173 2.070856763936023e-07 0.8326899670047023 2.070857632095989e-07 0.8306078985741704 \
2.070858511012833e-07 0.8284959280419055 2.070859423503732e-07 0.8262996967350639 2.070860451122409e-07 0.8238226494465998 2.070861436157165e-07 0.8214450402687625 \
2.070862559486315e-07 0.8187302447322098 2.070863689227678e-07 0.8159967029774419 2.070864902106627e-07 0.8130591602364435 2.070866207178167e-07 0.8098958628758253 \
2.070867497637196e-07 0.8067658935936169 2.070869032393199e-07 0.8030416153605923 2.070870685235405e-07 0.799029304640783 2.070872362647447e-07 0.7949567682299736 \
2.070874327883338e-07 0.7901857478752816 2.07087637550659e-07 0.7852160332972318 2.070878502277154e-07 0.7800563994093253 2.070880508476619e-07 0.7751902022758907 \
2.070882517063895e-07 0.7703212856706637 2.070884017284074e-07 0.766686939713112 2.070885322635739e-07 0.7635264252913375 2.070886666810141e-07 0.7602735436595947 \
2.070887728765446e-07 0.7577048602246427 2.070889061828774e-07 0.754482067181252 2.070890132158029e-07 0.7518959494812111 2.070891562917044e-07 0.7484409822837247 \
2.07089320797846e-07 0.7444713482725677 2.070894416150925e-07 0.74155777711076 2.070896127217565e-07 0.7374334100931738 2.070897736123089e-07 0.733558046396253 \
2.070899902049297e-07 0.7283457217000903 2.070901834606309e-07 0.7236999380850822 2.07090362395765e-07 0.7194029726762079 2.070905292123874e-07 0.7154015770462002 \
2.070907154183522e-07 0.7109395231330657 2.070909033515935e-07 0.7064416825495208 2.070910692736986e-07 0.7024749886985119 2.07091261631787e-07 0.6978803202016938 \
2.07091402988682e-07 0.6945068232011449 2.070915599964439e-07 0.6907636199298515 2.07091755976089e-07 0.6860965106368763 2.070919184101942e-07 0.6822325558671515 \
2.070920795863762e-07 0.6784034260021697 2.070922718945739e-07 0.6738409413562468 2.070924895564538e-07 0.6686845685784016 2.070927375777557e-07 0.6628199086538362 \
2.07092915635219e-07 0.6586162961343578 2.070931641790282e-07 0.6527567611811057 2.070933667862709e-07 0.6479896840619462 2.070935365969381e-07 0.6440011601507294 \
2.07093695213124e-07 0.6402799599229552 2.070938337435587e-07 0.637035894415233 2.070939699513215e-07 0.6338503464729111 2.070940962626978e-07 0.6309003762865483 \
2.070942257219331e-07 0.6278810604265532 2.070943540536725e-07 0.6248911458464299 2.070944853836027e-07 0.6218374290191309 2.070946174102147e-07 0.6187713222160208 \
2.070947615700952e-07 0.6154276788919771 2.070949057786871e-07 0.6120888358645944 2.070950534337911e-07 0.6086753592300279 2.070952004901491e-07 0.6052842859263143 \
2.070953583041757e-07 0.6016504852589418 2.070954909098278e-07 0.5986039825107707 2.070956223747947e-07 0.5955897059985247 2.070957418045935e-07 0.5928552647156846 \
2.070958778732863e-07 0.5897484304797134 2.070959928015483e-07 0.5871283594046445 2.070961439122689e-07 0.5836892419704927 2.070962585613368e-07 0.5810871834776226 \
2.070963764990064e-07 0.5784138884735546 2.070964662802944e-07 0.576381560286313 2.070965565996887e-07 0.5743415774978985 2.070966232905592e-07 0.5728373329037385 \
2.070966888523724e-07 0.5713590910263378 2.070967398944957e-07 0.5702089751121119 2.070968015962151e-07 0.5688198806440578 2.070968646860707e-07 0.5674025889664359 \
2.070969290444246e-07 0.5659586381304559 2.070969824382236e-07 0.5647616504486359 2.070970750808062e-07 0.5626864159088959 2.070971516880785e-07 0.5609719030357503 \
2.070972075131406e-07 0.5597256439368602 2.070972765672667e-07 0.5581857825097393 2.070973834553926e-07 0.5558054549196561 2.070974611990176e-07 0.5540764009223496 \
2.070975620491174e-07 0.5518382286767042 2.070976877299716e-07 0.5490568313009737 2.070977879716568e-07 0.5468419758621708 2.070978998893402e-07 0.5443739014182352 \
2.070980031552469e-07 0.5421024366463116 2.070981229045887e-07 0.5394737463112931 2.07098224637469e-07 0.5372436950013484 2.070983401572132e-07 0.5347185748314579 \
2.070984551922987e-07 0.5322102907975605 2.07098581673211e-07 0.529456475824718 2.070987070470086e-07 0.5267350629320526 2.070988538629319e-07 0.5235577714138258 \
2.070989894263807e-07 0.5206304261698983 2.070991471246342e-07 0.5172373565578411 2.070993094436886e-07 0.5137528589513558 2.070994902675847e-07 0.5098871206809381 \
2.070996827159054e-07 0.5057874350093188 2.070998956212086e-07 0.5012700264709963 2.071001278026081e-07 0.4963634062180514 2.071003850931867e-07 0.4909555076455908 \
2.071006247190101e-07 0.4859407514401474 2.071009264344461e-07 0.479662588092526 2.071012143537997e-07 0.4737079198104491 2.071015272426189e-07 0.4672821326282255 \
2.071018469808238e-07 0.4607585360408045 2.071021865759847e-07 0.4538766993710576 2.071025134784829e-07 0.4472977926730654 2.071028490368641e-07 0.4405887635920606 \
2.071031661327868e-07 0.4342949501181722 2.071035003705415e-07 0.4277061431972559 2.071038518016635e-07 0.4208322784122511 2.071041663278176e-07 0.4147233751108969 \
2.07104489505308e-07 0.4084912998479469 2.071049306200656e-07 0.400057814108821 2.071052727361035e-07 0.3935812134363078 2.071055726806328e-07 0.3879522399691127 \
2.071059478116385e-07 0.3809760137481454 2.071062775558777e-07 0.3749002425561211 2.071065607988036e-07 0.3697269896098562 2.071068609450588e-07 0.3642865787664632 \
2.071071405472531e-07 0.3592589179584539 2.071073643233647e-07 0.3552676761685443 2.071075761036954e-07 0.3515151294490645 2.071077785371594e-07 0.3479514629380864 \
2.071079796284271e-07 0.3444362246481504 2.071081853428453e-07 0.3408632458568372 2.071084529657171e-07 0.3362478643926977 2.071086918970113e-07 0.3321601360780691 \
2.07108925403074e-07 0.3281974319442653 2.071091388684736e-07 0.3246000376975314 2.071093602460465e-07 0.3208952602338652 2.071095602096931e-07 0.3175728982722026 \
2.071097644820061e-07 0.3142073831356898 2.071099618288778e-07 0.3109812293225088 2.071101472014048e-07 0.3079732989686547 2.071103433077958e-07 0.3048147723336881 \
2.071105455849362e-07 0.3015820927993307 2.071107212432327e-07 0.2988007390096292 2.0711090711339e-07 0.295878328903569 2.071111140927825e-07 0.2926488196724605 \
2.071112994143739e-07 0.2897857719971084 2.071114946411816e-07 0.2867989994419413 2.07111650415531e-07 0.28443329608414 2.071118291723129e-07 0.2817356906084737 \
2.071120102032329e-07 0.2790344478478936 2.071121601003467e-07 0.2768142575519123 2.071123611437744e-07 0.273859574769726 2.071125102589039e-07 0.2716833853889438 \
2.071126487983335e-07 0.2696726034832688 2.071128006734089e-07 0.2674956304896134 2.071129151475376e-07 0.2658586287383957 2.071130466774683e-07 0.2639823142040156 \
2.071131724359563e-07 0.2622048582339201 2.071132767763623e-07 0.2607341604582348 2.071133897557217e-07 0.2591418073851619 2.071135060842464e-07 0.2575033437579446 \
2.071136490116675e-07 0.2554974228347739 2.071137622731725e-07 0.2539102348881249 2.071138964299053e-07 0.2520298733123076 2.071140069027097e-07 0.2504818583075984 \
2.071141623352847e-07 0.2483006006477398 2.071143032203835e-07 0.2463217957442577 2.071144546129539e-07 0.2441928603691365 2.071146097750346e-07 0.2420086586735095 \
2.071147391842834e-07 0.2401849910837116 2.071148738963765e-07 0.2382868210192302 2.071150115942015e-07 0.2363478190565156 2.071151293462172e-07 0.2346905900295477 \
2.071152886704099e-07 0.2324499447852502 2.071154259326364e-07 0.2305210708572645 2.071155666789934e-07 0.2285488733964877 2.071156724701667e-07 0.2270688194984586 \
2.071158024115646e-07 0.2252532503786337 2.071159029480282e-07 0.2238506847401111 2.071160052817357e-07 0.2224250970611539 2.071160790103172e-07 0.2214012665004395 \
2.071161582442603e-07 0.2203047212273054 2.071162292155075e-07 0.2193236206014474 2.071162806785351e-07 0.218612902325451 2.071163336269882e-07 0.2178825126218075 \
2.071164127819908e-07 0.2167921001391954 2.071164550546259e-07 0.2162104926182252 2.071164948991708e-07 0.2156628374086678 2.071165381228204e-07 0.2150692779925967 \
2.071165790298225e-07 0.2145080585354088 2.071166491522843e-07 0.2135474129702876 2.071166828372557e-07 0.2130867492099046 2.071167276666377e-07 0.212477723463 \
2.071167865237998e-07 0.2116792343136102 2.071168513092605e-07 0.2108017053965978 2.071169087900245e-07 0.2100241135398916 2.071169692190328e-07 0.209207737948094 \
2.071170662554631e-07 0.2078991976528634 2.07117150945123e-07 0.2067595417901527 2.071172598558851e-07 0.2052972881712416 2.071173562566921e-07 0.2040065614180294 \
2.071174512733294e-07 0.2027428333585779 2.071175547051275e-07 0.2013717100485363 2.071176496344728e-07 0.2001158751783069 2.071177526548994e-07 0.198757993281026 \
2.071178577373321e-07 0.1973779917312911 2.071179670461462e-07 0.1959482000350934 2.071180774896281e-07 0.1945091075764383 2.071181937799036e-07 0.1929996650696684 \
2.071183037098964e-07 0.1915811184357085 2.071184133723204e-07 0.1901717999899754 2.071185150889654e-07 0.1888694322720079 2.071186080436791e-07 0.1876837490531375 \
2.07118700772569e-07 0.1865049219968967 2.07118774458125e-07 0.1855719169757668 2.071188572993399e-07 0.1845269810791141 2.071189318853365e-07 0.1835895008849975 \
2.071190016086783e-07 0.1827150226754214 2.071190683270854e-07 0.1818808699270075 2.071191641704113e-07 0.1806871657728035 2.071192468771839e-07 0.1796611249561687 \
2.071193404410076e-07 0.1785035608809835 2.07119435337095e-07 0.1773351434884491 2.071195467074053e-07 0.1759704596301353 2.071196883497589e-07 0.1742450478777388 \
2.071198035966122e-07 0.1728486436789435 2.071199481442513e-07 0.1711076225712051 2.071200597399285e-07 0.1697708811114609 2.071202009589021e-07 0.1680898955975501 \
2.071203166961755e-07 0.1667201145354908 2.071204226568608e-07 0.1654722325850081 2.071205214164775e-07 0.164314417410061 2.071206177596498e-07 0.1631901152369615 \
2.071207064174022e-07 0.1621596955203892 2.071208317516728e-07 0.1607099933926625 2.071209262770884e-07 0.1596224416957933 2.071210240160401e-07 0.1585042187118262 \
2.071211321109172e-07 0.1572745454417887 2.071212267786047e-07 0.1562036643369483 2.071213342264514e-07 0.1549951394274829 2.071214253154951e-07 0.1539767092330788 \
2.071215320872068e-07 0.1527896463435911 2.071216354804728e-07 0.1516469620792683 2.071217465609577e-07 0.1504267727114754 2.071218357869395e-07 0.1494522115900035 \
2.071219212668682e-07 0.1485231035185812 2.071220051920549e-07 0.1476157397758405 2.071220748986192e-07 0.1468658175993407 2.071221535366968e-07 0.1460232248551682 \
2.071222318479542e-07 0.1451880611912267 2.071223024838273e-07 0.1444378248611795 2.071223879746948e-07 0.1435337156153706 2.071224753636722e-07 0.1426139614481139 \
2.071225569511858e-07 0.1417594571206545 2.071226542701372e-07 0.1407454482154784 2.071227349596596e-07 0.139910090776864 2.071228257446906e-07 0.1389752404035735 \
2.07122947088963e-07 0.1377336220260025 2.071230361386038e-07 0.13682812281983 2.07123134655454e-07 0.1358318692385875 2.071232217417229e-07 0.1349560640726983 \
2.071233321526109e-07 0.1338550874529322 2.071234206114333e-07 0.1329791517134813 2.071235213400266e-07 0.1319874611681985 2.071236261295802e-07 0.1309622419763913 \
2.071237205198131e-07 0.1300442429014473 2.07123817024605e-07 0.1291112112475518 2.071239165112583e-07 0.1281591654439075 2.071240029124292e-07 0.1273384721630967 \
2.071240978925599e-07 0.1264411177628728 2.071242020813879e-07 0.1254629331099751 2.071243112001386e-07 0.124445178694 2.071244055505945e-07 0.1235704029653004 \
2.07124517846343e-07 0.1225411084520107 2.071246133096967e-07 0.1216733466577494 2.071247175205873e-07 0.1207311846737792 2.071248068659445e-07 0.1199276649878674 \
2.071248772532175e-07 0.1192980345746366 2.071249526392512e-07 0.1186268760051257 2.071250287714207e-07 0.1179522201461119 2.071250977489184e-07 0.1173458504859956 \
2.071251802680909e-07 0.1166263596898966 2.071252522115779e-07 0.1160015972854393 2.071253342903043e-07 0.1152916772467617 2.071254186247801e-07 0.1145654108773922 \
2.07125496418619e-07 0.113898375935255 2.071255891835211e-07 0.1131065723182637 2.071257047873425e-07 0.1121254933399327 2.071258106929114e-07 0.1112341778178403 \
2.071258883498312e-07 0.1105854195321705 2.071259766463023e-07 0.1098504899494786 2.071260567033545e-07 0.1091866403929743 2.071261536294793e-07 0.1083861389179563 \
2.07126248864964e-07 0.1076031391441806 2.071263374361587e-07 0.1068780200140514 2.071264387442599e-07 0.1060523297458165 2.071265442899473e-07 0.1051963702337609 \
2.071266534843119e-07 0.1043160928234657 2.071267616019328e-07 0.1034503663302994 2.071268815196938e-07 0.1024949450012773 2.071269828815214e-07 0.1016914181115986 \
2.071270888911509e-07 0.100855068690839 2.071272146827803e-07 0.09986840123414902 2.071273442400857e-07 0.09885896724496235 2.071274799154405e-07 0.09780904711780367 \
2.071276559873037e-07 0.09645781830037269 2.071278197878238e-07 0.09521257997344186 2.071279826125652e-07 0.09398642071914091 2.071280677512003e-07 0.09334985726464029 \
2.07128137589223e-07 0.09282999162688726 2.071282070848284e-07 0.09231474740697931 2.071282810434879e-07 0.09176875214326782 2.071283771983755e-07 0.09106241641841166 \
2.071284516137408e-07 0.09051841344162129 2.071285296033096e-07 0.08995079828656057 2.071286060521396e-07 0.08939693755534793 2.071286935462239e-07 0.08876614459792892 \
2.071287957229341e-07 0.08803382885421264 2.071288842873223e-07 0.08740269463919083 2.071289939528099e-07 0.08662585268124241 2.071291100092175e-07 0.08580942306245626 \
2.07129251558034e-07 0.0848216759818637 2.071293844270176e-07 0.08390253510334872 2.071295251873282e-07 0.08293727564630923 2.071296748969478e-07 0.08192024575105315 \
2.071298106088348e-07 0.08100683753927941 2.071299521257171e-07 0.08006309454860433 2.071300872475907e-07 0.07917070961097784 2.071302285200282e-07 0.07824718349428782 \
2.071303756129204e-07 0.07729532867436953 2.07130527122786e-07 0.07632524417621221 2.071306924984999e-07 0.07527819040792309 2.071308562596902e-07 0.07425356708383206 \
2.071310323896319e-07 0.07316505371836476 2.071312215286099e-07 0.07201151367936541 2.071314322022337e-07 0.07074528708793332 2.071316517688556e-07 0.06944624562626683 \
2.071318865352622e-07 0.06808094281860989 2.071321449277003e-07 0.06660616301228137 2.071324395923605e-07 0.06496103773121734 2.071327436716829e-07 0.06330286177969326 \
2.071331045821629e-07 0.06138472526627536 2.071334404990352e-07 0.05964719353945821 2.071338806764061e-07 0.05743991201668189 2.071342590438092e-07 0.05560437501227136 \
2.071347015027716e-07 0.05352996728430704 2.071350555229165e-07 0.05192508193542229 2.071354420396718e-07 0.05022502935509546 2.07135786643729e-07 0.04875485597254389 \
2.071361086186649e-07 0.04741934964807833 2.07136412152492e-07 0.04619304551845941 2.071367070734883e-07 0.04503122626702559 2.071369895557667e-07 0.04394770877170886 \
2.071372666361775e-07 0.04291147062934708 2.071375323636684e-07 0.04194013461971725 2.071378035943552e-07 0.0409708748276704 2.071380798533722e-07 0.04000619535229137 \
2.071383697525942e-07 0.03901828782233653 2.071385981289875e-07 0.03825741181922668 2.071389030130544e-07 0.03726495139513845 2.071391196849105e-07 0.03657573971894532 \
2.071393110416374e-07 0.03597943984071691 2.071395096361558e-07 0.03537298232318693 2.071398395514967e-07 0.03438820140908775 2.071400814971701e-07 0.03368375433354889 \
2.071403968092223e-07 0.03278771666975258 2.071406669292072e-07 0.03203957074185158 2.071409233008807e-07 0.03134567005659093 2.071412033128806e-07 0.03060515313352298 \
2.071414489686567e-07 0.02997014710356035 2.071416817043018e-07 0.02938120249260199 2.07141924434299e-07 0.02878348292867495 2.071421611615635e-07 0.02821317433052753 \
2.071423898079744e-07 0.0276732289298247 2.071428070936345e-07 0.02671456010533928 2.071430022743284e-07 0.02627749693639509 2.071433834414109e-07 0.02544369227895442 \
2.071435606942329e-07 0.02506446942885681 2.071439031456878e-07 0.02434654114125227 2.071440564141201e-07 0.02403127656358269 2.071444314325841e-07 0.02327616399748992 \
2.071445690667252e-07 0.02300530455388665 2.071450533333593e-07 0.02207084195640928 2.071451729527604e-07 0.02184403312078184 2.071455899915636e-07 0.02106026682208277 \
2.07145733393791e-07 0.02079332360769017 2.071462546051726e-07 0.01984598817089831 2.071463823790427e-07 0.0196205814374062 2.071469667914167e-07 0.01863359713481367 \
2.071471392268229e-07 0.01835589372257288 2.071477433235728e-07 0.01743644241612937 2.071479047552142e-07 0.01720262545858322 2.071485447014338e-07 0.01631831686205014 \
2.071487230176005e-07 0.016083210242981 2.071493710016487e-07 0.01526127675881721 2.071495362552397e-07 0.01505930898173208 2.071502725571753e-07 0.01419381259610907 \
2.071504068332255e-07 0.01404154276213586 2.071512039327433e-07 0.01317592498067951 2.071513445303545e-07 0.01302934089458718 2.071523098735771e-07 0.0120661300044765 \
2.071524742123827e-07 0.01190857475316222 2.071534749435119e-07 0.01099048917119646 2.07153612213369e-07 0.01087009009405628 2.071547509078863e-07 0.009949273443646761 \
2.071548650857872e-07 0.009863136028526375 2.071562457306217e-07 0.008889755784408603 2.071564000878327e-07 0.00878832203975914 2.071579465820612e-07 0.00781340401000951 \
2.071580309437644e-07 0.007760176032106158 2.071597163710821e-07 0.006770348169342283 2.071598398995725e-07 0.00670487246831437 2.071618897141387e-07 0.005720970231232756 \
2.071620861142965e-07 0.005634691917282852 2.071644047936537e-07 0.004698942116576918 2.071648654079885e-07 0.004530544077955615 2.071676055035305e-07 0.003639937533647344 \
2.071681236485673e-07 0.00349159181499799 2.071722742898753e-07 0.002502201117031859 2.071728121398825e-07 0.002396807933581942 2.0717889437533e-07 0.001421603691354927 \
2.071791533557405e-07 0.001378272220758726 2.071844761190904e-07 0.0003814093765652445 2.071845892761344e-07 0.0003711807182531981 2.098307063923701e-07 -0.0004615907568095335 \
2.098308688313385e-07 -0.0006852153244161934 2.098313698328069e-07 -0.001554404032531494 2.098314540153697e-07 -0.001725199767551738 2.098318555381938e-07 -0.002626792336557519 \
2.098319448731607e-07 -0.002845673237760077 2.098322314649697e-07 -0.0035898660494722 2.098323590334993e-07 -0.003937855927128601 2.098326777451613e-07 -0.004830400105952924 \
2.098327919463135e-07 -0.00515011308870196 2.098330743466382e-07 -0.005887653497963378 2.098332045728569e-07 -0.006177415671381139 2.098341829257541e-07 -0.005220113099403402 \
2.098343702332871e-07 -0.004004368716724641 2.098345016776888e-07 -0.002901539130564616 2.098346071052425e-07 -0.001869327786897239 2.098346928227261e-07 -0.0009323217369615201 \
2.098347747492128e-07 4.151965372454519e-05 2.098348957860361e-07 0.001618129410352471 2.098349947146829e-07 0.003024565667809575 2.098351531113568e-07 0.005482561958548801 \
2.098353705585867e-07 0.00923691162542661 2.098355517808096e-07 0.0126653356758144 2.098357638749061e-07 0.01697021734206094 2.098359268985627e-07 0.02046388365739064 \
2.098360875209785e-07 0.02403759527126768 2.09836241061221e-07 0.02755862871109176 2.098363891179022e-07 0.031036270750196 2.098365381988111e-07 0.03460722192241437 \
2.098366927287225e-07 0.03837091703902212 2.098368533795379e-07 0.04234026030123839 2.098370180342186e-07 0.04645786783841532 2.098371945751169e-07 0.05091770581196236 \
2.098373735379688e-07 0.05547793877747508 2.098375642811338e-07 0.0603721650098247 2.09837769062163e-07 0.06565647483694508 2.098379895344492e-07 0.07137203566208646 \
2.098382223941741e-07 0.0774299331224613 2.098384715816505e-07 0.08392829098722057 2.098387444237776e-07 0.09105513637423955 2.098390411275777e-07 0.09880974921055499 \
2.098393684539683e-07 0.1073623706929605 2.098397381053549e-07 0.11701033799881 2.09840132977169e-07 0.1273002725707723 2.098405908154097e-07 0.1392030195235975 \
2.098411226222497e-07 0.1529832553757746 2.09841747860046e-07 0.1691182447448397 2.098424336075175e-07 0.1867241161332086 2.098432360033912e-07 0.2071957342970069 \
2.09844134802183e-07 0.2299563735557614 2.098449404156324e-07 0.2501946571168963 2.098456541669658e-07 0.2679877251922811 2.098462837288478e-07 0.2835633151515627 \
2.098468540922982e-07 0.2975737963344939 2.098473850476804e-07 0.3105173405876944 2.098478868351306e-07 0.3226580892822354 2.098483661296844e-07 0.3341673054699896 \
2.098488316851033e-07 0.3452566901045974 2.098492954815109e-07 0.3562094254686541 2.098497512295407e-07 0.3668794056881832 2.098502114496752e-07 0.3775613305945491 \
2.098507497336462e-07 0.3899285626759094 2.098512505841796e-07 0.4013172511919189 2.098516508068632e-07 0.4103337945930838 2.098521576676441e-07 0.421642452039157 \
2.098526436338564e-07 0.4323669409017459 2.098530431485677e-07 0.4410997362599856 2.098534537606271e-07 0.4500002277813482 2.098538826870602e-07 0.4592207708982954 \
2.098542842014423e-07 0.4677760623951868 2.098545915918887e-07 0.4742753916877908 2.098549418336473e-07 0.4816249679276425 2.098552950738506e-07 0.4889795533930016 \
2.0985554824443e-07 0.4942125642332652 2.098557811883199e-07 0.4989990073547648 2.098560228316108e-07 0.5039392821429431 2.098562478222295e-07 0.5085102868389438 \
2.098564398583375e-07 0.5123881070394828 2.098566246700343e-07 0.5161059569497825 2.098568469603498e-07 0.5205538992744256 2.098570136717574e-07 0.5238726938135662 \
2.098572308883525e-07 0.5281726418673847 2.098574339672442e-07 0.5321820613122353 2.098576113786994e-07 0.5356681922482178 2.098577994510863e-07 0.5393528234657015 \
2.098580354832656e-07 0.5439555888699217 2.098583013652896e-07 0.5491186112539347 2.098585231271783e-07 0.5534070305875756 2.098588031850331e-07 0.5588091140818973 \
2.098590461848179e-07 0.5634839438879177 2.09859321538161e-07 0.5687575845994758 2.098595665335016e-07 0.5734440561015828 2.098598068277205e-07 0.5780305526007354 \
2.098600478670234e-07 0.5826153106864888 2.09860305457841e-07 0.5874946531182738 2.098605408246178e-07 0.5919209497705462 2.09860772126727e-07 0.5962518282209535 \
2.098609946534482e-07 0.6003950532231523 2.098612030130559e-07 0.6042587207462122 2.098614408548706e-07 0.6086392006348278 2.098616517150854e-07 0.612499186772883 \
2.09861907322267e-07 0.617151767543529 2.098621060500327e-07 0.620751700070918 2.098623816826772e-07 0.6257066023742009 2.098626044387981e-07 0.6296824120643636 \
2.098628978099216e-07 0.6348814180513288 2.098631305799232e-07 0.6389753720667986 2.098633507813092e-07 0.6428252659334456 2.098635520519211e-07 0.6463216644290061 \
2.098637693407936e-07 0.6500784077528632 2.098639440567036e-07 0.6530842133917786 2.098641303213334e-07 0.6562672470877895 2.098643090603859e-07 0.6593113758161715 \
2.098644717643993e-07 0.6620700940033843 2.098646370334099e-07 0.6648583661366954 2.098647803012238e-07 0.6672607123132118 2.09864919531648e-07 0.669583864918244 \
2.098650593322146e-07 0.6719085596965743 2.098651941074223e-07 0.6741424479378803 2.098653216016633e-07 0.6762463034350935 2.098654545557747e-07 0.6784344250006583 \
2.098655761601249e-07 0.680430207161383 2.098657045733663e-07 0.6825336955632141 2.098658203404209e-07 0.6844241240890321 2.098659183815937e-07 0.686020684362688 \
2.098660190776997e-07 0.687656981754083 2.098661288314626e-07 0.689434454762776 2.098662455994179e-07 0.6913211166705923 2.098663368261916e-07 0.6927889453402305 \
2.098664460316049e-07 0.6945396927028351 2.098665471403262e-07 0.6961566646470493 2.098666425406182e-07 0.6976767415743361 2.098667520226426e-07 0.6994136821864276 \
2.098668864742773e-07 0.7015344809028976 2.098670354932137e-07 0.7038694457768003 2.098671644232324e-07 0.7058755144243859 2.09867311083691e-07 0.7081418729260142 \
2.098674378680718e-07 0.7100885084081828 2.098675624659611e-07 0.7119899232102255 2.098676743197281e-07 0.7136874821928206 2.098677872756922e-07 0.7153928249203609 \
2.098678878290893e-07 0.716903336497302 2.098680251105924e-07 0.7189542886859326 2.098681449794518e-07 0.7207346491296758 2.09868264162204e-07 0.7224952472954583 \
2.098683911643136e-07 0.7243608783177121 2.098685157126648e-07 0.726179956024653 2.098686393836757e-07 0.7279757435764195 2.09868765971953e-07 0.7298035010246171 \
2.098688965411881e-07 0.7316777339938921 2.098690190562223e-07 0.7334262671520465 2.098691552997129e-07 0.7353588786631546 2.098692567424861e-07 0.7367901064855561 \
2.09869362765969e-07 0.7382789144707947 2.098694532971524e-07 0.7395446819117977 2.098695671233782e-07 0.7411267287627761 2.098696547849604e-07 0.742338113895605 \
2.098697606802377e-07 0.7437932991468792 2.098698910335325e-07 0.7455718205320391 2.098700016011403e-07 0.7470699275523445 2.098701062716115e-07 0.7484790865773925 \
2.09870230233143e-07 0.7501360792234356 2.09870378790597e-07 0.752105598322839 2.098705004731933e-07 0.7537054667443914 2.098706145848825e-07 0.7551949470168074 \
2.098707550054835e-07 0.7570132059451244 2.098708965335436e-07 0.7588296197226846 2.098710143228134e-07 0.7603289862386273 2.098711425226351e-07 0.7619481626911874 \
2.098712845904683e-07 0.7637269294216019 2.098714014655762e-07 0.7651780119234867 2.098715471393621e-07 0.7669714049983392 2.098716688778096e-07 0.7684572223066155 \
2.098717875183015e-07 0.7698939375992205 2.098719099845946e-07 0.7713653733660819 2.098720367016846e-07 0.7728756341192486 2.098721466036788e-07 0.7741754302862822 \
2.098722722190223e-07 0.7756497674172792 2.098723780294307e-07 0.7768823528242577 2.098725141995534e-07 0.7784559787239111 2.098726385466015e-07 0.7798807766277074 \
2.098727659718769e-07 0.7813271999647126 2.098728805279564e-07 0.7826155184370988 2.098729872082259e-07 0.7838050786084815 2.098731251508229e-07 0.785328674235108 \
2.098732746003193e-07 0.7869612315653352 2.098734194525364e-07 0.7885256944569791 2.098735388882871e-07 0.7898026796320731 2.0987367431316e-07 0.7912364721526877 \
2.09873795807481e-07 0.7925100718437531 2.098739391665555e-07 0.7939977458315933 2.09874082600237e-07 0.7954699260458764 2.098742084112467e-07 0.7967479640295563 \
2.098743274579285e-07 0.7979459892863545 2.098744394715731e-07 0.7990632136113104 2.098745442634543e-07 0.8000996927221937 2.098746394563032e-07 0.8010335634530776 \
2.098747758668286e-07 0.8023587211299719 2.098748926790049e-07 0.8034813603122919 2.098750121402484e-07 0.8046180202255495 2.098751341806002e-07 0.8057672874017472 \
2.098752570806969e-07 0.8069126780167393 2.098753842000533e-07 0.8080849010520604 2.098755093419151e-07 0.8092265787736463 2.098756398931422e-07 0.8104047139317369 \
2.09875765969389e-07 0.811530109085512 2.098758939660489e-07 0.8126603425876329 2.098759994272971e-07 0.8135823118114501 2.098761026965977e-07 0.814477091043954 \
2.098761953499458e-07 0.8152732203909091 2.098763190441811e-07 0.8163262937528154 2.098764066640956e-07 0.8170655553659417 2.098765053301514e-07 0.8178914289762149 \
2.098766488771539e-07 0.819080619224994 2.098767844633066e-07 0.8201904093102529 2.098768936532881e-07 0.8210742465492874 2.098770411027471e-07 0.8222539401850584 \
2.09877191506449e-07 0.8234410273756358 2.098773169754118e-07 0.8244188977545531 2.098774611413952e-07 0.8255287290252299 2.098775854299599e-07 0.8264738611628292 \
2.098777359002563e-07 0.8276038147969816 2.098778715066145e-07 0.8286089145501508 2.09877996601616e-07 0.8295251220930787 2.098781143174533e-07 0.8303776282987162 \
2.098782602030521e-07 0.8314210189912619 2.098784266961482e-07 0.8325942517713072 2.098785575628508e-07 0.833503494447128 2.098787310074617e-07 0.8346911703335461 \
2.098788991402022e-07 0.8358239212093587 2.098790689939496e-07 0.8369500705213252 2.098792498869552e-07 0.838129582835239 2.098793930212163e-07 0.8390486258646698 \
2.098795071191619e-07 0.8397723391454259 2.098796372463218e-07 0.8405879656882547 2.098797391021787e-07 0.8412191375388212 2.098798559475988e-07 0.8419354178465567 \
2.098799929193963e-07 0.84276453896487 2.098801907591422e-07 0.843942473808897 2.098803824446297e-07 0.8450620046306492 2.09880591850993e-07 0.8462610422160779 \
2.098807738618767e-07 0.8472832413425977 2.098809709773334e-07 0.8483697584184032 2.098811442904469e-07 0.8493077402131245 2.098813273256562e-07 0.8502809338042043 \
2.098814984787832e-07 0.8511747489972419 2.098816731317363e-07 0.8520708361396651 2.098818483828913e-07 0.8529540285731302 2.098820245303913e-07 0.8538259128238825 \
2.098822148367787e-07 0.8547503816925358 2.098824054277479e-07 0.8556583881771193 2.098826059797908e-07 0.8565949481971697 2.098827985825885e-07 0.8574764650234362 \
2.098830093312883e-07 0.8584213553684483 2.098832373621857e-07 0.8594210644592908 2.098835032419522e-07 0.8605573106989262 2.098838018200941e-07 0.8617960322792503 \
2.098840779837292e-07 0.8629075153790151 2.098843622302292e-07 0.8640180616030438 2.098846364142308e-07 0.8650581816846495 2.098849086694401e-07 0.8660616517296992 \
2.098851788589146e-07 0.8670295451208139 2.098854360232381e-07 0.8679256252637404 2.098857085969722e-07 0.8688492356117473 2.098859846024351e-07 0.8697577927663542 \
2.09886254710518e-07 0.8706213441784563 2.098865545689379e-07 0.8715508809746347 2.098869255828164e-07 0.8726599440782473 2.098872205155291e-07 0.873510245983525 \
2.098874748008955e-07 0.8742218447789023 2.098877730441708e-07 0.8750318897722944 2.098880466409288e-07 0.8757523113099853 2.098882827679075e-07 0.8763571312809064 \
2.098885231072055e-07 0.876957042728428 2.098887454408612e-07 0.8774982514557473 2.098889394467937e-07 0.8779599514934209 2.098892691652286e-07 0.8787226653583874 \
2.098894243380191e-07 0.8790722725343518 2.098897420714095e-07 0.8797700114458387 2.098899209390604e-07 0.880152324917399 2.09890263400534e-07 0.8808637455080008 \
2.098904475523683e-07 0.8812353200296749 2.098909224784184e-07 0.8821594045029107 2.098910898716537e-07 0.8824737723885729 2.098915556929605e-07 0.8833186808430151 \
2.098917365204472e-07 0.883635209600208 2.098922305497857e-07 0.8844687288968743 2.098923718877729e-07 0.8846990198924604 2.098929782491027e-07 0.8856473543416146 \
2.098931303209552e-07 0.8858754372639542 2.098937770089477e-07 0.8868048391838264 2.098939053031091e-07 0.8869818633102416 2.098945534965822e-07 0.8878410756373726 \
2.098946832451334e-07 0.8880061989117775 2.09895451498601e-07 0.8889361126992519 2.098955812406254e-07 0.8890847997417872 2.098964346975575e-07 0.8900046759307325 \
2.098965779246734e-07 0.8901495209380393 2.098975641580769e-07 0.8910738355210844 2.09897785636141e-07 0.8912643084423501 2.098989286536885e-07 0.8921737958641509 \
2.098990586319894e-07 0.8922730011388891 2.099004103389882e-07 0.8932565980587214 2.099005606923423e-07 0.8933589605607284 2.09902041315768e-07 0.8942730372387374 \
2.0990228021907e-07 0.8944047337041336 2.099040613442277e-07 0.8952702388217941 2.099044473255946e-07 0.8954343910560414 2.099068488716345e-07 0.896309305076933 \
2.099073238084202e-07 0.8964562995603377 2.099111419701395e-07 0.8973944547681553 2.099116244593365e-07 0.897487269196476 2.099195104748494e-07 0.898471373493449 \
2.099201266375397e-07 0.8985180228791175 2.100152826123789e-07 0.899508178894561 2.100167732145567e-07 0.8995204306067698 2.101280612887407e-07 0.9005118233983579 \
2.101282376257435e-07 0.9005706457326812 2.10131860757067e-07 0.8996048713171836 2.101320419550936e-07 0.8994654179496379 2.101333530765704e-07 0.8985275682722235 \
2.101335349539762e-07 0.8984123497545736 2.101353579441702e-07 0.8974436520388238 2.101355178574244e-07 0.8973766233009967 2.101486686887231e-07 0.8983720910457982 \
2.101487796702765e-07 0.8983905835035384 2.101576012543832e-07 0.8993863063850064 2.101581480238467e-07 0.8994226481040219 2.106507199766805e-07 0.9003987622903815 \
2.106507897691656e-07 0.9004496773542636 2.106516224219291e-07 0.9012853800543292 2.106517484680941e-07 0.9014513953152168 2.106523289889575e-07 0.9023435091985418 \
2.106524699532118e-07 0.9025895326188698 2.106528690912908e-07 0.9033428289365844 2.106530192408316e-07 0.9036449200440446 2.106534623221535e-07 0.9045762589490434 \
2.106536194942562e-07 0.9049121924877023 2.106540651209874e-07 0.9058152254958243 2.106541635773263e-07 0.9059929146639856 2.106555802587204e-07 0.9052304871087643 \
2.10655711415865e-07 0.904616184869324 2.106558804230411e-07 0.9036290332250884 2.106560457149166e-07 0.9024406226812831 2.106561519806978e-07 0.9015554774641358 \
2.106562554175281e-07 0.9006052096506509 2.106563411842469e-07 0.8997486040545581 2.106564306782332e-07 0.8987887485205278 2.106565549226324e-07 0.8973492764100613 \
2.106566730035805e-07 0.8958624931586439 2.106567602196721e-07 0.8946938835082598 2.106568845267161e-07 0.8929289312882503 2.106569915106439e-07 0.8913158670103165 \
2.106570913423478e-07 0.8897378501708729 2.106572176331742e-07 0.8876466417139378 2.106573858217853e-07 0.884705368138502 2.106575415215381e-07 0.8818365157686672 \
2.106577381263672e-07 0.8780362649814708 2.106579217476167e-07 0.8743271923380105 2.106581332550105e-07 0.8698916163736473 2.106583140648106e-07 0.8659808238081558 \
2.106584986458582e-07 0.8618945354625286 2.106586716498537e-07 0.8579913311618118 2.106588570505038e-07 0.8537436868396935 2.106590361336512e-07 0.8495884889292737 \
2.106592197227131e-07 0.8452850234109005 2.106593864844183e-07 0.8413449312544377 2.10659554574996e-07 0.8373487193315756 2.10659717684167e-07 0.8334514816705533 \
2.106598728704027e-07 0.829729402178684 2.10660045969282e-07 0.8255639501984255 2.106602319597377e-07 0.8210763864673301 2.106603965802216e-07 0.8170961425007568 \
2.106605614501323e-07 0.8131038678717658 2.106607367821645e-07 0.8088537582860886 2.106609012086681e-07 0.8048648186953292 2.106610698442787e-07 0.8007719922541914 \
2.106612606476452e-07 0.7961398815555145 2.106614461718184e-07 0.7916360074082958 2.106616551006281e-07 0.7865651471012967 2.10661879917618e-07 0.7811107659751856 \
2.106620697327054e-07 0.77650678233121 2.106622715901883e-07 0.7716133355283564 2.106624158608269e-07 0.76811790639139 2.106625575043926e-07 0.7646880872338248 \
2.106626852021022e-07 0.7615975116975136 2.106627962479435e-07 0.7589113686396982 2.106629248105796e-07 0.7558028559024855 2.10663057376087e-07 0.7525995467138866 \
2.106631706977832e-07 0.7498629233610832 2.106633070324095e-07 0.7465723252212872 2.106634134316607e-07 0.7440058350410135 2.106635726504468e-07 0.7401674766516904 \
2.106637450281421e-07 0.7360137588823189 2.10663907275386e-07 0.7321074183421575 2.106640796243437e-07 0.7279612819449855 2.106642390105271e-07 0.7241302920521341 \
2.106644468157139e-07 0.7191408067115369 2.106646073553789e-07 0.7152908836069264 2.106647998447152e-07 0.7106793324906435 2.10664985361064e-07 0.7062404417184839 \
2.106651552371093e-07 0.7021802791355866 2.106653471069473e-07 0.6975984806629684 2.106654933309623e-07 0.6941099299715526 2.106656536173094e-07 0.6902897983225644 \
2.10665856006145e-07 0.6854719661536142 2.10666037294609e-07 0.681161582477689 2.106662061160357e-07 0.6771536053116509 2.106663919619109e-07 0.6727470762459599 \
2.106665978927512e-07 0.6678715161770782 2.10666765819558e-07 0.6639016226084196 2.106669260812615e-07 0.6601182542089066 2.106671649337354e-07 0.65448589698252 \
2.106673326948486e-07 0.6505369020837752 2.106675137682881e-07 0.6462813620835641 2.106676749231988e-07 0.642499550819208 2.106678211904597e-07 0.6390715923276049 \
2.106679598785689e-07 0.6358268652274862 2.106680892356149e-07 0.6328040340451749 2.106682186201702e-07 0.6297855584526113 2.106683469414899e-07 0.6267952385336898 \
2.106684771436295e-07 0.6237652412672913 2.106686061600736e-07 0.6207683673242944 2.106687447356331e-07 0.6175525629501428 2.106688928112201e-07 0.6141227553162802 \
2.106690791385052e-07 0.60981438109949 2.106692268222044e-07 0.6064079319686639 2.106694619864099e-07 0.600995965122186 2.106696544341406e-07 0.5965821560879089 \
2.106698950039548e-07 0.5910808370261941 2.106700640513256e-07 0.587228367631822 2.106702017177501e-07 0.5840969866928536 2.106703298227265e-07 0.581191110277254 \
2.10670443409422e-07 0.5786182870235701 2.106705347742257e-07 0.5765512826027382 2.106706241961132e-07 0.5745328691003393 2.106706914578463e-07 0.573016830490748 \
2.106707574780489e-07 0.5715297341779608 2.106708095317241e-07 0.5703577032508095 2.106708737705932e-07 0.5689124506700958 2.106709353071159e-07 0.5675311492520995 \
2.106709995886598e-07 0.5660899724818867 2.106710527797555e-07 0.5648985048860162 2.106711451255398e-07 0.5628316153148989 2.106712217014409e-07 0.5611191615154557 \
2.106712775450911e-07 0.5598732849310241 2.106713468881998e-07 0.5583285932816697 2.106714527394756e-07 0.5559733466166974 2.1067153043128e-07 0.5542469170533902 \
2.106716310298676e-07 0.5520159549745236 2.106717590630782e-07 0.5491849411292137 2.106718585604598e-07 0.5469885705929382 2.106719711258113e-07 0.544508366501287 \
2.106720741701315e-07 0.5422442603473754 2.106721942190172e-07 0.5396115972585003 2.106722958334261e-07 0.5373863339265779 2.10672411457693e-07 0.5348611538529422 \
2.106725265738742e-07 0.5323536236546169 2.106726530109181e-07 0.529604142030661 2.106727785251858e-07 0.5268822104345234 2.106729252048618e-07 0.5237112381511962 \
2.106730608755698e-07 0.5207845659358002 2.106732186414087e-07 0.5173942078023266 2.106733810633495e-07 0.5139116507621072 2.106735619718178e-07 0.5100482739823553 \
2.106737545639722e-07 0.5059503908118104 2.106739675557428e-07 0.5014368974673542 2.106741999884595e-07 0.4965308659362653 2.106744575093732e-07 0.49112491222925 \
2.106746974735513e-07 0.4861095397820235 2.106749986779057e-07 0.4798501326413723 2.106752869755342e-07 0.4738957353990632 2.106756000618611e-07 0.4674739717793394 \
2.106759195881407e-07 0.4609631488871989 2.106762590854062e-07 0.4540919149088484 2.106765852755184e-07 0.4475353831519197 2.106769217567802e-07 0.4408159131180407 \
2.106772384675873e-07 0.4345373385230166 2.106775725526604e-07 0.4279587671099637 2.106779242615287e-07 0.4210864038135054 2.106782387463783e-07 0.4149846225409808 \
2.106785621928357e-07 0.4087533091618546 2.106790031209485e-07 0.400331870031168 2.106793449160247e-07 0.3938679283557566 2.106796443500686e-07 0.3882534014213259 \
2.10680018872672e-07 0.3812944595528024 2.106803482503896e-07 0.375233915169682 2.10680631354694e-07 0.3700684563936956 2.106809310997049e-07 0.3646408765157301 \
2.106812105955488e-07 0.3596219010422631 2.10681434267487e-07 0.3556377385586224 2.106816459791946e-07 0.3518907610576284 2.106818484819268e-07 0.3483292724130969 \
2.10682049543475e-07 0.3448190020587957 2.106822552213837e-07 0.3412518188287665 2.106824735968598e-07 0.3374887625241871 2.106827173592566e-07 0.3333167726275162 \
2.106829441158294e-07 0.3294678078423895 2.106831640268007e-07 0.3257615367192951 2.106833824514083e-07 0.3221060038181086 2.106835864764178e-07 0.318715141566024 \
2.106837883342076e-07 0.3153870758963987 2.106839886575955e-07 0.3121102802474151 2.106841752715021e-07 0.309079115007194 2.106843725731086e-07 0.3058982938882217 \
2.10684581156335e-07 0.3025606704206737 2.106847867910569e-07 0.2992974534031506 2.106850115231368e-07 0.2957609785165763 2.106852284189794e-07 0.2923771984023277 \
2.106854360983307e-07 0.2891642611511841 2.106856671491776e-07 0.2856239464683982 2.10685841949429e-07 0.2829684481899911 2.10686021147604e-07 0.2802647299798244 \
2.106861900221201e-07 0.2777348429135014 2.106864183453934e-07 0.274348458173166 2.106865950826614e-07 0.2717528218126659 2.106867633653918e-07 0.2693020894036587 \
2.106869358321621e-07 0.2668230333489093 2.106870699344411e-07 0.264903804409765 2.10687215894446e-07 0.2628277003548514 2.106873545899465e-07 0.2608803500812688 \
2.106874768715512e-07 0.2591684246570544 2.106876109903814e-07 0.2572942758553639 2.106877400914859e-07 0.2554978336754472 2.106878595252204e-07 0.2538430842138498 \
2.106879863604196e-07 0.2520939183506197 2.106881060014414e-07 0.2504447954274527 2.106882556176353e-07 0.2483797066042054 2.106883904811462e-07 0.2465170278296022 \
2.106885200385602e-07 0.2447289494531232 2.10688677103379e-07 0.2425624627506451 2.106888010990138e-07 0.2408491463446025 2.106889412471492e-07 0.2389135279283614 \
2.106890711400503e-07 0.2371200701944942 2.106891917576705e-07 0.2354534357320198 2.106893542306008e-07 0.2332087289724075 2.106895002846996e-07 0.2311905595759856 \
2.106896386054839e-07 0.2292825126447264 2.106897465327019e-07 0.2277949627009887 2.106898773176093e-07 0.225993474229161 2.106899758236256e-07 0.22463752857886 \
2.106900799069717e-07 0.2232056532573264 2.106901527838364e-07 0.2222046546567725 2.10690234937313e-07 0.2210804129356655 2.10690302346398e-07 0.2201585377209549 \
2.106903490506606e-07 0.2195201149856669 2.106903984680203e-07 0.2188449488487562 2.10690489422163e-07 0.2176035744446363 2.106905558165761e-07 0.2166983392055156 \
2.106906027798693e-07 0.2160586379972232 2.106906530910749e-07 0.2153737902794619 2.106907122404248e-07 0.2145693142997165 2.106907550863284e-07 0.2139870779821451 \
2.10690798893629e-07 0.2133941263688522 2.106908684238941e-07 0.2124566309962414 2.106909553407082e-07 0.2112864027023158 2.106910365295633e-07 0.2101949018929156 \
2.106911224290264e-07 0.2090416531541652 2.106912165752074e-07 0.2077796428137634 2.106913083290811e-07 0.2065517647617813 2.106914036255171e-07 0.2052788208685862 \
2.106915001042083e-07 0.2039945431316728 2.106916009294901e-07 0.2026602783061639 2.106916968855022e-07 0.2013924147365721 2.10691799571213e-07 0.2000377255165624 \
2.106919026075665e-07 0.1986831378210229 2.10692012697906e-07 0.1972405340748948 2.106921214497938e-07 0.1958206085628783 2.106922411717489e-07 0.1942631948714586 \
2.106923516146512e-07 0.1928328887741874 2.106924596174588e-07 0.1914411844406488 2.10692584973803e-07 0.1898318066870429 2.106926779079788e-07 0.1886434908940876 \
2.106927562787551e-07 0.1876443873000938 2.10692832918829e-07 0.1866698667869858 2.106929154301432e-07 0.1856249297118943 2.106929849397592e-07 0.1847473639743596 \
2.106930508953873e-07 0.1839166514106665 2.106931151627221e-07 0.1831089953192083 2.106932271462069e-07 0.1817072258029639 2.106933212001737e-07 0.1805353135896268 \
2.106934288419354e-07 0.1791985758407087 2.106935353149934e-07 0.1778827552324552 2.106936553069199e-07 0.1764073736674057 2.106937933595456e-07 0.174720142305475 \
2.106939095201005e-07 0.1733081217455876 2.106940716169029e-07 0.1713503924599185 2.106941867054196e-07 0.1699688234017716 2.106943266910192e-07 0.1682987764548305 \
2.106944438970947e-07 0.1669083002780509 2.106945548164474e-07 0.1655990025649634 2.106946524449328e-07 0.1644521190704843 2.106947472954813e-07 0.1633427224865242 \
2.106948633498935e-07 0.161991523106341 2.106949548984438e-07 0.1609305136382055 2.106950510074198e-07 0.1598214181625073 2.106951452255534e-07 0.1587403933520305 \
2.106952387261563e-07 0.1576732160104884 2.106953323234783e-07 0.1566104070550305 2.106954280050165e-07 0.1555300824433628 2.106955185929212e-07 0.1545132165873678 \
2.106956096060781e-07 0.1534969984004868 2.106957051545556e-07 0.1524358767948732 2.106957958202681e-07 0.1514342506187442 2.106958988926308e-07 0.1503020548964867 \
2.106959713440797e-07 0.1495100717445464 2.106960504448726e-07 0.148649146151682 2.106961249930915e-07 0.1478424742503694 2.106961960245005e-07 0.1470770917224498 \
2.106962687889816e-07 0.1462962409077327 2.106963434061567e-07 0.1454990959398698 2.106964133891184e-07 0.1447543557055888 2.106964875500381e-07 0.143968261688537 \
2.106965412953772e-07 0.1434005634796054 2.106965945789319e-07 0.1428396203849428 2.106966597746903e-07 0.1421555039833398 2.106967310807313e-07 0.141411576573238 \
2.106967954507931e-07 0.1407432786314442 2.106968688027537e-07 0.1399847409254479 2.106969294203207e-07 0.1393607073002494 2.106970154538046e-07 0.1384787080092832 \
2.106970914048206e-07 0.1377037134581418 2.106971813727262e-07 0.1367902106004182 2.106972630996836e-07 0.1359645165492482 2.106973457896615e-07 0.1351360437760365 \
2.106974283459693e-07 0.1343145513298757 2.106975339081247e-07 0.1332698421778018 2.106976157754082e-07 0.1324642397250402 2.106977131428679e-07 0.1315110876582503 \
2.106978031437286e-07 0.130634908321232 2.106978911139876e-07 0.1297829978838479 2.106979740438426e-07 0.1289892226181523 2.106980482809344e-07 0.1282822873521282 \
2.106981479319927e-07 0.1273377645104763 2.106982436870518e-07 0.1264350619688987 2.106983305344566e-07 0.1256206895242312 2.106984205359939e-07 0.1247808744623497 \
2.106985008686745e-07 0.1240346855852102 2.106985875627031e-07 0.1232365419604467 2.106986863930319e-07 0.1223331159004786 2.106987764751698e-07 0.1215131568528167 \
2.106988867184272e-07 0.1205141992263624 2.106989739498662e-07 0.1197275966302077 2.106990425230003e-07 0.1191120727131645 2.106991271853926e-07 0.1183553887582162 \
2.106991936928737e-07 0.1177634990399222 2.106992651487993e-07 0.1171309945267847 2.106993348226041e-07 0.1165184920865242 2.106994121596921e-07 0.1158409171037389 \
2.106995079029745e-07 0.1150054407698888 2.10699579157887e-07 0.1143861389207103 2.106996465274204e-07 0.1138025718558601 2.106997149641909e-07 0.113211685696446 \
2.106997905545423e-07 0.1125613765304429 2.106998812963886e-07 0.1117840233035959 2.106999640001163e-07 0.1110788257213999 2.107000775991873e-07 0.1101151050704521 \
2.107001874748992e-07 0.1091895325357105 2.107002796742132e-07 0.1084169374841771 2.107004036235445e-07 0.1073835127717347 2.107004919878672e-07 0.1066505015902263 \
2.107006314468373e-07 0.1055001025916527 2.107007307435382e-07 0.1046863788921388 2.107008233935897e-07 0.1039306459201802 2.10700933598102e-07 0.1030359883605075 \
2.107010188925422e-07 0.1023467905686673 2.107011037933452e-07 0.101663637589173 2.107011867443086e-07 0.1009989740617136 2.107013092542103e-07 0.1000225794851696 \
2.107014311960626e-07 0.09905761200121259 2.10701557818349e-07 0.09806258992746317 2.107016706304718e-07 0.09718220909187772 2.107018152059564e-07 0.09606278874246346 \
2.107019529198845e-07 0.09500564015228773 2.107020696106743e-07 0.09411672853020667 2.107021973542416e-07 0.0931507147971556 2.107022970187578e-07 0.09240236948627445 \
2.107023764526375e-07 0.09180921593916676 2.107024751879354e-07 0.09107599640376031 2.10702553063239e-07 0.09050081472416407 2.107026345291548e-07 0.08990210528957472 \
2.107027092464628e-07 0.0893557072655629 2.107027897762006e-07 0.08876971652456604 2.107029086085259e-07 0.08791061481419053 2.107029982690622e-07 0.08726673116015753 \
2.107031031831091e-07 0.08651800316437093 2.107032346576667e-07 0.08558693768262025 2.107033957658019e-07 0.08445695903909305 2.107035359474973e-07 0.08348350561263763 \
2.107036844501031e-07 0.08246223579158835 2.10703821170292e-07 0.08153124812726546 2.107039611820024e-07 0.08058696725890066 2.10704098179202e-07 0.07967195061625794 \
2.107042367898133e-07 0.07875532825288725 2.107043812626999e-07 0.07780967510081127 2.107045288089374e-07 0.07685421131041187 2.107046863126477e-07 0.07584560580436887 \
2.107048507078841e-07 0.07480523464991846 2.107050187999819e-07 0.07375451744755303 2.10705199799341e-07 0.07263751640721161 2.107053985126234e-07 0.07142823309373261 \
2.10705611921415e-07 0.07014922396308329 2.107058380853001e-07 0.06881630383186611 2.107060786456226e-07 0.06742468841361035 2.107063562065355e-07 0.06585179211508728 \
2.107066534109385e-07 0.06420523370201831 2.107069717116618e-07 0.06248365192299224 2.10707361695962e-07 0.06043183534616462 2.107077605227481e-07 0.05839861031494715 \
2.10708202994687e-07 0.05621846258761681 2.107085879755898e-07 0.05438828987170503 2.107090000221824e-07 0.05249218901100536 2.10709351759698e-07 0.05092353490091287 \
2.107096872643497e-07 0.04946969867921969 2.107099977632446e-07 0.04816021644386199 2.107102917000643e-07 0.04695194805701195 2.107105844309969e-07 0.04577883625507727 \
2.107108592742044e-07 0.04470700909733757 2.107111331179271e-07 0.04366353526031765 2.107113988076876e-07 0.04267398813878486 2.107116741167033e-07 0.04167180388267511 \
2.107119586736207e-07 0.04066026046469497 2.107122549717362e-07 0.03963283340811159 2.107125138471216e-07 0.03875659098599576 2.107127418035276e-07 0.03800131046948733 \
2.107129605287219e-07 0.03729095380188759 2.107131803834489e-07 0.03659437723507575 2.107135212495136e-07 0.03554043311314246 2.107137972903943e-07 0.03470953269536187 \
2.107140907211692e-07 0.03384790442147732 2.107143732890922e-07 0.03303898052111545 2.107146281985287e-07 0.03232625790162248 2.107149088829884e-07 0.03155947796597136 \
2.107151547163818e-07 0.03090318379665042 2.107153868776701e-07 0.03029616297556957 2.10715627215008e-07 0.02968398395812225 2.107158628518432e-07 0.02909722707395018 \
2.107160910630208e-07 0.0285403787496557 2.107165078357495e-07 0.02755138287878544 2.10716702361127e-07 0.02710176794309662 2.107170886015322e-07 0.02623051698020805 \
2.10717267770925e-07 0.0258356865503758 2.107176189981086e-07 0.02507792837274256 2.107177869041566e-07 0.0247229612172224 2.107181711668123e-07 0.02392944198669211 \
2.107182864485406e-07 0.02369675911063252 2.107187284963783e-07 0.02282172072611499 2.107189503116517e-07 0.02239223679446916 2.107194739313108e-07 0.02139838041889957 \
2.107196292938196e-07 0.02110714647916685 2.107201469998876e-07 0.02015295207761772 2.10720272033152e-07 0.01992792118872039 2.10720796234659e-07 0.01901759738223179 \
2.107209324540342e-07 0.01879045572456909 2.107215387304897e-07 0.01783210191617334 2.107217057396231e-07 0.01758082406519646 2.107223489472666e-07 0.01666064795441237 \
2.107225280915353e-07 0.0164167113061686 2.107232182502689e-07 0.01551958953683085 2.107233818701531e-07 0.01531511209162885 2.107241423508398e-07 0.01440332854054019 \
2.107242893929629e-07 0.01423371673427115 2.107251072646214e-07 0.01333087949608782 2.107252268131343e-07 0.01320411419549955 2.107261426746556e-07 0.01227329163592313 \
2.107262840275722e-07 0.01213544173166964 2.107272325031483e-07 0.01124488043697059 2.107273911425863e-07 0.01110230805801717 2.1072857354363e-07 0.01011356759191894 \
2.107286716440201e-07 0.01003725601038859 2.1072993325548e-07 0.009120360285939955 2.107300676693304e-07 0.009028655389366201 2.107316082406548e-07 0.008043892937307966 \
2.107316892739987e-07 0.007992925041580451 2.107332778679313e-07 0.007023242357651564 2.10733410759078e-07 0.006948518507451114 2.107353874624203e-07 0.005952856104192286 \
2.107355692005682e-07 0.005869662958407677 2.107376715542283e-07 0.004980929874643355 2.107381123459968e-07 0.004810448874467742 2.107407675608552e-07 0.003892108290451164 \
2.107412441403943e-07 0.003745909362026665 2.107448822226149e-07 0.00279447349697209 2.107454077460605e-07 0.002678838783887205 2.107510138108453e-07 0.001700248310874221 \
2.107513248985468e-07 0.001653333728976835 2.107564592262458e-07 0.0006858192122199529 2.107566532060193e-07 0.0006440832883579712 2.134045769148618e-07 -0.0002037173203380238 \
2.134047411152831e-07 -0.0003889174928863678 2.134053144580912e-07 -0.001270938904608877 2.134053893922784e-07 -0.001411855863724778 2.134058499760551e-07 -0.002393592696522268 \
2.134059619168068e-07 -0.002660411672198376 2.134062151887948e-07 -0.003300974950034667 2.134063815720996e-07 -0.003745951779090856 2.134066765678696e-07 -0.004566571567208835 \
2.134067880554425e-07 -0.00488071790655901 2.134070674282164e-07 -0.005641221413069743 2.134071883865554e-07 -0.005938820066262044 2.134082823393885e-07 -0.005180465225493313 \
2.13408406471631e-07 -0.004410796826645887 2.134085308790492e-07 -0.003456122327429311 2.134086504354286e-07 -0.002364170815481491 2.13408748579805e-07 -0.001341064316055312 \
2.13408855004127e-07 -0.0001052154991983786 2.134089672399721e-07 0.001336046702817826 2.134091021958209e-07 0.003249882807978809 2.134092247823306e-07 0.005149402351921401 \
2.134094136442457e-07 0.008353592055059769 2.134095548265785e-07 0.01094873860302964 2.134097081879224e-07 0.01393943619118621 2.134098515614267e-07 0.01687898420971235 \
2.13410005752867e-07 0.02017576688295359 2.134101618928252e-07 0.02363796584892512 2.134103176188778e-07 0.02719811802828209 2.134104651125568e-07 0.03065407560139007 \
2.134106137843234e-07 0.03420778369279751 2.134107691144076e-07 0.03798436241030867 2.134109277402875e-07 0.04189786275883118 2.134110926734479e-07 0.0460171220807938 \
2.134112670963364e-07 0.05041857973200652 2.134114460857363e-07 0.05497510627343041 2.134116353855968e-07 0.05982852266675163 2.134118383936028e-07 0.06506368941101938 \
2.134120578706689e-07 0.07075025585284363 2.134122889353305e-07 0.07675903373893865 2.134125359956494e-07 0.08319974270080552 2.134128064206373e-07 0.0902619122132732 \
2.134130999843244e-07 0.09793335781011638 2.13413424033306e-07 0.1064001814721126 2.134137882548562e-07 0.1159066558703892 2.134141808063258e-07 0.1261372395632307 \
2.134146303042508e-07 0.1378252442462487 2.134151530964837e-07 0.1513754922073403 2.134157666942192e-07 0.1672157090591849 2.134164444550933e-07 0.184625848284817 \
2.134172327202124e-07 0.2047487967247964 2.134181155530716e-07 0.22712469896725 2.134189338390288e-07 0.2476994923478653 2.13419661268608e-07 0.2658503723959502 \
2.134203013816358e-07 0.2817009601644404 2.134208756853502e-07 0.2958213763442377 2.134214132513172e-07 0.3089396094373287 2.134219172487762e-07 0.3211464104224903 \
2.1342239337143e-07 0.3325930942309646 2.134228712594449e-07 0.3439912352478621 2.134233245925507e-07 0.3547121966731367 2.134237958852587e-07 0.3657614311162562 \
2.134242385610847e-07 0.3760518588326446 2.13424757059872e-07 0.3879885572071845 2.134252842219919e-07 0.3999987293386327 2.134256631316234e-07 0.4085537955782026 \
2.134261930471663e-07 0.4204060347738258 2.13426622963746e-07 0.429919877745455 2.134270766645209e-07 0.4398653393542544 2.134275433780368e-07 0.4500002271552926 \
2.134279810592672e-07 0.4594210430579985 2.134283890215308e-07 0.468120704286539 2.134287084545646e-07 0.4748816926501604 2.134290805898366e-07 0.4826992142337162 \
2.134293155719776e-07 0.4876010339127531 2.13429549178225e-07 0.4924491904621348 2.134297971906479e-07 0.4975647713404599 2.134300955920778e-07 0.5036796627825791 \
2.134303519484798e-07 0.5088948470128004 2.134305642417897e-07 0.5131878547336713 2.134307582598616e-07 0.5170959594548015 2.134309052463942e-07 0.5200432695146362 \
2.134310592244046e-07 0.523118600542271 2.134312771061538e-07 0.5274469616807909 2.134315302104803e-07 0.5324525256580425 2.134317400493245e-07 0.5365797337241586 \
2.134319515026335e-07 0.5407247601751553 2.134322337095338e-07 0.5462280430697679 2.134324632548168e-07 0.5506821559930507 2.134326791510236e-07 0.5548604062613707 \
2.134329613725408e-07 0.560308769190463 2.134332126802682e-07 0.5651538146135803 2.134335103411598e-07 0.5708625224168123 2.134337605680607e-07 0.5756519166658941 \
2.134340169315557e-07 0.5805516059354519 2.134342573415699e-07 0.585116682128892 2.134345155213862e-07 0.5900038400537884 2.134347391135916e-07 0.5942175703762435 \
2.134349776231628e-07 0.5986919452581434 2.134351852078615e-07 0.6025689278491061 2.134354017304866e-07 0.6065904171332736 2.134356510330919e-07 0.6111939272561876 \
2.134358561065347e-07 0.6149609706257601 2.134361073788606e-07 0.6195555361399968 2.13436310600886e-07 0.6232455818254186 2.134365074727914e-07 0.6267987644955494 \
2.134367007643072e-07 0.630267737067843 2.134369555427623e-07 0.6348113783570861 2.13437185753374e-07 0.638887973644319 2.134374031071848e-07 0.6427143472883045 \
2.134377015129076e-07 0.6479268061885751 2.134379169157571e-07 0.6516657345437264 2.134381181394757e-07 0.6551344108237934 2.134382930609835e-07 0.6581323437428509 \
2.13438458126254e-07 0.6609495238976936 2.134386275947746e-07 0.6638251431769452 2.134387797316125e-07 0.666392827642013 2.134389176422984e-07 0.6687037209181631 \
2.134390664784122e-07 0.6711867545200138 2.134391945930143e-07 0.6733159837320549 2.134393378158276e-07 0.6756849429836936 2.134394590900776e-07 0.6776819274526149 \
2.134395966887617e-07 0.6799401191146522 2.134397160692161e-07 0.6818929034138137 2.134398631769624e-07 0.6842914131385206 2.134399803786278e-07 0.6861933934268433 \
2.13440073884205e-07 0.6877071857403232 2.13440164873897e-07 0.6891752279197846 2.134402676159613e-07 0.6908280855439021 2.134403691335249e-07 0.6924555900607121 \
2.134404875166309e-07 0.6943444167618776 2.134405996372169e-07 0.6961264383846065 2.134407171927181e-07 0.6979868779962457 2.134409023430049e-07 0.7008959348649784 \
2.134410335352131e-07 0.7029413755586562 2.134411697037528e-07 0.7050491462541959 2.134412912224561e-07 0.7069171228306749 2.134414311454679e-07 0.7090538254196674 \
2.134415350881169e-07 0.7106315721465845 2.134416462491007e-07 0.712309798010818 2.134417505089649e-07 0.7138759052437967 2.134418801470564e-07 0.7158124745844324 \
2.134419770777692e-07 0.7172526339884565 2.134421160000042e-07 0.7193052800722975 2.134422355492927e-07 0.7210612846995991 2.134423551218654e-07 0.7228080613301419 \
2.134424808972429e-07 0.7246353354365959 2.134426076155857e-07 0.7264656873164689 2.134427296554369e-07 0.728218443613998 2.134428578038805e-07 0.7300486655261287 \
2.13442987872205e-07 0.7318956587421809 2.134431088632273e-07 0.7336041830685722 2.134432496338107e-07 0.7355801168346318 2.1344335060338e-07 0.7369898206659778 \
2.134434522042367e-07 0.7384020079314992 2.13443548224548e-07 0.7397310783624924 2.134436591374029e-07 0.7412570822736337 2.134437467850298e-07 0.7424563811251772 \
2.134438466394007e-07 0.7438154404043728 2.134439814045385e-07 0.7456370856934184 2.13444097699018e-07 0.747198032089633 2.13444201190815e-07 0.7485782798032956 \
2.134443254462628e-07 0.7502239458264747 2.13444470359203e-07 0.7521280942578691 2.134445883397714e-07 0.753666143975803 2.134447072708787e-07 0.7552056331692281 \
2.134448468504184e-07 0.7569980918234445 2.134449912028081e-07 0.7588357421297242 2.134451092636163e-07 0.7603265096672839 2.134452340853355e-07 0.7618908200857619 \
2.134453739165311e-07 0.7636286950759973 2.134454986794279e-07 0.7651662633748356 2.134456421928987e-07 0.7669199865864609 2.134457628783765e-07 0.7683824344671055 \
2.13445883722124e-07 0.7698356273746885 2.134460033670484e-07 0.7712633747646481 2.134461330746874e-07 0.7727989859455529 2.134462418184901e-07 0.7740766298596218 \
2.134463644662266e-07 0.7755070372682662 2.134464742429112e-07 0.7767778749889983 2.13446603267025e-07 0.7782599816788072 2.134467350433437e-07 0.7797610257751375 \
2.134468483559198e-07 0.7810403609326458 2.134469694418617e-07 0.7823954393038701 2.134470733144949e-07 0.7835479431998941 2.134472155975174e-07 0.785111775748914 \
2.134473638006659e-07 0.7867227488076519 2.134475226942012e-07 0.7884297907063792 2.134476428872234e-07 0.7897074707829422 2.134477924539297e-07 0.7912811323018302 \
2.134479165691468e-07 0.7925734175081853 2.134480422734439e-07 0.7938699048627912 2.134481452190109e-07 0.7949224966762399 2.134482595901654e-07 0.7960823495211882 \
2.134483720644089e-07 0.7972131756542409 2.134484623369833e-07 0.7981137961420948 2.134485516778793e-07 0.7989989930139054 2.134486769038167e-07 0.800229513878344 \
2.134487846751798e-07 0.8012785338618679 2.134489143429785e-07 0.8025281307685926 2.134490357222573e-07 0.8036855380110038 2.134491522780568e-07 0.8047859282369955 \
2.134492730834528e-07 0.80591497746663 2.134494057087579e-07 0.8071413435168892 2.134495275023783e-07 0.8082555056211007 2.13449654106103e-07 0.8094015704683005 \
2.134497797196214e-07 0.8105266036187198 2.13449899211046e-07 0.8115857443778658 2.134500374092988e-07 0.8127973981963581 2.134501469085475e-07 0.8137473213416323 \
2.134502310566626e-07 0.8144713378799666 2.134503518607202e-07 0.8155017394983226 2.134504473695572e-07 0.8163089346032877 2.134505836603603e-07 0.8174496006492775 \
2.13450726424414e-07 0.8186303638797883 2.13450860857535e-07 0.8197292014569521 2.134509707295191e-07 0.8206175763825388 2.134511146291367e-07 0.8217677661037901 \
2.134512679567201e-07 0.8229768690765377 2.134513958055741e-07 0.8239722812379519 2.134515362029048e-07 0.8250521595273246 2.13451662107844e-07 0.8260088941474263 \
2.134518167240102e-07 0.8271688948348412 2.134519490793395e-07 0.8281489842609937 2.134520753461681e-07 0.8290730392392056 2.134521930066954e-07 0.8299245984162376 \
2.134523414090921e-07 0.8309852945996649 2.134525086032604e-07 0.8321626230293395 2.134526413805716e-07 0.8330844501529713 2.134528142817687e-07 0.8342675727345584 \
2.134529826990627e-07 0.8354015168591284 2.134531521935363e-07 0.8365246342267009 2.134533336304179e-07 0.8377070668209077 2.134534761865593e-07 0.8386219603417975 \
2.134535900974499e-07 0.8393441765511721 2.134537209736586e-07 0.8401643924869071 2.134538225966329e-07 0.8407940582489307 2.134539390368715e-07 0.8415078269750864 \
2.134540743300576e-07 0.8423269142909066 2.134542715951592e-07 0.8435017451489455 2.134544621144827e-07 0.844614933042255 2.13454672039296e-07 0.8458175693076773 \
2.134548528178267e-07 0.8468334846981137 2.134550501858462e-07 0.8479221976595614 2.134552240443405e-07 0.8488638701886076 2.134554065585834e-07 0.8498353939890455 \
2.134555779026936e-07 0.8507314120859523 2.13455752248258e-07 0.8516272398309612 2.134559276512583e-07 0.8525125793730954 2.134561038964483e-07 0.8533864315694911 \
2.134562936653265e-07 0.8543099749208749 2.134564844233442e-07 0.8552205033559714 2.134566862125501e-07 0.8561646193034282 2.134568789161161e-07 0.8570482883232282 \
2.134570883567927e-07 0.8579892478796384 2.134573180985592e-07 0.8589986827500428 2.134575835675109e-07 0.8601360945383778 2.134578822138556e-07 0.8613786760148464 \
2.134581606012222e-07 0.8625023989005415 2.134584447911769e-07 0.8636161469557806 2.13458719285784e-07 0.8646608622318305 2.134589913772806e-07 0.8656672252055042 \
2.134592615937268e-07 0.8666387059277968 2.134595187619146e-07 0.8675381145236246 2.134597913209795e-07 0.8684653318325959 2.1346006734232e-07 0.8693777905953765 \
2.13460337484171e-07 0.8702455402709716 2.134606372319547e-07 0.8711796653984102 2.134610081058124e-07 0.872294745819888 2.134613030287967e-07 0.8731503023941 \
2.134615572848448e-07 0.8738665406311316 2.134618555155772e-07 0.8746822274488602 2.134621291339016e-07 0.8754080260278182 2.134623652695491e-07 0.8760175227551726 \
2.134626056214059e-07 0.876622281264788 2.134628279637853e-07 0.8771680781109068 2.134630219681285e-07 0.8776338860468618 2.134633516912075e-07 0.8784037109613512 \
2.1346350686397e-07 0.8787567114621292 2.134638246164967e-07 0.879461652496718 2.134640034818579e-07 0.8798480920375044 2.134643459433238e-07 0.8805675499479563 \
2.134645300848474e-07 0.8809434933546246 2.134650049902839e-07 0.8818790560183651 2.134651723847029e-07 0.8821975058309585 2.134656382161285e-07 0.8830540251881659 \
2.134658190409674e-07 0.8833751042472839 2.134663130743469e-07 0.8842212008576973 2.134664544170557e-07 0.884455124402366 2.13467060806836e-07 0.8854193259359495 \
2.134672128789829e-07 0.8856514227360587 2.134678595574705e-07 0.8865980751852495 2.134679878538246e-07 0.8867785329419297 2.134686359799261e-07 0.8876550049536978 \
2.134687657724472e-07 0.8878236738033012 2.134695440340947e-07 0.8887860366092379 2.134696590259732e-07 0.8889208282599539 2.134705147583919e-07 0.8898661633196656 \
2.134706600215368e-07 0.8900169066926564 2.134716457777221e-07 0.8909664261264102 2.134718668828627e-07 0.8911622482549515 2.134730119973067e-07 0.8921020388386462 \
2.134731432072641e-07 0.8922053928944147 2.134743308657994e-07 0.8931033243919096 2.134744844860915e-07 0.8932130731307282 2.13475894522803e-07 0.8941348173026452 \
2.13476117329622e-07 0.8942660193790342 2.134777980203304e-07 0.8951452796684343 2.134781256415096e-07 0.8952966652167414 2.134803555826309e-07 0.8961896554712738 \
2.134809084965924e-07 0.8963788593752812 2.134844767111233e-07 0.8973573335043913 2.134848002235382e-07 0.8974284307984646 2.134911566318259e-07 0.8984120886469452 \
2.134917055346727e-07 0.8984686671268907 2.13544207609024e-07 0.8994658645395698 2.135448506378865e-07 0.8994692460188505 2.137369893085195e-07 0.9004073346715066 \
2.137371907224907e-07 0.9004708280105613 2.137411505004318e-07 0.8995366825576255 2.137413345272296e-07 0.8993953949813248 2.137426511245044e-07 0.8984641879157507 \
2.137428231683587e-07 0.8983566564859006 2.137447195446537e-07 0.8973720929359315 2.137448932508418e-07 0.897304621671452 2.137574671778748e-07 0.8982933655523699 \
2.137575523681118e-07 0.8983081509245614 2.137658192411513e-07 0.8993078551592517 2.137662939605718e-07 0.8993433667976791 2.142597948700116e-07 0.9002974142054325 \
2.142599143497356e-07 0.9003767372269074 2.142608071727864e-07 0.9012336455299185 2.142609534294226e-07 0.901423267690772 2.142615483221009e-07 0.9023325668564308 \
2.142616832929176e-07 0.9025673929107925 2.14262187968707e-07 0.9035294259428087 2.142623205796079e-07 0.9038000271808221 2.142627212069726e-07 0.9046475051114249 \
2.142628655723708e-07 0.9049556543240072 2.142632886935802e-07 0.9058123566484279 2.142633841506385e-07 0.9059850892484415 2.142648087094547e-07 0.9052205906349737 \
2.142649337473088e-07 0.9046352442223391 2.142650601578981e-07 0.9039223775493039 2.142651628066418e-07 0.9032486771507763 2.142652900219319e-07 0.9022944222362175 \
2.142654088677579e-07 0.9012801950564071 2.142655065202371e-07 0.9003603330664713 2.142655885222584e-07 0.8995243596151602 2.142656681858213e-07 0.8986589236008835 \
2.142657789639895e-07 0.8973708307079206 2.142658801400036e-07 0.8961049472956977 2.142659630844751e-07 0.8950067229086057 2.142660715298925e-07 0.8934921260891034 \
2.142661799938501e-07 0.8918872687155874 2.14266275049989e-07 0.8904106867557802 2.142663959226416e-07 0.8884444419111864 2.14266516699262e-07 0.8863849482818795 \
2.142666297444327e-07 0.8843763393508186 2.142667329151817e-07 0.8824794505619851 2.142668185153382e-07 0.8808620855018965 2.142668929893991e-07 0.8794251273161163 \
2.142669873129417e-07 0.8775673968166831 2.142670757738577e-07 0.8757888800524039 2.142671548468696e-07 0.8741711975775893 2.142672488342247e-07 0.872216793437976 \
2.142673301795293e-07 0.8704993514258973 2.14267425093555e-07 0.8684673705816817 2.14267518136275e-07 0.8664480751909672 2.142676149220692e-07 0.8643215060814092 \
2.142677382174414e-07 0.8615778533848952 2.142678516644525e-07 0.859022019682563 2.142679775164913e-07 0.8561558571929792 2.142681008446355e-07 0.8533196845306243 \
2.142682300229265e-07 0.850323637950593 2.142683706197831e-07 0.8470370034914 2.142684793995045e-07 0.8444782910716596 2.142686144592575e-07 0.8412850455921466 \
2.14268724119566e-07 0.8386804253780991 2.142688532993454e-07 0.8356002443501571 2.14268979483175e-07 0.8325812421138936 2.142691065735304e-07 0.8295317031556502 \
2.142692355958039e-07 0.826427745883674 2.142693446760448e-07 0.8237985689995477 2.142694845267009e-07 0.8204223029647078 2.142696239548932e-07 0.8170507778356514 \
2.142697567085239e-07 0.8138366863616762 2.142698867771992e-07 0.8106848159989707 2.142700104726457e-07 0.8076853837479523 2.142701474270357e-07 0.8043627031572629 \
2.142702611388824e-07 0.8016030849198694 2.142703886159226e-07 0.7985086235398901 2.142704994169941e-07 0.7958187897651571 2.142706186034522e-07 0.7929254985494992 \
2.142707319825085e-07 0.7901733724735396 2.142708662929012e-07 0.7869138859547327 2.142709733871687e-07 0.7843152933129034 2.142710894043117e-07 0.7815009627552112 \
2.142712185952754e-07 0.778367508739124 2.142713162077106e-07 0.7760002683782802 2.142714217871509e-07 0.773440790716327 2.142715304693199e-07 0.7708069008430674 \
2.142716328855832e-07 0.7683258101021144 2.142717262792412e-07 0.7660641808432364 2.142718458350171e-07 0.7631702213567544 2.142719383073787e-07 0.7609327305817616 \
2.14272030945494e-07 0.7586922094322426 2.142721293703097e-07 0.7563124992069843 2.142722373479617e-07 0.7537030947613649 2.142723336164742e-07 0.7513778334636231 \
2.142724198728768e-07 0.7492952979736797 2.142725227366661e-07 0.7468128004450286 2.14272601580994e-07 0.744910856519283 2.142727023870358e-07 0.7424801602439853 \
2.142728369152764e-07 0.7392377693660663 2.142729741401358e-07 0.7359316755186537 2.142731176199873e-07 0.7324773442723981 2.142732660441767e-07 0.7289066083419234 \
2.142734093054719e-07 0.7254625447335662 2.142735493824514e-07 0.7220977259655398 2.142737058083174e-07 0.7183435968963056 2.142738302100673e-07 0.715360858370426 \
2.14273951271848e-07 0.7124600029613375 2.1427410478411e-07 0.7087850045121084 2.142742395660554e-07 0.7055614325718365 2.142743656650877e-07 0.7025479112911024 \
2.142745088393713e-07 0.6991289103945657 2.142746289211628e-07 0.6962626602560111 2.142747581554914e-07 0.6931807499479741 2.142748646405391e-07 0.6906432840523983 \
2.142749769163615e-07 0.6879696524977363 2.142750732516477e-07 0.6856773754336868 2.142751760613402e-07 0.683232326200841 2.14275270865193e-07 0.6809792012818872 \
2.142753761871231e-07 0.6784784437814733 2.14275484625777e-07 0.6759058899658261 2.142755836350576e-07 0.673558569590366 2.142757003916503e-07 0.6707929011939652 \
2.142758084769278e-07 0.6682347329991606 2.142759184831366e-07 0.6656332609774134 2.142760045709787e-07 0.6635992664604092 2.142761341661182e-07 0.6605400273835189 \
2.142762267673659e-07 0.6583552307294462 2.142763225550924e-07 0.6560965362104854 2.142764075070784e-07 0.6540950852804182 2.142765268016021e-07 0.6512869789851043 \
2.142766140715399e-07 0.6492343850333612 2.142767047785614e-07 0.6471030993779646 2.14276805943536e-07 0.6447280068361273 2.142768857743593e-07 0.6428551652550211 \
2.142769745601937e-07 0.6407732405330839 2.142770522504205e-07 0.6389536101386547 2.142771140193684e-07 0.6375081226244841 2.142771777840134e-07 0.6360167668935747 \
2.142772410182332e-07 0.634538653569437 2.142772802588059e-07 0.6336218002627473 2.142773208978281e-07 0.6326726453797233 2.142774009823624e-07 0.6308039353694699 \
2.142774708865426e-07 0.6291742390428672 2.142775215232567e-07 0.6279942052995945 2.142775602728994e-07 0.6270914175114127 2.142775992678787e-07 0.6261832343283663 \
2.142776438826267e-07 0.6251445623164014 2.142776867390832e-07 0.6241478292286105 2.142777370536867e-07 0.6229782634938205 2.142777889908641e-07 0.6217719122409077 \
2.142778740584487e-07 0.6197972300178722 2.142779340388659e-07 0.6184052992407258 2.142780238260749e-07 0.61632338076978 2.142781002901565e-07 0.6145529519516876 \
2.142781798544472e-07 0.6127119801362371 2.142782608910593e-07 0.6108383709630588 2.142783501053817e-07 0.6087775861620425 2.142784409653938e-07 0.6066826282541496 \
2.142785281841023e-07 0.6046739453334793 2.142786219572931e-07 0.6025158549334848 2.142787236427565e-07 0.6001788642681311 2.142788232408485e-07 0.5978941858483342 \
2.142789350958888e-07 0.5953317151711254 2.14279051129026e-07 0.5926772450523136 2.142791727501318e-07 0.5899020947998995 2.142792771339459e-07 0.5875236635596754 \
2.142794219241658e-07 0.5842296531729801 2.142795345841267e-07 0.5816734289694181 2.14279643596094e-07 0.5792035939892568 2.142797360755373e-07 0.5771100174076607 \
2.142798295261766e-07 0.5749994714793375 2.142799218520404e-07 0.5729181236728181 2.142799944387413e-07 0.571283073141143 2.142800503929671e-07 0.5700232888304386 \
2.142801114612485e-07 0.5686498830286455 2.142802099507645e-07 0.5664400707212188 2.142802731622084e-07 0.5650238531380825 2.14280333588177e-07 0.5636708824310654 \
2.142804105365601e-07 0.5619492451093103 2.142804736951014e-07 0.5605380106414651 2.142805620087099e-07 0.558569506627369 2.14280633210033e-07 0.5569845302974165 \
2.14280719745787e-07 0.555060151797141 2.142808410985601e-07 0.5523665438352664 2.142809690278082e-07 0.5495364947125975 2.142810671584392e-07 0.5473694328713704 \
2.142811802824346e-07 0.5448752016832871 2.14281282350254e-07 0.5426314425864434 2.142814012991245e-07 0.5400217272291628 2.142815043868322e-07 0.5377630705755105 \
2.142816185939865e-07 0.5352670017334624 2.142817320096582e-07 0.532794946211756 2.14281859080713e-07 0.5300302694710822 2.14281982900802e-07 0.5273426867079006 \
2.142821276896071e-07 0.5242103332418484 2.142822635131097e-07 0.5212782585303676 2.142824185679684e-07 0.5179428401013338 2.142825794198528e-07 0.5144913885072363 \
2.142827581493005e-07 0.5106699876709851 2.1428294832834e-07 0.5066200804011861 2.142831582303623e-07 0.5021665212646098 2.142833869363468e-07 0.4973332357952056 \
2.142836408642853e-07 0.4919960258408594 2.142838817977506e-07 0.4869529241725989 2.142841779602358e-07 0.4807889695952298 2.142844679576231e-07 0.4747910561470179 \
2.142847742009558e-07 0.4684976697011882 2.142850948768875e-07 0.4619520863481486 2.142854227440541e-07 0.4553041925245184 2.142857629891091e-07 0.4484521981997251 \
2.142860884146545e-07 0.4419418052309769 2.142864103218022e-07 0.4355465312739703 2.142867405359073e-07 0.4290298934287748 2.142870965284996e-07 0.4220583188787752 \
2.142874154069286e-07 0.4158579595363656 2.14287752858691e-07 0.4093433989943853 2.142881807254075e-07 0.4011531841887147 2.142885294373556e-07 0.3945419525178304 \
2.142888370733194e-07 0.388759214407489 2.142892168998106e-07 0.3816861832573664 2.142895480893721e-07 0.3755780492082042 2.142898316974524e-07 0.370391509977049 \
2.142901425163967e-07 0.3647512908748707 2.142904218330045e-07 0.3597258263082204 2.142906483291526e-07 0.3556836811642302 2.142908640115379e-07 0.3518598964090484 \
2.142910612955428e-07 0.3483842179544538 2.142912662800023e-07 0.3447988491770444 2.142914785019664e-07 0.3411119200457455 2.142917338071541e-07 0.33670771290924 \
2.142919753294027e-07 0.3325734463267218 2.14292206706731e-07 0.3286464933807047 2.142924215592308e-07 0.3250253651850565 2.142926421183882e-07 0.3213332986541765 \
2.142928435443551e-07 0.3179852906236645 2.142930466126061e-07 0.3146379646143546 2.142932445082156e-07 0.3114011111455273 2.142934314693022e-07 0.3083651674074345 \
2.142936252695217e-07 0.3052406640298299 2.142938291861339e-07 0.3019773030815858 2.142940082554678e-07 0.2991336297844484 2.142942438463241e-07 0.2954229173226265 \
2.142944446504233e-07 0.2922868215109002 2.142946458293147e-07 0.2891696385850206 2.142948696390574e-07 0.2857334090862961 2.142950342018033e-07 0.2832271910241367 \
2.142952111291889e-07 0.2805503385691353 2.14295396922194e-07 0.2777610713150803 2.142955787376702e-07 0.2750538970423583 2.142957577624632e-07 0.2724132377985424 \
2.142959251076164e-07 0.2699606650006489 2.142960855365337e-07 0.2676371805838822 2.142962081102854e-07 0.2658719571410424 2.14296357874814e-07 0.2637236906090554 \
2.142964855719403e-07 0.2619099339733745 2.142965928803121e-07 0.2603957336038235 2.142967088809744e-07 0.2587625259947361 2.142968191895705e-07 0.2572125806747212 \
2.142969450687671e-07 0.2554509781935611 2.142970605506183e-07 0.2538402638894013 2.142971951315211e-07 0.2519757335310172 2.142973071947753e-07 0.2504255755821768 \
2.142974575341346e-07 0.2483447107137444 2.142975971599893e-07 0.2464124269747185 2.142977430518096e-07 0.2444035064209518 2.142978760124476e-07 0.2425734862730615 \
2.14297999574161e-07 0.2408709992523319 2.142981467838532e-07 0.2388417729476062 2.142982633706824e-07 0.2372355665500016 2.142984028258316e-07 0.23532008003217 \
2.142985370003013e-07 0.2334768281602104 2.142986629767575e-07 0.2317465561243653 2.142987823761605e-07 0.2301094434087779 2.142988772305854e-07 0.2288105340759602 \
2.142989903681845e-07 0.2272617792622066 2.142990706846421e-07 0.2261626001158484 2.142991582496986e-07 0.2249657246820506 2.142992837868356e-07 0.2232507767215072 \
2.142993894805428e-07 0.2218101326756785 2.142994791350539e-07 0.2205921574607158 2.14299549986253e-07 0.2196300825522397 2.142995930147827e-07 0.2190460135436258 \
2.142996353053263e-07 0.2184724035808872 2.142996776470424e-07 0.2178984240735344 2.142997498424616e-07 0.2169203674089526 2.142997922358174e-07 0.2163464205126744 \
2.14299827490656e-07 0.2158693585303403 2.142998716822395e-07 0.2152716287340076 2.142999412904665e-07 0.2143309212991285 2.142999756337965e-07 0.2138672544767182 \
2.143000200933248e-07 0.2132698436071631 2.143000877718062e-07 0.2123628126304402 2.143001741990649e-07 0.2112058698236149 2.143002488356675e-07 0.2102078598594563 \
2.143003301376756e-07 0.2091219706754807 2.143004270150594e-07 0.2078300362310651 2.143005529985482e-07 0.2061528795789772 2.143006555333841e-07 0.2047906894256944 \
2.143007570169014e-07 0.2034500128132261 2.143008580825969e-07 0.202119416354989 2.143009546968166e-07 0.2008491615811921 2.143010566612396e-07 0.1995112314821507 \
2.143011633834836e-07 0.1981153840927639 2.143012717886237e-07 0.1967018790395962 2.143013837827796e-07 0.1952465002768531 2.14301496249907e-07 0.1937897263683151 \
2.143016083232463e-07 0.1923454332378671 2.143017162157206e-07 0.1909603537828802 2.143018175986494e-07 0.1896629368444172 2.143019092360985e-07 0.1884941330679491 \
2.143020032117073e-07 0.1872990757663449 2.143020744780721e-07 0.1863957871745983 2.1430215115336e-07 0.1854271890400033 2.143022548124749e-07 0.184122202819407 \
2.143023284795955e-07 0.1831974022686171 2.143024018254956e-07 0.1822796569444652 2.143025152158449e-07 0.1808667181969195 2.143026030744852e-07 0.1797760932362061 \
2.143026869231622e-07 0.1787387947787487 2.143028158855897e-07 0.1771515524267008 2.143029177720844e-07 0.1759040172436072 2.143030234727908e-07 0.1746156056808686 \
2.143031251208657e-07 0.1733818993219825 2.143032559825841e-07 0.1718019019596718 2.143033631792215e-07 0.1705140034701537 2.14303492508118e-07 0.168969083715685 \
2.143036042046102e-07 0.167642098072289 2.143037045351887e-07 0.1664555496840579 2.143038003357432e-07 0.1653276075899142 2.143039111480153e-07 0.1640289617085985 \
2.143039985482962e-07 0.1630090521997956 2.143041098694134e-07 0.1617156184952586 2.143042028212722e-07 0.1606409001560029 2.143042903941502e-07 0.1596330843918451 \
2.143043920250233e-07 0.1584700928658864 2.143044764790781e-07 0.1575086241734052 2.143045515834575e-07 0.1566573095634876 2.143046294056999e-07 0.1557789554714152 \
2.143047097635688e-07 0.1548759612316424 2.143048108183989e-07 0.1537464547857493 2.143048932519626e-07 0.1528311848879565 2.143049855565143e-07 0.1518114053368895 \
2.143050624909871e-07 0.150965812476358 2.143051454135576e-07 0.1500585909391909 2.143052169442981e-07 0.1492793026301012 2.143053133277974e-07 0.1482344968214558 \
2.143053835562832e-07 0.1474766665551334 2.143054665365612e-07 0.1465853655470201 2.143055279788246e-07 0.1459298106834085 2.143055996612094e-07 0.1451677491870439 \
2.14305668289752e-07 0.1444408762699853 2.143057185582615e-07 0.1439102090153988 2.143057661380673e-07 0.143409423336876 2.14305820187418e-07 0.1428423132663369 \
2.143058795295158e-07 0.1422216078256897 2.143059475649228e-07 0.1415124633834424 2.14306023828345e-07 0.1407207186008814 2.143060921081446e-07 0.1400161356079559 \
2.143061868943229e-07 0.1390460813732662 2.143062764481352e-07 0.1381341561933974 2.143063481336088e-07 0.1374075731330657 2.143064320850176e-07 0.1365606113096345 \
2.143064973974727e-07 0.1359045398875483 2.143065588405982e-07 0.1352895588344758 2.143066331170967e-07 0.1345490408254265 2.143066953273574e-07 0.1339328028964004 \
2.143067632983657e-07 0.133265236037424 2.143068225054055e-07 0.1326856657519672 2.143068951778785e-07 0.1319767402814105 2.143069701979877e-07 0.1312477270463112 \
2.143070556514107e-07 0.1304208267333309 2.143071417517503e-07 0.1295914604616623 2.143072418772051e-07 0.1286317929389105 2.143073231668748e-07 0.127857435971709 \
2.143074249342228e-07 0.1268981149578782 2.143075091821821e-07 0.1261072369695883 2.143076079989111e-07 0.1251836587365037 2.143076808394557e-07 0.1245055382686853 \
2.143077608655429e-07 0.1237631876254407 2.14307831351338e-07 0.1231117958237987 2.143079038817606e-07 0.1224439308288319 2.143079813507563e-07 0.1217331219782777 \
2.143080887021039e-07 0.1207554316575004 2.143081893401196e-07 0.1198442997624752 2.143082619276736e-07 0.1191899427853172 2.143083307595138e-07 0.1185715582611356 \
2.143083965463339e-07 0.1179824683205609 2.143084661751317e-07 0.1173610347366148 2.143085365588769e-07 0.1167350538439435 2.143086117372496e-07 0.1160688810594495 \
2.143087159914846e-07 0.1151493019715505 2.143087911261386e-07 0.114489769343061 2.143088600412231e-07 0.1138870655592168 2.143089232460945e-07 0.1133369146236164 \
2.143089927874599e-07 0.1127339156958381 2.14309050088964e-07 0.1122385190692166 2.14309121730019e-07 0.1116210355509516 2.143091795650925e-07 0.1111240709857579 \
2.143092516865272e-07 0.1105063809580559 2.1430931410261e-07 0.1099736279351742 2.143093984241316e-07 0.1092565349771765 2.143094660201e-07 0.1086842173446869 \
2.143095748160323e-07 0.1077671916889585 2.143096791265639e-07 0.1068924975608609 2.14309758614772e-07 0.1062289053282379 2.143098461831825e-07 0.1055008617114655 \
2.143099096395349e-07 0.1049752776433979 2.143099713506517e-07 0.10446579874651 2.14310075190416e-07 0.103612238268202 2.143101578711175e-07 0.1029362225408096 \
2.143102563391439e-07 0.1021348761715451 2.14310340785582e-07 0.101450818648051 2.143104572630618e-07 0.1005121841703865 2.143105919965077e-07 0.09943411943161744 \
2.143107280660444e-07 0.0983541971400249 2.143108423854515e-07 0.09745369041838402 2.143109278525961e-07 0.09678457778867394 2.143110381342688e-07 0.09592640631053104 \
2.143111189226223e-07 0.09530159220710262 2.143112184734934e-07 0.09453592511176086 2.143113084215428e-07 0.09384821103094763 2.14311380924943e-07 0.09329669945188329 \
2.143114626670093e-07 0.09267796846073476 2.143115907872446e-07 0.09171467366828615 2.143116721993079e-07 0.09110674702409056 2.143117466312153e-07 0.09055373306570065 \
2.143118216050993e-07 0.08999936228352182 2.143119010240745e-07 0.08941505746347288 2.143120096849318e-07 0.08862052380504259 2.143121040449035e-07 0.08793517800096999 \
2.143121934400264e-07 0.08728987318634121 2.143123002057426e-07 0.086524181682867 2.143124187081826e-07 0.08568073755029131 2.143125602332527e-07 0.08468224831562859 \
2.143126933716762e-07 0.08375174214918565 2.143128342170073e-07 0.08277682112810406 2.143129832689884e-07 0.08175525972387458 2.143131190667176e-07 0.08083369778093191 \
2.143132605232322e-07 0.0798830809748103 2.143133957831475e-07 0.07898330517332906 2.143135371649882e-07 0.07805242629322809 2.143136842327613e-07 0.07709434677344783 \
2.143138359609018e-07 0.07611680364043326 2.143140013092032e-07 0.07506403321855706 2.143141651767209e-07 0.07403332863189842 2.143143414906487e-07 0.07293832728335037 \
2.143145309257506e-07 0.07177777688466977 2.143147416924551e-07 0.07050569389938771 2.143149614649522e-07 0.06920150027616521 2.143151964331044e-07 0.06783224552442871 \
2.14315455333654e-07 0.06635227408830123 2.14315750264117e-07 0.06470266364809808 2.143160546101784e-07 0.06304001691994518 2.143164165564573e-07 0.06111393619706453 \
2.143167326842125e-07 0.05947639552636011 2.143171740066774e-07 0.0572596911373907 2.143174875727196e-07 0.05573556853365672 2.14317911072189e-07 0.0537382660685313 \
2.143182550240426e-07 0.05216649213267931 2.143185952653102e-07 0.05065508790922631 2.143189061028998e-07 0.04931137323461653 2.143192005748017e-07 0.04807062469528345 \
2.143194942742994e-07 0.04686392507224969 2.143197691455356e-07 0.04576537019482012 2.143200446857014e-07 0.04468949010490332 2.143203097762298e-07 0.04367785045825667 \
2.143205865333108e-07 0.04264571401740119 2.143208698014357e-07 0.04161414314527601 2.143211677947347e-07 0.04055545327485047 2.143214272801311e-07 0.03965542606183669 \
2.143216573035691e-07 0.03887446236327848 2.143218769951559e-07 0.03814321686473518 2.14322101935296e-07 0.0374128399305801 2.1432242218897e-07 0.0363978329183388 \
2.143227099868201e-07 0.03550963653148703 2.143229863821537e-07 0.03467738358988744 2.143232702012828e-07 0.03384352473043348 2.143235083105866e-07 0.03315996078327022 \
2.143237926213707e-07 0.03236211345273886 2.143240345332207e-07 0.03169864947531036 2.143242696733945e-07 0.03106710921041438 2.143245113809233e-07 0.03043352335444016 \
2.143247483338566e-07 0.02982731501219571 2.14324978676274e-07 0.02925002048968134 2.143251924268523e-07 0.02872465224286764 2.143253982738151e-07 0.02822791768061097 \
2.143257906108381e-07 0.02730524204782691 2.143259790028487e-07 0.02687312495148303 2.143263546143073e-07 0.02603163971789 2.143265290810819e-07 0.02564950258131362 \
2.143269530155409e-07 0.02474274850847508 2.14327073769958e-07 0.02449086781212801 2.143275440207215e-07 0.02353384026002922 2.143276932357865e-07 0.02323677291035493 \
2.143280868679981e-07 0.02246740853134286 2.143282578943424e-07 0.02213909006726131 2.143287451732745e-07 0.02121869533024997 2.143288872209832e-07 0.02095326544309953 \
2.143294202372519e-07 0.01997576278857772 2.14329542401289e-07 0.01975737097014436 2.143300645590335e-07 0.01885981776906158 2.143302351373363e-07 0.01857989792133653 \
2.143307224503994e-07 0.01781360777737795 2.143308939733227e-07 0.01755501440977742 2.143315137600803e-07 0.01666567753024489 2.143316846844061e-07 0.0164316648397145 \
2.143323902353964e-07 0.01551160061118263 2.14332552852409e-07 0.01530799450170666 2.143333097458994e-07 0.01439879525764199 2.143334506625442e-07 0.01423641007536438 \
2.143343506613842e-07 0.01324361033368418 2.143344380106346e-07 0.01315122959105692 2.14335342363989e-07 0.01223321097894121 2.14335479555938e-07 0.01209984223734439 \
2.14336450212214e-07 0.01118944790767422 2.14336578130092e-07 0.01107451071402888 2.143377285400387e-07 0.01011008206277823 2.143378223420747e-07 0.01003687265682024 \
2.143390783878875e-07 0.009120584045805383 2.143392159292007e-07 0.009026502753623255 2.14340774683602e-07 0.008029670037698805 2.143408584862873e-07 0.007977066150721189 \
2.143424638651059e-07 0.00699828665725172 2.143425747634502e-07 0.006935886594503895 2.143445070098238e-07 0.005959177461785255 2.143446867147596e-07 0.005876661013304485 \
2.143467985058761e-07 0.004981749118765498 2.143471412910116e-07 0.004848482978762325 2.143496544570453e-07 0.003966891390423618 2.143501241787149e-07 0.003819799497680527 \
2.143537644949897e-07 0.002847564273158896 2.143542802321751e-07 0.002731633924241866 2.143596220620139e-07 0.001773027297371861 2.14359907382299e-07 0.001729522787584184 \
2.143651360301289e-07 0.0007540451492352357 2.143653101766958e-07 0.0007162692714263865 2.170136987690021e-07 -0.0001123232525192561 2.170138717942903e-07 -0.0002901710972538241 \
2.170144915460445e-07 -0.001202022686018724 2.170145801152216e-07 -0.001365806793032466 2.170149410863549e-07 -0.002110727959526865 2.1701506578065e-07 -0.002395793696299351 \
2.170154296225314e-07 -0.003299857180474864 2.170156008981996e-07 -0.003758114451912169 2.170158948960377e-07 -0.004576312838821549 2.170160051044431e-07 -0.004886880824040592 \
2.170162833584409e-07 -0.005643955697619643 2.1701640463225e-07 -0.00594200199557267 2.17017498254348e-07 -0.00517389603226481 2.170176213582281e-07 -0.004409713243767066 \
2.170177448263029e-07 -0.003462788751204457 2.170178649920999e-07 -0.002366010162083454 2.170179628537677e-07 -0.001346276287748183 2.170180695561039e-07 -0.0001076498664581183 \
2.170181813974884e-07 0.001328007358939307 2.170183173718548e-07 0.003256083960376262 2.170184394010113e-07 0.00514709866632534 2.170186278172891e-07 0.008343062029134115 \
2.170187688058191e-07 0.01093380316938193 2.170189215775226e-07 0.01391176330477175 2.170190642801506e-07 0.01683596409946878 2.170192186323876e-07 0.02013443377634912 \
2.170193744260432e-07 0.02358734537610087 2.170195304833402e-07 0.02715365164079262 2.170196778877403e-07 0.03060642997674319 2.170198265044852e-07 0.03415780069914553 \
2.170199819257017e-07 0.03793559522944389 2.170201403115322e-07 0.04184227512730877 2.170203052511541e-07 0.04596085539464361 2.170204795004229e-07 0.05035714787605008 \
2.170206584435392e-07 0.05491177248689325 2.170208475830321e-07 0.0597604232635115 2.170210503636104e-07 0.06498910043066243 2.170212697356369e-07 0.07067233091134768 \
2.170215005721334e-07 0.07667464705993039 2.170217473839693e-07 0.0831083675499642 2.1702201751608e-07 0.09016243555275107 2.170223107041881e-07 0.0978236474935409 \
2.170226343596258e-07 0.1062798466079799 2.170229979269121e-07 0.1157689210849182 2.170233902204302e-07 0.1259925151671456 2.170238386999148e-07 0.1376538644086695 \
2.170243603994004e-07 0.1511757390224034 2.170249727720439e-07 0.1669844191341421 2.170256494173592e-07 0.1843663871188266 2.170264363276496e-07 0.2044554566749352 \
2.170273175487439e-07 0.2267919980918504 2.170281372923844e-07 0.2474048556006221 2.170288657453285e-07 0.2655829647002126 2.17029507221317e-07 0.2814688958417333 \
2.170300831444854e-07 0.2956305456066151 2.170306204013019e-07 0.3087428400511723 2.17031124292597e-07 0.3209487846516751 2.17031601896145e-07 0.3324328152479784 \
2.170320800193789e-07 0.343838772307344 2.170325321182285e-07 0.3545331600964184 2.170330038845194e-07 0.365596737404158 2.170334475813599e-07 0.3759140547845509 \
2.170339695498976e-07 0.3879344734281669 2.170344970878305e-07 0.399956933836353 2.170348766025744e-07 0.4085271910771138 2.170354055641746e-07 0.4203606102508351 \
2.170358748832554e-07 0.4307444005277802 2.170363100387911e-07 0.4402814026247405 2.170367575161174e-07 0.4500002273945978 2.170371975395924e-07 0.4594737646471725 \
2.170376008413354e-07 0.4680814138276727 2.170379192411013e-07 0.4748254127722248 2.170382892190148e-07 0.4826007100982719 2.17038525472097e-07 0.4875314737878706 \
2.170387605434932e-07 0.4924129045770672 2.170390118828312e-07 0.4975994385012801 2.170393182698655e-07 0.5038799449729535 2.170395752283189e-07 0.5091120301871851 \
2.170397837026154e-07 0.5133309170973237 2.170399840849048e-07 0.5173683849445317 2.170401264786059e-07 0.5202244049244739 2.170402754030717e-07 0.5231993726577677 \
2.170404869493287e-07 0.5274019882470222 2.170407130069516e-07 0.5318780389403845 2.170409075493335e-07 0.5357103559602913 2.170410966812289e-07 0.539423417888626 \
2.170413261282768e-07 0.5439012399750046 2.170415086340828e-07 0.5474563135343053 2.170417459969519e-07 0.5520623276458133 2.170420149912601e-07 0.5572695987004129 \
2.170422639017101e-07 0.5620706638085723 2.170425079185314e-07 0.5667633705755619 2.170427802737438e-07 0.5719926523718327 2.170430416698736e-07 0.5769928369418796 \
2.170432993012793e-07 0.5819084237686675 2.17043546144628e-07 0.586601202059797 2.170437918903539e-07 0.5912552023551558 2.170440184678743e-07 0.5955288021520931 \
2.170442496200641e-07 0.5998646534936181 2.170444559004441e-07 0.6037202012184053 2.170446840212041e-07 0.6079592993751251 2.170449064011853e-07 0.6120725203834017 \
2.17045133377667e-07 0.6162454422471376 2.170453484306168e-07 0.6201823359462864 2.170455778001903e-07 0.6243500782103125 2.170458468230649e-07 0.6292041961704016 \
2.170460698367118e-07 0.6331993632081415 2.170462820912892e-07 0.6369772451758789 2.170464934888789e-07 0.6407176358819484 2.17046693558109e-07 0.644236566349866 \
2.170469231519586e-07 0.6482486956559365 2.170471639888863e-07 0.6524328529570182 2.170473457382733e-07 0.6555667906748446 2.170475342865e-07 0.6588018260593631 \
2.170476873661394e-07 0.6614154033769962 2.170478593744213e-07 0.6643352515471471 2.170480095472396e-07 0.6668697017322168 2.170481460645294e-07 0.6691578850264722 \
2.170482956937163e-07 0.6716547631652277 2.170484234340851e-07 0.673777752640997 2.170485630202226e-07 0.6760856948620949 2.170486872589102e-07 0.6781310478824312 \
2.170488184087496e-07 0.6802827752320969 2.170489428500932e-07 0.6823179209931315 2.170490800809157e-07 0.6845542421253382 2.170492003290863e-07 0.6865048414796368 \
2.170493416605295e-07 0.6887891282595083 2.170494419916407e-07 0.6904033553735033 2.170495631093427e-07 0.6923460943304175 2.170496538868777e-07 0.6937948943079848 \
2.170497511453436e-07 0.6953408241330762 2.170498473532237e-07 0.6968660703265798 2.170499359670681e-07 0.6982647859968389 2.170500332550912e-07 0.6997938110311075 \
2.170501657237294e-07 0.7018622871835729 2.170503209139279e-07 0.7042674555997347 2.170504587918793e-07 0.7063866855441746 2.170506036461533e-07 0.7085960165693863 \
2.170507307079098e-07 0.7105202221428537 2.170508553934701e-07 0.7123960184768648 2.170509680988463e-07 0.7140814553427599 2.170510798891907e-07 0.7157437310299281 \
2.170511806678399e-07 0.7172341607972841 2.170513179462954e-07 0.7192525454101454 2.170514376303672e-07 0.7210013704967912 2.170515570598379e-07 0.7227365757678518 \
2.170516839430602e-07 0.7245692610776365 2.170518083607121e-07 0.7263556789600311 2.170519320935366e-07 0.728121726658988 2.170520586890634e-07 0.7299181396522603 \
2.170521890744641e-07 0.7317573312219798 2.170523118842844e-07 0.7334798522758219 2.170524473200596e-07 0.7353678990088863 2.170525486098379e-07 0.7367723836293941 \
2.170526562323338e-07 0.7382576460517265 2.170527457604157e-07 0.7394878879617913 2.170528603087849e-07 0.7410528648863303 2.170529483370413e-07 0.7422487366778059 \
2.170530554151068e-07 0.7436953530868765 2.170531854801004e-07 0.7454403311053276 2.170532967597954e-07 0.7469230742113165 2.170534013783548e-07 0.7483084058091373 \
2.170535254613402e-07 0.7499400420429273 2.170536737621685e-07 0.7518749696944975 2.170537951620328e-07 0.7534462209622173 2.170539096027802e-07 0.7549170836379747 \
2.170540499400977e-07 0.7567069362027918 2.170541917029811e-07 0.7584995177563068 2.170543095039188e-07 0.759977341175643 2.170544374807853e-07 0.761570846386187 \
2.170545791832092e-07 0.7633205808366864 2.170546966945227e-07 0.7647599110190483 2.170548422997917e-07 0.7665289162262866 2.170549639940994e-07 0.7679951561698679 \
2.170550827247088e-07 0.7694149786178283 2.170552050113037e-07 0.7708662727382939 2.170553320558197e-07 0.77236234268503 2.170554416997921e-07 0.7736439866494906 \
2.170555673867047e-07 0.7751025186690397 2.170556734018052e-07 0.776323977486031 2.170558089877718e-07 0.7778743028704433 2.170559339507686e-07 0.7792913979962601 \
2.17056059856921e-07 0.7807070123991936 2.17056175124167e-07 0.7819915514687489 2.170562814286401e-07 0.7831664991275713 2.17056419833432e-07 0.7846822315516878 \
2.170565691298821e-07 0.7862997378875561 2.170567146373276e-07 0.7878588534534761 2.170568340418389e-07 0.7891257303126159 2.170569691346634e-07 0.7905455128963393 \
2.170570903878263e-07 0.7918076974797237 2.170572333811048e-07 0.7932816011184505 2.170573775854105e-07 0.7947523458802197 2.170575031222391e-07 0.7960199014141693 \
2.170576221686118e-07 0.7972110037065316 2.170577341044954e-07 0.7983213107123885 2.170578389760474e-07 0.7993531099923881 2.170579342264591e-07 0.8002831901653534 \
2.170580705697047e-07 0.8016020813281191 2.170581873938354e-07 0.8027203407102198 2.170583067984452e-07 0.803852171037294 2.170584289052493e-07 0.8049980820693966 \
2.170585518602505e-07 0.8061401395390313 2.17058678828951e-07 0.8073073595000361 2.170588040685604e-07 0.8084467645495962 2.17058934640955e-07 0.8096220968518901 \
2.170590606314733e-07 0.8107441738369082 2.170591888173857e-07 0.8118738099374113 2.170592943471138e-07 0.8127947795787664 2.170593972188869e-07 0.8136847278655364 \
2.17059490214057e-07 0.8144826950388273 2.170596140106596e-07 0.8155354283166244 2.170597019789174e-07 0.8162769513478326 2.170598007099885e-07 0.8171027376706747 \
2.170599439751418e-07 0.8182889948057973 2.170600792538271e-07 0.8193962136425846 2.170601883684495e-07 0.8202800249700468 2.17060336451758e-07 0.8214657808291811 \
2.170604862226849e-07 0.8226492530953341 2.170606114572855e-07 0.8236267526687548 2.170607554487032e-07 0.8247372275730155 2.170608795047738e-07 0.8256825756473101 \
2.170610299680322e-07 0.8268152483647575 2.17061165678884e-07 0.8278240064655301 2.170612906973921e-07 0.828742521381556 2.170614084523219e-07 0.8295983347934622 \
2.170615544291349e-07 0.8306466023667578 2.170617209384522e-07 0.8318251482734692 2.170618518610282e-07 0.8327390940956469 2.170620252884658e-07 0.8339327615268647 \
2.170621934353481e-07 0.8350717495747054 2.170623632702773e-07 0.8362042975620877 2.170625441950479e-07 0.8373912937861997 2.170626872933069e-07 0.8383160748488641 \
2.170628013791983e-07 0.8390446117604563 2.170629315531841e-07 0.8398665237782376 2.170630333942664e-07 0.8405024977857931 2.170631502136154e-07 0.8412243379523001 \
2.170632870780449e-07 0.8420597162999857 2.170634848766686e-07 0.8432475311273343 2.170636764807398e-07 0.8443767279905872 2.170638859212216e-07 0.8455874169714939 \
2.170640678468519e-07 0.8466193100105236 2.170642649799575e-07 0.8477171434207121 2.170644383298479e-07 0.8486653666163242 2.170646213292318e-07 0.8496493024239481 \
2.17064792495495e-07 0.8505537352954988 2.170649671272818e-07 0.8514606693963016 2.170651423896692e-07 0.8523550102558151 2.170653185417845e-07 0.8532381479010797 \
2.170655088128238e-07 0.8541746551565574 2.170656994147745e-07 0.85509499218684 2.170659000624008e-07 0.8560449689899254 2.170660926729659e-07 0.8569390259424264 \
2.170663033306522e-07 0.8578972157030333 2.170665314560509e-07 0.8589122247267402 2.170667972133685e-07 0.8600655879592763 2.17067095837813e-07 0.8613244245924475 \
2.170673721693318e-07 0.862454900702886 2.170676564023905e-07 0.8635842083919951 2.17067930614306e-07 0.8646423892283146 2.170682028423722e-07 0.8656634505877856 \
2.170684730511913e-07 0.8666487272755322 2.170687302040671e-07 0.8675609437488442 2.170690027863351e-07 0.868501515423508 2.170692787713349e-07 0.8694269133137555 \
2.170695488729115e-07 0.8703069289141475 2.170698487348628e-07 0.8712546000783432 2.170702197689933e-07 0.8723856543073821 2.170705147067536e-07 0.8732530157608677 \
2.170707689975357e-07 0.8739790309043101 2.170710672549513e-07 0.8748056771600844 2.170713408634847e-07 0.8755409825400007 2.170715769915496e-07 0.8761583495732972 \
2.170718173369303e-07 0.876770807053994 2.170720396702121e-07 0.8773233906735478 2.170722336759598e-07 0.8777948466981503 2.17072563398506e-07 0.8785737911727464 \
2.170727185719444e-07 0.8789308835864816 2.17073036347473e-07 0.8796437246174529 2.170732152091701e-07 0.8800342982281311 2.170735576710472e-07 0.8807611334253193 \
2.170737417995192e-07 0.8811407335605206 2.170742166778565e-07 0.8820849466541889 2.170743840740528e-07 0.8824061830950772 2.170748499154564e-07 0.8832696475595492 \
2.170750307376651e-07 0.8835931319180218 2.170755247759143e-07 0.8844450822729043 2.170756661243274e-07 0.8846804878101884 2.170762724573853e-07 0.8856498028150036 \
2.170764245267248e-07 0.8858829444029697 2.170770712152002e-07 0.8868329272509302 2.170771995097231e-07 0.8870138524519416 2.170778476269279e-07 0.8878919388991984 \
2.170779774257916e-07 0.8880607713689423 2.17078755627481e-07 0.8890227771434612 2.170788706844142e-07 0.8891574578072456 2.170797263428482e-07 0.8901003239091128 \
2.170798717076157e-07 0.8902505899439886 2.1708085746403e-07 0.8911948786459364 2.170810785690402e-07 0.8913892999646706 2.170822236960192e-07 0.8923206810037944 \
2.170823549126186e-07 0.892422953350996 2.170836961242674e-07 0.8934189515818408 2.170838475232108e-07 0.8935240845833778 2.170853289614591e-07 0.8944568913393511 \
2.170855678408922e-07 0.8945912088657246 2.170873371610739e-07 0.8954685138428928 2.170877263108405e-07 0.895637400736999 2.170901199766276e-07 0.896526474291006 \
2.170905956894499e-07 0.8966764365754722 2.17094011699057e-07 0.8975478548673914 2.170946588490717e-07 0.8976786076740833 2.171021370136781e-07 0.8986646932675814 \
2.171028095907965e-07 0.8987192862546014 2.171952539953667e-07 0.8997188196574962 2.171959172280509e-07 0.8997241906476866 2.17385126389945e-07 0.900686595210158 \
2.173852884627892e-07 0.9007292695325627 2.173879339836764e-07 0.8998161167154269 2.173881025331539e-07 0.8996881690130656 2.173893792855451e-07 0.8987393243250013 \
2.173895814518808e-07 0.8986030018074492 2.173911895612674e-07 0.8976721249252815 2.173913816671926e-07 0.8975774045828077 2.174064950498388e-07 0.8985726115129884 \
2.174066831087563e-07 0.8986004060702872 2.174179880377677e-07 0.8995874924221801 2.174183614235164e-07 0.8996034751727418 2.17907373786698e-07 0.9005892719715856 \
2.179074845548976e-07 0.9006868984798269 2.179082372272589e-07 0.9015617873136611 2.179083390219455e-07 0.9017086238768567 2.179088744204902e-07 0.9025814930725723 \
2.179089769296628e-07 0.9027670217776843 2.179093691484817e-07 0.9035254014384071 2.17909509991429e-07 0.9038129158713877 2.179099510288813e-07 0.9047472953155866 \
2.179101365144842e-07 0.9051402477015744 2.179106528276013e-07 0.9061269394579334 2.17910737502694e-07 0.9062564181617988 2.179119721747438e-07 0.9053011091537977 \
2.179121293881559e-07 0.9045688862145235 2.179123212048176e-07 0.9034162411061901 2.179124880453484e-07 0.9021712267446264 2.179126350037463e-07 0.9008824031243315 \
2.179127491199425e-07 0.8997575350477262 2.179128789920323e-07 0.8983446880789033 2.179129901095502e-07 0.8970273815442567 2.179130829140294e-07 0.8958483937359277 \
2.17913171236719e-07 0.8946639786015808 2.179132744174779e-07 0.8932058048613533 2.179133666254135e-07 0.8918333298588224 2.179134541956103e-07 0.8904732289418564 \
2.179135681890766e-07 0.8886245408236838 2.179137299935004e-07 0.8858564722885236 2.179139149921176e-07 0.8825005184224666 2.179141071517853e-07 0.8788219124347386 \
2.179143085991386e-07 0.874780227084481 2.179145150097281e-07 0.8704697801294994 2.179147001816807e-07 0.8664790122147591 2.179148846894051e-07 0.862405115500708 \
2.179150578412964e-07 0.8585071391690239 2.179152428873213e-07 0.8542751393552932 2.179154202615245e-07 0.8501657390392787 2.179155970079552e-07 0.8460284987362284 \
2.179157631666058e-07 0.8421077870518131 2.179159252110445e-07 0.8382599993991456 2.179160917839251e-07 0.8342839555277276 2.179162504376618e-07 0.8304816347052207 \
2.179164413136869e-07 0.8258903812682129 2.179166162972586e-07 0.8216694867670907 2.179167862433926e-07 0.8175615830390965 2.179169514195676e-07 0.8135626411663678 \
2.179171246116744e-07 0.8093650119631921 2.179172956738769e-07 0.8052155696745213 2.179174637749139e-07 0.801136095357175 2.179176541098628e-07 0.7965156511928794 \
2.179178376918066e-07 0.7920591698039 2.179180456827317e-07 0.7870113041480956 2.179182682592422e-07 0.7816114142545842 2.17918457674258e-07 0.7770174196885687 \
2.17918650984654e-07 0.7723312127316435 2.179187944302406e-07 0.7688556734481145 2.179189438535907e-07 0.7652374066097742 2.179190630060629e-07 0.7623536300085233 \
2.179191757225445e-07 0.7596269484184472 2.179192849974512e-07 0.7569846861296079 2.179194210272094e-07 0.753697254849378 2.179195338230239e-07 0.750972995067179 \
2.179196560209801e-07 0.7480232093637929 2.179197676057526e-07 0.7453311011793381 2.179198923122156e-07 0.7423241425761796 2.179200466941669e-07 0.7386034578119585 \
2.179202134782327e-07 0.7345862494782525 2.179204306429213e-07 0.7293605768817599 2.179206252035101e-07 0.7246835946359503 2.179207855343955e-07 0.7208333202545074 \
2.179209609599985e-07 0.7166251500492028 2.179211507235729e-07 0.7120779400724765 2.179213394518974e-07 0.7075610435995559 2.179215212732644e-07 0.7032145396962334 \
2.179217058706759e-07 0.6988062725207448 2.179218429538112e-07 0.6955348514212173 2.179219962420495e-07 0.6918805091472418 2.179221916137951e-07 0.6872279990818534 \
2.179223477705467e-07 0.6835136309588888 2.179225057227664e-07 0.6797605476340507 2.179227039740297e-07 0.6750570282453686 2.179228973199279e-07 0.6704763548785364 \
2.17923133825274e-07 0.6648822204491218 2.179233200303777e-07 0.6604858901039825 2.179235576526979e-07 0.6548824851665868 2.179237444514522e-07 0.6504854738275335 \
2.179239250092116e-07 0.6462424706993735 2.179240880851561e-07 0.6424159959781919 2.179242326967206e-07 0.6390271817202816 2.179243732990706e-07 0.6357379642635244 \
2.179245001086569e-07 0.632774906490579 2.179246322451931e-07 0.6296924762754078 2.179247584891446e-07 0.6267508340255646 2.179248897527744e-07 0.6236963630311418 \
2.179250188505141e-07 0.6206978048938425 2.179251582761788e-07 0.6174624210713571 2.179253066461711e-07 0.6140261568477932 2.179255012030603e-07 0.6095278574984737 \
2.179256446489368e-07 0.6062198040692683 2.179258791091827e-07 0.6008245134060309 2.179260510074948e-07 0.5968818013610552 2.179262639280334e-07 0.5920102583789468 \
2.179264363946513e-07 0.5880775912131976 2.179265667191976e-07 0.5851108450968721 2.179266982755174e-07 0.5821241897920357 2.179268085055992e-07 0.5796262478458715 \
2.179269041598466e-07 0.5774603558442819 2.179270033938061e-07 0.5752182923213994 2.179270863119075e-07 0.5733484809858778 2.179271652275343e-07 0.5715706040143225 \
2.179272281563093e-07 0.5701535626562365 2.179272936647862e-07 0.5686800671140783 2.179273741508387e-07 0.5668736364148982 2.179274240168465e-07 0.5657560592102344 \
2.179274732056154e-07 0.5646541775062763 2.179275346754008e-07 0.5632780399140616 2.179275825969294e-07 0.5622058085646952 2.179276334416479e-07 0.5610687758404553 \
2.179276925419032e-07 0.5597501790023616 2.1792775115623e-07 0.5584442118409422 2.179278267823233e-07 0.5567607189607793 2.17927897341035e-07 0.5551915720267918 \
2.17927986471042e-07 0.5532116467156011 2.1792807569462e-07 0.5512351177508077 2.179281609982305e-07 0.5493490637975145 2.17928248625197e-07 0.5474138635528197 \
2.179283456271202e-07 0.545274424894262 2.179284499728913e-07 0.5429792414815097 2.179285662643155e-07 0.5404269323775457 2.17928672601932e-07 0.5380963700835184 \
2.179287843108152e-07 0.5356536306660374 2.179288966052949e-07 0.5332047801427824 2.179290238028543e-07 0.5304364255197962 2.17929146572528e-07 0.5277698476303582 \
2.179292887969246e-07 0.5246912237717902 2.179294251600566e-07 0.5217463069543907 2.179295773811234e-07 0.5184691491721333 2.179297370173294e-07 0.5150420887864461 \
2.179299129925215e-07 0.5112761258030903 2.179301015011087e-07 0.5072591542828934 2.179303085676898e-07 0.5028616940969075 2.179305335096624e-07 0.4981043078903621 \
2.179307849056189e-07 0.4928144328841237 2.179310213311851e-07 0.4878598554762091 2.179313184949192e-07 0.4816683149127979 2.179316091722113e-07 0.4756487143466775 \
2.17931917027196e-07 0.469313240945046 2.179322308529534e-07 0.4628991126846517 2.179325599943131e-07 0.4562163541974347 2.179328933724197e-07 0.4494927613461197 \
2.179332249990283e-07 0.4428490490857003 2.179335465484253e-07 0.4364504708187015 2.179338742242378e-07 0.4299742838549845 2.179342218438604e-07 0.4231546934710667 \
2.179345550651743e-07 0.4166645133789623 2.179349009744022e-07 0.4099771621835854 2.179353463882216e-07 0.4014400148089548 2.179357041780923e-07 0.3946500490499754 \
2.179360183349117e-07 0.3887397205534429 2.179364027453916e-07 0.3815756289527631 2.179367327200365e-07 0.3754830843203271 2.179370179301253e-07 0.3702633801070484 \
2.179373262203822e-07 0.3646649204592909 2.179376060174434e-07 0.3596257204303125 2.179378320117929e-07 0.3555880084110294 2.179380468497475e-07 0.3517755993421203 \
2.179382452848198e-07 0.3482769933469286 2.179384492243371e-07 0.3447071465415313 2.179386597603963e-07 0.3410461989361561 2.179389167345215e-07 0.3366091000429626 \
2.179391579951288e-07 0.3324763702393667 2.179393895688451e-07 0.3285420159269506 2.179396042222912e-07 0.3249208057821749 2.17939825046275e-07 0.3212218866489027 \
2.179400262928671e-07 0.3178749657716667 2.179402293821204e-07 0.3145250552959265 2.179404272269915e-07 0.3112865758726304 2.179406140799367e-07 0.3082497660855442 \
2.179408080166626e-07 0.3051208532403978 2.179410117613171e-07 0.30185834615803 2.179411904885829e-07 0.2990186060348319 2.179414281343783e-07 0.2952727068736475 \
2.179416278966111e-07 0.2921508861588616 2.179418295254275e-07 0.2890253490052915 2.179420549918856e-07 0.285561995332 2.17942221086285e-07 0.2830312764183137 \
2.179423997053871e-07 0.2803277612349699 2.179425814095885e-07 0.2775983111934518 2.179427700433049e-07 0.2747882307029562 2.17942947466508e-07 0.2721695222189568 \
2.179431246596456e-07 0.2695724116247911 2.179432847315606e-07 0.2672552081803913 2.179434051322386e-07 0.2655193337608355 2.179435529583031e-07 0.2633957862580221 \
2.179436815880755e-07 0.2615692882062232 2.179437837936585e-07 0.2601227034409412 2.179439020289393e-07 0.2584516051170885 2.179440224822997e-07 0.2567534139348401 \
2.179441461906177e-07 0.2550183706610066 2.179442644426428e-07 0.2533694204037282 2.179443922957733e-07 0.2515887492000971 2.179445125816039e-07 0.249915736161692 \
2.179446652612099e-07 0.2477917697339537 2.179448001739884e-07 0.2459264316518071 2.1794492881341e-07 0.2441493177932957 2.17945086528788e-07 0.2419705448111171 \
2.179452132100908e-07 0.2402201997919771 2.179453485361585e-07 0.2383592392624043 2.179454874487268e-07 0.2364550510890953 2.179456052210313e-07 0.2348405558720491 \
2.179457644918496e-07 0.2326580599570062 2.179459010137043e-07 0.2307878375452989 2.179460422456504e-07 0.2288626996658652 2.179461480586929e-07 0.2274220928889542 \
2.179462784016402e-07 0.2256484734765637 2.17946378112453e-07 0.2242944442559471 2.179464809338881e-07 0.2228991027388591 2.179465543495424e-07 0.2219046249368765 \
2.179466341811041e-07 0.2208265149641777 2.179467042283352e-07 0.2198809561195558 2.179467546314264e-07 0.2192009305305119 2.179468068832254e-07 0.2184966408607167 \
2.179468861207429e-07 0.2174292050927151 2.179469279646958e-07 0.2168658036437602 2.179469673046481e-07 0.216336351877609 2.179470103400575e-07 0.2157575332679269 \
2.179470545074838e-07 0.2151638767852215 2.179471282732236e-07 0.2141731338947761 2.179471637852207e-07 0.2136967174286463 2.179472115000211e-07 0.2130606706933813 \
2.17947272229561e-07 0.2122518321687151 2.179473404867867e-07 0.2113438957752176 2.179474130085659e-07 0.2103801801047663 2.179474856831929e-07 0.2094152724966429 \
2.179475939991808e-07 0.2079788886429202 2.179476916703231e-07 0.20668564243436 2.179478032218192e-07 0.2052110974836689 2.179479017572532e-07 0.2039136008387587 \
2.179480052503929e-07 0.2025572972554956 2.179481011521277e-07 0.2013021587886929 2.17948203780057e-07 0.1999606878451601 2.179483066031699e-07 0.1986207062101238 \
2.179484167227972e-07 0.1971897063011611 2.179485254183531e-07 0.1957815523781236 2.179486450955818e-07 0.1942360962608612 2.179487553732606e-07 0.192818053470401 \
2.179488634364806e-07 0.1914343471929882 2.179489885351485e-07 0.1898375077741012 2.179490785049817e-07 0.1886931806549971 2.179491571919347e-07 0.1876950225942949 \
2.17949234476806e-07 0.1867173468865102 2.179493209853825e-07 0.1856271834369256 2.179494199345929e-07 0.1843848109964498 2.179494904434582e-07 0.1835017733581451 \
2.179495618945114e-07 0.1826096997732476 2.179496670398458e-07 0.1813018727451555 2.179497462794755e-07 0.1803200401832796 2.179498273633695e-07 0.1793174195483187 \
2.179499208553101e-07 0.1781663090788374 2.179500216312847e-07 0.1769308188703378 2.179501713433884e-07 0.175105380089017 2.179502871327037e-07 0.1737009932372819 \
2.179504381380806e-07 0.1718807311127691 2.179505492465001e-07 0.1705485445502526 2.179506913729584e-07 0.168854666407182 2.179508090313791e-07 0.167460358327668 \
2.179509139359749e-07 0.1662230887079887 2.179510089985733e-07 0.1651069099307241 2.179511024298279e-07 0.1640147999883682 2.179512034764903e-07 0.1628388413495604 \
2.179512998233979e-07 0.1617223204899406 2.179513969756437e-07 0.1606011553546776 2.179514800242163e-07 0.1596469772300165 2.179515900618698e-07 0.1583897228513109 \
2.179516723644316e-07 0.1574542248873526 2.179517773641412e-07 0.156267858580057 2.179518550602102e-07 0.1553950893374849 2.179519378796887e-07 0.1544690878994293 \
2.179520195415937e-07 0.1535604570452941 2.179521088908844e-07 0.152571060794856 2.1795218460332e-07 0.1517364980793458 2.179522671659343e-07 0.1508307726525361 \
2.179523437473671e-07 0.1499942554682341 2.179524120352535e-07 0.1492531084507001 2.179525054022655e-07 0.1482449401818621 2.179525745556768e-07 0.1475015570698688 \
2.179526501800083e-07 0.1466917482325688 2.179527117291286e-07 0.1460354497178591 2.179527789778923e-07 0.1453208357145237 2.179528500398917e-07 0.1445684785944268 \
2.179529255373203e-07 0.143772322008306 2.179529844488598e-07 0.1431546944759192 2.179530611224699e-07 0.1423563022825049 2.179531414432115e-07 0.1415233898163201 \
2.179532145945195e-07 0.1407682091691316 2.179533087509408e-07 0.139800669784813 2.179533803551248e-07 0.1390684367429364 2.179534538159005e-07 0.1383201464810226 \
2.179535373276515e-07 0.1374732033664194 2.179536268067954e-07 0.1365744208092838 2.179536918717003e-07 0.1359252211013016 2.179538039977229e-07 0.1348115665849295 \
2.179538691838635e-07 0.1341670699454539 2.179539392221084e-07 0.1334770515823289 2.179539995271633e-07 0.1328849371768329 2.179540545379868e-07 0.1323464455745446 \
2.17954142654965e-07 0.1314871014507438 2.179541834412595e-07 0.131090685705856 2.179542871440105e-07 0.1300923774523848 2.179543304565801e-07 0.1296773144713907 \
2.17954391675178e-07 0.1290920262082728 2.179544365118974e-07 0.1286643765206081 2.179545241079233e-07 0.127831527987147 2.179545656618794e-07 0.1274377589706847 \
2.179546255233895e-07 0.1268718307679372 2.179546973671149e-07 0.1261946708524367 2.179547535798413e-07 0.1256664967939027 2.179548160673402e-07 0.125081039250218 \
2.179548902953232e-07 0.1243877959456236 2.179549649763284e-07 0.1236954937854857 2.179550521595408e-07 0.1228905551604285 2.179551205580918e-07 0.1222610287411191 \
2.17955201128775e-07 0.1215216597888775 2.179552824242559e-07 0.120778012781285 2.179553493407808e-07 0.1201677797529914 2.179554321577256e-07 0.1194156054679852 \
2.179554913464481e-07 0.1188799972037829 2.179555572674477e-07 0.1182853617472536 2.179556371414917e-07 0.1175675408705869 2.179557136372899e-07 0.1168828806096336 \
2.179557950994005e-07 0.1161574242846086 2.179558935702815e-07 0.1152852106851665 2.179559686806303e-07 0.114622623867465 2.179560716684202e-07 0.1137180076826871 \
2.179561458523715e-07 0.1130691786503039 2.179562434718251e-07 0.1122190343868764 2.179563392827804e-07 0.1113890351962442 2.179564351312053e-07 0.110562946039519 \
2.179565160694118e-07 0.1098685209805978 2.179566044526832e-07 0.1091134439098378 2.179567030526616e-07 0.108274944429282 2.179567758368656e-07 0.1076586405352824 \
2.17956865109775e-07 0.1069058608836731 2.179569270917884e-07 0.1063852406583179 2.179569896849557e-07 0.1058613310701875 2.179570749071042e-07 0.105150777260444 \
2.179571803694782e-07 0.1042758147594986 2.179572601999606e-07 0.1036167065755082 2.179573409142144e-07 0.1029530974056021 2.179574235279495e-07 0.1022768941101355 \
2.179574939725617e-07 0.1017026162492672 2.179575972319282e-07 0.1008648142128753 2.179576700720535e-07 0.1002767039768694 2.179577557123351e-07 0.09958839426015198 \
2.179578745140727e-07 0.09863954321822334 2.179579421518979e-07 0.09810250133474645 2.179580119020204e-07 0.09755100310752296 2.17958089237e-07 0.09694230106952094 \
2.179581816572539e-07 0.09621870517595056 2.17958253354782e-07 0.09566033062548993 2.179583391719417e-07 0.09499542738017568 2.17958441597192e-07 0.09420660575030523 \
2.17958534892083e-07 0.09349264652734962 2.179586312085565e-07 0.09276005482712441 2.179587081108176e-07 0.09217843893134048 2.179588015908053e-07 0.09147541043939374 \
2.179588808332317e-07 0.09088281005358793 2.17958995455426e-07 0.0900310686188453 2.179591250636858e-07 0.08907580221142102 2.179592583208766e-07 0.08810234090122065 \
2.179594023507657e-07 0.08705990691030199 2.179595595189096e-07 0.08593388720602639 2.179597092953871e-07 0.08487214151476249 2.179598717629786e-07 0.08373303262435308 \
2.179600149429843e-07 0.08273971668837025 2.17960167622107e-07 0.0816913199659166 2.179603018918778e-07 0.08077856892457436 2.179604436441555e-07 0.07982444400446118 \
2.179605786438163e-07 0.07892500874648442 2.179607206012136e-07 0.07798882638923543 2.179608674486441e-07 0.07703088995320664 2.17961019894053e-07 0.07604750978240994 \
2.179611851127758e-07 0.07499422991502351 2.179613492506213e-07 0.07396067809208305 2.17961526112024e-07 0.07286119333145537 2.179617164535802e-07 0.07169407515132428 \
2.179619274100931e-07 0.07042030845332216 2.179621478192316e-07 0.0691121699798517 2.17962383344393e-07 0.06773900533435212 2.179626437937674e-07 0.0662496528900723 \
2.179629394591772e-07 0.06459579389282195 2.179632445814628e-07 0.06292902455725519 2.179636095760241e-07 0.06098725515092194 2.179640044568393e-07 0.05894944116461652 \
2.179644108474933e-07 0.05692211719668253 2.179648265730353e-07 0.05491854459141238 2.179651893793582e-07 0.0532251207245777 2.179655339806477e-07 0.05166301626031383 \
2.179658491605098e-07 0.05027284652491828 2.179661446898748e-07 0.04900240867073854 2.179664426703825e-07 0.04775344010203557 2.179667184691725e-07 0.04662857640242725 \
2.179669972437684e-07 0.04551884372531381 2.179672611786382e-07 0.04449205559535935 2.179675372013766e-07 0.04344260531795661 2.179678161576298e-07 0.04240676967887352 \
2.179681298509633e-07 0.04127097799875453 2.179683658512502e-07 0.04043636567030678 2.179686216459875e-07 0.03955075129286261 2.17968881769487e-07 0.03867033103466553 \
2.179691519047594e-07 0.03778142289416799 2.179694311247467e-07 0.03688501536902895 2.179697129633963e-07 0.03600226561751176 2.17969989839066e-07 0.03515600409566183 \
2.179702689326649e-07 0.03432349610146775 2.179705018102725e-07 0.03364444121149882 2.179707856469894e-07 0.03283527291840588 2.179710257519236e-07 0.03216626441466421 \
2.179712655507464e-07 0.0315119836023277 2.179715048279204e-07 0.03087436846876356 2.179717400849421e-07 0.03026290129608995 2.17971971011964e-07 0.02967475842909434 \
2.17972186001007e-07 0.02913788335257221 2.179725881554596e-07 0.02816043724496065 2.179727868782784e-07 0.02768988489927659 2.179731605612946e-07 0.0268265706552881 \
2.179733473596173e-07 0.02640514011949098 2.179736949193039e-07 0.02563810810034544 2.179738168487671e-07 0.0253740445387235 2.179741993202075e-07 0.02456430406701914 \
2.179743700282368e-07 0.02421180751242828 2.179748271256211e-07 0.02328894863848502 2.179750127580069e-07 0.0229225623309489 2.179753762152598e-07 0.02221803970155307 \
2.179755965826125e-07 0.02179832126591805 2.179760543089696e-07 0.02093867417890744 2.179761897285988e-07 0.02068687731869814 2.179767196240474e-07 0.01972418011126781 \
2.17976838945017e-07 0.01951377505543128 2.179774047306961e-07 0.01856069823426573 2.17977569110437e-07 0.0182962226476828 2.179781876557339e-07 0.01735107502432094 \
2.179783577099333e-07 0.01710418363667701 2.179788898421661e-07 0.01636278834442301 2.179790869261418e-07 0.01610013864443424 2.179798100452149e-07 0.01517806887136661 \
2.179799746753809e-07 0.01497647803580381 2.179807238007678e-07 0.01409711804523418 2.179808571001203e-07 0.01394643716836554 2.179817173537587e-07 0.01301449210748497 \
2.179818524573794e-07 0.01287422877142914 2.179827950348197e-07 0.01193816285908547 2.179829586305738e-07 0.01178202925388569 2.179839599872008e-07 0.0108653384673985 \
2.179840975299883e-07 0.01074500730514941 2.179853196363713e-07 0.009765086624518643 2.179854265890839e-07 0.00968516078425012 2.179868307805774e-07 0.008707372520026449 \
2.179869356112841e-07 0.008639312158696611 2.179884704482461e-07 0.00767719340797631 2.179885657315476e-07 0.007617466071856052 2.179901745288685e-07 0.006680264535635283 \
2.179903086056077e-07 0.006609506832171614 2.179924056185594e-07 0.005610918814474722 2.179926361631908e-07 0.005510783990371394 2.179949591584347e-07 0.004586584533412417 \
2.179954404886379e-07 0.004413562233393853 2.179982780502688e-07 0.003511943147855551 2.179988229699549e-07 0.003360532104877318 2.180029471783516e-07 0.002408309874554541 \
2.180034909020111e-07 0.002305347543005144 2.180093621912368e-07 0.001333291345955189 2.180096050564212e-07 0.001286469439319215 2.180239329487719e-07 0.0002880570268237783 \
2.180240775074142e-07 0.0002853642807229123 2.206613564285128e-07 -0.0006859155495331031 2.206614959836499e-07 -0.000901903561740745 2.206620050775826e-07 -0.001859438188174024 \
2.206620945650851e-07 -0.002052812934985279 2.206624579599451e-07 -0.00291126965001638 2.206625489820155e-07 -0.003143482006111167 2.206629144200523e-07 -0.004127275145644371 \
2.206630246806195e-07 -0.004436819103926468 2.206633367277739e-07 -0.005309594399865315 2.206634394426211e-07 -0.005584800160857357 2.206638032904768e-07 -0.006384516484886619 \
2.206639680812086e-07 -0.006586298968823262 2.206645476774082e-07 -0.005791490933239759 2.206647227875511e-07 -0.004914057272375438 2.206648394794853e-07 -0.004132845175365214 \
2.206649660640906e-07 -0.003100877896798674 2.206650678730126e-07 -0.002132773363901063 2.206651883617228e-07 -0.0008283127610571584 2.206652788087988e-07 0.0002599396317828252 \
2.206653766989305e-07 0.001541559978017447 2.206654757632395e-07 0.002943971508909197 2.206656465705158e-07 0.005594911825788154 2.206658683385388e-07 0.00944046646559993 \
2.206660642423845e-07 0.01317281463966807 2.206662231237664e-07 0.01639870563256729 2.206663875522633e-07 0.01989779506365397 2.206665419182936e-07 0.02331070396473752 \
2.20666700690818e-07 0.02693200463312963 2.20666847428777e-07 0.03036422445567413 2.206669960527481e-07 0.0339113704936035 2.20667151667245e-07 0.03768995713197771 \
2.206673089092589e-07 0.04156499463828727 2.206674738020577e-07 0.04567927910670353 2.206676472215784e-07 0.05005184210758699 2.20667825915293e-07 0.05459761989277153 \
2.206680145311307e-07 0.05943075613080645 2.206682154312736e-07 0.06460909294799391 2.206684348880646e-07 0.0702927970720964 2.206686644343515e-07 0.07626037976612585 \
2.20668910133291e-07 0.08266408948881369 2.206691786982297e-07 0.08967663153997742 2.206694700401445e-07 0.09728936802005522 2.206697917081718e-07 0.1056939239977524 \
2.20670152022263e-07 0.1150987971742611 2.206705430017012e-07 0.1252892839303718 2.206709864165172e-07 0.1368209045172546 2.206715027296046e-07 0.1502062239570841 \
2.206721089348208e-07 0.16586000516691 2.206727801918478e-07 0.1831102247110778 2.206735596915048e-07 0.20301830483439 2.206744320013886e-07 0.2251413938832897 \
2.206752623367137e-07 0.2460320778586349 2.206759936670634e-07 0.264292249712138 2.206766416128433e-07 0.280346965484095 2.206772249233171e-07 0.29469740877147 \
2.20677760655584e-07 0.3077798509628869 2.20678263914169e-07 0.3199778888071559 2.2067874911767e-07 0.3316516836183861 2.206792280403756e-07 0.3430829066939081 \
2.20679674471008e-07 0.3536501814456421 2.206801488007181e-07 0.3647819492304352 2.206805979917124e-07 0.3752331958288908 2.206810884639696e-07 0.3865396207984229 \
2.206816170367226e-07 0.3985997842463301 2.206819881810625e-07 0.4069920784971888 2.206825159354181e-07 0.4188173133762567 2.206829782921778e-07 0.4290642331729484 \
2.206834506243179e-07 0.4394285229343968 2.206839324090407e-07 0.4498981261869666 2.206839654481592e-07 0.4506126593745911 2.206840032071518e-07 0.45142837879914 \
2.20684078725137e-07 0.4530572051633331 2.206842297611073e-07 0.4563088938659436 2.206844372803726e-07 0.460764549126051 2.206846253191843e-07 0.4647825567212808 \
2.206848443283984e-07 0.469441659996985 2.206850871594094e-07 0.4745824626509371 2.206853869350375e-07 0.4808894567257585 2.206856247281872e-07 0.4858624696070272 \
2.206858879495879e-07 0.4913374535260851 2.206861488471327e-07 0.4967277906005185 2.206863784012197e-07 0.5014431429135263 2.206866014614136e-07 0.506003872007333 \
2.206868030374043e-07 0.5100983586086808 2.206869518674631e-07 0.51310967141356 2.206871961785157e-07 0.5180317772556589 2.206873287837491e-07 0.5206893064287169 \
2.206874681403308e-07 0.5234717264876519 2.206876791057242e-07 0.5276623644271943 2.206878539796058e-07 0.5311266030493931 2.206881220278524e-07 0.5364094032095129 \
2.206883170535098e-07 0.5402319029111832 2.206884966150174e-07 0.5437361368949839 2.206887475711459e-07 0.5486228351952749 2.20689024979257e-07 0.5540035987981641 \
2.20689308928559e-07 0.5594901708581531 2.206895645658505e-07 0.5644152233389156 2.206898555480696e-07 0.570006772487656 2.20690115853754e-07 0.5749917787111524 \
2.206903842978737e-07 0.5801232573974072 2.206906270630043e-07 0.5847450403362237 2.206908835942051e-07 0.5896146675871002 2.206911097576483e-07 0.59388771440121 \
2.206913470991427e-07 0.5983512154742827 2.206915564878602e-07 0.6022720321566808 2.206917702606284e-07 0.6062574570422776 2.206920237134688e-07 0.6109557890491497 \
2.206922265678164e-07 0.6146943332140289 2.206924193723378e-07 0.6182333111593361 2.206926096773651e-07 0.6217090173923294 2.206928003358541e-07 0.6251694921350958 \
2.206930029137797e-07 0.6288260100903066 2.206932656625422e-07 0.6335359534764116 2.206934946302321e-07 0.6376100987349322 2.206937145778672e-07 0.6414991146358265 \
2.206939402625401e-07 0.6454625140719233 2.206941491499662e-07 0.6491091855837361 2.206943708035853e-07 0.652957810138281 2.206945556930106e-07 0.6561429680377227 \
2.206947457075645e-07 0.6594017273991298 2.206948958626861e-07 0.6619630641908443 2.206950707405929e-07 0.6649292185271485 2.206952164613095e-07 0.6673855496832628 \
2.206953524938417e-07 0.6696641287411549 2.206955008561211e-07 0.672138295335571 2.206956303038336e-07 0.6742883907026684 2.206957641695307e-07 0.6764996355878535 \
2.206958925139303e-07 0.6786115243545502 2.206960179020585e-07 0.6806677490053815 2.20696147367755e-07 0.6827843190971332 2.206962783489702e-07 0.6849171426143115 \
2.206964267220724e-07 0.6873221141612875 2.206965347848267e-07 0.6890667486235877 2.206966633164996e-07 0.6911333958680312 2.206967987562836e-07 0.6933004139195943 \
2.206969236906072e-07 0.6952876996714908 2.206970494478751e-07 0.6972799977491608 2.206971559637663e-07 0.6989584331773744 2.20697273081655e-07 0.7007929859467624 \
2.206973916214008e-07 0.7026383448210159 2.206975149247975e-07 0.704545102273978 2.206976180976957e-07 0.7061304255463237 2.206977690688591e-07 0.7084341141567283 \
2.206978853230653e-07 0.7101955266062138 2.206980158834539e-07 0.7121605601685687 2.206981344459821e-07 0.7139335830373704 2.206982405198518e-07 0.7155108922888329 \
2.206983405447916e-07 0.716990346352101 2.206984778700066e-07 0.719009255813789 2.206985965313623e-07 0.7207429633399333 2.20698718230586e-07 0.7225107522614664 \
2.206988434131515e-07 0.7243181860083944 2.206989654329653e-07 0.7260693242762759 2.206990934647187e-07 0.7278954552757622 2.20699217946458e-07 0.7296603419865877 \
2.206993462457807e-07 0.7314685590147565 2.206994733395841e-07 0.7332489547570846 2.206995993644231e-07 0.7350034830462163 2.2069970210311e-07 0.7364262918236342 \
2.206998167758557e-07 0.7380063527755659 2.206998981819179e-07 0.7391232259175492 2.207000173814378e-07 0.7407496908814458 2.207001100237781e-07 0.7420059782745783 \
2.207002481828348e-07 0.7438668850244906 2.207003792383344e-07 0.7456179978167152 2.207005093705019e-07 0.7473439783685625 2.207006143445769e-07 0.7487266533969134 \
2.207007534844189e-07 0.7505456565005918 2.207009074287187e-07 0.7525407731682957 2.207010293729987e-07 0.7541080835708853 2.207011769193594e-07 0.7559892974429111 \
2.20701298924537e-07 0.7575320275232224 2.207014476244666e-07 0.7593968175435225 2.207015816710922e-07 0.7610632318338031 2.207017039243472e-07 0.7625711443351471 \
2.207018167902567e-07 0.763953046884334 2.207019596412247e-07 0.7656882893306027 2.207020863641194e-07 0.7672149413549471 2.207022021689945e-07 0.7685995877768005 \
2.207023319108228e-07 0.7701390587657672 2.207024476492106e-07 0.7715019052061673 2.207025706016372e-07 0.7729391548276606 2.20702688317297e-07 0.7743051053122872 \
2.207027942872733e-07 0.7755262985206828 2.207029106984675e-07 0.7768586864857919 2.207030173164004e-07 0.7780703956921795 2.207031295151206e-07 0.7793369495935717 \
2.207032161836897e-07 0.7803089322889447 2.207033195691813e-07 0.7814603789665585 2.207034327334326e-07 0.7827108149434853 2.207035383807156e-07 0.783868819044773 \
2.207036477202729e-07 0.7850578567336689 2.207037548972878e-07 0.786214126597127 2.20703884303365e-07 0.7875981444497275 2.207039967207506e-07 0.7887899291890393 \
2.207041201084898e-07 0.7900869036018625 2.207042375588255e-07 0.7913106402786101 2.207043810857437e-07 0.7927918312347375 2.20704496005322e-07 0.7939667362870242 \
2.207046347277352e-07 0.7953719780830618 2.207047727598755e-07 0.7967562205547866 2.207048822530295e-07 0.7978444364842524 2.207049832714595e-07 0.7988406866985471 \
2.207050843594198e-07 0.7998302780396641 2.207052167466158e-07 0.8011146558616069 2.207053354720369e-07 0.8022550163876687 2.207054572565424e-07 0.8034134048507504 \
2.20705576346336e-07 0.8045351524060473 2.207056975508533e-07 0.8056657048884367 2.207058291946645e-07 0.8068811249615274 2.207059522127029e-07 0.8080052413861453 \
