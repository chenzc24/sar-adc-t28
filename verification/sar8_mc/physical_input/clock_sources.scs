1.710723218250269e-06 0.01551958953683085 1.710723381870153e-06 0.01531511209162885 1.71072414235084e-06 0.01440332854054019 1.710724289392963e-06 0.01423371673427115 \
1.710725107264621e-06 0.01333087949608782 1.710725226813134e-06 0.01320411419549955 1.710726142674656e-06 0.01227329163592313 1.710726284027572e-06 0.01213544173166964 \
1.710727232503148e-06 0.01124488043697059 1.710727391142586e-06 0.01110230805801717 1.71072857354363e-06 0.01011356759191894 1.71072867164402e-06 0.01003725601038859 \
1.71072993325548e-06 0.009120360285939955 1.71073006766933e-06 0.009028655389366201 1.710731608240655e-06 0.008043892937307966 1.710731689273999e-06 0.007992925041580451 \
1.710733277867931e-06 0.007023242357651564 1.710733410759078e-06 0.006948518507451114 1.71073538746242e-06 0.005952856104192286 1.710735569200568e-06 0.005869662958407677 \
1.710737671554228e-06 0.004980929874643355 1.710738112345997e-06 0.004810448874467742 1.710740767560855e-06 0.003892108290451164 1.710741244140394e-06 0.003745909362026665 \
1.710744882222615e-06 0.00279447349697209 1.71074540774606e-06 0.002678838783887205 1.710751013810845e-06 0.001700248310874221 1.710751324898547e-06 0.001653333728976835 \
1.710756459226246e-06 0.0006858192122199529 1.710756653206019e-06 0.0006440832883579712 1.713404576914862e-06 -0.0002037173203380238 1.713404741115283e-06 -0.0003889174928863678 \
1.713405314458091e-06 -0.001270938904608877 1.713405389392278e-06 -0.001411855863724778 1.713405849976055e-06 -0.002393592696522268 1.713405961916807e-06 -0.002660411672198376 \
1.713406215188795e-06 -0.003300974950034667 1.7134063815721e-06 -0.003745951779090856 1.71340667656787e-06 -0.004566571567208835 1.713406788055442e-06 -0.00488071790655901 \
1.713407067428216e-06 -0.005641221413069743 1.713407188386555e-06 -0.005938820066262044 1.713408282339388e-06 -0.005180465225493313 1.713408406471631e-06 -0.004410796826645887 \
1.713408530879049e-06 -0.003456122327429311 1.713408650435429e-06 -0.002364170815481491 1.713408748579805e-06 -0.001341064316055312 1.713408855004127e-06 -0.0001052154991983786 \
1.713408967239972e-06 0.001336046702817826 1.713409102195821e-06 0.003249882807978809 1.713409224782331e-06 0.005149402351921401 1.713409413644246e-06 0.008353592055059769 \
1.713409554826578e-06 0.01094873860302964 1.713409708187922e-06 0.01393943619118621 1.713409851561427e-06 0.01687898420971235 1.713410005752867e-06 0.02017576688295359 \
1.713410161892825e-06 0.02363796584892512 1.713410317618878e-06 0.02719811802828209 1.713410465112557e-06 0.03065407560139007 1.713410613784323e-06 0.03420778369279751 \
1.713410769114407e-06 0.03798436241030867 1.713410927740287e-06 0.04189786275883118 1.713411092673448e-06 0.0460171220807938 1.713411267096336e-06 0.05041857973200652 \
1.713411446085736e-06 0.05497510627343041 1.713411635385597e-06 0.05982852266675163 1.713411838393603e-06 0.06506368941101938 1.713412057870669e-06 0.07075025585284363 \
1.71341228893533e-06 0.07675903373893865 1.713412535995649e-06 0.08319974270080552 1.713412806420637e-06 0.0902619122132732 1.713413099984324e-06 0.09793335781011638 \
1.713413424033306e-06 0.1064001814721126 1.713413788254856e-06 0.1159066558703892 1.713414180806326e-06 0.1261372395632307 1.713414630304251e-06 0.1378252442462487 \
1.713415153096484e-06 0.1513754922073403 1.713415766694219e-06 0.1672157090591849 1.713416444455093e-06 0.184625848284817 1.713417232720212e-06 0.2047487967247964 \
1.713418115553072e-06 0.22712469896725 1.713418933839029e-06 0.2476994923478653 1.713419661268608e-06 0.2658503723959502 1.713420301381636e-06 0.2817009601644404 \
1.71342087568535e-06 0.2958213763442377 1.713421413251317e-06 0.3089396094373287 1.713421917248776e-06 0.3211464104224903 1.71342239337143e-06 0.3325930942309646 \
1.713422871259445e-06 0.3439912352478621 1.713423324592551e-06 0.3547121966731367 1.713423795885259e-06 0.3657614311162562 1.713424238561085e-06 0.3760518588326446 \
1.713424757059872e-06 0.3879885572071845 1.713425284221992e-06 0.3999987293386327 1.713425663131623e-06 0.4085537955782026 1.713426193047166e-06 0.4204060347738258 \
1.713426622963746e-06 0.429919877745455 1.713427076664521e-06 0.4398653393542544 1.713427543378037e-06 0.4500002271552926 1.713427981059267e-06 0.4594210430579985 \
1.713428389021531e-06 0.468120704286539 1.713428708454565e-06 0.4748816926501604 1.713429080589836e-06 0.4826992142337162 1.713429315571978e-06 0.4876010339127531 \
1.713429549178225e-06 0.4924491904621348 1.713429797190648e-06 0.4975647713404599 1.713430095592078e-06 0.5036796627825791 1.71343035194848e-06 0.5088948470128004 \
1.71343056424179e-06 0.5131878547336713 1.713430758259862e-06 0.5170959594548015 1.713430905246394e-06 0.5200432695146362 1.713431059224405e-06 0.523118600542271 \
1.713431277106154e-06 0.5274469616807909 1.71343153021048e-06 0.5324525256580425 1.713431740049324e-06 0.5365797337241586 1.713431951502634e-06 0.5407247601751553 \
1.713432233709534e-06 0.5462280430697679 1.713432463254817e-06 0.5506821559930507 1.713432679151023e-06 0.5548604062613707 1.713432961372541e-06 0.560308769190463 \
1.713433212680268e-06 0.5651538146135803 1.71343351034116e-06 0.5708625224168123 1.713433760568061e-06 0.5756519166658941 1.713434016931556e-06 0.5805516059354519 \
1.71343425734157e-06 0.585116682128892 1.713434515521386e-06 0.5900038400537884 1.713434739113591e-06 0.5942175703762435 1.713434977623163e-06 0.5986919452581434 \
1.713435185207861e-06 0.6025689278491061 1.713435401730486e-06 0.6065904171332736 1.713435651033092e-06 0.6111939272561876 1.713435856106535e-06 0.6149609706257601 \
1.71343610737886e-06 0.6195555361399968 1.713436310600886e-06 0.6232455818254186 1.713436507472791e-06 0.6267987644955494 1.713436700764307e-06 0.630267737067843 \
1.713436955542762e-06 0.6348113783570861 1.713437185753374e-06 0.638887973644319 1.713437403107185e-06 0.6427143472883045 1.713437701512908e-06 0.6479268061885751 \
1.713437916915757e-06 0.6516657345437264 1.713438118139476e-06 0.6551344108237934 1.713438293060983e-06 0.6581323437428509 1.713438458126254e-06 0.6609495238976936 \
1.713438627594774e-06 0.6638251431769452 1.713438779731612e-06 0.666392827642013 1.713438917642298e-06 0.6687037209181631 1.713439066478412e-06 0.6711867545200138 \
1.713439194593014e-06 0.6733159837320549 1.713439337815827e-06 0.6756849429836936 1.713439459090078e-06 0.6776819274526149 1.713439596688762e-06 0.6799401191146522 \
1.713439716069216e-06 0.6818929034138137 1.713439863176962e-06 0.6842914131385206 1.713439980378628e-06 0.6861933934268433 1.713440073884205e-06 0.6877071857403232 \
1.713440164873897e-06 0.6891752279197846 1.713440267615961e-06 0.6908280855439021 1.713440369133525e-06 0.6924555900607121 1.713440487516631e-06 0.6943444167618776 \
1.713440599637217e-06 0.6961264383846065 1.713440717192718e-06 0.6979868779962457 1.713440902343005e-06 0.7008959348649784 1.713441033535213e-06 0.7029413755586562 \
1.713441169703753e-06 0.7050491462541959 1.713441291222456e-06 0.7069171228306749 1.713441431145468e-06 0.7090538254196674 1.713441535088117e-06 0.7106315721465845 \
1.713441646249101e-06 0.712309798010818 1.713441750508965e-06 0.7138759052437967 1.713441880147056e-06 0.7158124745844324 1.713441977077769e-06 0.7172526339884565 \
1.713442116000004e-06 0.7193052800722975 1.713442235549293e-06 0.7210612846995991 1.713442355121865e-06 0.7228080613301419 1.713442480897243e-06 0.7246353354365959 \
1.713442607615586e-06 0.7264656873164689 1.713442729655437e-06 0.728218443613998 1.71344285780388e-06 0.7300486655261287 1.713442987872205e-06 0.7318956587421809 \
1.713443108863227e-06 0.7336041830685722 1.713443249633811e-06 0.7355801168346318 1.71344335060338e-06 0.7369898206659778 1.713443452204237e-06 0.7384020079314992 \
1.713443548224548e-06 0.7397310783624924 1.713443659137403e-06 0.7412570822736337 1.71344374678503e-06 0.7424563811251772 1.713443846639401e-06 0.7438154404043728 \
1.713443981404538e-06 0.7456370856934184 1.713444097699018e-06 0.747198032089633 1.713444201190815e-06 0.7485782798032956 1.713444325446263e-06 0.7502239458264747 \
1.713444470359203e-06 0.7521280942578691 1.713444588339771e-06 0.753666143975803 1.713444707270879e-06 0.7552056331692281 1.713444846850418e-06 0.7569980918234445 \
1.713444991202808e-06 0.7588357421297242 1.713445109263616e-06 0.7603265096672839 1.713445234085335e-06 0.7618908200857619 1.713445373916531e-06 0.7636286950759973 \
1.713445498679428e-06 0.7651662633748356 1.713445642192899e-06 0.7669199865864609 1.713445762878377e-06 0.7683824344671055 1.713445883722124e-06 0.7698356273746885 \
1.713446003367048e-06 0.7712633747646481 1.713446133074687e-06 0.7727989859455529 1.71344624181849e-06 0.7740766298596218 1.713446364466226e-06 0.7755070372682662 \
1.713446474242911e-06 0.7767778749889983 1.713446603267025e-06 0.7782599816788072 1.713446735043344e-06 0.7797610257751375 1.71344684835592e-06 0.7810403609326458 \
1.713446969441862e-06 0.7823954393038701 1.713447073314495e-06 0.7835479431998941 1.713447215597517e-06 0.785111775748914 1.713447363800666e-06 0.7867227488076519 \
1.713447522694201e-06 0.7884297907063792 1.713447642887223e-06 0.7897074707829422 1.71344779245393e-06 0.7912811323018302 1.713447916569147e-06 0.7925734175081853 \
1.713448042273444e-06 0.7938699048627912 1.713448145219011e-06 0.7949224966762399 1.713448259590165e-06 0.7960823495211882 1.713448372064409e-06 0.7972131756542409 \
1.713448462336983e-06 0.7981137961420948 1.713448551677879e-06 0.7989989930139054 1.713448676903817e-06 0.800229513878344 1.71344878467518e-06 0.8012785338618679 \
1.713448914342978e-06 0.8025281307685926 1.713449035722257e-06 0.8036855380110038 1.713449152278057e-06 0.8047859282369955 1.713449273083453e-06 0.80591497746663 \
1.713449405708758e-06 0.8071413435168892 1.713449527502378e-06 0.8082555056211007 1.713449654106103e-06 0.8094015704683005 1.713449779719621e-06 0.8105266036187198 \
1.713449899211046e-06 0.8115857443778658 1.713450037409299e-06 0.8127973981963581 1.713450146908547e-06 0.8137473213416323 1.713450231056662e-06 0.8144713378799666 \
1.71345035186072e-06 0.8155017394983226 1.713450447369557e-06 0.8163089346032877 1.71345058366036e-06 0.8174496006492775 1.713450726424414e-06 0.8186303638797883 \
1.713450860857535e-06 0.8197292014569521 1.713450970729519e-06 0.8206175763825388 1.713451114629137e-06 0.8217677661037901 1.71345126795672e-06 0.8229768690765377 \
1.713451395805574e-06 0.8239722812379519 1.713451536202905e-06 0.8250521595273246 1.713451662107844e-06 0.8260088941474263 1.71345181672401e-06 0.8271688948348412 \
1.71345194907934e-06 0.8281489842609937 1.713452075346168e-06 0.8290730392392056 1.713452193006695e-06 0.8299245984162376 1.713452341409092e-06 0.8309852945996649 \
1.71345250860326e-06 0.8321626230293395 1.713452641380572e-06 0.8330844501529713 1.713452814281769e-06 0.8342675727345584 1.713452982699063e-06 0.8354015168591284 \
1.713453152193536e-06 0.8365246342267009 1.713453333630418e-06 0.8377070668209077 1.713453476186559e-06 0.8386219603417975 1.71345359009745e-06 0.8393441765511721 \
1.713453720973658e-06 0.8401643924869071 1.713453822596633e-06 0.8407940582489307 1.713453939036871e-06 0.8415078269750864 1.713454074330057e-06 0.8423269142909066 \
1.713454271595159e-06 0.8435017451489455 1.713454462114483e-06 0.844614933042255 1.713454672039296e-06 0.8458175693076773 1.713454852817827e-06 0.8468334846981137 \
1.713455050185846e-06 0.8479221976595614 1.71345522404434e-06 0.8488638701886076 1.713455406558583e-06 0.8498353939890455 1.713455577902693e-06 0.8507314120859523 \
1.713455752248258e-06 0.8516272398309612 1.713455927651258e-06 0.8525125793730954 1.713456103896448e-06 0.8533864315694911 1.713456293665327e-06 0.8543099749208749 \
1.713456484423344e-06 0.8552205033559714 1.71345668621255e-06 0.8561646193034282 1.713456878916116e-06 0.8570482883232282 1.713457088356793e-06 0.8579892478796384 \
1.713457318098559e-06 0.8589986827500428 1.713457583567511e-06 0.8601360945383778 1.713457882213856e-06 0.8613786760148464 1.713458160601222e-06 0.8625023989005415 \
1.713458444791177e-06 0.8636161469557806 1.713458719285784e-06 0.8646608622318305 1.713458991377281e-06 0.8656672252055042 1.713459261593727e-06 0.8666387059277968 \
1.713459518761914e-06 0.8675381145236246 1.713459791320979e-06 0.8684653318325959 1.71346006734232e-06 0.8693777905953765 1.713460337484171e-06 0.8702455402709716 \
1.713460637231955e-06 0.8711796653984102 1.713461008105812e-06 0.872294745819888 1.713461303028797e-06 0.8731503023941 1.713461557284845e-06 0.8738665406311316 \
1.713461855515577e-06 0.8746822274488602 1.713462129133901e-06 0.8754080260278182 1.713462365269549e-06 0.8760175227551726 1.713462605621406e-06 0.876622281264788 \
1.713462827963785e-06 0.8771680781109068 1.713463021968128e-06 0.8776338860468618 1.713463351691207e-06 0.8784037109613512 1.71346350686397e-06 0.8787567114621292 \
1.713463824616497e-06 0.879461652496718 1.713464003481858e-06 0.8798480920375044 1.713464345943324e-06 0.8805675499479563 1.713464530084847e-06 0.8809434933546246 \
1.713465004990284e-06 0.8818790560183651 1.713465172384703e-06 0.8821975058309585 1.713465638216128e-06 0.8830540251881659 1.713465819040967e-06 0.8833751042472839 \
1.713466313074347e-06 0.8842212008576973 1.713466454417056e-06 0.884455124402366 1.713467060806836e-06 0.8854193259359495 1.713467212878983e-06 0.8856514227360587 \
1.71346785955747e-06 0.8865980751852495 1.713467987853824e-06 0.8867785329419297 1.713468635979926e-06 0.8876550049536978 1.713468765772447e-06 0.8878236738033012 \
1.713469544034095e-06 0.8887860366092379 1.713469659025973e-06 0.8889208282599539 1.713470514758392e-06 0.8898661633196656 1.713470660021537e-06 0.8900169066926564 \
1.713471645777722e-06 0.8909664261264102 1.713471866882863e-06 0.8911622482549515 1.713473011997307e-06 0.8921020388386462 1.713473143207264e-06 0.8922053928944147 \
1.713474330865799e-06 0.8931033243919096 1.713474484486091e-06 0.8932130731307282 1.713475894522803e-06 0.8941348173026452 1.713476117329622e-06 0.8942660193790342 \
1.71347779802033e-06 0.8951452796684343 1.713478125641509e-06 0.8952966652167414 1.713480355582631e-06 0.8961896554712738 1.713480908496592e-06 0.8963788593752812 \
1.713484476711123e-06 0.8973573335043913 1.713484800223538e-06 0.8974284307984646 1.713491156631826e-06 0.8984120886469452 1.713491705534673e-06 0.8984686671268907 \
1.713544207609024e-06 0.8994658645395698 1.713544850637886e-06 0.8994692460188505 1.713736989308519e-06 0.9004073346715066 1.713737190722491e-06 0.9004708280105613 \
1.713741150500432e-06 0.8995366825576255 1.71374133452723e-06 0.8993953949813248 1.713742651124504e-06 0.8984641879157507 1.713742823168359e-06 0.8983566564859006 \
1.713744719544654e-06 0.8973720929359315 1.713744893250842e-06 0.897304621671452 1.713757467177875e-06 0.8982933655523699 1.713757552368112e-06 0.8983081509245614 \
1.713765819241151e-06 0.8993078551592517 1.713766293960572e-06 0.8993433667976791 1.714259794870012e-06 0.9002974142054325 1.714259914349736e-06 0.9003767372269074 \
1.714260807172786e-06 0.9012336455299185 1.714260953429423e-06 0.901423267690772 1.714261548322101e-06 0.9023325668564308 1.714261683292918e-06 0.9025673929107925 \
1.714262187968707e-06 0.9035294259428087 1.714262320579608e-06 0.9038000271808221 1.714262721206973e-06 0.9046475051114249 1.714262865572371e-06 0.9049556543240072 \
1.71426328869358e-06 0.9058123566484279 1.714263384150638e-06 0.9059850892484415 1.714264808709455e-06 0.9052205906349737 1.714264933747309e-06 0.9046352442223391 \
1.714265060157898e-06 0.9039223775493039 1.714265162806642e-06 0.9032486771507763 1.714265290021932e-06 0.9022944222362175 1.714265408867758e-06 0.9012801950564071 \
1.714265506520237e-06 0.9003603330664713 1.714265588522258e-06 0.8995243596151602 1.714265668185821e-06 0.8986589236008835 1.714265778963989e-06 0.8973708307079206 \
1.714265880140003e-06 0.8961049472956977 1.714265963084475e-06 0.8950067229086057 1.714266071529892e-06 0.8934921260891034 1.71426617999385e-06 0.8918872687155874 \
1.714266275049989e-06 0.8904106867557802 1.714266395922641e-06 0.8884444419111864 1.714266516699262e-06 0.8863849482818795 1.714266629744433e-06 0.8843763393508186 \
1.714266732915182e-06 0.8824794505619851 1.714266818515338e-06 0.8808620855018965 1.714266892989399e-06 0.8794251273161163 1.714266987312942e-06 0.8775673968166831 \
1.714267075773858e-06 0.8757888800524039 1.71426715484687e-06 0.8741711975775893 1.714267248834225e-06 0.872216793437976 1.714267330179529e-06 0.8704993514258973 \
1.714267425093555e-06 0.8684673705816817 1.714267518136275e-06 0.8664480751909672 1.714267614922069e-06 0.8643215060814092 1.714267738217441e-06 0.8615778533848952 \
1.714267851664452e-06 0.859022019682563 1.714267977516491e-06 0.8561558571929792 1.714268100844635e-06 0.8533196845306243 1.714268230022926e-06 0.850323637950593 \
1.714268370619783e-06 0.8470370034914 1.714268479399505e-06 0.8444782910716596 1.714268614459257e-06 0.8412850455921466 1.714268724119566e-06 0.8386804253780991 \
1.714268853299345e-06 0.8356002443501571 1.714268979483175e-06 0.8325812421138936 1.71426910657353e-06 0.8295317031556502 1.714269235595804e-06 0.826427745883674 \
1.714269344676045e-06 0.8237985689995477 1.714269484526701e-06 0.8204223029647078 1.714269623954893e-06 0.8170507778356514 1.714269756708524e-06 0.8138366863616762 \
1.714269886777199e-06 0.8106848159989707 1.714270010472646e-06 0.8076853837479523 1.714270147427036e-06 0.8043627031572629 1.714270261138882e-06 0.8016030849198694 \
1.714270388615923e-06 0.7985086235398901 1.714270499416994e-06 0.7958187897651571 1.714270618603452e-06 0.7929254985494992 1.714270731982509e-06 0.7901733724735396 \
1.714270866292901e-06 0.7869138859547327 1.714270973387169e-06 0.7843152933129034 1.714271089404312e-06 0.7815009627552112 1.714271218595275e-06 0.778367508739124 \
1.71427131620771e-06 0.7760002683782802 1.714271421787151e-06 0.773440790716327 1.71427153046932e-06 0.7708069008430674 1.714271632885583e-06 0.7683258101021144 \
1.714271726279241e-06 0.7660641808432364 1.714271845835017e-06 0.7631702213567544 1.714271938307379e-06 0.7609327305817616 1.714272030945494e-06 0.7586922094322426 \
1.71427212937031e-06 0.7563124992069843 1.714272237347962e-06 0.7537030947613649 1.714272333616474e-06 0.7513778334636231 1.714272419872877e-06 0.7492952979736797 \
1.714272522736666e-06 0.7468128004450286 1.714272601580994e-06 0.744910856519283 1.714272702387036e-06 0.7424801602439853 1.714272836915276e-06 0.7392377693660663 \
1.714272974140136e-06 0.7359316755186537 1.714273117619987e-06 0.7324773442723981 1.714273266044177e-06 0.7289066083419234 1.714273409305472e-06 0.7254625447335662 \
1.714273549382451e-06 0.7220977259655398 1.714273705808317e-06 0.7183435968963056 1.714273830210067e-06 0.715360858370426 1.714273951271848e-06 0.7124600029613375 \
1.71427410478411e-06 0.7087850045121084 1.714274239566055e-06 0.7055614325718365 1.714274365665088e-06 0.7025479112911024 1.714274508839371e-06 0.6991289103945657 \
1.714274628921163e-06 0.6962626602560111 1.714274758155491e-06 0.6931807499479741 1.714274864640539e-06 0.6906432840523983 1.714274976916361e-06 0.6879696524977363 \
1.714275073251648e-06 0.6856773754336868 1.71427517606134e-06 0.683232326200841 1.714275270865193e-06 0.6809792012818872 1.714275376187123e-06 0.6784784437814733 \
1.714275484625777e-06 0.6759058899658261 1.714275583635058e-06 0.673558569590366 1.71427570039165e-06 0.6707929011939652 1.714275808476928e-06 0.6682347329991606 \
1.714275918483137e-06 0.6656332609774134 1.714276004570979e-06 0.6635992664604092 1.714276134166118e-06 0.6605400273835189 1.714276226767366e-06 0.6583552307294462 \
1.714276322555092e-06 0.6560965362104854 1.714276407507078e-06 0.6540950852804182 1.714276526801602e-06 0.6512869789851043 1.71427661407154e-06 0.6492343850333612 \
1.714276704778561e-06 0.6471030993779646 1.714276805943536e-06 0.6447280068361273 1.714276885774359e-06 0.6428551652550211 1.714276974560194e-06 0.6407732405330839 \
1.71427705225042e-06 0.6389536101386547 1.714277114019368e-06 0.6375081226244841 1.714277177784013e-06 0.6360167668935747 1.714277241018233e-06 0.634538653569437 \
1.714277280258806e-06 0.6336218002627473 1.714277320897828e-06 0.6326726453797233 1.714277400982362e-06 0.6308039353694699 1.714277470886542e-06 0.6291742390428672 \
1.714277521523257e-06 0.6279942052995945 1.714277560272899e-06 0.6270914175114127 1.714277599267879e-06 0.6261832343283663 1.714277643882627e-06 0.6251445623164014 \
1.714277686739083e-06 0.6241478292286105 1.714277737053687e-06 0.6229782634938205 1.714277788990864e-06 0.6217719122409077 1.714277874058449e-06 0.6197972300178722 \
1.714277934038866e-06 0.6184052992407258 1.714278023826075e-06 0.61632338076978 1.714278100290156e-06 0.6145529519516876 1.714278179854447e-06 0.6127119801362371 \
1.714278260891059e-06 0.6108383709630588 1.714278350105382e-06 0.6087775861620425 1.714278440965394e-06 0.6066826282541496 1.714278528184102e-06 0.6046739453334793 \
1.714278621957293e-06 0.6025158549334848 1.714278723642756e-06 0.6001788642681311 1.714278823240849e-06 0.5978941858483342 1.714278935095889e-06 0.5953317151711254 \
1.714279051129026e-06 0.5926772450523136 1.714279172750132e-06 0.5899020947998995 1.714279277133946e-06 0.5875236635596754 1.714279421924166e-06 0.5842296531729801 \
1.714279534584127e-06 0.5816734289694181 1.714279643596094e-06 0.5792035939892568 1.714279736075537e-06 0.5771100174076607 1.714279829526176e-06 0.5749994714793375 \
1.71427992185204e-06 0.5729181236728181 1.714279994438741e-06 0.571283073141143 1.714280050392967e-06 0.5700232888304386 1.714280111461248e-06 0.5686498830286455 \
1.714280209950764e-06 0.5664400707212188 1.714280273162208e-06 0.5650238531380825 1.714280333588177e-06 0.5636708824310654 1.71428041053656e-06 0.5619492451093103 \
1.714280473695101e-06 0.5605380106414651 1.71428056200871e-06 0.558569506627369 1.714280633210033e-06 0.5569845302974165 1.714280719745787e-06 0.555060151797141 \
1.71428084109856e-06 0.5523665438352664 1.714280969027808e-06 0.5495364947125975 1.714281067158439e-06 0.5473694328713704 1.714281180282434e-06 0.5448752016832871 \
1.714281282350254e-06 0.5426314425864434 1.714281401299124e-06 0.5400217272291628 1.714281504386832e-06 0.5377630705755105 1.714281618593986e-06 0.5352670017334624 \
1.714281732009658e-06 0.532794946211756 1.714281859080713e-06 0.5300302694710822 1.714281982900802e-06 0.5273426867079006 1.714282127689607e-06 0.5242103332418484 \
1.71428226351311e-06 0.5212782585303676 1.714282418567968e-06 0.5179428401013338 1.714282579419853e-06 0.5144913885072363 1.7142827581493e-06 0.5106699876709851 \
1.71428294832834e-06 0.5066200804011861 1.714283158230362e-06 0.5021665212646098 1.714283386936347e-06 0.4973332357952056 1.714283640864285e-06 0.4919960258408594 \
1.714283881797751e-06 0.4869529241725989 1.714284177960236e-06 0.4807889695952298 1.714284467957623e-06 0.4747910561470179 1.714284774200956e-06 0.4684976697011882 \
1.714285094876887e-06 0.4619520863481486 1.714285422744054e-06 0.4553041925245184 1.714285762989109e-06 0.4484521981997251 1.714286088414654e-06 0.4419418052309769 \
1.714286410321802e-06 0.4355465312739703 1.714286740535907e-06 0.4290298934287748 1.714287096528499e-06 0.4220583188787752 1.714287415406929e-06 0.4158579595363656 \
1.714287752858691e-06 0.4093433989943853 1.714288180725407e-06 0.4011531841887147 1.714288529437356e-06 0.3945419525178304 1.714288837073319e-06 0.388759214407489 \
1.714289216899811e-06 0.3816861832573664 1.714289548089372e-06 0.3755780492082042 1.714289831697452e-06 0.370391509977049 1.714290142516397e-06 0.3647512908748707 \
1.714290421833005e-06 0.3597258263082204 1.714290648329153e-06 0.3556836811642302 1.714290864011538e-06 0.3518598964090484 1.714291061295543e-06 0.3483842179544538 \
1.714291266280002e-06 0.3447988491770444 1.714291478501966e-06 0.3411119200457455 1.714291733807154e-06 0.33670771290924 1.714291975329403e-06 0.3325734463267218 \
1.714292206706731e-06 0.3286464933807047 1.714292421559231e-06 0.3250253651850565 1.714292642118388e-06 0.3213332986541765 1.714292843544355e-06 0.3179852906236645 \
1.714293046612606e-06 0.3146379646143546 1.714293244508215e-06 0.3114011111455273 1.714293431469302e-06 0.3083651674074345 1.714293625269522e-06 0.3052406640298299 \
1.714293829186134e-06 0.3019773030815858 1.714294008255468e-06 0.2991336297844484 1.714294243846324e-06 0.2954229173226265 1.714294444650423e-06 0.2922868215109002 \
1.714294645829315e-06 0.2891696385850206 1.714294869639057e-06 0.2857334090862961 1.714295034201803e-06 0.2832271910241367 1.714295211129189e-06 0.2805503385691353 \
1.714295396922194e-06 0.2777610713150803 1.71429557873767e-06 0.2750538970423583 1.714295757762463e-06 0.2724132377985424 1.714295925107616e-06 0.2699606650006489 \
1.714296085536534e-06 0.2676371805838822 1.714296208110285e-06 0.2658719571410424 1.714296357874814e-06 0.2637236906090554 1.71429648557194e-06 0.2619099339733745 \
1.714296592880312e-06 0.2603957336038235 1.714296708880974e-06 0.2587625259947361 1.71429681918957e-06 0.2572125806747212 1.714296945068767e-06 0.2554509781935611 \
1.714297060550618e-06 0.2538402638894013 1.714297195131521e-06 0.2519757335310172 1.714297307194775e-06 0.2504255755821768 1.714297457534135e-06 0.2483447107137444 \
1.714297597159989e-06 0.2464124269747185 1.714297743051809e-06 0.2444035064209518 1.714297876012448e-06 0.2425734862730615 1.714297999574161e-06 0.2408709992523319 \
1.714298146783853e-06 0.2388417729476062 1.714298263370682e-06 0.2372355665500016 1.714298402825831e-06 0.23532008003217 1.714298537000301e-06 0.2334768281602104 \
1.714298662976757e-06 0.2317465561243653 1.71429878237616e-06 0.2301094434087779 1.714298877230585e-06 0.2288105340759602 1.714298990368184e-06 0.2272617792622066 \
1.714299070684642e-06 0.2261626001158484 1.714299158249698e-06 0.2249657246820506 1.714299283786835e-06 0.2232507767215072 1.714299389480543e-06 0.2218101326756785 \
1.714299479135054e-06 0.2205921574607158 1.714299549986253e-06 0.2196300825522397 1.714299593014783e-06 0.2190460135436258 1.714299635305326e-06 0.2184724035808872 \
1.714299677647042e-06 0.2178984240735344 1.714299749842462e-06 0.2169203674089526 1.714299792235817e-06 0.2163464205126744 1.714299827490656e-06 0.2158693585303403 \
1.714299871682239e-06 0.2152716287340076 1.714299941290466e-06 0.2143309212991285 1.714299975633796e-06 0.2138672544767182 1.714300020093325e-06 0.2132698436071631 \
1.714300087771806e-06 0.2123628126304402 1.714300174199065e-06 0.2112058698236149 1.714300248835667e-06 0.2102078598594563 1.714300330137675e-06 0.2091219706754807 \
1.714300427015059e-06 0.2078300362310651 1.714300552998548e-06 0.2061528795789772 1.714300655533384e-06 0.2047906894256944 1.714300757016901e-06 0.2034500128132261 \
1.714300858082597e-06 0.202119416354989 1.714300954696816e-06 0.2008491615811921 1.71430105666124e-06 0.1995112314821507 1.714301163383484e-06 0.1981153840927639 \
1.714301271788624e-06 0.1967018790395962 1.714301383782779e-06 0.1952465002768531 1.714301496249907e-06 0.1937897263683151 1.714301608323246e-06 0.1923454332378671 \
1.714301716215721e-06 0.1909603537828802 1.714301817598649e-06 0.1896629368444172 1.714301909236098e-06 0.1884941330679491 1.714302003211707e-06 0.1872990757663449 \
1.714302074478072e-06 0.1863957871745983 1.71430215115336e-06 0.1854271890400033 1.714302254812475e-06 0.184122202819407 1.714302328479595e-06 0.1831974022686171 \
1.714302401825496e-06 0.1822796569444652 1.714302515215845e-06 0.1808667181969195 1.714302603074485e-06 0.1797760932362061 1.714302686923162e-06 0.1787387947787487 \
1.71430281588559e-06 0.1771515524267008 1.714302917772084e-06 0.1759040172436072 1.714303023472791e-06 0.1746156056808686 1.714303125120866e-06 0.1733818993219825 \
1.714303255982584e-06 0.1718019019596718 1.714303363179221e-06 0.1705140034701537 1.714303492508118e-06 0.168969083715685 1.71430360420461e-06 0.167642098072289 \
1.714303704535189e-06 0.1664555496840579 1.714303800335743e-06 0.1653276075899142 1.714303911148015e-06 0.1640289617085985 1.714303998548296e-06 0.1630090521997956 \
1.714304109869413e-06 0.1617156184952586 1.714304202821272e-06 0.1606409001560029 1.71430429039415e-06 0.1596330843918451 1.714304392025023e-06 0.1584700928658864 \
1.714304476479078e-06 0.1575086241734052 1.714304551583457e-06 0.1566573095634876 1.7143046294057e-06 0.1557789554714152 1.714304709763569e-06 0.1548759612316424 \
1.714304810818399e-06 0.1537464547857493 1.714304893251963e-06 0.1528311848879565 1.714304985556514e-06 0.1518114053368895 1.714305062490987e-06 0.150965812476358 \
1.714305145413557e-06 0.1500585909391909 1.714305216944298e-06 0.1492793026301012 1.714305313327797e-06 0.1482344968214558 1.714305383556283e-06 0.1474766665551334 \
1.714305466536561e-06 0.1465853655470201 1.714305527978825e-06 0.1459298106834085 1.714305599661209e-06 0.1451677491870439 1.714305668289752e-06 0.1444408762699853 \
1.714305718558261e-06 0.1439102090153988 1.714305766138067e-06 0.143409423336876 1.714305820187418e-06 0.1428423132663369 1.714305879529516e-06 0.1422216078256897 \
1.714305947564923e-06 0.1415124633834424 1.714306023828345e-06 0.1407207186008814 1.714306092108144e-06 0.1400161356079559 1.714306186894323e-06 0.1390460813732662 \
1.714306276448135e-06 0.1381341561933974 1.714306348133609e-06 0.1374075731330657 1.714306432085017e-06 0.1365606113096345 1.714306497397473e-06 0.1359045398875483 \
1.714306558840598e-06 0.1352895588344758 1.714306633117097e-06 0.1345490408254265 1.714306695327357e-06 0.1339328028964004 1.714306763298366e-06 0.133265236037424 \
1.714306822505406e-06 0.1326856657519672 1.714306895177878e-06 0.1319767402814105 1.714306970197988e-06 0.1312477270463112 1.714307055651411e-06 0.1304208267333309 \
1.71430714175175e-06 0.1295914604616623 1.714307241877205e-06 0.1286317929389105 1.714307323166875e-06 0.127857435971709 1.714307424934223e-06 0.1268981149578782 \
1.714307509182182e-06 0.1261072369695883 1.714307607998911e-06 0.1251836587365037 1.714307680839456e-06 0.1245055382686853 1.714307760865543e-06 0.1237631876254407 \
1.714307831351338e-06 0.1231117958237987 1.71430790388176e-06 0.1224439308288319 1.714307981350756e-06 0.1217331219782777 1.714308088702104e-06 0.1207554316575004 \
1.71430818934012e-06 0.1198442997624752 1.714308261927673e-06 0.1191899427853172 1.714308330759514e-06 0.1185715582611356 1.714308396546334e-06 0.1179824683205609 \
1.714308466175132e-06 0.1173610347366148 1.714308536558877e-06 0.1167350538439435 1.714308611737249e-06 0.1160688810594495 1.714308715991484e-06 0.1151493019715505 \
1.714308791126139e-06 0.114489769343061 1.714308860041223e-06 0.1138870655592168 1.714308923246095e-06 0.1133369146236164 1.71430899278746e-06 0.1127339156958381 \
1.714309050088964e-06 0.1122385190692166 1.714309121730019e-06 0.1116210355509516 1.714309179565093e-06 0.1111240709857579 1.714309251686527e-06 0.1105063809580559 \
1.71430931410261e-06 0.1099736279351742 1.714309398424131e-06 0.1092565349771765 1.7143094660201e-06 0.1086842173446869 1.714309574816032e-06 0.1077671916889585 \
1.714309679126564e-06 0.1068924975608609 1.714309758614772e-06 0.1062289053282379 1.714309846183182e-06 0.1055008617114655 1.714309909639535e-06 0.1049752776433979 \
1.714309971350652e-06 0.10446579874651 1.714310075190416e-06 0.103612238268202 1.714310157871117e-06 0.1029362225408096 1.714310256339144e-06 0.1021348761715451 \
1.714310340785582e-06 0.101450818648051 1.714310457263062e-06 0.1005121841703865 1.714310591996508e-06 0.09943411943161744 1.714310728066044e-06 0.0983541971400249 \
1.714310842385451e-06 0.09745369041838402 1.714310927852596e-06 0.09678457778867394 1.714311038134269e-06 0.09592640631053104 1.714311118922622e-06 0.09530159220710262 \
1.714311218473493e-06 0.09453592511176086 1.714311308421543e-06 0.09384821103094763 1.714311380924943e-06 0.09329669945188329 1.714311462667009e-06 0.09267796846073476 \
1.714311590787244e-06 0.09171467366828615 1.714311672199308e-06 0.09110674702409056 1.714311746631215e-06 0.09055373306570065 1.714311821605099e-06 0.08999936228352182 \
1.714311901024074e-06 0.08941505746347288 1.714312009684932e-06 0.08862052380504259 1.714312104044903e-06 0.08793517800096999 1.714312193440026e-06 0.08728987318634121 \
1.714312300205743e-06 0.086524181682867 1.714312418708182e-06 0.08568073755029131 1.714312560233253e-06 0.08468224831562859 1.714312693371676e-06 0.08375174214918565 \
1.714312834217007e-06 0.08277682112810406 1.714312983268988e-06 0.08175525972387458 1.714313119066717e-06 0.08083369778093191 1.714313260523232e-06 0.0798830809748103 \
1.714313395783147e-06 0.07898330517332906 1.714313537164988e-06 0.07805242629322809 1.714313684232761e-06 0.07709434677344783 1.714313835960902e-06 0.07611680364043326 \
1.714314001309203e-06 0.07506403321855706 1.714314165176721e-06 0.07403332863189842 1.714314341490649e-06 0.07293832728335037 1.71431453092575e-06 0.07177777688466977 \
1.714314741692455e-06 0.07050569389938771 1.714314961464952e-06 0.06920150027616521 1.714315196433104e-06 0.06783224552442871 1.714315455333654e-06 0.06635227408830123 \
1.714315750264117e-06 0.06470266364809808 1.714316054610178e-06 0.06304001691994518 1.714316416556457e-06 0.06111393619706453 1.714316732684212e-06 0.05947639552636011 \
1.714317174006677e-06 0.0572596911373907 1.714317487572719e-06 0.05573556853365672 1.714317911072189e-06 0.0537382660685313 1.714318255024042e-06 0.05216649213267931 \
1.71431859526531e-06 0.05065508790922631 1.7143189061029e-06 0.04931137323461653 1.714319200574802e-06 0.04807062469528345 1.714319494274299e-06 0.04686392507224969 \
1.714319769145536e-06 0.04576537019482012 1.714320044685701e-06 0.04468949010490332 1.71432030977623e-06 0.04367785045825667 1.714320586533311e-06 0.04264571401740119 \
1.714320869801436e-06 0.04161414314527601 1.714321167794735e-06 0.04055545327485047 1.714321427280131e-06 0.03965542606183669 1.714321657303569e-06 0.03887446236327848 \
1.714321876995156e-06 0.03814321686473518 1.714322101935296e-06 0.0374128399305801 1.71432242218897e-06 0.0363978329183388 1.71432270998682e-06 0.03550963653148703 \
1.714322986382154e-06 0.03467738358988744 1.714323270201283e-06 0.03384352473043348 1.714323508310587e-06 0.03315996078327022 1.714323792621371e-06 0.03236211345273886 \
1.714324034533221e-06 0.03169864947531036 1.714324269673394e-06 0.03106710921041438 1.714324511380923e-06 0.03043352335444016 1.714324748333857e-06 0.02982731501219571 \
1.714324978676274e-06 0.02925002048968134 1.714325192426852e-06 0.02872465224286764 1.714325398273815e-06 0.02822791768061097 1.714325790610838e-06 0.02730524204782691 \
1.714325979002849e-06 0.02687312495148303 1.714326354614307e-06 0.02603163971789 1.714326529081082e-06 0.02564950258131362 1.714326953015541e-06 0.02474274850847508 \
1.714327073769958e-06 0.02449086781212801 1.714327544020721e-06 0.02353384026002922 1.714327693235786e-06 0.02323677291035493 1.714328086867998e-06 0.02246740853134286 \
1.714328257894342e-06 0.02213909006726131 1.714328745173274e-06 0.02121869533024997 1.714328887220983e-06 0.02095326544309953 1.714329420237252e-06 0.01997576278857772 \
1.714329542401289e-06 0.01975737097014436 1.714330064559033e-06 0.01885981776906158 1.714330235137336e-06 0.01857989792133653 1.714330722450399e-06 0.01781360777737795 \
1.714330893973323e-06 0.01755501440977742 1.71433151376008e-06 0.01666567753024489 1.714331684684406e-06 0.0164316648397145 1.714332390235396e-06 0.01551160061118263 \
1.714332552852409e-06 0.01530799450170666 1.714333309745899e-06 0.01439879525764199 1.714333450662544e-06 0.01423641007536438 1.714334350661384e-06 0.01324361033368418 \
1.714334438010635e-06 0.01315122959105692 1.714335342363989e-06 0.01223321097894121 1.714335479555938e-06 0.01209984223734439 1.714336450212214e-06 0.01118944790767422 \
1.714336578130092e-06 0.01107451071402888 1.714337728540039e-06 0.01011008206277823 1.714337822342075e-06 0.01003687265682024 1.714339078387887e-06 0.009120584045805383 \
1.714339215929201e-06 0.009026502753623255 1.714340774683602e-06 0.008029670037698805 1.714340858486287e-06 0.007977066150721189 1.714342463865106e-06 0.00699828665725172 \
1.71434257476345e-06 0.006935886594503895 1.714344507009824e-06 0.005959177461785255 1.71434468671476e-06 0.005876661013304485 1.714346798505876e-06 0.004981749118765498 \
1.714347141291012e-06 0.004848482978762325 1.714349654457045e-06 0.003966891390423618 1.714350124178715e-06 0.003819799497680527 1.71435376449499e-06 0.002847564273158896 \
1.714354280232175e-06 0.002731633924241866 1.714359622062014e-06 0.001773027297371861 1.714359907382299e-06 0.001729522787584184 1.714365136030129e-06 0.0007540451492352357 \
1.714365310176696e-06 0.0007162692714263865 1.717013698769002e-06 -0.0001123232525192561 1.71701387179429e-06 -0.0002901710972538241 1.717014491546044e-06 -0.001202022686018724 \
1.717014580115221e-06 -0.001365806793032466 1.717014941086355e-06 -0.002110727959526865 1.71701506578065e-06 -0.002395793696299351 1.717015429622531e-06 -0.003299857180474864 \
1.7170156008982e-06 -0.003758114451912169 1.717015894896038e-06 -0.004576312838821549 1.717016005104443e-06 -0.004886880824040592 1.717016283358441e-06 -0.005643955697619643 \
1.71701640463225e-06 -0.00594200199557267 1.717017498254348e-06 -0.00517389603226481 1.717017621358228e-06 -0.004409713243767066 1.717017744826303e-06 -0.003462788751204457 \
1.7170178649921e-06 -0.002366010162083454 1.717017962853768e-06 -0.001346276287748183 1.717018069556104e-06 -0.0001076498664581183 1.717018181397488e-06 0.001328007358939307 \
1.717018317371855e-06 0.003256083960376262 1.717018439401011e-06 0.00514709866632534 1.717018627817289e-06 0.008343062029134115 1.717018768805819e-06 0.01093380316938193 \
1.717018921577522e-06 0.01391176330477175 1.717019064280151e-06 0.01683596409946878 1.717019218632387e-06 0.02013443377634912 1.717019374426043e-06 0.02358734537610087 \
1.71701953048334e-06 0.02715365164079262 1.71701967788774e-06 0.03060642997674319 1.717019826504485e-06 0.03415780069914553 1.717019981925702e-06 0.03793559522944389 \
1.717020140311532e-06 0.04184227512730877 1.717020305251154e-06 0.04596085539464361 1.717020479500423e-06 0.05035714787605008 1.717020658443539e-06 0.05491177248689325 \
1.717020847583032e-06 0.0597604232635115 1.71702105036361e-06 0.06498910043066243 1.717021269735637e-06 0.07067233091134768 1.717021500572133e-06 0.07667464705993039 \
1.717021747383969e-06 0.0831083675499642 1.71702201751608e-06 0.09016243555275107 1.717022310704188e-06 0.0978236474935409 1.717022634359626e-06 0.1062798466079799 \
1.717022997926912e-06 0.1157689210849182 1.71702339022043e-06 0.1259925151671456 1.717023838699915e-06 0.1376538644086695 1.7170243603994e-06 0.1511757390224034 \
1.717024972772044e-06 0.1669844191341421 1.717025649417359e-06 0.1843663871188266 1.71702643632765e-06 0.2044554566749352 1.717027317548744e-06 0.2267919980918504 \
1.717028137292384e-06 0.2474048556006221 1.717028865745328e-06 0.2655829647002126 1.717029507221317e-06 0.2814688958417333 1.717030083144485e-06 0.2956305456066151 \
1.717030620401302e-06 0.3087428400511723 1.717031124292597e-06 0.3209487846516751 1.717031601896145e-06 0.3324328152479784 1.717032080019379e-06 0.343838772307344 \
1.717032532118229e-06 0.3545331600964184 1.717033003884519e-06 0.365596737404158 1.71703344758136e-06 0.3759140547845509 1.717033969549898e-06 0.3879344734281669 \
1.71703449708783e-06 0.399956933836353 1.717034876602574e-06 0.4085271910771138 1.717035405564175e-06 0.4203606102508351 1.717035874883255e-06 0.4307444005277802 \
1.717036310038791e-06 0.4402814026247405 1.717036757516117e-06 0.4500002273945978 1.717037197539592e-06 0.4594737646471725 1.717037600841335e-06 0.4680814138276727 \
1.717037919241101e-06 0.4748254127722248 1.717038289219015e-06 0.4826007100982719 1.717038525472097e-06 0.4875314737878706 1.717038760543493e-06 0.4924129045770672 \
1.717039011882831e-06 0.4975994385012801 1.717039318269865e-06 0.5038799449729535 1.717039575228319e-06 0.5091120301871851 1.717039783702615e-06 0.5133309170973237 \
1.717039984084905e-06 0.5173683849445317 1.717040126478606e-06 0.5202244049244739 1.717040275403072e-06 0.5231993726577677 1.717040486949329e-06 0.5274019882470222 \
1.717040713006952e-06 0.5318780389403845 1.717040907549333e-06 0.5357103559602913 1.717041096681229e-06 0.539423417888626 1.717041326128277e-06 0.5439012399750046 \
1.717041508634083e-06 0.5474563135343053 1.717041745996952e-06 0.5520623276458133 1.71704201499126e-06 0.5572695987004129 1.71704226390171e-06 0.5620706638085723 \
1.717042507918531e-06 0.5667633705755619 1.717042780273744e-06 0.5719926523718327 1.717043041669873e-06 0.5769928369418796 1.717043299301279e-06 0.5819084237686675 \
1.717043546144628e-06 0.586601202059797 1.717043791890354e-06 0.5912552023551558 1.717044018467874e-06 0.5955288021520931 1.717044249620064e-06 0.5998646534936181 \
1.717044455900444e-06 0.6037202012184053 1.717044684021204e-06 0.6079592993751251 1.717044906401185e-06 0.6120725203834017 1.717045133377667e-06 0.6162454422471376 \
1.717045348430617e-06 0.6201823359462864 1.71704557780019e-06 0.6243500782103125 1.717045846823065e-06 0.6292041961704016 1.717046069836712e-06 0.6331993632081415 \
1.717046282091289e-06 0.6369772451758789 1.717046493488879e-06 0.6407176358819484 1.717046693558109e-06 0.644236566349866 1.717046923151958e-06 0.6482486956559365 \
1.717047163988886e-06 0.6524328529570182 1.717047345738273e-06 0.6555667906748446 1.7170475342865e-06 0.6588018260593631 1.717047687366139e-06 0.6614154033769962 \
1.717047859374421e-06 0.6643352515471471 1.717048009547239e-06 0.6668697017322168 1.717048146064529e-06 0.6691578850264722 1.717048295693716e-06 0.6716547631652277 \
1.717048423434085e-06 0.673777752640997 1.717048563020223e-06 0.6760856948620949 1.71704868725891e-06 0.6781310478824312 1.71704881840875e-06 0.6802827752320969 \
1.717048942850093e-06 0.6823179209931315 1.717049080080916e-06 0.6845542421253382 1.717049200329086e-06 0.6865048414796368 1.717049341660529e-06 0.6887891282595083 \
1.717049441991641e-06 0.6904033553735033 1.717049563109343e-06 0.6923460943304175 1.717049653886878e-06 0.6937948943079848 1.717049751145344e-06 0.6953408241330762 \
1.717049847353224e-06 0.6968660703265798 1.717049935967068e-06 0.6982647859968389 1.717050033255091e-06 0.6997938110311075 1.717050165723729e-06 0.7018622871835729 \
1.717050320913928e-06 0.7042674555997347 1.717050458791879e-06 0.7063866855441746 1.717050603646153e-06 0.7085960165693863 1.71705073070791e-06 0.7105202221428537 \
1.71705085539347e-06 0.7123960184768648 1.717050968098846e-06 0.7140814553427599 1.717051079889191e-06 0.7157437310299281 1.71705118066784e-06 0.7172341607972841 \
1.717051317946295e-06 0.7192525454101454 1.717051437630367e-06 0.7210013704967912 1.717051557059838e-06 0.7227365757678518 1.71705168394306e-06 0.7245692610776365 \
1.717051808360712e-06 0.7263556789600311 1.717051932093537e-06 0.728121726658988 1.717052058689063e-06 0.7299181396522603 1.717052189074464e-06 0.7317573312219798 \
1.717052311884284e-06 0.7334798522758219 1.717052447320059e-06 0.7353678990088863 1.717052548609838e-06 0.7367723836293941 1.717052656232334e-06 0.7382576460517265 \
1.717052745760416e-06 0.7394878879617913 1.717052860308785e-06 0.7410528648863303 1.717052948337041e-06 0.7422487366778059 1.717053055415107e-06 0.7436953530868765 \
1.7170531854801e-06 0.7454403311053276 1.717053296759795e-06 0.7469230742113165 1.717053401378355e-06 0.7483084058091373 1.71705352546134e-06 0.7499400420429273 \
1.717053673762168e-06 0.7518749696944975 1.717053795162033e-06 0.7534462209622173 1.71705390960278e-06 0.7549170836379747 1.717054049940098e-06 0.7567069362027918 \
1.717054191702981e-06 0.7584995177563068 1.717054309503919e-06 0.759977341175643 1.717054437480785e-06 0.761570846386187 1.717054579183209e-06 0.7633205808366864 \
1.717054696694523e-06 0.7647599110190483 1.717054842299792e-06 0.7665289162262866 1.717054963994099e-06 0.7679951561698679 1.717055082724709e-06 0.7694149786178283 \
1.717055205011304e-06 0.7708662727382939 1.71705533205582e-06 0.77236234268503 1.717055441699792e-06 0.7736439866494906 1.717055567386705e-06 0.7751025186690397 \
1.717055673401805e-06 0.776323977486031 1.717055808987772e-06 0.7778743028704433 1.717055933950769e-06 0.7792913979962601 1.717056059856921e-06 0.7807070123991936 \
1.717056175124167e-06 0.7819915514687489 1.71705628142864e-06 0.7831664991275713 1.717056419833432e-06 0.7846822315516878 1.717056569129882e-06 0.7862997378875561 \
1.717056714637327e-06 0.7878588534534761 1.717056834041839e-06 0.7891257303126159 1.717056969134663e-06 0.7905455128963393 1.717057090387826e-06 0.7918076974797237 \
1.717057233381105e-06 0.7932816011184505 1.71705737758541e-06 0.7947523458802197 1.717057503122239e-06 0.7960199014141693 1.717057622168612e-06 0.7972110037065316 \
1.717057734104495e-06 0.7983213107123885 1.717057838976047e-06 0.7993531099923881 1.717057934226459e-06 0.8002831901653534 1.717058070569705e-06 0.8016020813281191 \
1.717058187393835e-06 0.8027203407102198 1.717058306798445e-06 0.803852171037294 1.717058428905249e-06 0.8049980820693966 1.71705855186025e-06 0.8061401395390313 \
1.717058678828951e-06 0.8073073595000361 1.71705880406856e-06 0.8084467645495962 1.717058934640955e-06 0.8096220968518901 1.717059060631473e-06 0.8107441738369082 \
1.717059188817386e-06 0.8118738099374113 1.717059294347114e-06 0.8127947795787664 1.717059397218887e-06 0.8136847278655364 1.717059490214057e-06 0.8144826950388273 \
1.71705961401066e-06 0.8155354283166244 1.717059701978917e-06 0.8162769513478326 1.717059800709988e-06 0.8171027376706747 1.717059943975142e-06 0.8182889948057973 \
1.717060079253827e-06 0.8193962136425846 1.717060188368449e-06 0.8202800249700468 1.717060336451758e-06 0.8214657808291811 1.717060486222685e-06 0.8226492530953341 \
1.717060611457285e-06 0.8236267526687548 1.717060755448703e-06 0.8247372275730155 1.717060879504774e-06 0.8256825756473101 1.717061029968032e-06 0.8268152483647575 \
1.717061165678884e-06 0.8278240064655301 1.717061290697392e-06 0.828742521381556 1.717061408452322e-06 0.8295983347934622 1.717061554429135e-06 0.8306466023667578 \
1.717061720938452e-06 0.8318251482734692 1.717061851861028e-06 0.8327390940956469 1.717062025288466e-06 0.8339327615268647 1.717062193435348e-06 0.8350717495747054 \
1.717062363270277e-06 0.8362042975620877 1.717062544195048e-06 0.8373912937861997 1.717062687293307e-06 0.8383160748488641 1.717062801379198e-06 0.8390446117604563 \
1.717062931553184e-06 0.8398665237782376 1.717063033394266e-06 0.8405024977857931 1.717063150213615e-06 0.8412243379523001 1.717063287078045e-06 0.8420597162999857 \
1.717063484876668e-06 0.8432475311273343 1.71706367648074e-06 0.8443767279905872 1.717063885921222e-06 0.8455874169714939 1.717064067846852e-06 0.8466193100105236 \
1.717064264979957e-06 0.8477171434207121 1.717064438329848e-06 0.8486653666163242 1.717064621329232e-06 0.8496493024239481 1.717064792495495e-06 0.8505537352954988 \
1.717064967127282e-06 0.8514606693963016 1.717065142389669e-06 0.8523550102558151 1.717065318541785e-06 0.8532381479010797 1.717065508812824e-06 0.8541746551565574 \
1.717065699414774e-06 0.85509499218684 1.717065900062401e-06 0.8560449689899254 1.717066092672966e-06 0.8569390259424264 1.717066303330652e-06 0.8578972157030333 \
1.717066531456051e-06 0.8589122247267402 1.717066797213368e-06 0.8600655879592763 1.717067095837813e-06 0.8613244245924475 1.717067372169332e-06 0.862454900702886 \
1.71706765640239e-06 0.8635842083919951 1.717067930614306e-06 0.8646423892283146 1.717068202842372e-06 0.8656634505877856 1.717068473051191e-06 0.8666487272755322 \
1.717068730204067e-06 0.8675609437488442 1.717069002786335e-06 0.868501515423508 1.717069278771335e-06 0.8694269133137555 1.717069548872911e-06 0.8703069289141475 \
1.717069848734863e-06 0.8712546000783432 1.717070219768993e-06 0.8723856543073821 1.717070514706754e-06 0.8732530157608677 1.717070768997536e-06 0.8739790309043101 \
1.717071067254951e-06 0.8748056771600844 1.717071340863485e-06 0.8755409825400007 1.71707157699155e-06 0.8761583495732972 1.71707181733693e-06 0.876770807053994 \
1.717072039670212e-06 0.8773233906735478 1.71707223367596e-06 0.8777948466981503 1.717072563398506e-06 0.8785737911727464 1.717072718571944e-06 0.8789308835864816 \
1.717073036347473e-06 0.8796437246174529 1.71707321520917e-06 0.8800342982281311 1.717073557671047e-06 0.8807611334253193 1.717073741799519e-06 0.8811407335605206 \
1.717074216677856e-06 0.8820849466541889 1.717074384074053e-06 0.8824061830950772 1.717074849915456e-06 0.8832696475595492 1.717075030737665e-06 0.8835931319180218 \
1.717075524775914e-06 0.8844450822729043 1.717075666124327e-06 0.8846804878101884 1.717076272457385e-06 0.8856498028150036 1.717076424526725e-06 0.8858829444029697 \
1.7170770712152e-06 0.8868329272509302 1.717077199509723e-06 0.8870138524519416 1.717077847626928e-06 0.8878919388991984 1.717077977425791e-06 0.8880607713689423 \
1.717078755627481e-06 0.8890227771434612 1.717078870684414e-06 0.8891574578072456 1.717079726342848e-06 0.8901003239091128 1.717079871707616e-06 0.8902505899439886 \
1.71708085746403e-06 0.8911948786459364 1.71708107856904e-06 0.8913892999646706 1.717082223696019e-06 0.8923206810037944 1.717082354912618e-06 0.892422953350996 \
1.717083696124267e-06 0.8934189515818408 1.717083847523211e-06 0.8935240845833778 1.717085328961459e-06 0.8944568913393511 1.717085567840892e-06 0.8945912088657246 \
1.717087337161074e-06 0.8954685138428928 1.717087726310841e-06 0.895637400736999 1.717090119976628e-06 0.896526474291006 1.71709059568945e-06 0.8966764365754722 \
1.717094011699057e-06 0.8975478548673914 1.717094658849072e-06 0.8976786076740833 1.717102137013678e-06 0.8986646932675814 1.717102809590796e-06 0.8987192862546014 \
1.717195253995367e-06 0.8997188196574962 1.717195917228051e-06 0.8997241906476866 1.717385126389945e-06 0.900686595210158 1.717385288462789e-06 0.9007292695325627 \
1.717387933983676e-06 0.8998161167154269 1.717388102533154e-06 0.8996881690130656 1.717389379285545e-06 0.8987393243250013 1.717389581451881e-06 0.8986030018074492 \
1.717391189561267e-06 0.8976721249252815 1.717391381667192e-06 0.8975774045828077 1.717406495049839e-06 0.8985726115129884 1.717406683108756e-06 0.8986004060702872 \
1.717417988037768e-06 0.8995874924221801 1.717418361423516e-06 0.8996034751727418 1.717907373786698e-06 0.9005892719715856 1.717907484554898e-06 0.9006868984798269 \
1.717908237227259e-06 0.9015617873136611 1.717908339021945e-06 0.9017086238768567 1.71790887442049e-06 0.9025814930725723 1.717908976929663e-06 0.9027670217776843 \
1.717909369148482e-06 0.9035254014384071 1.717909509991429e-06 0.9038129158713877 1.717909951028881e-06 0.9047472953155866 1.717910136514484e-06 0.9051402477015744 \
1.717910652827601e-06 0.9061269394579334 1.717910737502694e-06 0.9062564181617988 1.717911972174744e-06 0.9053011091537977 1.717912129388156e-06 0.9045688862145235 \
1.717912321204817e-06 0.9034162411061901 1.717912488045348e-06 0.9021712267446264 1.717912635003746e-06 0.9008824031243315 1.717912749119942e-06 0.8997575350477262 \
1.717912878992032e-06 0.8983446880789033 1.71791299010955e-06 0.8970273815442567 1.717913082914029e-06 0.8958483937359277 1.717913171236719e-06 0.8946639786015808 \
1.717913274417478e-06 0.8932058048613533 1.717913366625413e-06 0.8918333298588224 1.71791345419561e-06 0.8904732289418564 1.717913568189077e-06 0.8886245408236838 \
1.7179137299935e-06 0.8858564722885236 1.717913914992118e-06 0.8825005184224666 1.717914107151785e-06 0.8788219124347386 1.717914308599139e-06 0.874780227084481 \
1.717914515009728e-06 0.8704697801294994 1.717914700181681e-06 0.8664790122147591 1.717914884689405e-06 0.862405115500708 1.717915057841296e-06 0.8585071391690239 \
1.717915242887321e-06 0.8542751393552932 1.717915420261525e-06 0.8501657390392787 1.717915597007955e-06 0.8460284987362284 1.717915763166606e-06 0.8421077870518131 \
1.717915925211044e-06 0.8382599993991456 1.717916091783925e-06 0.8342839555277276 1.717916250437662e-06 0.8304816347052207 1.717916441313687e-06 0.8258903812682129 \
1.717916616297259e-06 0.8216694867670907 1.717916786243393e-06 0.8175615830390965 1.717916951419567e-06 0.8135626411663678 1.717917124611674e-06 0.8093650119631921 \
1.717917295673877e-06 0.8052155696745213 1.717917463774914e-06 0.801136095357175 1.717917654109863e-06 0.7965156511928794 1.717917837691806e-06 0.7920591698039 \
1.717918045682732e-06 0.7870113041480956 1.717918268259242e-06 0.7816114142545842 1.717918457674258e-06 0.7770174196885687 1.717918650984654e-06 0.7723312127316435 \
1.717918794430241e-06 0.7688556734481145 1.717918943853591e-06 0.7652374066097742 1.717919063006063e-06 0.7623536300085233 1.717919175722544e-06 0.7596269484184472 \
1.717919284997451e-06 0.7569846861296079 1.717919421027209e-06 0.753697254849378 1.717919533823024e-06 0.750972995067179 1.71791965602098e-06 0.7480232093637929 \
1.717919767605753e-06 0.7453311011793381 1.717919892312216e-06 0.7423241425761796 1.717920046694167e-06 0.7386034578119585 1.717920213478233e-06 0.7345862494782525 \
1.717920430642921e-06 0.7293605768817599 1.71792062520351e-06 0.7246835946359503 1.717920785534395e-06 0.7208333202545074 1.717920960959998e-06 0.7166251500492028 \
1.717921150723573e-06 0.7120779400724765 1.717921339451897e-06 0.7075610435995559 1.717921521273264e-06 0.7032145396962334 1.717921705870676e-06 0.6988062725207448 \
1.717921842953811e-06 0.6955348514212173 1.717921996242049e-06 0.6918805091472418 1.717922191613795e-06 0.6872279990818534 1.717922347770547e-06 0.6835136309588888 \
1.717922505722766e-06 0.6797605476340507 1.71792270397403e-06 0.6750570282453686 1.717922897319928e-06 0.6704763548785364 1.717923133825274e-06 0.6648822204491218 \
1.717923320030378e-06 0.6604858901039825 1.717923557652698e-06 0.6548824851665868 1.717923744451452e-06 0.6504854738275335 1.717923925009211e-06 0.6462424706993735 \
1.717924088085156e-06 0.6424159959781919 1.717924232696721e-06 0.6390271817202816 1.717924373299071e-06 0.6357379642635244 1.717924500108657e-06 0.632774906490579 \
1.717924632245193e-06 0.6296924762754078 1.717924758489145e-06 0.6267508340255646 1.717924889752774e-06 0.6236963630311418 1.717925018850514e-06 0.6206978048938425 \
1.717925158276179e-06 0.6174624210713571 1.717925306646171e-06 0.6140261568477932 1.71792550120306e-06 0.6095278574984737 1.717925644648937e-06 0.6062198040692683 \
1.717925879109183e-06 0.6008245134060309 1.717926051007495e-06 0.5968818013610552 1.717926263928033e-06 0.5920102583789468 1.717926436394651e-06 0.5880775912131976 \
1.717926566719198e-06 0.5851108450968721 1.717926698275517e-06 0.5821241897920357 1.717926808505599e-06 0.5796262478458715 1.717926904159846e-06 0.5774603558442819 \
1.717927003393806e-06 0.5752182923213994 1.717927086311907e-06 0.5733484809858778 1.717927165227534e-06 0.5715706040143225 1.717927228156309e-06 0.5701535626562365 \
1.717927293664786e-06 0.5686800671140783 1.717927374150839e-06 0.5668736364148982 1.717927424016846e-06 0.5657560592102344 1.717927473205615e-06 0.5646541775062763 \
1.717927534675401e-06 0.5632780399140616 1.717927582596929e-06 0.5622058085646952 1.717927633441648e-06 0.5610687758404553 1.717927692541903e-06 0.5597501790023616 \
1.71792775115623e-06 0.5584442118409422 1.717927826782323e-06 0.5567607189607793 1.717927897341035e-06 0.5551915720267918 1.717927986471042e-06 0.5532116467156011 \
1.71792807569462e-06 0.5512351177508077 1.71792816099823e-06 0.5493490637975145 1.717928248625197e-06 0.5474138635528197 1.71792834562712e-06 0.545274424894262 \
1.717928449972891e-06 0.5429792414815097 1.717928566264316e-06 0.5404269323775457 1.717928672601932e-06 0.5380963700835184 1.717928784310815e-06 0.5356536306660374 \
1.717928896605295e-06 0.5332047801427824 1.717929023802854e-06 0.5304364255197962 1.717929146572528e-06 0.5277698476303582 1.717929288796925e-06 0.5246912237717902 \
1.717929425160057e-06 0.5217463069543907 1.717929577381123e-06 0.5184691491721333 1.717929737017329e-06 0.5150420887864461 1.717929912992521e-06 0.5112761258030903 \
1.717930101501109e-06 0.5072591542828934 1.71793030856769e-06 0.5028616940969075 1.717930533509662e-06 0.4981043078903621 1.717930784905619e-06 0.4928144328841237 \
1.717931021331185e-06 0.4878598554762091 1.717931318494919e-06 0.4816683149127979 1.717931609172211e-06 0.4756487143466775 1.717931917027196e-06 0.469313240945046 \
1.717932230852953e-06 0.4628991126846517 1.717932559994313e-06 0.4562163541974347 1.71793289337242e-06 0.4494927613461197 1.717933224999028e-06 0.4428490490857003 \
1.717933546548425e-06 0.4364504708187015 1.717933874224238e-06 0.4299742838549845 1.71793422184386e-06 0.4231546934710667 1.717934555065174e-06 0.4166645133789623 \
1.717934900974402e-06 0.4099771621835854 1.717935346388221e-06 0.4014400148089548 1.717935704178092e-06 0.3946500490499754 1.717936018334912e-06 0.3887397205534429 \
1.717936402745392e-06 0.3815756289527631 1.717936732720036e-06 0.3754830843203271 1.717937017930125e-06 0.3702633801070484 1.717937326220382e-06 0.3646649204592909 \
1.717937606017443e-06 0.3596257204303125 1.717937832011793e-06 0.3555880084110294 1.717938046849748e-06 0.3517755993421203 1.71793824528482e-06 0.3482769933469286 \
1.717938449224337e-06 0.3447071465415313 1.717938659760396e-06 0.3410461989361561 1.717938916734521e-06 0.3366091000429626 1.717939157995129e-06 0.3324763702393667 \
1.717939389568845e-06 0.3285420159269506 1.717939604222291e-06 0.3249208057821749 1.717939825046275e-06 0.3212218866489027 1.717940026292867e-06 0.3178749657716667 \
1.71794022938212e-06 0.3145250552959265 1.717940427226991e-06 0.3112865758726304 1.717940614079937e-06 0.3082497660855442 1.717940808016663e-06 0.3051208532403978 \
1.717941011761317e-06 0.30185834615803 1.717941190488583e-06 0.2990186060348319 1.717941428134378e-06 0.2952727068736475 1.717941627896611e-06 0.2921508861588616 \
1.717941829525427e-06 0.2890253490052915 1.717942054991886e-06 0.285561995332 1.717942221086285e-06 0.2830312764183137 1.717942399705387e-06 0.2803277612349699 \
1.717942581409588e-06 0.2775983111934518 1.717942770043305e-06 0.2747882307029562 1.717942947466508e-06 0.2721695222189568 1.717943124659646e-06 0.2695724116247911 \
1.717943284731561e-06 0.2672552081803913 1.717943405132238e-06 0.2655193337608355 1.717943552958303e-06 0.2633957862580221 1.717943681588075e-06 0.2615692882062232 \
1.717943783793658e-06 0.2601227034409412 1.717943902028939e-06 0.2584516051170885 1.7179440224823e-06 0.2567534139348401 1.717944146190618e-06 0.2550183706610066 \
1.717944264442643e-06 0.2533694204037282 1.717944392295773e-06 0.2515887492000971 1.717944512581604e-06 0.249915736161692 1.71794466526121e-06 0.2477917697339537 \
1.717944800173988e-06 0.2459264316518071 1.71794492881341e-06 0.2441493177932957 1.717945086528788e-06 0.2419705448111171 1.717945213210091e-06 0.2402201997919771 \
1.717945348536158e-06 0.2383592392624043 1.717945487448727e-06 0.2364550510890953 1.717945605221031e-06 0.2348405558720491 1.717945764491849e-06 0.2326580599570062 \
1.717945901013704e-06 0.2307878375452989 1.71794604224565e-06 0.2288626996658652 1.717946148058693e-06 0.2274220928889542 1.71794627840164e-06 0.2256484734765637 \
1.717946378112453e-06 0.2242944442559471 1.717946480933888e-06 0.2228991027388591 1.717946554349542e-06 0.2219046249368765 1.717946634181104e-06 0.2208265149641777 \
1.717946704228335e-06 0.2198809561195558 1.717946754631426e-06 0.2192009305305119 1.717946806883225e-06 0.2184966408607167 1.717946886120743e-06 0.2174292050927151 \
1.717946927964696e-06 0.2168658036437602 1.717946967304648e-06 0.216336351877609 1.717947010340057e-06 0.2157575332679269 1.717947054507484e-06 0.2151638767852215 \
1.717947128273224e-06 0.2141731338947761 1.717947163785221e-06 0.2136967174286463 1.717947211500021e-06 0.2130606706933813 1.717947272229561e-06 0.2122518321687151 \
1.717947340486787e-06 0.2113438957752176 1.717947413008566e-06 0.2103801801047663 1.717947485683193e-06 0.2094152724966429 1.717947593999181e-06 0.2079788886429202 \
1.717947691670323e-06 0.20668564243436 1.717947803221819e-06 0.2052110974836689 1.717947901757253e-06 0.2039136008387587 1.717948005250393e-06 0.2025572972554956 \
1.717948101152128e-06 0.2013021587886929 1.717948203780057e-06 0.1999606878451601 1.71794830660317e-06 0.1986207062101238 1.717948416722797e-06 0.1971897063011611 \
1.717948525418353e-06 0.1957815523781236 1.717948645095582e-06 0.1942360962608612 1.717948755373261e-06 0.192818053470401 1.717948863436481e-06 0.1914343471929882 \
1.717948988535148e-06 0.1898375077741012 1.717949078504982e-06 0.1886931806549971 1.717949157191935e-06 0.1876950225942949 1.717949234476806e-06 0.1867173468865102 \
1.717949320985383e-06 0.1856271834369256 1.717949419934593e-06 0.1843848109964498 1.717949490443458e-06 0.1835017733581451 1.717949561894511e-06 0.1826096997732476 \
1.717949667039846e-06 0.1813018727451555 1.717949746279475e-06 0.1803200401832796 1.717949827363369e-06 0.1793174195483187 1.71794992085531e-06 0.1781663090788374 \
1.717950021631285e-06 0.1769308188703378 1.717950171343388e-06 0.175105380089017 1.717950287132704e-06 0.1737009932372819 1.71795043813808e-06 0.1718807311127691 \
1.7179505492465e-06 0.1705485445502526 1.717950691372958e-06 0.168854666407182 1.717950809031379e-06 0.167460358327668 1.717950913935975e-06 0.1662230887079887 \
1.717951008998573e-06 0.1651069099307241 1.717951102429828e-06 0.1640147999883682 1.71795120347649e-06 0.1628388413495604 1.717951299823398e-06 0.1617223204899406 \
1.717951396975644e-06 0.1606011553546776 1.717951480024216e-06 0.1596469772300165 1.71795159006187e-06 0.1583897228513109 1.717951672364432e-06 0.1574542248873526 \
1.717951777364141e-06 0.156267858580057 1.71795185506021e-06 0.1553950893374849 1.717951937879689e-06 0.1544690878994293 1.717952019541594e-06 0.1535604570452941 \
1.717952108890884e-06 0.152571060794856 1.71795218460332e-06 0.1517364980793458 1.717952267165934e-06 0.1508307726525361 1.717952343747367e-06 0.1499942554682341 \
1.717952412035253e-06 0.1492531084507001 1.717952505402265e-06 0.1482449401818621 1.717952574555677e-06 0.1475015570698688 1.717952650180008e-06 0.1466917482325688 \
1.717952711729128e-06 0.1460354497178591 1.717952778977892e-06 0.1453208357145237 1.717952850039892e-06 0.1445684785944268 1.71795292553732e-06 0.143772322008306 \
1.71795298444886e-06 0.1431546944759192 1.71795306112247e-06 0.1423563022825049 1.717953141443211e-06 0.1415233898163201 1.71795321459452e-06 0.1407682091691316 \
1.717953308750941e-06 0.139800669784813 1.717953380355125e-06 0.1390684367429364 1.7179534538159e-06 0.1383201464810226 1.717953537327651e-06 0.1374732033664194 \
1.717953626806795e-06 0.1365744208092838 1.7179536918717e-06 0.1359252211013016 1.717953803997723e-06 0.1348115665849295 1.717953869183863e-06 0.1341670699454539 \
1.717953939222108e-06 0.1334770515823289 1.717953999527163e-06 0.1328849371768329 1.717954054537987e-06 0.1323464455745446 1.717954142654965e-06 0.1314871014507438 \
1.71795418344126e-06 0.131090685705856 1.71795428714401e-06 0.1300923774523848 1.71795433045658e-06 0.1296773144713907 1.717954391675178e-06 0.1290920262082728 \
1.717954436511897e-06 0.1286643765206081 1.717954524107923e-06 0.127831527987147 1.717954565661879e-06 0.1274377589706847 1.717954625523389e-06 0.1268718307679372 \
1.717954697367115e-06 0.1261946708524367 1.717954753579841e-06 0.1256664967939027 1.71795481606734e-06 0.125081039250218 1.717954890295323e-06 0.1243877959456236 \
1.717954964976328e-06 0.1236954937854857 1.717955052159541e-06 0.1228905551604285 1.717955120558092e-06 0.1222610287411191 1.717955201128775e-06 0.1215216597888775 \
1.717955282424256e-06 0.120778012781285 1.717955349340781e-06 0.1201677797529914 1.717955432157726e-06 0.1194156054679852 1.717955491346448e-06 0.1188799972037829 \
1.717955557267448e-06 0.1182853617472536 1.717955637141492e-06 0.1175675408705869 1.71795571363729e-06 0.1168828806096336 1.7179557950994e-06 0.1161574242846086 \
1.717955893570281e-06 0.1152852106851665 1.71795596868063e-06 0.114622623867465 1.71795607166842e-06 0.1137180076826871 1.717956145852371e-06 0.1130691786503039 \
1.717956243471825e-06 0.1122190343868764 1.71795633928278e-06 0.1113890351962442 1.717956435131205e-06 0.110562946039519 1.717956516069412e-06 0.1098685209805978 \
1.717956604452683e-06 0.1091134439098378 1.717956703052662e-06 0.108274944429282 1.717956775836865e-06 0.1076586405352824 1.717956865109775e-06 0.1069058608836731 \
1.717956927091788e-06 0.1063852406583179 1.717956989684956e-06 0.1058613310701875 1.717957074907104e-06 0.105150777260444 1.717957180369478e-06 0.1042758147594986 \
1.717957260199961e-06 0.1036167065755082 1.717957340914214e-06 0.1029530974056021 1.717957423527949e-06 0.1022768941101355 1.717957493972562e-06 0.1017026162492672 \
1.717957597231928e-06 0.1008648142128753 1.717957670072053e-06 0.1002767039768694 1.717957755712335e-06 0.09958839426015198 1.717957874514073e-06 0.09863954321822334 \
1.717957942151898e-06 0.09810250133474645 1.71795801190202e-06 0.09755100310752296 1.717958089237e-06 0.09694230106952094 1.717958181657254e-06 0.09621870517595056 \
1.717958253354782e-06 0.09566033062548993 1.717958339171942e-06 0.09499542738017568 1.717958441597192e-06 0.09420660575030523 1.717958534892083e-06 0.09349264652734962 \
1.717958631208556e-06 0.09276005482712441 1.717958708110818e-06 0.09217843893134048 1.717958801590805e-06 0.09147541043939374 1.717958880833232e-06 0.09088281005358793 \
1.717958995455426e-06 0.0900310686188453 1.717959125063686e-06 0.08907580221142102 1.717959258320877e-06 0.08810234090122065 1.717959402350766e-06 0.08705990691030199 \
1.71795955951891e-06 0.08593388720602639 1.717959709295387e-06 0.08487214151476249 1.717959871762979e-06 0.08373303262435308 1.717960014942984e-06 0.08273971668837025 \
1.717960167622107e-06 0.0816913199659166 1.717960301891878e-06 0.08077856892457436 1.717960443644156e-06 0.07982444400446118 1.717960578643816e-06 0.07892500874648442 \
1.717960720601214e-06 0.07798882638923543 1.717960867448644e-06 0.07703088995320664 1.717961019894053e-06 0.07604750978240994 1.717961185112776e-06 0.07499422991502351 \
1.717961349250621e-06 0.07396067809208305 1.717961526112024e-06 0.07286119333145537 1.71796171645358e-06 0.07169407515132428 1.717961927410093e-06 0.07042030845332216 \
1.717962147819232e-06 0.0691121699798517 1.717962383344393e-06 0.06773900533435212 1.717962643793767e-06 0.0662496528900723 1.717962939459177e-06 0.06459579389282195 \
1.717963244581463e-06 0.06292902455725519 1.717963609576024e-06 0.06098725515092194 1.717964004456839e-06 0.05894944116461652 1.717964410847493e-06 0.05692211719668253 \
1.717964826573035e-06 0.05491854459141238 1.717965189379358e-06 0.0532251207245777 1.717965533980648e-06 0.05166301626031383 1.71796584916051e-06 0.05027284652491828 \
1.717966144689875e-06 0.04900240867073854 1.717966442670382e-06 0.04775344010203557 1.717966718469172e-06 0.04662857640242725 1.717966997243768e-06 0.04551884372531381 \
1.717967261178638e-06 0.04449205559535935 1.717967537201377e-06 0.04344260531795661 1.71796781615763e-06 0.04240676967887352 1.717968129850963e-06 0.04127097799875453 \
1.71796836585125e-06 0.04043636567030678 1.717968621645987e-06 0.03955075129286261 1.717968881769487e-06 0.03867033103466553 1.717969151904759e-06 0.03778142289416799 \
1.717969431124747e-06 0.03688501536902895 1.717969712963396e-06 0.03600226561751176 1.717969989839066e-06 0.03515600409566183 1.717970268932665e-06 0.03432349610146775 \
1.717970501810272e-06 0.03364444121149882 1.717970785646989e-06 0.03283527291840588 1.717971025751924e-06 0.03216626441466421 1.717971265550746e-06 0.0315119836023277 \
1.71797150482792e-06 0.03087436846876356 1.717971740084942e-06 0.03026290129608995 1.717971971011964e-06 0.02967475842909434 1.717972186001007e-06 0.02913788335257221 \
1.71797258815546e-06 0.02816043724496065 1.717972786878278e-06 0.02768988489927659 1.717973160561295e-06 0.0268265706552881 1.717973347359617e-06 0.02640514011949098 \
1.717973694919304e-06 0.02563810810034544 1.717973816848767e-06 0.0253740445387235 1.717974199320207e-06 0.02456430406701914 1.717974370028237e-06 0.02421180751242828 \
1.717974827125621e-06 0.02328894863848502 1.717975012758007e-06 0.0229225623309489 1.71797537621526e-06 0.02221803970155307 1.717975596582612e-06 0.02179832126591805 \
1.71797605430897e-06 0.02093867417890744 1.717976189728599e-06 0.02068687731869814 1.717976719624047e-06 0.01972418011126781 1.717976838945017e-06 0.01951377505543128 \
1.717977404730696e-06 0.01856069823426573 1.717977569110437e-06 0.0182962226476828 1.717978187655734e-06 0.01735107502432094 1.717978357709933e-06 0.01710418363667701 \
1.717978889842166e-06 0.01636278834442301 1.717979086926142e-06 0.01610013864443424 1.717979810045215e-06 0.01517806887136661 1.717979974675381e-06 0.01497647803580381 \
1.717980723800768e-06 0.01409711804523418 1.71798085710012e-06 0.01394643716836554 1.717981717353759e-06 0.01301449210748497 1.717981852457379e-06 0.01287422877142914 \
1.71798279503482e-06 0.01193816285908547 1.717982958630574e-06 0.01178202925388569 1.717983959987201e-06 0.0108653384673985 1.717984097529988e-06 0.01074500730514941 \
1.717985319636371e-06 0.009765086624518643 1.717985426589084e-06 0.00968516078425012 1.717986830780577e-06 0.008707372520026449 1.717986935611284e-06 0.008639312158696611 \
1.717988470448246e-06 0.00767719340797631 1.717988565731547e-06 0.007617466071856052 1.717990174528868e-06 0.006680264535635283 1.717990308605608e-06 0.006609506832171614 \
1.717992405618559e-06 0.005610918814474722 1.717992636163191e-06 0.005510783990371394 1.717994959158435e-06 0.004586584533412417 1.717995440488638e-06 0.004413562233393853 \
1.717998278050269e-06 0.003511943147855551 1.717998822969955e-06 0.003360532104877318 1.718002947178352e-06 0.002408309874554541 1.718003490902011e-06 0.002305347543005144 \
1.718009362191237e-06 0.001333291345955189 1.718009605056421e-06 0.001286469439319215 1.718023932948772e-06 0.0002880570268237783 1.718024077507414e-06 0.0002853642807229123 \
1.720661356428513e-06 -0.0006859155495331031 1.72066149598365e-06 -0.000901903561740745 1.720662005077583e-06 -0.001859438188174024 1.720662094565085e-06 -0.002052812934985279 \
1.720662457959945e-06 -0.00291126965001638 1.720662548982015e-06 -0.003143482006111167 1.720662914420052e-06 -0.004127275145644371 1.720663024680619e-06 -0.004436819103926468 \
1.720663336727774e-06 -0.005309594399865315 1.720663439442621e-06 -0.005584800160857357 1.720663803290477e-06 -0.006384516484886619 1.720663968081208e-06 -0.006586298968823262 \
1.720664547677408e-06 -0.005791490933239759 1.720664722787551e-06 -0.004914057272375438 1.720664839479485e-06 -0.004132845175365214 1.720664966064091e-06 -0.003100877896798674 \
1.720665067873013e-06 -0.002132773363901063 1.720665188361723e-06 -0.0008283127610571584 1.720665278808799e-06 0.0002599396317828252 1.72066537669893e-06 0.001541559978017447 \
1.720665475763239e-06 0.002943971508909197 1.720665646570516e-06 0.005594911825788154 1.720665868338539e-06 0.00944046646559993 1.720666064242384e-06 0.01317281463966807 \
1.720666223123766e-06 0.01639870563256729 1.720666387552263e-06 0.01989779506365397 1.720666541918294e-06 0.02331070396473752 1.720666700690818e-06 0.02693200463312963 \
1.720666847428777e-06 0.03036422445567413 1.720666996052748e-06 0.0339113704936035 1.720667151667245e-06 0.03768995713197771 1.720667308909259e-06 0.04156499463828727 \
1.720667473802058e-06 0.04567927910670353 1.720667647221578e-06 0.05005184210758699 1.720667825915293e-06 0.05459761989277153 1.720668014531131e-06 0.05943075613080645 \
1.720668215431273e-06 0.06460909294799391 1.720668434888064e-06 0.0702927970720964 1.720668664434351e-06 0.07626037976612585 1.720668910133291e-06 0.08266408948881369 \
1.72066917869823e-06 0.08967663153997742 1.720669470040144e-06 0.09728936802005522 1.720669791708172e-06 0.1056939239977524 1.720670152022263e-06 0.1150987971742611 \
1.720670543001701e-06 0.1252892839303718 1.720670986416517e-06 0.1368209045172546 1.720671502729605e-06 0.1502062239570841 1.720672108934821e-06 0.16586000516691 \
1.720672780191848e-06 0.1831102247110778 1.720673559691505e-06 0.20301830483439 1.720674432001389e-06 0.2251413938832897 1.720675262336714e-06 0.2460320778586349 \
1.720675993667063e-06 0.264292249712138 1.720676641612843e-06 0.280346965484095 1.720677224923317e-06 0.29469740877147 1.720677760655584e-06 0.3077798509628869 \
1.720678263914169e-06 0.3199778888071559 1.72067874911767e-06 0.3316516836183861 1.720679228040375e-06 0.3430829066939081 1.720679674471008e-06 0.3536501814456421 \
1.720680148800718e-06 0.3647819492304352 1.720680597991712e-06 0.3752331958288908 1.72068108846397e-06 0.3865396207984229 1.720681617036722e-06 0.3985997842463301 \
1.720681988181062e-06 0.4069920784971888 1.720682515935418e-06 0.4188173133762567 1.720682978292178e-06 0.4290642331729484 1.720683450624318e-06 0.4394285229343968 \
1.720683932409041e-06 0.4498981261869666 1.720683965448159e-06 0.4506126593745911 1.720684003207152e-06 0.45142837879914 1.720684078725137e-06 0.4530572051633331 \
1.720684229761107e-06 0.4563088938659436 1.720684437280373e-06 0.460764549126051 1.720684625319184e-06 0.4647825567212808 1.720684844328398e-06 0.469441659996985 \
1.720685087159409e-06 0.4745824626509371 1.720685386935037e-06 0.4808894567257585 1.720685624728187e-06 0.4858624696070272 1.720685887949588e-06 0.4913374535260851 \
1.720686148847133e-06 0.4967277906005185 1.72068637840122e-06 0.5014431429135263 1.720686601461413e-06 0.506003872007333 1.720686803037404e-06 0.5100983586086808 \
1.720686951867463e-06 0.51310967141356 1.720687196178516e-06 0.5180317772556589 1.720687328783749e-06 0.5206893064287169 1.720687468140331e-06 0.5234717264876519 \
1.720687679105724e-06 0.5276623644271943 1.720687853979606e-06 0.5311266030493931 1.720688122027852e-06 0.5364094032095129 1.72068831705351e-06 0.5402319029111832 \
1.720688496615017e-06 0.5437361368949839 1.720688747571146e-06 0.5486228351952749 1.720689024979257e-06 0.5540035987981641 1.720689308928559e-06 0.5594901708581531 \
1.72068956456585e-06 0.5644152233389156 1.72068985554807e-06 0.570006772487656 1.720690115853754e-06 0.5749917787111524 1.720690384297874e-06 0.5801232573974072 \
1.720690627063004e-06 0.5847450403362237 1.720690883594205e-06 0.5896146675871002 1.720691109757648e-06 0.59388771440121 1.720691347099143e-06 0.5983512154742827 \
1.72069155648786e-06 0.6022720321566808 1.720691770260628e-06 0.6062574570422776 1.720692023713469e-06 0.6109557890491497 1.720692226567816e-06 0.6146943332140289 \
1.720692419372338e-06 0.6182333111593361 1.720692609677365e-06 0.6217090173923294 1.720692800335854e-06 0.6251694921350958 1.72069300291378e-06 0.6288260100903066 \
1.720693265662542e-06 0.6335359534764116 1.720693494630232e-06 0.6376100987349322 1.720693714577867e-06 0.6414991146358265 1.72069394026254e-06 0.6454625140719233 \
1.720694149149966e-06 0.6491091855837361 1.720694370803585e-06 0.652957810138281 1.720694555693011e-06 0.6561429680377227 1.720694745707565e-06 0.6594017273991298 \
1.720694895862686e-06 0.6619630641908443 1.720695070740593e-06 0.6649292185271485 1.72069521646131e-06 0.6673855496832628 1.720695352493842e-06 0.6696641287411549 \
1.720695500856121e-06 0.672138295335571 1.720695630303834e-06 0.6742883907026684 1.720695764169531e-06 0.6764996355878535 1.72069589251393e-06 0.6786115243545502 \
1.720696017902058e-06 0.6806677490053815 1.720696147367755e-06 0.6827843190971332 1.72069627834897e-06 0.6849171426143115 1.720696426722072e-06 0.6873221141612875 \
1.720696534784827e-06 0.6890667486235877 1.7206966633165e-06 0.6911333958680312 1.720696798756283e-06 0.6933004139195943 1.720696923690607e-06 0.6952876996714908 \
1.720697049447875e-06 0.6972799977491608 1.720697155963766e-06 0.6989584331773744 1.720697273081655e-06 0.7007929859467624 1.720697391621401e-06 0.7026383448210159 \
1.720697514924797e-06 0.704545102273978 1.720697618097696e-06 0.7061304255463237 1.720697769068859e-06 0.7084341141567283 1.720697885323065e-06 0.7101955266062138 \
1.720698015883454e-06 0.7121605601685687 1.720698134445982e-06 0.7139335830373704 1.720698240519852e-06 0.7155108922888329 1.720698340544791e-06 0.716990346352101 \
1.720698477870007e-06 0.719009255813789 1.720698596531362e-06 0.7207429633399333 1.720698718230586e-06 0.7225107522614664 1.720698843413151e-06 0.7243181860083944 \
1.720698965432965e-06 0.7260693242762759 1.720699093464719e-06 0.7278954552757622 1.720699217946458e-06 0.7296603419865877 1.720699346245781e-06 0.7314685590147565 \
1.720699473339584e-06 0.7332489547570846 1.720699599364423e-06 0.7350034830462163 1.72069970210311e-06 0.7364262918236342 1.720699816775856e-06 0.7380063527755659 \
1.720699898181918e-06 0.7391232259175492 1.720700017381438e-06 0.7407496908814458 1.720700110023778e-06 0.7420059782745783 1.720700248182835e-06 0.7438668850244906 \
1.720700379238334e-06 0.7456179978167152 1.720700509370502e-06 0.7473439783685625 1.720700614344577e-06 0.7487266533969134 1.720700753484419e-06 0.7505456565005918 \
1.720700907428719e-06 0.7525407731682957 1.720701029372999e-06 0.7541080835708853 1.720701176919359e-06 0.7559892974429111 1.720701298924537e-06 0.7575320275232224 \
1.720701447624467e-06 0.7593968175435225 1.720701581671092e-06 0.7610632318338031 1.720701703924347e-06 0.7625711443351471 1.720701816790257e-06 0.763953046884334 \
1.720701959641225e-06 0.7656882893306027 1.720702086364119e-06 0.7672149413549471 1.720702202168994e-06 0.7685995877768005 1.720702331910823e-06 0.7701390587657672 \
1.72070244764921e-06 0.7715019052061673 1.720702570601637e-06 0.7729391548276606 1.720702688317297e-06 0.7743051053122872 1.720702794287273e-06 0.7755262985206828 \
1.720702910698467e-06 0.7768586864857919 1.7207030173164e-06 0.7780703956921795 1.72070312951512e-06 0.7793369495935717 1.72070321618369e-06 0.7803089322889447 \
1.720703319569181e-06 0.7814603789665585 1.720703432733433e-06 0.7827108149434853 1.720703538380715e-06 0.783868819044773 1.720703647720273e-06 0.7850578567336689 \
1.720703754897288e-06 0.786214126597127 1.720703884303365e-06 0.7875981444497275 1.72070399672075e-06 0.7887899291890393 1.72070412010849e-06 0.7900869036018625 \
1.720704237558825e-06 0.7913106402786101 1.720704381085744e-06 0.7927918312347375 1.720704496005322e-06 0.7939667362870242 1.720704634727735e-06 0.7953719780830618 \
1.720704772759875e-06 0.7967562205547866 1.72070488225303e-06 0.7978444364842524 1.72070498327146e-06 0.7988406866985471 1.72070508435942e-06 0.7998302780396641 \
1.720705216746616e-06 0.8011146558616069 1.720705335472037e-06 0.8022550163876687 1.720705457256542e-06 0.8034134048507504 1.720705576346336e-06 0.8045351524060473 \
1.720705697550853e-06 0.8056657048884367 1.720705829194664e-06 0.8068811249615274 1.720705952212703e-06 0.8080052413861453 1.720706079823023e-06 0.8091594649786741 \
1.720706210891683e-06 0.8103325925767672 1.720706334212046e-06 0.8114249716726942 1.72070644213631e-06 0.8123719892944993 1.720706549931703e-06 0.8133095350680949 \
1.720706631652631e-06 0.8140147772069938 1.720706748520247e-06 0.815015186305849 1.720706839581256e-06 0.8157880755829442 1.720706973749887e-06 0.8169164295805346 \
1.72070711832076e-06 0.8181184617099191 1.720707251823127e-06 0.8192158725965917 1.720707361789037e-06 0.8201107352847025 1.720707505654698e-06 0.8212684563313245 \
1.720707658960262e-06 0.8224861772268215 1.720707786698555e-06 0.8234883060891934 1.720707927340891e-06 0.8245786478120171 1.720708053124456e-06 0.8255423809867173 \
1.720708207742427e-06 0.8267124309768116 1.720708340154194e-06 0.8277017767197102 1.720708466433798e-06 0.8286345641820314 1.720708584064113e-06 0.8294941055817234 \
1.720708732230976e-06 0.8305638349826423 1.720708899375221e-06 0.8317531470681401 1.720709031993881e-06 0.832683775428688 1.720709204938569e-06 0.8338803479528284 \
1.720709373325224e-06 0.8350269493631071 1.720709542859754e-06 0.8361634673386688 1.720709724228909e-06 0.8373596561587384 1.720709866861491e-06 0.8382862741713709 \
1.72070998079734e-06 0.8390176620397163 1.720710111571134e-06 0.8398476357987267 1.720710213225074e-06 0.8404856735008092 1.720710329718803e-06 0.8412091703399448 \
1.720710465236349e-06 0.8420405885319162 1.720710662580143e-06 0.8432318270427018 1.720710853245141e-06 0.8443612543037786 1.72071106310198e-06 0.8455804035625291 \
1.720711244039104e-06 0.8466117334714958 1.720711441374591e-06 0.8477160230260256 1.720711615161427e-06 0.8486711109012058 1.720711797742881e-06 0.8496572451898022 \
1.720711969062461e-06 0.850566499179887 1.720712143447507e-06 0.8514760798656241 1.720712318831052e-06 0.8523748177975867 1.720712495063209e-06 0.8532619682996843 \
1.720712684901452e-06 0.8542000584728613 1.720712875637665e-06 0.8551245802328369 1.720713077434399e-06 0.856083442102113 1.720713270127775e-06 0.8569809170305027 \
1.720713479756076e-06 0.857937542729613 1.72071370919384e-06 0.8589615588718806 1.72071397499048e-06 0.8601183337444025 1.720714273565708e-06 0.8613802063570262 \
1.720714551467221e-06 0.8625196921548358 1.720714835677695e-06 0.8636511027355716 1.720715110089482e-06 0.8647118800460076 1.720715382252364e-06 0.8657341977214618 \
1.720715652421456e-06 0.8667205537246333 1.720715909616139e-06 0.8676338760342862 1.72071618215581e-06 0.868575115807136 1.720716458190291e-06 0.8695013130444248 \
1.720716728342986e-06 0.8703818891200001 1.720717028049788e-06 0.8713292845176382 1.720717398867258e-06 0.8724597217497643 1.720717693785921e-06 0.8733269024855727 \
1.720717948030199e-06 0.8740525764960509 1.720718246254198e-06 0.8748787854419284 1.720718519878969e-06 0.8756137195941651 1.720718756017959e-06 0.8762307200963571 \
1.720718996373686e-06 0.8768427579093606 1.720719218719338e-06 0.8773949085683344 1.720719412723072e-06 0.877865919014753 1.720719742447196e-06 0.878644045115768 \
1.720719897619855e-06 0.8790007149587372 1.720720215373248e-06 0.879712598742095 1.720720394238605e-06 0.8801026384247937 1.720720736700093e-06 0.8808283583858193 \
1.720720920841293e-06 0.8812073588304842 1.720721395746114e-06 0.8821499412898334 1.720721563140601e-06 0.8824705695712217 1.720722028971889e-06 0.8833323038036038 \
1.720722209796771e-06 0.8836551183393088 1.720722703830028e-06 0.8845051821644966 1.720722845172603e-06 0.8847400410050358 1.720723451563118e-06 0.8857071861637142 \
1.720723603635685e-06 0.8859397703602404 1.720724250313758e-06 0.8868873789663725 1.720724378610247e-06 0.8870678433440622 1.720725026723245e-06 0.8879435266410994 \
1.720725156528523e-06 0.8881118897635528 1.720725934785608e-06 0.8890711781604964 1.720726049780423e-06 0.8892053868933587 1.720726905511062e-06 0.8901454611437621 \
1.720727050777629e-06 0.8902951528450479 1.720728036533732e-06 0.8912364417375994 1.720728257640946e-06 0.8914302300078862 1.720729402752027e-06 0.892358484239638 \
1.720729533960174e-06 0.8924604119362172 1.720730875263369e-06 0.8934531785430913 1.72073102665103e-06 0.8935579568409697 1.720732508109867e-06 0.8944876667405802 \
1.720732746990229e-06 0.894621531696939 1.720734516461986e-06 0.8954958910368339 1.720734905568823e-06 0.8956641700186337 1.720737299334232e-06 0.8965498195158238 \
1.720737774894223e-06 0.8966991754584082 1.720741837950387e-06 0.8976977719002629 1.720742329424408e-06 0.8977905759376156 1.720750645951487e-06 0.8987839664765119 \
1.720751565805377e-06 0.8988472044554419 1.720877770945903e-06 0.8998441026240215 1.720878784754255e-06 0.8998514601858095 1.721070497347411e-06 0.8990059056521554 \
1.721070727348974e-06 0.8988405173838494 1.721072342221535e-06 0.8978439928078279 1.721072519935389e-06 0.8977495532019018 1.721089285710428e-06 0.8987316330193963 \
1.721089421698825e-06 0.8987497732072308 1.721104884427938e-06 0.8997471920221268 1.72110515229253e-06 0.8997526389354535 1.721588977619798e-06 0.9006560548284696 \
1.721589098408999e-06 0.9007687033315858 1.721589886180037e-06 0.9017381658104292 1.721590020318756e-06 0.901943163319478 1.72159051393353e-06 0.9027850367016239 \
1.721590658833145e-06 0.9030569221572713 1.72159105464053e-06 0.9038490360455199 1.721591174436184e-06 0.9041001886668685 1.721591558609717e-06 0.9049189780371781 \
1.721591670731365e-06 0.9051556495331843 1.721592178052336e-06 0.9061253139956988 1.721592272051192e-06 0.90626859229291 1.721593430700898e-06 0.9055667778886739 \
1.721593533663832e-06 0.9051589876696525 1.721593617506701e-06 0.9047707260375384 1.721593751246752e-06 0.9040404158978201 1.721593851964133e-06 0.9033957423200318 \
1.721593959579919e-06 0.9026166239542108 1.721594077153173e-06 0.9016533104038295 1.721594165418223e-06 0.90085556431878 1.721594285051691e-06 0.8996698288011099 \
1.721594382373389e-06 0.8986166602050341 1.721594493390828e-06 0.8973222354192386 1.721594595500415e-06 0.8960407982554908 1.721594678931815e-06 0.8949326975987755 \
1.721594783112883e-06 0.8934749428758865 1.721594874199646e-06 0.8921321265381427 1.721594966740432e-06 0.8907058396397178 1.72159506189443e-06 0.8891776325191247 \
1.721595176449407e-06 0.88725933118288 1.721595265292509e-06 0.8857137884271823 1.721595363531691e-06 0.8839502506198179 1.721595448901865e-06 0.8823735982707064 \
1.721595529802107e-06 0.8808434949738935 1.7215956027634e-06 0.8794355441897157 1.721595669782045e-06 0.8781198554636557 1.721595738393124e-06 0.8767515715160701 \
1.721595821888036e-06 0.8750591081124355 1.721595884015366e-06 0.8737811510706814 1.721595946997964e-06 0.8724704924326797 1.721596042153715e-06 0.8704632161180945 \
1.721596142764353e-06 0.8683077530860182 1.721596222643545e-06 0.8665738309361769 1.721596306905814e-06 0.8647250601592834 1.721596386016074e-06 0.8629723295901451 \
1.721596448831519e-06 0.8615696597604833 1.721596536288554e-06 0.8596016864744445 1.721596602182084e-06 0.8581079708060287 1.721596670243626e-06 0.856556281928966 \
1.721596719556134e-06 0.8554267461646872 1.721596774792924e-06 0.85415654045335 1.721596815532529e-06 0.8532164928603474 1.721596861834283e-06 0.8521450198670055 \
1.721596892048343e-06 0.8514441160591502 1.721596921089625e-06 0.8507691938976955 1.72159695172822e-06 0.8500558939662993 1.72159701300541e-06 0.8486254874746039 \
1.721597066077972e-06 0.8473828229799116 1.721597119733165e-06 0.8461232012188223 1.721597182390447e-06 0.8446482873934593 1.721597245673395e-06 0.8431545995644786 \
1.721597336171269e-06 0.8410121009440262 1.721597433169049e-06 0.8387078554355326 1.72159751614655e-06 0.8367307351423475 1.721597598150905e-06 0.8347721678896715 \
1.721597687219307e-06 0.8326403548070889 1.721597771732643e-06 0.8306135893189693 1.721597862591523e-06 0.8284303722590877 1.721597954526378e-06 0.8262176456275642 \
1.721598056957308e-06 0.8237486178045141 1.72159815707534e-06 0.8213320995840899 1.721598271896223e-06 0.8185572053828121 1.72159838410276e-06 0.8158423448209959 \
1.721598509096305e-06 0.8128151787794674 1.721598640356713e-06 0.8096337870015397 1.721598785627755e-06 0.8061104108175116 1.721598940135368e-06 0.8023613213197434 \
1.721599111575989e-06 0.7981999722344618 1.721599275625781e-06 0.794217661721315 1.721599460041203e-06 0.7897413884478564 1.721599666533577e-06 0.7847307375046715 \
1.72159985602742e-06 0.7801344622909899 1.721600049421183e-06 0.775444374634302 1.721600249988037e-06 0.7705834242206392 1.721600397552439e-06 0.7670092004965298 \
1.72160052756389e-06 0.7638619034739171 1.721600662428303e-06 0.7605987503374771 1.721600768918754e-06 0.7580234999254772 1.721600900608547e-06 0.7548403390839162 \
1.721601007032976e-06 0.7522693550468039 1.721601150211605e-06 0.7488125398635642 1.721601311338716e-06 0.7449250928176189 1.721601429565533e-06 0.7420746008290786 \
1.721601599798354e-06 0.7379721584775248 1.721601765724623e-06 0.7339761998059781 1.721601985266954e-06 0.7286940862104242 1.721602178454078e-06 0.724050920820232 \
1.721602353368041e-06 0.719851304223293 1.721602520315139e-06 0.7158476177432674 1.7216027078061e-06 0.711355754450834 1.721602895234537e-06 0.7068709122373377 \
1.721603063571096e-06 0.7028473835914892 1.72160325640163e-06 0.6982428782038785 1.721603396451377e-06 0.694901318858167 1.721603552708666e-06 0.6911769338170629 \
1.721603746878113e-06 0.6865540563080536 1.721603905984602e-06 0.6827702245679255 1.721604064344632e-06 0.679008548037742 1.72160425966174e-06 0.6743756772263459 \
1.721604470090519e-06 0.6693917663527935 1.721604722792665e-06 0.6634173774538097 1.721604902460615e-06 0.6591769455535931 1.721605154037489e-06 0.6532475027332399 \
1.721605354410306e-06 0.6485340174553987 1.721605526064158e-06 0.6445032789616798 1.721605684756275e-06 0.6407814961122935 1.721605823964202e-06 0.637522316374186 \
1.721605960288252e-06 0.6343349641335875 1.721606087501276e-06 0.6313646237382058 1.721606216993834e-06 0.6283457899522861 1.721606344985121e-06 0.6253646753452949 \
1.72160647605963e-06 0.6223174651643489 1.721606606771705e-06 0.6192830747181834 1.721606749379757e-06 0.6159760732208495 1.721606892103235e-06 0.612672916206165 \
1.721607044651037e-06 0.6091471600588 1.721607189155024e-06 0.6058158037532523 1.721607353173272e-06 0.6020406322262999 1.721607490637933e-06 0.5988837056407329 \
1.721607625454949e-06 0.5957940466067043 1.721607746953592e-06 0.5930134750293682 1.721607885803897e-06 0.5898448108574432 1.721607999450713e-06 0.5872554148224447 \
1.721608150860885e-06 0.5838116422847746 1.72160826457956e-06 0.5812320812748947 1.721608383992651e-06 0.5785269636915771 1.721608472673178e-06 0.5765205397309219 \
1.721608563818269e-06 0.5744630259469776 1.721608629157145e-06 0.5729901393713442 1.721608693626847e-06 0.5715377831648228 1.721608744447459e-06 0.5703933076453638 \
1.721608803422398e-06 0.569066051987989 1.721608870867106e-06 0.5675516747474645 1.721608937959298e-06 0.5660472084764079 1.721608990879742e-06 0.5648615894615425 \
1.721609086527225e-06 0.5627204246953637 1.721609143708362e-06 0.5614413394337 1.721609197510977e-06 0.5602399192081799 1.721609259253082e-06 0.5588634520375642 \
1.721609345086214e-06 0.5569525037715509 1.721609427781862e-06 0.5551133137453282 1.721609553910589e-06 0.552313430559463 1.721609689009664e-06 0.5493247407981657 \
1.721609787329828e-06 0.5471534914294828 1.72160989990789e-06 0.5446716589975775 1.721610002452305e-06 0.5424173856211837 1.721610122561131e-06 0.5397821662853191 \
1.721610224248782e-06 0.5375541863492928 1.721610339752746e-06 0.5350300289250629 1.721610454643861e-06 0.5325260225312031 1.721610581121134e-06 0.5297740207092871 \
1.72161070633833e-06 0.5270565158317848 1.721610853184312e-06 0.5238798967507053 1.721610988642446e-06 0.5209557060405445 1.721611146203054e-06 0.5175672114705414 \
1.721611308357229e-06 0.5140875588169389 1.721611489068307e-06 0.5102248342695275 1.72161168131606e-06 0.5061308236654174 1.721611894038323e-06 0.5016182665703952 \
1.721612125943484e-06 0.4967183500883584 1.721612383137188e-06 0.4913135654247419 1.721612622690498e-06 0.4863004534671564 1.721612924620373e-06 0.4800178499336004 \
1.721613212386814e-06 0.4740665530855001 1.721613525189057e-06 0.4676409412178996 1.721613845020806e-06 0.4611139840073785 1.721614184657409e-06 0.4542292677834274 \
1.721614511873228e-06 0.4476411633207955 1.721614847034797e-06 0.4409363684817221 1.721615164291458e-06 0.4346351592989786 1.721615498111436e-06 0.4280489847791872 \
1.72161584979678e-06 0.4211625252737479 1.721616163864498e-06 0.4150547397555842 1.721616486893702e-06 0.4088175946446666 1.721616927873099e-06 0.4003732788922496 \
1.721617270275942e-06 0.3938810608698495 1.72161757072383e-06 0.3882325136127223 1.721617946053401e-06 0.3812375944419973 1.72161827612863e-06 0.3751439175705365 \
1.721618559406411e-06 0.3699597784791666 1.721618859913772e-06 0.3645020109013299 1.721619139561233e-06 0.3594637112692664 1.721619363423524e-06 0.3554634414471464 \
1.721619575274513e-06 0.35170280677964 1.721619777623113e-06 0.3481338771034005 1.721619978758139e-06 0.3446120049995081 1.721620184535657e-06 0.3410324794262659 \
1.721620445514371e-06 0.3365252478245505 1.721620685004553e-06 0.3324209773202946 1.721620917679624e-06 0.3284665339262754 1.721621131761216e-06 0.3248537323113044 \
1.721621352906983e-06 0.3211475567840967 1.721621553789873e-06 0.3178053707831449 1.721621757181075e-06 0.3144500223650613 1.721621954849488e-06 0.3112139453100684 \
1.721622141093175e-06 0.3081862077816076 1.721622336074257e-06 0.3050391973134606 1.721622539536502e-06 0.3017803754370622 1.721622717477408e-06 0.2989521325826759 \
1.721622953201112e-06 0.2952356640875101 1.721623151333966e-06 0.2921385263640672 1.721623352678033e-06 0.2890160050544278 1.72162357696723e-06 0.2855690750291008 \
1.721623741897129e-06 0.2830551950838826 1.721623919525814e-06 0.2803657404651576 1.721624103924961e-06 0.2775946687427531 1.721624287746306e-06 0.2748547260732712 \
1.721624466202979e-06 0.2722194282383935 1.721624638103246e-06 0.2696976713509589 1.721624798643653e-06 0.2673699088296289 1.721624920125711e-06 0.265617282026588 \
1.721625073047239e-06 0.2634201198254058 1.721625200480934e-06 0.2616085083773952 1.721625304654605e-06 0.2601317890528609 1.721625421559082e-06 0.2584775571399547 \
1.721625536570573e-06 0.2568557450124987 1.721625660932803e-06 0.2551103168403305 1.721625776507087e-06 0.2534925198640895 1.721625910614607e-06 0.2516172680784447 \
1.721626025601848e-06 0.2500177396912131 1.721626179351445e-06 0.2478798443778067 1.721626316154646e-06 0.2459790966208961 1.721626450740453e-06 0.2441094379339017 \
1.721626606604589e-06 0.2419575875351012 1.721626731253411e-06 0.2402378086535915 1.721626870468935e-06 0.2383186229544463 1.72162700069296e-06 0.236525770455347 \
1.721627121045801e-06 0.2348769158236033 1.721627256439084e-06 0.233027137746051 1.721627407644063e-06 0.2309620730808924 1.721627542400533e-06 0.2291249940296414 \
1.72162764708672e-06 0.2277003186426776 1.721627769622861e-06 0.2260366668203369 1.72162790456742e-06 0.2242086518061946 1.721627999683167e-06 0.2229209267876512 \
1.721628114943222e-06 0.2213657311907907 1.721628197476202e-06 0.2202562617028589 1.721628268681533e-06 0.2192992955643472 1.721628317389017e-06 0.2186449771734718 \
1.721628364583973e-06 0.2180112263680214 1.721628411132791e-06 0.2173864029843717 1.721628464521355e-06 0.2166701476649976 1.721628501898025e-06 0.2161690444847812 \
1.721628539283138e-06 0.2156680710113931 1.721628579604508e-06 0.2151283464800275 1.721628650854647e-06 0.2141753141901174 1.721628685068904e-06 0.2137180869447317 \
1.721628731463534e-06 0.2131018213873352 1.721628791907201e-06 0.2122998083652294 1.72162886091012e-06 0.2113853596849882 1.721628926205072e-06 0.210520730631805 \
1.721628994183195e-06 0.2096212333552783 1.721629110629525e-06 0.2080823984153433 1.721629200551713e-06 0.2068957989735914 1.72162930821762e-06 0.2054771097790837 \
1.721629404278935e-06 0.2042146625011118 1.721629507657509e-06 0.2028641889872041 1.721629604342544e-06 0.2016026287683381 1.721629707152397e-06 0.2002625524503448 \
1.721629807912368e-06 0.1989526210414513 1.721629919058034e-06 0.1975116692735505 1.721630026097528e-06 0.1961279675313261 1.721630144004064e-06 0.1946083430154048 \
1.721630252114387e-06 0.1932197128021231 1.721630361412988e-06 0.1918224631760269 1.721630482044739e-06 0.1902849927564414 1.721630576945331e-06 0.1890796997295432 \
1.72163070550625e-06 0.18745262875399 1.721630798541038e-06 0.1862801166370808 1.721630900937595e-06 0.1849947785893032 1.721630988904886e-06 0.1838942174288659 \
1.721631087175557e-06 0.182668828510528 1.721631183776179e-06 0.1814691026470878 1.721631270414692e-06 0.1803971466393716 1.721631356823704e-06 0.1793305247657973 \
1.721631452660814e-06 0.1781527189679156 1.721631557387688e-06 0.1768710765218302 1.721631703199975e-06 0.1750963017969037 1.721631819167907e-06 0.1736923427161618 \
1.721631975631711e-06 0.1718092975148396 1.72163208681163e-06 0.1704786474822015 1.721632227061631e-06 0.1688098560703619 1.721632350073035e-06 0.1673544160765056 \
1.721632456564033e-06 0.1661007559767333 1.721632552889491e-06 0.1649724583647661 1.721632650322958e-06 0.1638357962207703 1.721632754176237e-06 0.1626293386330815 \
1.72163284597681e-06 0.1615673458739011 1.721632944364525e-06 0.1604337426303964 1.72163302728317e-06 0.1594828374885931 1.721633122651503e-06 0.1583950132920943 \
1.721633205213851e-06 0.1574587876231885 1.721633307798537e-06 0.1563016192679324 1.721633384076854e-06 0.1554454316211293 1.721633472662479e-06 0.1544557264474612 \
1.721633544831984e-06 0.1536532700165102 1.721633626541473e-06 0.1527486200895024 1.721633700220281e-06 0.1519363404455653 1.721633780440409e-06 0.1510573496788611 \
1.721633852168484e-06 0.1502755532525617 1.721633920425463e-06 0.149534520573691 1.721634018141422e-06 0.1484788062294206 1.721634087591606e-06 0.147731872792437 \
1.721634170343085e-06 0.1468455801890639 1.721634230379995e-06 0.1462052652532956 1.721634300618659e-06 0.1454587420502366 1.721634372046193e-06 0.1447037411390827 \
1.721634452559695e-06 0.1438588888651768 1.721634515822599e-06 0.1431977449412327 1.721634593496578e-06 0.1423892845091393 1.721634682806343e-06 0.141463758692191 \
1.721634752169929e-06 0.1407479403162204 1.721634850118149e-06 0.1397418416088305 1.721634940462669e-06 0.1388188591118084 1.721635026242994e-06 0.1379520826379384 \
1.721635093896779e-06 0.1372719511642241 1.721635160204629e-06 0.1366075914250998 1.721635238824321e-06 0.1358227655030745 1.72163531951923e-06 0.135020537018139 \
1.721635377921894e-06 0.1344419857224206 1.721635438674417e-06 0.1338420332148588 1.721635532580729e-06 0.1329184183639811 1.721635574978232e-06 0.1325029080242558 \
1.721635654222426e-06 0.1317336600863391 1.721635694592585e-06 0.1313430593815061 1.721635784293463e-06 0.130477658168832 1.72163582324155e-06 0.1301029732927899 \
1.721635918857236e-06 0.1291862249441596 1.721635957741065e-06 0.1288146335111444 1.721636050975841e-06 0.1279263274670414 1.72163611931843e-06 0.1272775968534341 \
1.721636171639285e-06 0.1267823325594629 1.721636253739999e-06 0.1260075984242486 1.721636324903378e-06 0.1253406747583812 1.721636402856366e-06 0.1246136378429537 \
1.721636481976102e-06 0.1238779526756392 1.721636560619333e-06 0.1231489004754178 1.721636640654242e-06 0.122409328367501 1.721636702388658e-06 0.1218405706457005 \
1.72163677598364e-06 0.1211645344030958 1.721636859363458e-06 0.120401093559758 1.721636923460189e-06 0.1198161795466899 1.721636992898777e-06 0.119184869057559 \
1.721637065921715e-06 0.1185234239195788 1.721637150796627e-06 0.1177582144838446 1.721637230159478e-06 0.117046673033812 1.721637314893136e-06 0.1162898833629492 \
1.721637405604425e-06 0.1154830714735263 1.721637481187504e-06 0.1148135241260771 1.721637546915428e-06 0.1142333070693714 1.721637606975201e-06 0.1137047561823949 \
1.721637676580917e-06 0.1130943456353956 1.721637742999968e-06 0.1125141752866663 1.721637822411231e-06 0.1118230150855203 1.721637912674161e-06 0.1110406875128299 \
1.721637981718461e-06 0.1104447270551955 1.72163805627358e-06 0.1098035355921305 1.721638144757501e-06 0.1090456469739195 1.721638223865648e-06 0.1083709350695736 \
1.721638293734029e-06 0.1077773127978274 1.721638374743399e-06 0.1070920034756896 1.721638430948213e-06 0.106618206733547 1.721638493607492e-06 0.1060916009495399 \
1.721638558754098e-06 0.105545887371837 1.721638630089726e-06 0.1049504956797945 1.721638750386101e-06 0.1039516085561449 1.721638801939674e-06 0.103525508500865 \
1.721638857088742e-06 0.1030709598036589 1.721638947785926e-06 0.1023262935955709 1.721639030175778e-06 0.1016530765296615 1.721639125755585e-06 0.1008759670630478 \
1.721639232965152e-06 0.1000092507657299 1.721639336624558e-06 0.09917656019160864 1.721639422832161e-06 0.09848810438956324 1.721639509074386e-06 0.09780303991321163 \
1.72163958861546e-06 0.09717448010577609 1.721639668628333e-06 0.09654538840876434 1.721639759916661e-06 0.09583163072761708 1.721639841662079e-06 0.09519620281310773 \
1.721639930588917e-06 0.09450872319168514 1.721640020366224e-06 0.09381864801001834 1.721640097328872e-06 0.09323024625953365 1.721640187653689e-06 0.0925435244861572 \
1.721640251462415e-06 0.09206084550525626 1.721640323925983e-06 0.09151514907748673 1.721640388054635e-06 0.09103438864950099 1.721640466302011e-06 0.09045054736970405 \
1.721640566003292e-06 0.08971110930136832 1.721640640056444e-06 0.08916512281998501 1.721640726664979e-06 0.08852997392441805 1.721640872964685e-06 0.08746544055362569 \
1.721640983676948e-06 0.08666684197409438 1.721641093986626e-06 0.08587717033461532 1.721641236182269e-06 0.08486839672072237 1.72164137623472e-06 0.08388450488753585 \
1.721641518880534e-06 0.08289222299161547 1.721641667651249e-06 0.08186778387581196 1.721641804363935e-06 0.08093569403044946 1.721641946484565e-06 0.07997640434545976 \
1.721642081061545e-06 0.07907728405019222 1.721642221281423e-06 0.07814997945867638 1.721642369028229e-06 0.07718353387841098 1.721642518982415e-06 0.07621348085094087 \
1.721642683698247e-06 0.07516037195605636 1.721642847284363e-06 0.07412732798506308 1.721643021932716e-06 0.07303837372665309 1.721643208986408e-06 0.07188781219077654 \
1.721643418972926e-06 0.0706159374129187 1.721643637046174e-06 0.06931715807027321 1.721643870366327e-06 0.06795188046253516 1.721644124845882e-06 0.0664909822812602 \
1.72164441780254e-06 0.06484528303377844 1.721644719953089e-06 0.06318745987130532 1.721645057674792e-06 0.06138078634948794 1.721645452783393e-06 0.05932807220464856 \
1.721645820234636e-06 0.05747953410674719 1.721646237842402e-06 0.05544691527644593 1.721646582838376e-06 0.0538196438399016 1.721646933380665e-06 0.05221302159193914 \
1.721647248341029e-06 0.0508087490907442 1.721647547582395e-06 0.049508488261462 1.721647846948248e-06 0.04824029756235761 1.721648122190958e-06 0.04710512226277328 \
1.721648405654524e-06 0.04596497870754415 1.721648667254947e-06 0.04493681260994405 1.721648944707071e-06 0.04387103439794762 1.721649220766506e-06 0.04283531238677037 \
1.721649529036243e-06 0.04170718945545093 1.721649751468863e-06 0.0409114719535993 1.721650039009947e-06 0.03990505631995635 1.72165027524288e-06 0.0390969788355163 \
1.721650593704555e-06 0.03803800466874574 1.721650844115589e-06 0.03722710566490722 1.721651167100391e-06 0.03620720400565681 1.721651425436406e-06 0.03541203096995557 \
1.721651715410285e-06 0.03454066075983582 1.721651945205102e-06 0.0338658635512188 1.721652230100444e-06 0.03304787219836024 1.721652469846563e-06 0.03237513696606491 \
1.721652710481132e-06 0.03171392889024889 1.721652949599619e-06 0.03107212555077287 1.72165318553853e-06 0.03045460689686571 1.721653416367391e-06 0.02986254663395104 \
1.721653631393919e-06 0.02932175456294728 1.72165403355976e-06 0.0283374222946415 1.72165423211788e-06 0.02786401170979088 1.721654605819066e-06 0.02699470773596776 \
1.721654792632261e-06 0.02657042318767052 1.721655138633508e-06 0.02580176906824739 1.721655260576946e-06 0.02553595448027303 1.721655643429963e-06 0.02472011952872977 \
1.721655803864149e-06 0.02438657631284594 1.721656246865303e-06 0.02348572425118655 1.721656417479345e-06 0.02314627247835563 1.721656738055941e-06 0.02251902970747987 \
1.721656938340868e-06 0.0221336684630111 1.721657385278801e-06 0.02128811173678137 1.721657513222917e-06 0.02104854104185888 1.721658001100276e-06 0.02014826272243131 \
1.721658136077553e-06 0.01990454278080647 1.721658618329071e-06 0.0190640092473091 1.721658780655186e-06 0.01879235028057063 1.721659267049527e-06 0.01801148170254873 \
1.721659430077186e-06 0.01776103207540622 1.721660110298877e-06 0.01676849304257711 1.721660249382614e-06 0.01657541006259178 1.721660981877148e-06 0.01560782569993242 \
1.72166114077078e-06 0.01540693214221847 1.721661923851867e-06 0.01445869962397344 1.721662069644422e-06 0.01428952172302696 1.721662920425781e-06 0.01334248985256295 \
1.721663031529053e-06 0.01322388191882306 1.721663964823417e-06 0.0122699293983148 1.721664098661466e-06 0.01213902814618388 1.721665057199482e-06 0.01123495036716388 \
1.721665178316551e-06 0.01112486091825863 1.721666300400349e-06 0.01017270671243764 1.721666405901602e-06 0.01008921053061839 1.721667734976014e-06 0.009112307258623473 \
1.721667855180288e-06 0.009029744095492466 1.721669403542048e-06 0.008036808760534916 1.721669484329818e-06 0.007986285493236449 1.721671055209352e-06 0.007024564730313319 \
1.721671122625551e-06 0.006986095570813155 1.721673043392229e-06 0.006001386377072119 1.721673230194113e-06 0.005914747648762168 1.72167554560806e-06 0.0049318160947762 \
1.721675945134908e-06 0.004777795182599986 1.721678508944408e-06 0.003889929704329555 1.721679007815328e-06 0.003736330440833864 1.721682637539317e-06 0.002784984367379526 \
1.721683188233292e-06 0.002663729254427667 1.721688586673671e-06 0.001711392372544448 1.721688899941243e-06 0.001662511220227468 1.721693892233791e-06 0.0006970413096974805 \
1.721694076252826e-06 0.0006571176749162138 1.72434255539561e-06 -0.0002691198397987355 1.724342711454572e-06 -0.0004551674219448388 1.724343259438427e-06 -0.001322174727784445 \
1.72434337237642e-06 -0.001539785040943742 1.72434380163135e-06 -0.002474302920374066 1.724343907888515e-06 -0.002730173903076456 1.724344190690667e-06 -0.003454402452283872 \
1.72434430428521e-06 -0.003760966378165151 1.724344642839789e-06 -0.004705104513819927 1.72434475526375e-06 -0.005021586953003071 1.724345083541651e-06 -0.005887841248467669 \
1.724345191080172e-06 -0.006130875888161453 1.724346071006203e-06 -0.005789627805322099 1.72434624621225e-06 -0.004910736584223327 1.724346363043013e-06 -0.004127745010746014 \
1.724346489910137e-06 -0.00309221842859156 1.724346591442863e-06 -0.002125750314016509 1.724346712864133e-06 -0.0008095618968406578 1.724346803029046e-06 0.0002767910803854594 \
1.724346900212696e-06 0.001550247908954045 1.72434699828696e-06 0.002938803805678211 1.724347165508045e-06 0.005530627736217106 1.724347387813323e-06 0.009378371294171852 \
1.724347573551714e-06 0.01290572951649239 1.724347797633049e-06 0.01747895571448658 1.724347957277782e-06 0.02091945933227325 1.724348121767111e-06 0.02459614091902196 \
1.724348271591569e-06 0.0280452875125503 1.724348420991461e-06 0.03156498790849799 1.724348570522767e-06 0.03515592969144176 1.724348724602661e-06 0.03891669635189081 \
1.724348886786809e-06 0.0429309674228065 1.724349053210035e-06 0.0470989728378523 1.724349229143508e-06 0.05154884981278444 1.724349410271779e-06 0.05616867911875007 \
1.724349602402705e-06 0.06110225049351239 1.724349810098117e-06 0.0664648391313285 1.724350032018198e-06 0.07222051812179281 1.72435026721968e-06 0.07834079218654426 \
1.724350519405989e-06 0.08491829088081257 1.724350795545224e-06 0.09213111703448683 1.724351096666701e-06 0.1000001933597138 1.724351428586562e-06 0.1086702418150647 \
1.72435180590533e-06 0.1185147411083515 1.724352204195387e-06 0.1288888856248832 1.724352673503706e-06 0.1410822143415975 1.724353219529231e-06 0.1552200475789812 \
1.724353854489538e-06 0.1715918832733369 1.724354553890129e-06 0.1895291194622146 1.724355372129055e-06 0.2103807608661494 1.724356277823022e-06 0.2332840710921665 \
1.724357067334088e-06 0.253091928008631 1.724357771092906e-06 0.2706124241987875 1.724358388943719e-06 0.2858796548825839 1.724358954567131e-06 0.2997575097153312 \
1.724359476302405e-06 0.3124620269501652 1.724359974086121e-06 0.3244932238414255 1.724360457724081e-06 0.3360954048923613 1.724360914598215e-06 0.3469667650518959 \
1.724361387439109e-06 0.3581213589834248 1.724361827052466e-06 0.3684065070151987 1.724362314929562e-06 0.379719432411247 1.724362845729985e-06 0.3919028193132517 \
1.724363343625359e-06 0.4032143644097119 1.724363775002613e-06 0.41292177789323 1.724364261889801e-06 0.4237731225600331 1.724364761989243e-06 0.4348012155672935 \
1.724365106609934e-06 0.4423321287141763 1.724365460003778e-06 0.4500000647748709 1.724365887773617e-06 0.4592134948422093 1.724366279634688e-06 0.4675816212925634 \
1.724366579929044e-06 0.4739471552041949 1.724366921860125e-06 0.4811428413521782 1.72436726519457e-06 0.4883132334011818 1.724367525955058e-06 0.4937215836208605 \
1.724367768011588e-06 0.4987106167174703 1.724368034010056e-06 0.5041617362307154 1.724368293498239e-06 0.5094435946950286 1.72436848341454e-06 0.5132872703533161 \
1.724368698649141e-06 0.5176241792560061 1.7243688371999e-06 0.5204025546691405 1.724368982080679e-06 0.5232962183003332 1.724369195494746e-06 0.5275364624051522 \
1.72436939751936e-06 0.5315382148201082 1.724369590248024e-06 0.5353370730264509 1.724369775503404e-06 0.5389735557287745 1.724369952500928e-06 0.5424323215059959 \
1.724370261764263e-06 0.5484573594957171 1.724370522912311e-06 0.5535233414883098 1.724370824731481e-06 0.5593562770234363 1.724371080160122e-06 0.5642781701956761 \
1.724371372515619e-06 0.5698968483756405 1.724371631969813e-06 0.5748654731717864 1.72437190208979e-06 0.5800301911327002 1.724372144100348e-06 0.5846380733684551 \
1.724372401610146e-06 0.5895273573494454 1.724372628054483e-06 0.5938057549890672 1.724372864942966e-06 0.5982619499065401 1.724373074987873e-06 0.6021962733001386 \
1.724373287918585e-06 0.6061670177072124 1.724373541397282e-06 0.6108668889270118 1.724373744692931e-06 0.6146150465592417 1.724373936381114e-06 0.6181346807088086 \
1.724374125007478e-06 0.6215812235468744 1.724374312325416e-06 0.6249823889551316 1.724374517937406e-06 0.6286953279350977 1.724374767760625e-06 0.6331759959753138 \
1.724374971572403e-06 0.6368063379741715 1.724375179211121e-06 0.6404826298163093 1.724375371862737e-06 0.6438748386876914 1.72437561647481e-06 0.6481531432733096 \
1.724375864373314e-06 0.6524620620600715 1.724376044208219e-06 0.6555644139995785 1.724376234982255e-06 0.6588391718544121 1.724376388158437e-06 0.6614554104590837 \
1.724376559827147e-06 0.6643705886591137 1.724376710293968e-06 0.6669108747194671 1.724376846897971e-06 0.6692010654183506 1.724376996338372e-06 0.6716954191563786 \
1.724377124072523e-06 0.6738189269502312 1.72437726394477e-06 0.6761323074508511 1.724377388021905e-06 0.6781756764962316 1.72437751938327e-06 0.6803315871556701 \
1.724377643554731e-06 0.6823627547057004 1.724377781331592e-06 0.6846081866267727 1.724377901575812e-06 0.6865586181592046 1.724378043628417e-06 0.6888545186016138 \
1.724378143856122e-06 0.6904668682779994 1.724378265160113e-06 0.6924123325129877 1.724378356135388e-06 0.6938641504265992 1.724378453518671e-06 0.695411869780077 \
1.724378550601538e-06 0.6969507228893711 1.724378639884158e-06 0.6983595753378042 1.724378737855943e-06 0.699898781449533 1.72437886813103e-06 0.7019319515314388 \
1.724379021543255e-06 0.7043083163565919 1.724379157109067e-06 0.7063909659299702 1.724379301449562e-06 0.708591461371511 1.724379427320445e-06 0.710496752775434 \
1.724379552347831e-06 0.712376488910674 1.724379666630191e-06 0.7140841686551523 1.724379777613335e-06 0.7157331888171029 1.724379877308405e-06 0.7172065512867005 \
1.724380014352622e-06 0.7192196995505324 1.724380133379835e-06 0.7209572005600779 1.724380253677943e-06 0.7227029412191364 1.724380380176863e-06 0.7245276185835638 \
1.724380504108467e-06 0.7263044524160376 1.7243806283948e-06 0.7280754330070212 1.724380754759953e-06 0.7298652243312684 1.724380884571695e-06 0.7316925631262517 \
1.724381008410214e-06 0.7334254795816325 1.7243811411911e-06 0.735272086289578 1.724381242042306e-06 0.7366670415914529 1.724381355233975e-06 0.738224777043618 \
1.724381442019956e-06 0.7394137384482823 1.724381558645253e-06 0.7410021813026957 1.72438164793451e-06 0.7422110784210975 1.724381759111394e-06 0.7437075443329063 \
1.724381888370158e-06 0.7454347509364776 1.724382002229194e-06 0.7469455276109591 1.724382106633406e-06 0.74832188588007 1.724382231000437e-06 0.7499498655229884 \
1.724382378240616e-06 0.7518616907275563 1.724382498520907e-06 0.753411006437983 1.724382614425446e-06 0.7548933175676444 1.72438275450129e-06 0.7566706674475765 \
1.72438289711296e-06 0.7584645678799224 1.724383015067203e-06 0.7599365027959469 1.724383141883712e-06 0.7615071445339606 1.724383282766856e-06 0.7632375905494565 \
1.724383402560354e-06 0.7646969139886852 1.724383547519211e-06 0.7664484133613445 1.724383669077996e-06 0.7679052725436226 1.72438378811749e-06 0.7693214142140735 \
1.724383909748853e-06 0.7707575700077021 1.724384037717832e-06 0.772256936813787 1.724384146933014e-06 0.7735272422640712 1.724384271823892e-06 0.774969549136603 \
1.724384378939953e-06 0.7761978171588899 1.724384512193147e-06 0.7777146071439789 1.724384639296593e-06 0.7791497354387434 1.724384761047568e-06 0.7805132846941326 \
1.724384877632151e-06 0.7818078758210534 1.724384983459753e-06 0.7829735233300771 1.724385122825895e-06 0.7844949153190801 1.724385271897694e-06 0.786105286864636 \
1.724385419626362e-06 0.7876841235632186 1.72438553893224e-06 0.7889471147195867 1.724385672939052e-06 0.7903527806482344 1.724385793365227e-06 0.791604423795974 \
1.724385934910404e-06 0.7930616786923709 1.724386082336417e-06 0.7945638089648995 1.724386206810925e-06 0.7958198087139573 1.724386325854918e-06 0.7970105506108808 \
1.724386437445202e-06 0.7981174590942314 1.72438654267449e-06 0.7991530841216606 1.724386638185594e-06 0.8000862307887144 1.724386774247548e-06 0.8014036057482816 \
1.724386891123682e-06 0.8025237700417888 1.724387010277354e-06 0.8036549841722296 1.724387132589548e-06 0.8048050501807249 1.724387255861622e-06 0.8059526272620129 \
1.724387382358398e-06 0.8071184350969989 1.724387507861062e-06 0.8082633544790385 1.724387638586967e-06 0.8094437311890262 1.724387764154939e-06 0.8105658358439867 \
1.724387893209803e-06 0.8117072367686948 1.724387999065961e-06 0.8126345588578442 1.724388100234836e-06 0.8135133322873783 1.724388194854657e-06 0.8143286754242188 \
1.72438831913574e-06 0.8153900871385379 1.724388408847426e-06 0.816149614585347 1.72438850788495e-06 0.8169816577628611 1.724388645662827e-06 0.8181280288377792 \
1.724388780198677e-06 0.81923501721715 1.724388888604944e-06 0.8201180631035904 1.724389038518447e-06 0.8213254631869725 1.724389189097026e-06 0.8225223201378843 \
1.72438931459218e-06 0.8235077122548546 1.724389458438707e-06 0.8246238332260477 1.724389583021971e-06 0.8255790649890803 1.724389731875191e-06 0.8267066458678887 \
1.724389868023775e-06 0.827725029289517 1.724389993047602e-06 0.8286494160599757 1.724390110754582e-06 0.8295103773055483 1.72439025639358e-06 0.8305630309532103 \
1.724390422774875e-06 0.8317484146982921 1.724390553358565e-06 0.8326660250626342 1.724390726880675e-06 0.8338683097812621 1.724390895002578e-06 0.8350147136930499 \
1.72439106486518e-06 0.8361549927788252 1.724391245766883e-06 0.8373497079260466 1.724391388876165e-06 0.8382806519784776 1.724391502965127e-06 0.839013953006387 \
1.724391633127604e-06 0.8398410866028793 1.724391734972734e-06 0.8404811280669765 1.72439185179894e-06 0.8412075886390841 1.72439198869038e-06 0.8420483852080155 \
1.724392186497604e-06 0.843243620449199 1.724392378122751e-06 0.8443797466267589 1.724392587554618e-06 0.8455974227529048 1.7243927695013e-06 0.8466352798309468 \
1.724392966630154e-06 0.8477391449715804 1.724393139971014e-06 0.8486924050423899 1.724393322979321e-06 0.8496814535024207 1.724393494142356e-06 0.8505903669473519 \
1.724393668779451e-06 0.851501688465695 1.724393844039281e-06 0.8524001683007644 1.72439402018973e-06 0.8532872510191711 1.72439421047003e-06 0.8542278331088334 \
1.72439440106916e-06 0.8551519386507073 1.724394601692395e-06 0.8561055033533737 1.72439479430095e-06 0.8570028516027762 1.724395004981641e-06 0.8579644845832216 \
1.724395233083109e-06 0.8589827023971403 1.724395498871092e-06 0.860139640227508 1.724395797483852e-06 0.8614018215255795 1.724396073772491e-06 0.8625348754565382 \
1.72439635800901e-06 0.8636666213345715 1.72439663221378e-06 0.8647267940813509 1.724396904448638e-06 0.8657495569722869 1.72439717465278e-06 0.8667361702337206 \
1.724397431808391e-06 0.867649441901348 1.724397704388604e-06 0.8685908808535525 1.72439798037489e-06 0.8695169452638583 1.724398250477721e-06 0.870397355937691 \
1.724398550334798e-06 0.8713451925332844 1.724398921362456e-06 0.8724761722512941 1.724399216299767e-06 0.8733433185969293 1.724399470589206e-06 0.8740690226522811 \
1.724399768845991e-06 0.874895168896023 1.724400042455427e-06 0.8756299040683481 1.724400278583914e-06 0.8762466977562872 1.724400518929827e-06 0.8768585021646264 \
1.724400741263492e-06 0.8774104263690854 1.724400935269169e-06 0.8778812671168952 1.724401264991885e-06 0.8786590883967833 1.724401420165319e-06 0.8790156160651978 \
1.724401737941389e-06 0.8797272612331356 1.724401916803032e-06 0.8801171459162566 1.724402259264861e-06 0.8808425821290963 1.724402443393021e-06 0.881221400612852 \
1.724402918270754e-06 0.8821634994206867 1.724403085666965e-06 0.8824839765989225 1.724403551508905e-06 0.8833452998114757 1.724403732330958e-06 0.8836679564577563 \
1.724404226369383e-06 0.8845176198113115 1.724404367718007e-06 0.8847523712107549 1.724404974052073e-06 0.8857188576377059 1.724405126121396e-06 0.8859512996759633 \
1.724405772809558e-06 0.8868983431897121 1.72440590110417e-06 0.8870786909355212 1.724406549221232e-06 0.8879538337624689 1.724406679020295e-06 0.8881220828502663 \
1.724407457223772e-06 0.8890807033877333 1.724407572278734e-06 0.8892148977954012 1.724408427940206e-06 0.8901543051721961 1.724408573301076e-06 0.8903040038307473 \
1.724409559057127e-06 0.8912446482480114 1.724409780162496e-06 0.8914382978987679 1.724410925289423e-06 0.8923659558950503 1.724411056506439e-06 0.8924678262926897 \
1.724412397715013e-06 0.8934599079028542 1.724412549114272e-06 0.8935646301988298 1.724414030551995e-06 0.8944937559627255 1.724414269431373e-06 0.8946275407274444 \
1.724416038746979e-06 0.8955013787854181 1.724416427898191e-06 0.8956696032899972 1.724418821561142e-06 0.8965547188539188 1.72441929727014e-06 0.8967039926079825 \
1.72442336043021e-06 0.8977020505850396 1.724423851854269e-06 0.8977948037134476 1.724432168453822e-06 0.898787348739254 1.72443308835295e-06 0.8988506593152591 \
1.72457657358348e-06 0.8998476076348748 1.724577692016456e-06 0.8998537475785264 1.724782783635956e-06 0.898985773748599 1.724783010725457e-06 0.8988224379910277 \
1.724784620332255e-06 0.8978282360369357 1.724784797740799e-06 0.8977338482811539 1.7248017048891e-06 0.8987315468430059 1.724801814328198e-06 0.8987460089186867 \
1.724817595049444e-06 0.8997418097871094 1.724817891375339e-06 0.8997476966799167 1.725301325027745e-06 0.9007060148833608 1.725301454078085e-06 0.9008313386292994 \
1.72530210422793e-06 0.9016292186224167 1.725302293723661e-06 0.9019133038041363 1.72530279694564e-06 0.9027675859898705 1.725302932418299e-06 0.9030208676018907 \
1.725303332877016e-06 0.9038195223753869 1.725303464814953e-06 0.9040958310886574 1.725303866030017e-06 0.9049509627747726 1.725303964290194e-06 0.9051582028152527 \
1.725304430164004e-06 0.9060587574877488 1.725304591662727e-06 0.9063060456044927 1.72530573567525e-06 0.9055153668657776 1.725305880654596e-06 0.9049059606760256 \
1.725306059207354e-06 0.9039396653125833 1.725306239402631e-06 0.9027054491383806 1.725306382093561e-06 0.9015369228101149 1.725306499253165e-06 0.9004524619440171 \
1.725306588234525e-06 0.8995505656965809 1.725306679878178e-06 0.8985529714258781 1.72530681299011e-06 0.8969831049011855 1.725306906711193e-06 0.8957895978311226 \
1.725306997850002e-06 0.8945634483845346 1.725307111142313e-06 0.8929516940777753 1.725307214251226e-06 0.8913998138690341 1.725307310518406e-06 0.8898830246517148 \
1.725307429655523e-06 0.8879200664089764 1.725307598240772e-06 0.8849885378698126 1.725307760012273e-06 0.8820195265790133 1.725307953231332e-06 0.8782956415026882 \
1.725308138794443e-06 0.8745571577041361 1.725308349060748e-06 0.8701566079887386 1.725308531309788e-06 0.8662213066841463 1.725308716173183e-06 0.8621339172744639 \
1.72530888885833e-06 0.8582419637438897 1.725309074966403e-06 0.8539816046497358 1.725309252782491e-06 0.849858603441091 1.725309433499072e-06 0.8456251963850057 \
1.725309598637331e-06 0.8417258760277182 1.725309763911433e-06 0.837798995916667 1.725309927159096e-06 0.8339004324287677 1.725310085749369e-06 0.8300982805770993 \
1.725310262673771e-06 0.8258418712800655 1.725310459187584e-06 0.8211009660847696 1.725310626744125e-06 0.8170498602679914 1.725310793484544e-06 0.8130123908857781 \
1.725310967908062e-06 0.8087844286215062 1.725311137277684e-06 0.8046757316210446 1.725311305476779e-06 0.8005936994537799 1.725311494325046e-06 0.7960093488074458 \
1.725311685140882e-06 0.7913773844868103 1.725311893523092e-06 0.7863203192056716 1.725312119942597e-06 0.7808277108969495 1.725312309142794e-06 0.7762391340290878 \
1.725312519289483e-06 0.7711455503222944 1.725312668057987e-06 0.7675418410361046 1.725312799050976e-06 0.7643705172588006 1.725312936616212e-06 0.7610417440783073 \
1.725313042367441e-06 0.7584842184275663 1.725313177141075e-06 0.7552262509102785 1.7253132889738e-06 0.7525244432456109 1.725313418408964e-06 0.7493992292091655 \
1.725313573597688e-06 0.7456545577979357 1.725313685233441e-06 0.7429626190147979 1.725313844808055e-06 0.7391166470929011 1.725314020129688e-06 0.7348935218456193 \
1.725314232505151e-06 0.7297828120356423 1.725314425387679e-06 0.7251458607116523 1.725314582088971e-06 0.7213823872711312 1.725314768763662e-06 0.716903961299824 \
1.725314957650011e-06 0.7123775767926828 1.725315148534203e-06 0.70780884692282 1.725315335282138e-06 0.7033444557767304 1.725315518366954e-06 0.698972331957095 \
1.725315655685935e-06 0.6956951921588121 1.725315808928892e-06 0.6920418367118417 1.725316004057543e-06 0.6873949992893974 1.725316161351872e-06 0.6836535194673684 \
1.725316320746467e-06 0.6798660670227984 1.72531651649026e-06 0.6752219404489795 1.725316708689394e-06 0.6706682621108646 1.725316943641022e-06 0.6651105611269369 \
1.72531713111727e-06 0.6606839627962382 1.725317368354404e-06 0.6550894036851447 1.725317557534366e-06 0.6506361170423679 1.725317738150179e-06 0.6463915264929231 \
1.725317901844741e-06 0.6425504277539856 1.72531804639615e-06 0.6391628119244788 1.72531818686792e-06 0.6358764726647652 1.725318313968707e-06 0.6329064225879303 \
1.725318446276184e-06 0.6298198307262635 1.72531857286323e-06 0.626870110582017 1.725318703443498e-06 0.62383130535404 1.725318832712897e-06 0.6208285625908692 \
1.725318971819793e-06 0.6176004736356133 1.725319120330103e-06 0.6141606483517721 1.725319309878658e-06 0.6097777958748198 1.725319455581914e-06 0.6064170107178907 \
1.725319690632478e-06 0.601007464699683 1.725319873631749e-06 0.5968099615921 1.725320097973423e-06 0.5916778694808832 1.725320269146672e-06 0.5877753019413697 \
1.725320401480491e-06 0.5847634284691802 1.72532053327703e-06 0.5817721407249107 1.725320639820933e-06 0.5793579518205488 1.725320735711292e-06 0.5771868999037388 \
1.725320828211542e-06 0.5750974572268882 1.725320920638905e-06 0.5730134868920421 1.725320993067211e-06 0.5713818265150021 1.725321048796317e-06 0.5701269325864891 \
1.725321109905405e-06 0.5687522410723198 1.72532120667008e-06 0.5665806864277688 1.725321268161594e-06 0.5652027770813386 1.725321327214216e-06 0.5638802801505602 \
1.725321402840882e-06 0.5621878686488651 1.72532146986366e-06 0.5606896577364279 1.72532154346077e-06 0.5590483558003441 1.725321611066772e-06 0.5575429304381756 \
1.725321727135829e-06 0.5549610936632026 1.725321827342234e-06 0.5527359403974305 1.725321939349424e-06 0.5502565947066531 1.725322033841475e-06 0.5481686943853854 \
1.725322154996172e-06 0.5454955387196141 1.725322255183939e-06 0.5432910220514219 1.725322371174451e-06 0.5407443765731218 1.725322478878288e-06 0.5383833065966291 \
1.725322588456977e-06 0.5359861028148916 1.725322700578421e-06 0.5335400310751951 1.725322827515605e-06 0.5307765704644959 1.725322949665123e-06 0.5281221248815906 \
1.725323089426038e-06 0.525095489155881 1.725323226564154e-06 0.522132778766487 1.725323376529244e-06 0.5189020692106626 1.725323535302247e-06 0.5154923220538846 \
1.725323709327904e-06 0.511765695450105 1.725323896158028e-06 0.5077823379664483 1.725324101125993e-06 0.5034264211640872 1.725324323834942e-06 0.4987133299464507 \
1.725324576739139e-06 0.4933874474923696 1.725324811693046e-06 0.4884604410272814 1.725325107961308e-06 0.4822828691822955 1.725325397751266e-06 0.4762763831984252 \
1.725325704087085e-06 0.4699660956099861 1.725326016405612e-06 0.4635767846525711 1.725326354971068e-06 0.4566963260653934 1.725326678082485e-06 0.4501741115777416 \
1.725327016477788e-06 0.4433881855507311 1.725327340309053e-06 0.4369378830387565 1.725327664703474e-06 0.4305204627449936 1.72532800763776e-06 0.4237851826852676 \
1.725328346918578e-06 0.4171698123421442 1.725328686393212e-06 0.4105997181257849 1.725329129505058e-06 0.4020958655332711 1.725329491573227e-06 0.3952155038183801 \
1.725329812124964e-06 0.3891775711374149 1.725330199059534e-06 0.3819561902961204 1.725330526929795e-06 0.3758957719299574 1.725330812088851e-06 0.3706704968427373 \
1.725331130457646e-06 0.3648820026298218 1.725331413288573e-06 0.3597820188690578 1.725331641977337e-06 0.3556924369094372 1.725331859870142e-06 0.3518226517641353 \
1.725332055119486e-06 0.3483769517668343 1.725332262027586e-06 0.344751588202948 1.725332476824342e-06 0.3410137651016431 1.725332729050892e-06 0.3366564674340092 \
1.725332971046205e-06 0.3325077909124976 1.725333201898484e-06 0.3285822460490526 1.725333416746675e-06 0.3249550452085373 1.725333637103364e-06 0.3212604562488142 \
1.725333838674264e-06 0.3179050685021769 1.72533404175821e-06 0.3145531374773136 1.725334239655597e-06 0.3113121771742085 1.725334426754836e-06 0.3082694484595072 \
1.725334620655179e-06 0.3051385396431291 1.725334825703514e-06 0.3018527636900292 1.725335005938266e-06 0.2989872106339772 1.725335241836277e-06 0.2952669081535775 \
1.725335443123827e-06 0.2921198200609627 1.725335644514631e-06 0.2889965001417216 1.725335869163794e-06 0.2855437159941698 1.725336034543768e-06 0.2830223598911593 \
1.725336212348105e-06 0.280330186126118 1.725336396004319e-06 0.277570343839212 1.725336581246076e-06 0.2748090658167894 1.725336759391454e-06 0.2721781298892599 \
1.725336932983517e-06 0.2696316866093095 1.72533709334837e-06 0.267306655456324 1.725337214459553e-06 0.2655585721882695 1.725337367654341e-06 0.2633570345323199 \
1.725337494985789e-06 0.2615475749425888 1.725337598313628e-06 0.2600830587034867 1.725337715638424e-06 0.2584225376281647 1.725337833445381e-06 0.2567591557214636 \
1.725337957409147e-06 0.2550199666844239 1.725338074393314e-06 0.2533821414201824 1.725338205189442e-06 0.2515535495016885 1.725338322399552e-06 0.2499173892700276 \
1.725338475652677e-06 0.2477853623028658 1.725338611183197e-06 0.2459029165157107 1.725338742864406e-06 0.244074199323236 1.725338899457317e-06 0.2419017673596028 \
1.725339024653875e-06 0.2401755227310949 1.725339160371501e-06 0.2383060149301216 1.725339292798663e-06 0.2364844144139329 1.725339412772324e-06 0.2348355337769661 \
1.725339575820161e-06 0.232606585912384 1.725339714627252e-06 0.230713852557009 1.725339853100972e-06 0.2288300961780371 1.725339958645721e-06 0.2273962817971701 \
1.725340087007401e-06 0.2256537837490921 1.725340191135024e-06 0.2242444877898851 1.725340291651026e-06 0.222886569499566 1.725340366695402e-06 0.2218745444235658 \
1.725340444028458e-06 0.2208349692306942 1.725340518791637e-06 0.2198305887827458 1.725340596755314e-06 0.218785487158918 1.725340651621824e-06 0.2180503923904892 \
1.7253407081186e-06 0.2172938400168352 1.725340751572119e-06 0.2167123195211523 1.725340791613165e-06 0.2161767335077376 1.725340830852113e-06 0.2156521099473339 \
1.72534087172635e-06 0.2151058606261434 1.72534092587884e-06 0.2143825797409383 1.725340964295971e-06 0.2138698309421548 1.725341003584678e-06 0.2133480458229882 \
1.725341065121386e-06 0.2125332203444249 1.725341127098915e-06 0.2117131287842428 1.725341183575664e-06 0.2109664019951111 1.725341248207255e-06 0.2101124842966758 \
1.725341343715876e-06 0.2088522205996687 1.725341431031607e-06 0.207701294711168 1.725341527641208e-06 0.2064291756790013 1.725341624870762e-06 0.2051510266126755 \
1.725341725717823e-06 0.2038307158897115 1.725341826317594e-06 0.2025192706911573 1.725341922808891e-06 0.2012627769767186 1.725342024991065e-06 0.1999338657614989 \
1.725342128630721e-06 0.1985898465970496 1.725342238404734e-06 0.1971698847140261 1.72534234757976e-06 0.1957617939809042 1.725342467677852e-06 0.1942174441246506 \
1.725342577697376e-06 0.1928086337505992 1.725342685809285e-06 0.1914295694688549 1.725342808837984e-06 0.1898652723262108 1.725342898948554e-06 0.1887234630454603 \
1.725343006314044e-06 0.1873671680421656 1.725343083125353e-06 0.1864004060894758 1.725343166570621e-06 0.1853535952511875 1.725343256102432e-06 0.1842338297700716 \
1.725343340667899e-06 0.1831790839553313 1.725343420384039e-06 0.1821880912968773 1.725343521709242e-06 0.1809331989518758 1.725343630056471e-06 0.1795959386230563 \
1.725343726532169e-06 0.1784102562612937 1.725343851909986e-06 0.1768766438339704 1.725343984693456e-06 0.1752616821119887 1.725344102464279e-06 0.1738362801839788 \
1.725344248115856e-06 0.1720835746408261 1.725344358713008e-06 0.1707596463148658 1.725344500843447e-06 0.1690680578777541 1.72534461655307e-06 0.1676985735146403 \
1.725344722027083e-06 0.166456424915798 1.725344816543742e-06 0.1653485352650968 1.725344912181115e-06 0.1642320043563913 1.725345009252958e-06 0.1631032360400927 \
1.725345108304212e-06 0.161956192050434 1.725345202227769e-06 0.1608730077890209 1.725345287503444e-06 0.1598934595213354 1.725345387883236e-06 0.1587475631033795 \
1.725345472186073e-06 0.1577906478848196 1.725345574585582e-06 0.1566342854655733 1.725345651979844e-06 0.1557646215197878 1.725345744324758e-06 0.154731814591042 \
1.72534581457623e-06 0.1539498814072817 1.725345910750659e-06 0.1528844393027091 1.725345987575322e-06 0.152038051282755 1.725346066345474e-06 0.1511758489440315 \
1.725346140238395e-06 0.150370438825067 1.725346207936138e-06 0.1496353997608715 1.725346304000026e-06 0.1485973848112393 1.725346373572453e-06 0.1478489919002561 \
1.725346457461625e-06 0.1469503328160803 1.725346518593461e-06 0.146298213254472 1.725346590861543e-06 0.1455309799806117 1.725346663300106e-06 0.1447677488542132 \
1.725346744281147e-06 0.1439178685120187 1.725346810355616e-06 0.1432275520600639 1.725346887756114e-06 0.1424219220725307 1.725346977131571e-06 0.1414956876531561 \
1.725347047992216e-06 0.1407644282175171 1.725347146879283e-06 0.1397487730030469 1.725347224198192e-06 0.1389620820751095 1.725347306243418e-06 0.1381330876879582 \
1.72534739435453e-06 0.1372467208126059 1.725347461981677e-06 0.1365690714953818 1.725347542278859e-06 0.1357674830239305 1.725347617062888e-06 0.1350239185327315 \
1.725347685064065e-06 0.1343502586094245 1.725347731746974e-06 0.1338891847862563 1.725347820998567e-06 0.1330118383700247 1.725347859221617e-06 0.1326395291833771 \
1.725347928213527e-06 0.1319690872918072 1.725347980961596e-06 0.1314578750898332 1.725348063954378e-06 0.1306559489775353 1.725348104132829e-06 0.1302688434457458 \
1.725348196650203e-06 0.1293805059784019 1.72534823536857e-06 0.1290098403727171 1.725348309129285e-06 0.1283055160094505 1.725348370757287e-06 0.1277188748199021 \
1.725348442784976e-06 0.1270353589407805 1.725348510952008e-06 0.1263909833196726 1.725348585574169e-06 0.1256908956540175 1.725348667426635e-06 0.1249253613889138 \
1.725348750880797e-06 0.124147338931438 1.725348823832511e-06 0.1234692772477456 1.725348896559441e-06 0.122795332839617 1.725348956549435e-06 0.1222410931008323 \
1.725349042917447e-06 0.121445549533078 1.725349103886165e-06 0.1208856452315438 1.725349162271955e-06 0.1203507897957366 1.72534922790662e-06 0.119751336354628 \
1.725349287260861e-06 0.1192111367930785 1.725349355292642e-06 0.1185941868697126 1.725349452587012e-06 0.11771710490035 1.725349531078992e-06 0.1170124163111649 \
1.725349621315123e-06 0.1162055395685231 1.725349717161808e-06 0.1153523005684616 1.725349792119505e-06 0.1146878351828532 1.725349896478921e-06 0.1137670532163148 \
1.725349983267518e-06 0.1130053589403202 1.725350092924934e-06 0.1120476726212376 1.725350174478997e-06 0.1113387926087848 1.725350270092629e-06 0.1105114393564785 \
1.725350346804822e-06 0.10985058581598 1.725350441723287e-06 0.1090364400125625 1.725350517546392e-06 0.1083889268999046 1.725350595246049e-06 0.1077282965354292 \
1.7253506775775e-06 0.1070311517075373 1.725350737142764e-06 0.1065286079538068 1.725350800900501e-06 0.1059924133642201 1.725350861995109e-06 0.1054803128126646 \
1.725350957858847e-06 0.1046801683739134 1.725351002721942e-06 0.1043071445723913 1.725351085962687e-06 0.1036173314376927 1.725351135082509e-06 0.1032117000904133 \
1.725351244131271e-06 0.1023149933518279 1.725351288967353e-06 0.1019479364619093 1.725351379228585e-06 0.1012117400678687 1.725351420105203e-06 0.1008795969612472 \
1.725351490563617e-06 0.1003088525914566 1.725351576851038e-06 0.09961307626065434 1.725351668628597e-06 0.09887705578174606 1.72535173815669e-06 0.09832225024344161 \
1.725351816683849e-06 0.09769854072774181 1.725351907412525e-06 0.09698178745350861 1.725351983228664e-06 0.09638605854785212 1.725352065241407e-06 0.09574500473888557 \
1.725352146994443e-06 0.09510943278387665 1.725352237502267e-06 0.09440967388330095 1.725352327061564e-06 0.09372126988887708 1.725352412671398e-06 0.09306698857649189 \
1.725352505450896e-06 0.09236212353634379 1.725352586338857e-06 0.0917510971760913 1.725352687467827e-06 0.09099177263830999 1.725352767961352e-06 0.09039108594384238 \
1.725352852204218e-06 0.08976589684797046 1.725352926049265e-06 0.08922077348043934 1.725353002898743e-06 0.08865632925481931 1.725353091039112e-06 0.08801255002475737 \
1.725353171103481e-06 0.08743108261130086 1.725353264139672e-06 0.08675939571108145 1.725353382140385e-06 0.08591369538214398 1.725353524513612e-06 0.08490278100234279 \
1.725353668761962e-06 0.08388867104764453 1.725353811089671e-06 0.08289807427203813 1.725353960667415e-06 0.08186746790234835 1.725354096981161e-06 0.08093761126893445 \
1.725354239101592e-06 0.0799778356000513 1.72535437365502e-06 0.07907840240745091 1.72535451400773e-06 0.07814980287393705 1.725354661689802e-06 0.0771833418413561 \
1.725354811805299e-06 0.07621180464723754 1.725354976525776e-06 0.07515824360926991 1.725355140155128e-06 0.07412455432658185 1.725355314933688e-06 0.07303438636984133 \
1.725355502186304e-06 0.07188220095900363 1.725355712231308e-06 0.07060976590783831 1.725355930441531e-06 0.06930979572898451 1.72535616389862e-06 0.06794333957253913 \
1.725356418744638e-06 0.06648001693367038 1.725356711839195e-06 0.06483321328442151 1.725357014178957e-06 0.06317411115207273 1.725357328765833e-06 0.06148945259513613 \
1.725357725026527e-06 0.05942677493938087 1.725358058743672e-06 0.05774249301432461 1.725358466054501e-06 0.05574994498853819 1.72535879393926e-06 0.05419380357502902 \
1.725359150629899e-06 0.05254809000207299 1.72535946386806e-06 0.05114243792209583 1.725359766835193e-06 0.04981740498512215 1.725360064375718e-06 0.04854875663330436 \
1.725360343155274e-06 0.04739109061078805 1.725360626155169e-06 0.04624570307560639 1.725360887895477e-06 0.04521055793698023 1.72536116713437e-06 0.04413130357485813 \
1.72536143924029e-06 0.0431040186124033 1.725361746607047e-06 0.04197194005652995 1.725361968409948e-06 0.04117329707315532 1.725362274870428e-06 0.04009446155587663 \
1.725362501059881e-06 0.03931650950691581 1.725362739977206e-06 0.03851359500741255 1.725362964401039e-06 0.03777663690506906 1.72536316666332e-06 0.03712468825868943 \
1.725363367705949e-06 0.03648814235703791 1.725363719479983e-06 0.03540095449820539 1.725363969725821e-06 0.03464776841732944 1.725364216044101e-06 0.03392252499723709 \
1.725364497376965e-06 0.03311308780599518 1.72536474046795e-06 0.03242954897046491 1.725364975941701e-06 0.03178112583711486 1.725365217601206e-06 0.03113119522156456 \
1.725365454483484e-06 0.03050988948014832 1.725365685016041e-06 0.02991733361391674 1.725365898984568e-06 0.02937801894285819 1.725366104927116e-06 0.02886851641492237 \
1.725366497651603e-06 0.02792196059063811 1.725366685729283e-06 0.02747992420741849 1.725367061168249e-06 0.02661861215736662 1.725367236042477e-06 0.02622659266649364 \
1.725367659365491e-06 0.02530049759795254 1.725367780614875e-06 0.02504150687334681 1.725368221176528e-06 0.02412433837770948 1.725368363674648e-06 0.02383402682615681 \
1.725368695728157e-06 0.02316883068419595 1.725368878693682e-06 0.02280879143785283 1.725369267997886e-06 0.02205689891561978 1.725369436343594e-06 0.02173705378531499 \
1.725369908457993e-06 0.02085107653961301 1.725370048202727e-06 0.0205916297664938 1.725370543782805e-06 0.01969297428531048 1.725370671008237e-06 0.01946923320191776 \
1.725371238917342e-06 0.01851512288677271 1.72537140317129e-06 0.0182513999453204 1.725372013043028e-06 0.0173209960017622 1.725372172728257e-06 0.01708922829277545 \
1.725372699639798e-06 0.01635462467776483 1.725372904157091e-06 0.01608193551804103 1.725373627634478e-06 0.01515939662837778 1.72537379307661e-06 0.01495683325581705 \
1.725374539636356e-06 0.01408081084911163 1.725374672939569e-06 0.01393008075245666 1.725375533124155e-06 0.01299799962960837 1.72537566920557e-06 0.01285670227674402 \
1.725376609799459e-06 0.01192267652923807 1.725376773572533e-06 0.01176632439256516 1.725377774751464e-06 0.01084959205883911 1.725377912229187e-06 0.01072929995296418 \
1.725379082926798e-06 0.009787962024485789 1.725379175323166e-06 0.009718668544398181 1.725380593399014e-06 0.008725931027897449 1.725380680375162e-06 0.00866912727384293 \
1.725382221370793e-06 0.00770199130002063 1.725382330686807e-06 0.007633428668288294 1.725383973934629e-06 0.006673746291950173 1.725384106791908e-06 0.006603544020797993 \
1.725386201172206e-06 0.005605323336654431 1.725386409576941e-06 0.00551468736035817 1.725388763913366e-06 0.004577307911602986 1.725389237472123e-06 0.004407121484391641 \
1.725392122908979e-06 0.003492041675788492 1.725392652573326e-06 0.00334538389506189 1.725396860800552e-06 0.00237996320858989 1.725397374234803e-06 0.002283557532494709 \
1.725403133485495e-06 0.001325291758975802 1.725403368066713e-06 0.001279502680325907 1.725418035894088e-06 0.0002809017338477542 1.72541814896418e-06 0.0002788534805396912 \
1.72805516904393e-06 -0.0006849217749926401 1.728055335205606e-06 -0.0009443270389602415 1.728055814074993e-06 -0.001850320037528519 1.72805590679462e-06 -0.002050462221988249 \
1.728056272019697e-06 -0.002913187630468476 1.728056363676814e-06 -0.00314709230904735 1.728056729783165e-06 -0.004133001189868674 1.728056839930291e-06 -0.004442309109773816 \
1.728057150668543e-06 -0.005311341427314526 1.728057252407188e-06 -0.005583925258601597 1.728057616111313e-06 -0.00638370916272213 1.728057780957636e-06 -0.006585924750287024 \
1.728058360754957e-06 -0.005792290386912202 1.728058535589415e-06 -0.004916934050781314 1.728058652279015e-06 -0.00413641027497409 1.728058778708708e-06 -0.00310656561120747 \
1.728058880730911e-06 -0.002137079422087956 1.728059000577393e-06 -0.0008406209844352954 1.728059091214629e-06 0.0002489246187367611 1.728059189634679e-06 0.001536790859923857 \
1.728059289358324e-06 0.002948496343048522 1.728059456842332e-06 0.005545701385567424 1.728059675420934e-06 0.009327395936412004 1.728059861491256e-06 0.0128572688386996 \
1.728060082873864e-06 0.01737012273305725 1.728060243533997e-06 0.02082840415615294 1.728060406999647e-06 0.02447866954313523 1.728060557635164e-06 0.02794359528291388 \
1.728060706690917e-06 0.03145289236167962 1.728060856153671e-06 0.03504014479003619 1.728061010184684e-06 0.03879791952579481 1.728061172300943e-06 0.04280891157365373 \
1.728061338330408e-06 0.04696567134311741 1.728061514283228e-06 0.05141478668696391 1.728061694953866e-06 0.05602187592747932 1.728061886774812e-06 0.06094655248807559 \
1.728062093880316e-06 0.06629309753158302 1.728062315452046e-06 0.07203901748582854 1.728062550186215e-06 0.07814662931008168 1.728062801725783e-06 0.08470684589377442 \
1.728063077167849e-06 0.09190125212984442 1.728063377363668e-06 0.09974607960254324 1.728063708295878e-06 0.108390578238945 1.728064083962612e-06 0.1181923833971668 \
1.72806448154548e-06 0.1285487285136021 1.728064948370082e-06 0.1406786766767902 1.728065491362617e-06 0.1547396794802719 1.72806612478764e-06 0.1710742296429572 \
1.728066820727691e-06 0.1889259607126788 1.7280676362848e-06 0.2097135943149445 1.728068546312904e-06 0.2327316641523666 1.728069339569124e-06 0.2526372689279454 \
1.7280700450442e-06 0.2702038474981599 1.728070663988468e-06 0.2855008995781749 1.728071231094408e-06 0.2994177966724069 1.728071754174414e-06 0.3121574438576628 \
1.728072253153207e-06 0.3242197130846058 1.728072737193214e-06 0.3358335658028451 1.728073192420047e-06 0.3466679577370423 1.728073666932009e-06 0.3578644504627745 \
1.728074106840717e-06 0.368158604789619 1.728074592685345e-06 0.3794271463718566 1.728075124288118e-06 0.3916316501999784 1.728075626951417e-06 0.4030538969706937 \
1.72807605602367e-06 0.4127111343288326 1.728076547040338e-06 0.4236561147984291 1.728077048470419e-06 0.434714731975362 1.728077395015009e-06 0.442288187401736 \
1.728077750424386e-06 0.4500000616404133 1.728078177652114e-06 0.4592019891792938 1.728078569851637e-06 0.4675774400278049 1.728078870233395e-06 0.4739448723400065 \
1.728079212045155e-06 0.4811381049525967 1.728079555484969e-06 0.4883107756756314 1.728079816220095e-06 0.4937186470393492 1.728080058250048e-06 0.4987071765458648 \
1.728080324195292e-06 0.5041573145298286 1.728080581464587e-06 0.509394255416739 1.72808077158369e-06 0.5132422368582924 1.728080985109851e-06 0.5175451019736222 \
1.728081124800157e-06 0.5203466115392713 1.728081271000449e-06 0.5232668091041763 1.72808148498835e-06 0.5275186200231483 1.72808169300461e-06 0.5316389396023125 \
1.728081885465879e-06 0.5354321131715788 1.72808207058211e-06 0.5390651926504321 1.728082244955557e-06 0.5424725330931349 1.728082549497633e-06 0.5484058192982523 \
1.728082810056515e-06 0.5534602958276967 1.728083111487545e-06 0.5592859190791987 1.728083365805138e-06 0.5641865993769294 1.728083658661328e-06 0.5698153316805189 \
1.72808391787448e-06 0.5747800306938655 1.728084188950812e-06 0.579963273174682 1.728084430794571e-06 0.5845680738798381 1.728084688299729e-06 0.5894577538325241 \
1.728084915043605e-06 0.5937419314630586 1.728085152044424e-06 0.5982006324572362 1.728085362230986e-06 0.6021379329905048 1.72808557499152e-06 0.6061060319396779 \
1.728085827870286e-06 0.6107954169450593 1.728086031533554e-06 0.6145509252949414 1.728086222250936e-06 0.6180531102377972 1.728086409587374e-06 0.6214768531423983 \
1.728086598465652e-06 0.6249070011644339 1.728086806665447e-06 0.6286671070650327 1.728087050997562e-06 0.6330499453121026 1.728087250564095e-06 0.6366057789565548 \
1.728087454709836e-06 0.6402215701419991 1.72808763934909e-06 0.643474671963314 1.728087908884781e-06 0.6481901084955864 1.728088136591637e-06 0.652149230294136 \
1.728088324263375e-06 0.6553888277830079 1.72808850516352e-06 0.6584949378977958 1.728088664704602e-06 0.661221510907812 1.728088835167002e-06 0.6641177016088209 \
1.728088986918443e-06 0.6666817235716488 1.728089124561455e-06 0.6689905419339194 1.728089273556319e-06 0.6714784915997724 1.728089401298182e-06 0.6736028790357499 \
1.728089544284695e-06 0.675968899142866 1.728089666067751e-06 0.6779749688503388 1.728089802351161e-06 0.6802121872853304 1.728089922180063e-06 0.682172759947357 \
1.728090068775623e-06 0.6845626218370968 1.728090187248565e-06 0.6864845934661837 1.728090283181927e-06 0.6880368302455475 1.728090375701511e-06 0.6895284278106264 \
1.728090480762022e-06 0.6912169000724893 1.728090578843908e-06 0.6927871490736753 1.728090715959225e-06 0.6949707622226827 1.728090835157868e-06 0.6968607547931925 \
1.728090945097838e-06 0.6985951241089645 1.728091082597081e-06 0.7007503743809057 1.728091214026983e-06 0.7027960765825516 1.728091346256499e-06 0.7048392108129343 \
1.728091459433897e-06 0.7065756917706891 1.728091613866752e-06 0.708927873976708 1.728091744646745e-06 0.7109048231498766 1.728091867315455e-06 0.7127465601965561 \
1.728091973583711e-06 0.7143329262278221 1.728092095963735e-06 0.7161490373358268 1.728092197817232e-06 0.7176517022913665 1.728092331955131e-06 0.7196190116794019 \
1.728092452648172e-06 0.7213783352064487 1.72809257178997e-06 0.7231049829175343 1.728092696807985e-06 0.7249059312823601 1.728092826647791e-06 0.7267645120560844 \
1.728092946459962e-06 0.7284691779696002 1.728093075453213e-06 0.730293808329565 1.728093207560277e-06 0.7321507998840678 1.728093325866095e-06 0.7338038328985433 \
1.728093469126786e-06 0.7357927618453034 1.728093571581473e-06 0.7372070005703254 1.728093667788359e-06 0.7385290937783453 1.72809377280598e-06 0.7399656334130889 \
1.728093883577511e-06 0.7414708009413548 1.728093985256052e-06 0.7428439364018735 1.728094088217507e-06 0.7442258341871242 1.72809420514366e-06 0.7457850038572696 \
1.728094333903936e-06 0.747489965072781 1.728094435062908e-06 0.7488201182152049 1.728094583931952e-06 0.7507626302114226 1.728094731611489e-06 0.75267249971878 \
1.728094850976855e-06 0.7542038164026367 1.7280949974607e-06 0.7560679527984652 1.72809512063619e-06 0.7576223900169708 1.728095261439865e-06 0.7593848990234215 \
1.728095398032531e-06 0.7610800595258669 1.728095520190381e-06 0.7625841275516777 1.728095632846779e-06 0.7639610711610054 1.72809577457292e-06 0.7656796138775311 \
1.72809590073942e-06 0.767196844592689 1.728096016156724e-06 0.768574452686535 1.728096146464904e-06 0.7701179991486644 1.728096262177572e-06 0.7714782821591826 \
1.72809638500186e-06 0.7729116492687436 1.728096502846128e-06 0.7742769236963016 1.728096608476118e-06 0.7754922619072108 1.728096723849553e-06 0.7768108638983861 \
1.728096829112716e-06 0.7780056027231214 1.728096940062529e-06 0.7792565499870431 1.72809702646703e-06 0.7802246528436213 1.728097130500851e-06 0.7813823422463088 \
1.728097244396594e-06 0.7826398494046257 1.728097347430013e-06 0.7837684443710583 1.728097455512714e-06 0.7849432998269023 1.72809756376437e-06 0.7861107422109641 \
1.728097699181616e-06 0.7875582910536544 1.728097811855724e-06 0.7887521292973186 1.728097936279784e-06 0.7900592323105087 1.728098054252648e-06 0.7912877959129118 \
1.728098198720603e-06 0.7927781272271259 1.728098316389742e-06 0.7939806363584788 1.728098452269581e-06 0.7953567374150946 1.728098587013954e-06 0.7967081403609936 \
1.728098698084933e-06 0.7978123285366109 1.728098797974273e-06 0.7987978371087655 1.728098899654231e-06 0.7997937268659365 1.728099032867897e-06 0.8010867894381996 \
1.728099151240716e-06 0.8022243628210853 1.72809927278179e-06 0.8033812848148773 1.728099392145442e-06 0.8045065422543012 1.728099513276819e-06 0.80563739819571 \
1.728099644976236e-06 0.8068544426691319 1.728099767984513e-06 0.8079795872959963 1.72809989582812e-06 0.8091371804586788 1.72810002673464e-06 0.8103101881504271 \
1.728100150327798e-06 0.8114062915203997 1.728100257500303e-06 0.8123479140825919 1.728100364929502e-06 0.8132835730547656 1.72810044759862e-06 0.8139979974227743 \
1.72810056531038e-06 0.8150069815425507 1.728100655915986e-06 0.8157770472204025 1.728100786569431e-06 0.8168774959419571 1.728100930959301e-06 0.8180800468042847 \
1.728101064133715e-06 0.8191766687328477 1.728101174025106e-06 0.8200725423139092 1.728101317623991e-06 0.8212302325252553 1.728101471014683e-06 0.8224508494407716 \
1.728101599092908e-06 0.8234574467428303 1.728101738880276e-06 0.8245431382086058 1.728101865129839e-06 0.8255122018650548 1.728102019728392e-06 0.8266841987320058 \
1.728102151939368e-06 0.8276738265999063 1.728102278166151e-06 0.8286078934539939 1.728102395913874e-06 0.8294698388787296 1.728102544986668e-06 0.8305480062617677 \
1.72810271231822e-06 0.8317406852496945 1.728102845539497e-06 0.8326770812274722 1.72810301832082e-06 0.8338744310092966 1.728103186826193e-06 0.8350236380668206 \
1.728103356205492e-06 0.8361608866600232 1.728103537840761e-06 0.8373606451951652 1.728103680174083e-06 0.8382866867625347 1.728103794011069e-06 0.8390185116470331 \
1.728103925192579e-06 0.8398522525089582 1.728104026724794e-06 0.8404903982372576 1.728104143009054e-06 0.8412135669902132 1.728104277643808e-06 0.8420406924792603 \
1.728104474666644e-06 0.8432316292878405 1.728104664772186e-06 0.8443592803112207 1.728104874895499e-06 0.8455816023960827 1.728105055213604e-06 0.8466107566581813 \
1.728105252676705e-06 0.8477171937062282 1.72810542674582e-06 0.8486750118570332 1.72810560906524e-06 0.8496608982186138 1.728105780480376e-06 0.8505716849290491 \
1.728105954593653e-06 0.8514808063694008 1.728106130324621e-06 0.8523822271368225 1.728106306436321e-06 0.8532696099472232 1.728106496054173e-06 0.8542074684498208 \
1.72810668683567e-06 0.8551330189126392 1.728106888431747e-06 0.8560917259710515 1.728107081166005e-06 0.856990088884472 1.728107290037826e-06 0.8579439907476532 \
1.728107520740263e-06 0.8589743400177088 1.728107785183227e-06 0.8601259267840322 1.728108084005915e-06 0.8613896125360476 1.728108363960216e-06 0.8625380186322354 \
1.728108648086082e-06 0.8636694076724545 1.728108922855057e-06 0.8647317823994775 1.728109194712217e-06 0.8657531067718063 1.728109465089334e-06 0.8667403371654003 \
1.728109722167856e-06 0.8676533221001362 1.728109994792687e-06 0.868594905839151 1.728110270759836e-06 0.8695208838709013 1.728110540864093e-06 0.8704012674911344 \
1.728110840740104e-06 0.8713491368600049 1.728111211801162e-06 0.8724801680184872 1.72811150674079e-06 0.8733472453740196 1.728111761036548e-06 0.8740729094291386 \
1.728112059297474e-06 0.8748989982677786 1.728112332904015e-06 0.8756336613858092 1.728112569029958e-06 0.876250392688866 1.728112809374056e-06 0.8768621356511911 \
1.728113031706182e-06 0.8774140071409635 1.728113225712247e-06 0.8778848105679672 1.728113555434997e-06 0.8786625669521169 1.728113710608526e-06 0.8790190643519731 \
1.728114028387606e-06 0.879730644938159 1.728114207248864e-06 0.8801204696806418 1.728114549710761e-06 0.8808457867651537 1.728114733837363e-06 0.8812245477320809 \
1.728115208711942e-06 0.8821665346129511 1.728115376108352e-06 0.8824869809105039 1.728115841951854e-06 0.883348261932613 1.728116022773548e-06 0.8836708855253055 \
1.728116516812651e-06 0.8845204537290557 1.728116658162059e-06 0.8847551796839913 1.728117264500122e-06 0.8857215808967022 1.728117416569336e-06 0.8859539944113424 \
1.728118063256356e-06 0.8869009218298172 1.728118191551239e-06 0.8870812460539503 1.728118839667745e-06 0.8879562712787433 1.728118969467641e-06 0.8881245027440973 \
1.72811974767834e-06 0.8890830197250962 1.728119862725472e-06 0.8892171882189283 1.728120718396314e-06 0.8901564861234483 1.728120863744077e-06 0.8903061494816453 \
1.728121849499649e-06 0.8912466483555094 1.728122070607711e-06 0.8914402669210102 1.728123215727714e-06 0.892367747196105 1.728123346939159e-06 0.8924695935232408 \
1.728124688211624e-06 0.8934615053489913 1.7281248396029e-06 0.8935661991834861 1.72812632105512e-06 0.8944951400107031 1.728126559934816e-06 0.8946288932334222 \
1.728128329356654e-06 0.895502508848118 1.728128718477945e-06 0.895670668133377 1.728131112210654e-06 0.8965556062201232 1.728131587750592e-06 0.8967047758494365 \
1.728135650819818e-06 0.8977025964496719 1.728136142295654e-06 0.8977953148389237 1.728144458892796e-06 0.8987880790885289 1.728145378794248e-06 0.8988514070442593 \
1.728299242370168e-06 0.8998485708192639 1.728302885496457e-06 0.8998628537402877 1.728529614276672e-06 0.8989664306490068 1.728529844616583e-06 0.8988008565867064 \
1.72853145953688e-06 0.897804750401333 1.728531637269166e-06 0.8977103535805105 1.728548403669271e-06 0.8986978311584225 1.728548539768403e-06 0.8987160394686986 \
1.728563710608672e-06 0.8997133888183054 1.728563987713508e-06 0.899719468756186 1.729048028906422e-06 0.9005852143835333 1.729048202241039e-06 0.9007408621809421 \
1.729048862730638e-06 0.9015135064485434 1.72904902879582e-06 0.9017527716291757 1.729049555130528e-06 0.9026184054967997 1.729049746244447e-06 0.9029704910143604 \
1.729050110465499e-06 0.9036902342402512 1.729050289664921e-06 0.9040628043424317 1.729050651551594e-06 0.9048333795345931 1.729050846661164e-06 0.9052442844328937 \
1.729051379059525e-06 0.9062266394381637 1.729051561413164e-06 0.9064623886473868 1.729052553393556e-06 0.905594670761786 1.729052714934123e-06 0.9049318860608667 \
1.729052882926576e-06 0.9040378649110347 1.729053042758061e-06 0.9029782421366458 1.729053180254799e-06 0.9018984154159868 1.729053313162111e-06 0.9007052793196499 \
1.729053439587579e-06 0.8994328447569792 1.729053546986819e-06 0.8982475863895881 1.729053651483477e-06 0.8970047013543965 1.729053765533147e-06 0.8955451342423859 \
1.729053855502734e-06 0.8943225684615312 1.729053960321373e-06 0.8928208677113324 1.729054049769612e-06 0.891473284704788 1.729054132145393e-06 0.8901820884368528 \
1.729054223238393e-06 0.8887006634027688 1.729054360574471e-06 0.8863657732814155 1.729054459067403e-06 0.8846195012157601 1.729054571141153e-06 0.8825649218508906 \
1.729054702024186e-06 0.880080778639088 1.729054838495216e-06 0.8774018563482072 1.729054991949379e-06 0.8742910281085086 1.729055151043747e-06 0.8709679977889497 \
1.729055315327649e-06 0.867445283300377 1.729055471995751e-06 0.8640104344288071 1.729055624086531e-06 0.860615744772629 1.729055777800206e-06 0.857132398554192 \
1.729055937362381e-06 0.853469801378647 1.729056092451083e-06 0.8498714074018293 1.729056266130402e-06 0.8458039138600054 1.729056429161269e-06 0.8419559450883216 \
1.729056590803684e-06 0.8381170660338335 1.729056753450421e-06 0.8342344554797501 1.729056914868927e-06 0.8303657475978833 1.729057083463406e-06 0.8263109424305363 \
1.729057266356504e-06 0.8219002364007665 1.729057434185218e-06 0.8178440888239877 1.729057602471033e-06 0.8137703061148112 1.729057773299085e-06 0.8096302849976138 \
1.729057945473642e-06 0.8054541271740473 1.729058113235561e-06 0.8013830614994394 1.729058296865018e-06 0.7969255463994016 1.729058468271496e-06 0.7927646873948894 \
1.729058653714802e-06 0.7882638003278283 1.729058820385454e-06 0.7842196820467244 1.729058989271585e-06 0.7801233737411432 1.729059173427882e-06 0.7756572567105651 \
1.72905936803791e-06 0.7709405333854473 1.729059515293241e-06 0.7673736106648734 1.729059641923832e-06 0.7643079795643375 1.729059783780644e-06 0.7608754495129878 \
1.729059888184422e-06 0.7583505812556488 1.729060020577074e-06 0.7551502542766809 1.729060130161271e-06 0.7525028097975122 1.729060263325923e-06 0.7492875979647342 \
1.729060419507685e-06 0.7455190770546114 1.729060532737112e-06 0.7427887939149777 1.729060695258476e-06 0.7388718945951063 1.729060867439291e-06 0.7347246296492568 \
1.729061063444044e-06 0.7300078517193382 1.729061227834023e-06 0.7260553905833119 1.729061380230704e-06 0.7223944885043934 1.729061543905858e-06 0.718466402706526 \
1.729061711831558e-06 0.7144406657912139 1.729061891671936e-06 0.7101336212543717 1.729062067965886e-06 0.7059164985576465 1.729062239040521e-06 0.7018286413152719 \
1.729062407358697e-06 0.6978099102718778 1.729062560624829e-06 0.6941537154717222 1.729062722508398e-06 0.6902960245155986 1.729062901459938e-06 0.6860364417190952 \
1.72906303567149e-06 0.6828448068431195 1.729063139177788e-06 0.6803854168085423 1.7290632384622e-06 0.6780286039046017 1.729063339916677e-06 0.6756220912380299 \
1.729063432373276e-06 0.6734303711245889 1.729063516962075e-06 0.6714267031582685 1.729063610539411e-06 0.6692114082407524 1.729063727081631e-06 0.6664546942583044 \
1.729063836559192e-06 0.6638675763958631 1.729063949672203e-06 0.6611971533414394 1.72906407279097e-06 0.6582923426231613 1.729064197017283e-06 0.6553636581362478 \
1.729064367777427e-06 0.6513432847262797 1.729064526226014e-06 0.6476181700514572 1.729064698513837e-06 0.6435738126612673 1.729064844491904e-06 0.6401512360303271 \
1.72906498628512e-06 0.6368325564797357 1.729065117883574e-06 0.6337564355289309 1.729065248046859e-06 0.630718219665797 1.729065373571799e-06 0.6277924818644975 \
1.729065505354707e-06 0.6247239543970449 1.729065635278203e-06 0.6217046839485236 1.729065771586778e-06 0.6185408917806742 1.729065916200345e-06 0.615188962872713 \
1.729066075692536e-06 0.611499189008522 1.729066249152652e-06 0.6074939486938447 1.729066420159954e-06 0.6035554342946753 1.729066651528522e-06 0.5982402936372396 \
1.729066894990528e-06 0.5926661367297537 1.729067069111016e-06 0.5886942528256315 1.729067215383093e-06 0.5853638081576373 1.729067349755311e-06 0.58231230528805 \
1.729067466850207e-06 0.5796585826255305 1.729067562614553e-06 0.5774900935424465 1.729067661461096e-06 0.5752566196463251 1.729067745438414e-06 0.5733628024369305 \
1.729067823052463e-06 0.571614165956722 1.729067884377937e-06 0.5702331258704825 1.729067949058575e-06 0.5687779664863769 1.729068030366711e-06 0.5669528575016536 \
1.729068080436707e-06 0.5658306078972934 1.729068129757269e-06 0.5647256890740617 1.729068191677069e-06 0.5633393552914843 1.729068239508894e-06 0.5622690492396486 \
1.72906829001368e-06 0.5611395143522533 1.729068350075717e-06 0.559799205480933 1.729068409358512e-06 0.5584782058326896 1.729068484415226e-06 0.5568072508052372 \
1.729068554097883e-06 0.5552574373576753 1.729068639686449e-06 0.5533559356568912 1.729068726753821e-06 0.5514265885063823 1.729068810416341e-06 0.5495763264044081 \
1.729068896561366e-06 0.5476734676082877 1.729068992265987e-06 0.5455621222678217 1.729069096550939e-06 0.5432673229847179 1.729069211218113e-06 0.5407497407899529 \
1.729069319936574e-06 0.5383664115638558 1.729069429508814e-06 0.5359693749054023 1.729069541813574e-06 0.5335193270114367 1.729069668589195e-06 0.530759392645703 \
1.729069790866427e-06 0.5281021910076299 1.729069930952405e-06 0.5250685463469849 1.729070067969763e-06 0.5221084647952599 1.729070218271135e-06 0.5188705764247719 \
1.729070377166376e-06 0.5154582091324615 1.729070551500259e-06 0.5117250894133971 1.729070738517481e-06 0.5077378180012799 1.729070943835486e-06 0.5033745272871338 \
1.729071155677679e-06 0.498891131759938 1.729071408479721e-06 0.4935662239713107 1.72907161056737e-06 0.4893264048484654 1.729071845160675e-06 0.4844277613141263 \
1.729072081275272e-06 0.4795194943790256 1.729072334451769e-06 0.474283574581623 1.729072644981732e-06 0.4679020429045382 1.72907286303971e-06 0.4634451779596257 \
1.729073036485344e-06 0.4599153839204358 1.729073212977781e-06 0.4563351808422506 1.729073492459577e-06 0.4506930409909046 1.729073724703484e-06 0.4460279192631412 \
1.729074011797073e-06 0.44029020239849 1.729074229643181e-06 0.435960758243863 1.729074439695769e-06 0.4318042429497612 1.729074640893605e-06 0.4278406951573778 \
1.729074823313765e-06 0.4242617300271556 1.729074997208751e-06 0.4208637793449936 1.729075162072867e-06 0.4176529694331993 1.72907532082684e-06 0.4145718140694327 \
1.729075487073787e-06 0.4113577680628809 1.729075635718993e-06 0.4084923702366076 1.729075788087249e-06 0.4055658186126443 1.729075930150432e-06 0.4028468403491589 \
1.72907609952631e-06 0.3996150665462138 1.72907621990823e-06 0.3973276483660343 1.729076329881494e-06 0.3952449223617059 1.729076444806895e-06 0.3930732253581283 \
1.729076597048475e-06 0.3902080468194818 1.72907670926954e-06 0.3881039677199808 1.729076816462041e-06 0.386098874836553 1.72907696899029e-06 0.383254723448244 \
1.729077097137419e-06 0.380874963946598 1.729077219985412e-06 0.3786015923730871 1.729077399083788e-06 0.375299968600122 1.72907754816842e-06 0.3725653942578417 \
1.729077715875808e-06 0.3695018296724824 1.729077871273443e-06 0.3666748141177644 1.729077995440288e-06 0.3644243980538668 1.729078109332155e-06 0.3623666676050148 \
1.729078230775526e-06 0.3601804966264144 1.729078410927293e-06 0.3569532670533712 1.729078577415113e-06 0.3539878629329621 1.729078767834223e-06 0.3506138544217919 \
1.729078959590819e-06 0.3472380408565978 1.729079142640212e-06 0.344035729794033 1.729079291612277e-06 0.3414435189591631 1.729079411552182e-06 0.3393660536257183 \
1.729079534213665e-06 0.3372483242714233 1.729079657244151e-06 0.3351324902755385 1.729079802148562e-06 0.3326515017845288 1.729079905461337e-06 0.3308907757076019 \
1.729079999190846e-06 0.3292979229163631 1.729080089851148e-06 0.3277620998585528 1.729080200972602e-06 0.3258853746017661 1.729080308145579e-06 0.3240820510456246 \
1.72908040642023e-06 0.3224338250618513 1.729080518824776e-06 0.3205545940512134 1.729080682764676e-06 0.3178277446588927 1.729080844402555e-06 0.3151576097143818 \
1.729080992189301e-06 0.3127316247504084 1.729081154434516e-06 0.3100832165115083 1.729081314465073e-06 0.3074868334344322 1.729081466728372e-06 0.3050304870660137 \
1.729081620100242e-06 0.3025703731928215 1.729081778808771e-06 0.3000411640344692 1.7290819432579e-06 0.297437246442505 1.729082110484976e-06 0.2948063590562646 \
1.729082263596513e-06 0.292412731930112 1.729082446694441e-06 0.2895700146919417 1.729082637002178e-06 0.2866380344427262 1.729082785905236e-06 0.2843603072871506 \
1.729082959842542e-06 0.2817165165722222 1.72908313671993e-06 0.2790484233348025 1.729083284317149e-06 0.2768363681311815 1.729083473948849e-06 0.2740172295061162 \
1.729083623950767e-06 0.2718052906662373 1.729083761060958e-06 0.2697943906627059 1.729083902591401e-06 0.2677397479842996 1.72908401605027e-06 0.2661005451260196 \
1.729084152340596e-06 0.2641384584581135 1.729084282417217e-06 0.2622807416655737 1.72908440067147e-06 0.2606037730704709 1.729084518527066e-06 0.2589348966568543 \
1.729084649420877e-06 0.2570853888657079 1.729084789659635e-06 0.2551145527343576 1.729084905154221e-06 0.2534976852533538 1.729085034005598e-06 0.2516957519945816 \
1.729085149151579e-06 0.2500885525459272 1.729085302462547e-06 0.2479513765689386 1.729085440316308e-06 0.2460367343642474 1.72908557977796e-06 0.2441002375748529 \
1.729085735245815e-06 0.2419427021952501 1.72908586002843e-06 0.2402176526454788 1.729085999893338e-06 0.2382916534360561 1.729086128595514e-06 0.2365220787132559 \
1.729086249554366e-06 0.234860341242685 1.729086366599666e-06 0.2332541163798121 1.72908649260073e-06 0.2315368940272461 1.729086589320323e-06 0.2302195772445239 \
1.729086681409196e-06 0.2289683907689286 1.729086795826667e-06 0.2274152998827935 1.729086894197314e-06 0.2260807986508055 1.729087011344108e-06 0.2244933520241092 \
1.729087114435226e-06 0.2231010305483718 1.729087219949952e-06 0.2216798666278746 1.729087300868012e-06 0.2205933880575098 1.729087374539197e-06 0.2196046443759679 \
1.729087417268434e-06 0.2190314036349237 1.729087460398579e-06 0.2184540235451489 1.729087511196061e-06 0.217774515685755 1.729087548370939e-06 0.217277430841393 \
1.729087589041954e-06 0.2167338127731004 1.729087631833756e-06 0.2161620985357572 1.729087668244897e-06 0.2156758299561118 1.729087710169888e-06 0.2151161507306283 \
1.729087764712098e-06 0.2143884526296278 1.729087803170857e-06 0.2138756926875936 1.729087842797626e-06 0.2133496230586122 1.729087904630128e-06 0.212531488259555 \
1.729087966356579e-06 0.2117156525305126 1.729088022493854e-06 0.210974237875411 1.729088086149084e-06 0.210134110843225 1.729088180240117e-06 0.2088936328424611 \
1.729088267048376e-06 0.2077505933124353 1.72908836100502e-06 0.2065146061917991 1.729088459047254e-06 0.2052266823513323 1.729088560634619e-06 0.2038976009052371 \
1.729088661543568e-06 0.2025832113009377 1.729088758279377e-06 0.2013244528083448 1.729088860404348e-06 0.1999972806373927 1.729088963735905e-06 0.1986583046056677 \
1.729089073618507e-06 0.1972379690671278 1.729089182560765e-06 0.1958337611883887 1.729089302395885e-06 0.1942937175364915 1.729089412679751e-06 0.1928822800638286 \
1.729089520558496e-06 0.191507108810815 1.729089646621254e-06 0.1899051957406391 1.729089736488961e-06 0.1887671190866151 1.7290898469673e-06 0.1873723090993208 \
1.729089924500249e-06 0.1863971337376019 1.729090008823992e-06 0.1853400660204312 1.72909009641205e-06 0.1842452710069853 1.729090184204644e-06 0.18315095174413 \
1.729090265924516e-06 0.1821357652581398 1.729090363486193e-06 0.1809282658474054 1.729090470197344e-06 0.1796118512064394 1.729090570679026e-06 0.178377576484793 \
1.729090694850237e-06 0.1768595317522179 1.729090828741761e-06 0.1752320886156309 1.729090947653953e-06 0.1737937102924047 1.729091098054147e-06 0.1719851742607024 \
1.72909120888924e-06 0.1706594030660365 1.729091348655982e-06 0.168997130456427 1.72909146718129e-06 0.1675953052211382 1.729091572608521e-06 0.1663548750207849 \
1.72909166731838e-06 0.1652455210322802 1.729091760628154e-06 0.1641568522804657 1.72909186153427e-06 0.1629842804551663 1.729091956952102e-06 0.1618800504313296 \
1.729092054143025e-06 0.1607598891027116 1.729092135704507e-06 0.1598237474547246 1.729092241020952e-06 0.1586229753023833 1.729092324500659e-06 0.1576763029943549 \
1.729092426029949e-06 0.1565306813704828 1.729092503260486e-06 0.1556635090415242 1.729092594132523e-06 0.154647919213242 1.729092663483833e-06 0.1538765336840219 \
1.729092748067884e-06 0.1529397840535594 1.729092822461091e-06 0.1521208717489242 1.729092901831293e-06 0.151251902275755 1.729092976418964e-06 0.1504388356812226 \
1.729093045640521e-06 0.1496871728711989 1.729093140321328e-06 0.1486640077242138 1.729093210087093e-06 0.1479134441579097 1.729093294531656e-06 0.147008717574758 \
1.729093356097002e-06 0.1463518850554192 1.729093430139493e-06 0.1455673550676988 1.729093503525017e-06 0.1447940960774066 1.729093584960258e-06 0.1439395015691976 \
1.729093654409405e-06 0.1432139999234875 1.729093729511102e-06 0.1424323701137583 1.729093819423173e-06 0.1415006120834361 1.729093896506793e-06 0.1407052977810757 \
1.729093995617377e-06 0.1396885207473417 1.72909406515744e-06 0.138983077430453 1.729094146475915e-06 0.1381612812129989 1.729094216644325e-06 0.1374549162714094 \
1.729094295612438e-06 0.1366629455350578 1.72909437459072e-06 0.1358740351737466 1.72909444691251e-06 0.1351544405911459 1.729094516277969e-06 0.1344667589602006 \
1.729094564981977e-06 0.1339854049281765 1.729094655744348e-06 0.1330945614011112 1.729094687765876e-06 0.1327823711724506 1.729094775869844e-06 0.131925672678654 \
1.729094808363886e-06 0.1316105445757083 1.729094907031543e-06 0.1306564447580443 1.729094950687519e-06 0.130235859061297 1.729095028669336e-06 0.1294866595045693 \
1.729095066000294e-06 0.1291289430202982 1.729095168151694e-06 0.128153223240932 1.729095235595654e-06 0.1275115375392494 1.729095300748612e-06 0.1268935577290946 \
1.729095366654626e-06 0.1262729746041904 1.729095437806609e-06 0.1256052797936485 1.72909552074397e-06 0.1248293808775363 1.729095606139451e-06 0.1240331657139879 \
1.729095682226844e-06 0.1233259817834828 1.729095762687521e-06 0.1225806238777534 1.729095820771462e-06 0.1220441728027253 1.729095892104936e-06 0.1213870835332726 \
1.729095976893369e-06 0.1206085709991845 1.729096038048402e-06 0.1200487744399507 1.729096108134853e-06 0.1194096117168642 1.729096170640142e-06 0.1188419501154776 \
1.72909623664509e-06 0.1182453094891599 1.729096305417857e-06 0.1176255789053269 1.729096374874481e-06 0.1170017375875525 1.729096458038731e-06 0.1162574953874909 \
1.729096531156255e-06 0.1156056107435251 1.729096601870241e-06 0.1149774116339468 1.729096661221924e-06 0.1144518657417393 1.729096766519136e-06 0.1135239342411639 \
1.72909681238663e-06 0.1131212254602471 1.729096899340683e-06 0.1123603821649216 1.729096942354464e-06 0.1119852310621949 1.729096987221211e-06 0.1115947726395539 \
1.729097076954706e-06 0.1108164664143028 1.729097147839057e-06 0.110204256460374 1.729097226692571e-06 0.109525796983828 1.729097289470346e-06 0.1089876103666232 \
1.729097349464702e-06 0.1084750215669379 1.729097460462474e-06 0.1075310013968523 1.72909754121676e-06 0.1068475792877216 1.729097653680086e-06 0.1059005796323111 \
1.729097704824629e-06 0.1054717782906781 1.729097787809798e-06 0.1047785948356612 1.729097845974503e-06 0.1042945647727652 1.729097960212503e-06 0.1033482075721767 \
1.72909801011597e-06 0.1029366076865433 1.729098095857569e-06 0.1022320954501846 1.729098144889019e-06 0.1018307629303728 1.729098227455441e-06 0.101157455862875 \
1.729098298387777e-06 0.1005815064560546 1.729098366538127e-06 0.1000302812267231 1.729098444148443e-06 0.0994053199805509 1.729098516491814e-06 0.09882546240595018 \
1.729098594067778e-06 0.09820656846618626 1.729098682738439e-06 0.09750287271560702 1.729098756553227e-06 0.09692010793638871 1.729098838144235e-06 0.09627924899616347 \
1.729098916282703e-06 0.09566870926115327 1.729099002032494e-06 0.09500229249765579 1.729099089729402e-06 0.09432453920671229 1.729099183638967e-06 0.09360304191323381 \
1.729099280098285e-06 0.09286661217778783 1.729099358728946e-06 0.09226977907248698 1.729099461452546e-06 0.09149473120661993 1.729099545280196e-06 0.09086620530027881 \
1.729099666032378e-06 0.08996702094116031 1.729099795302029e-06 0.08901247130467421 1.729099951190493e-06 0.08787237469953549 1.729100106290076e-06 0.08675000010972149 \
1.729100263305882e-06 0.08562614142917294 1.729100443326735e-06 0.08435280068725284 1.729100593847601e-06 0.08330035525696428 1.729100742221624e-06 0.08227363395463329 \
1.729100879838855e-06 0.08133079092382095 1.729101019758505e-06 0.08038162993974078 1.729101156365493e-06 0.07946425488810546 1.729101295092791e-06 0.07854214404995859 \
1.729101440403653e-06 0.07758663187171365 1.729101588151466e-06 0.07662571164688473 1.729101746748333e-06 0.07560598447141591 1.729101911000851e-06 0.07456266320243836 \
1.729102080017927e-06 0.07350246718885647 1.729102261906921e-06 0.07237646636762114 1.729102462529019e-06 0.07115268999588262 1.729102676406562e-06 0.0698691158856425 \
1.729102904040694e-06 0.0685263410462881 1.729103145626235e-06 0.06712722147996912 1.729103427215414e-06 0.06552977831071743 1.729103724369534e-06 0.06388229915275011 \
1.729104047802611e-06 0.06213267023812474 1.729104438962031e-06 0.0600758559534558 1.729104840456333e-06 0.05803293250078725 1.729105217397059e-06 0.05617754872181892 \
1.729105584510791e-06 0.05442503025024555 1.729105934627471e-06 0.05280240270907886 1.729106253933125e-06 0.05136309724710254 1.729106558257407e-06 0.05002640192327024 \
1.729106855163312e-06 0.04875503464657577 1.729107137163639e-06 0.04757867888787161 1.729107417596943e-06 0.04643900623749339 1.729107682320567e-06 0.04538777697325767 \
1.729107958218279e-06 0.04431704973151576 1.729108232683143e-06 0.04327654260273706 1.729108531102423e-06 0.04217254828989973 1.72910875761848e-06 0.04135316230013186 \
1.729109069531318e-06 0.04025053053625379 1.729109289786109e-06 0.03948972371590862 1.729109507050863e-06 0.03875470657060948 1.729109716773513e-06 0.03806113111453101 \
1.7291100269559e-06 0.03705828856757609 1.729110249553778e-06 0.03635538859683734 1.729110496919279e-06 0.03559019656168042 1.729110769325655e-06 0.03476651972027592 \
1.729110989958209e-06 0.03411384091885184 1.72911127423846e-06 0.03329124852897781 1.729111512151752e-06 0.0326183788879464 1.729111750241164e-06 0.03195887699386461 \
1.729111985496492e-06 0.03132132139405813 1.729112214275199e-06 0.03071728735992773 1.729112447005948e-06 0.03011490821398154 1.729112666308989e-06 0.02955843195412813 \
1.729112870252059e-06 0.02905055018162466 1.729113269161795e-06 0.02808303002558106 1.729113456316051e-06 0.02764052191221165 1.729113828521772e-06 0.0267814187683372 \
1.729114015473295e-06 0.02635997027055515 1.729114384827242e-06 0.02554620807076183 1.72911453848041e-06 0.02521471147941385 1.729114954694564e-06 0.02434161493068329 \
1.729115160182381e-06 0.02392065165079968 1.729115499190341e-06 0.02323955384462723 1.729115681885069e-06 0.02287916718068597 1.729116138978978e-06 0.02199597290476789 \
1.729116268719714e-06 0.02174967209293581 1.729116722140138e-06 0.02089828923199067 1.72911686451243e-06 0.0206336680476187 1.72911739407919e-06 0.01967289368906444 \
1.729117520286197e-06 0.01945139161001456 1.729118082520635e-06 0.01850749734048266 1.729118245259022e-06 0.01824627541187189 1.729118809439087e-06 0.01738327200207762 \
1.729118961183154e-06 0.01716165742474803 1.729119662862638e-06 0.01618760396393164 1.729119832951728e-06 0.01596324388168 1.729120488009604e-06 0.01513221026437959 \
1.729120654523916e-06 0.01492874613340729 1.729121387637676e-06 0.01406966818047924 1.729121520900854e-06 0.01391906482409888 1.729122372558029e-06 0.01299647369571925 \
1.729122510500477e-06 0.01285324185793544 1.729123450559967e-06 0.0119198170026788 1.729123614321604e-06 0.01176347583728811 1.729124601555039e-06 0.01085909507266535 \
1.729124736144114e-06 0.0107410715025141 1.729125877583545e-06 0.009819907073012045 1.729125985822443e-06 0.009738548299709823 1.729127309069827e-06 0.00880579379490502 \
1.729127441815525e-06 0.008718202093769473 1.72912896431665e-06 0.007760835273143199 1.729129076858719e-06 0.007690148685505111 1.729130769150306e-06 0.00669558715138598 \
1.729130909416891e-06 0.00662113250846694 1.729132982426194e-06 0.005629132576249021 1.72913317498771e-06 0.005545002188831318 1.729135385197559e-06 0.004656096148610405 \
1.729135791984232e-06 0.004507219767123045 1.729138613724209e-06 0.003590578528330178 1.729139135019959e-06 0.00344214578404881 1.729143347121009e-06 0.002447529662748036 \
1.729143899683877e-06 0.002340875287107731 1.729149782973417e-06 0.001359168649576994 1.729150032246415e-06 0.001311490127959886 1.729163182367465e-06 0.0003136950974005476 \
1.729163299150435e-06 0.0003112730584132499 1.758990000000011e-06 3.042397160644726e-06 1.802746667027013e-06 -0.0009024818035526668 1.802746739442629e-06 -0.001022682652537627 \
1.802747175467347e-06 -0.001858525046639076 1.80274726236173e-06 -0.002046124893065343 1.802747617065043e-06 -0.00288168582347465 1.802747716611644e-06 -0.003135075204051477 \
1.802747976881348e-06 -0.003828199033013717 1.80274811720375e-06 -0.004216406518003108 1.802748344689832e-06 -0.004856871791621592 1.802748481897271e-06 -0.005239031028659006 \
1.80274886679612e-06 -0.006187559915121 1.802748998893307e-06 -0.006423332025500122 1.802749687336335e-06 -0.005917035979538006 1.802749844265069e-06 -0.005202654566481615 \
1.802749971914231e-06 -0.004414133290428114 1.802750099456021e-06 -0.003433350487145549 1.802750217130233e-06 -0.002355902309038119 1.80275031626992e-06 -0.001320627313728655 \
1.80275042165263e-06 -9.507383675133965e-05 1.802750535559933e-06 0.001369964538583592 1.802750666615328e-06 0.003229572948258866 1.802750791978547e-06 0.005172303930030842 \
1.802750983820411e-06 0.008432154569684791 1.802751127490204e-06 0.01107975669588844 1.802751285472017e-06 0.01417105828876112 1.802751434071664e-06 0.01723098336859398 \
1.802751587122593e-06 0.02051714008521248 1.802751746187569e-06 0.02405720796424875 1.802751899257778e-06 0.02756764950178633 1.802752047604842e-06 0.03105219347129199 \
1.802752196711284e-06 0.03462388853332505 1.802752351275713e-06 0.03838854885099419 1.802752511961677e-06 0.04235886888523473 1.802752676640863e-06 0.04647718198980624 \
1.802752853163806e-06 0.05093664320808645 1.802753032175606e-06 0.05549818742091989 1.802753222948448e-06 0.0603932190016783 1.8027534277958e-06 0.06567927942044927 \
1.802753648293053e-06 0.07139554989571946 1.802753881211021e-06 0.07745499876455469 1.802754130458799e-06 0.08395499695136356 1.802754403380326e-06 0.09108394918256098 \
1.802754700173383e-06 0.09884095133633181 1.802755027609895e-06 0.1073964775374675 1.802755397423694e-06 0.1170487607486894 1.802755792369975e-06 0.1273407304921971 \
1.802756250458528e-06 0.1392499850125259 1.802756782558388e-06 0.1530377249371455 1.802757408110397e-06 0.169180864038255 1.802758094102463e-06 0.1867931863309214 \
1.802758896945878e-06 0.2072766958045763 1.80275979625821e-06 0.2300508264895909 1.802760696698322e-06 0.2526618731709107 1.802761498589855e-06 0.2726215666318766 \
1.802762194096996e-06 0.2897857674353052 1.802762826931282e-06 0.3052728323588638 1.802763422339773e-06 0.3197161646377594 1.802763969382815e-06 0.3328722959176427 \
1.802764503143161e-06 0.3455929446372428 1.802765022382586e-06 0.3578476146335662 1.802765529774048e-06 0.3697097539883151 1.802766033395218e-06 0.3813674725871593 \
1.802766545138114e-06 0.3930934709428262 1.802767052299123e-06 0.404595334768291 1.802767582595136e-06 0.4164962117964878 1.802768068708626e-06 0.4272847049163567 \
1.802768546816947e-06 0.437781779057129 1.802768986249071e-06 0.4473362978389137 1.802769109408535e-06 0.4500002106608159 1.802769355727462e-06 0.4553046876287923 \
1.802769698999458e-06 0.4626558934952216 1.802770010436459e-06 0.4692815017887791 1.802770261147724e-06 0.4745855323881177 1.802770531976867e-06 0.480281321066213 \
1.802770868458777e-06 0.4873122872019196 1.802771224467388e-06 0.4946959640027882 1.802771541737556e-06 0.5012322602315481 1.802771780618105e-06 0.506122906570856 \
1.802772021646287e-06 0.5110269393752048 1.802772273577991e-06 0.5161276795544476 1.802772513731834e-06 0.5209621749612534 1.802772736483296e-06 0.5254248476203834 \
1.802772925040943e-06 0.5291850880529715 1.802773139790986e-06 0.5334523706207774 1.802773354339378e-06 0.5376948565446859 1.80277361310367e-06 0.5427871977552768 \
1.802773863931241e-06 0.5477009885064807 1.802774119350104e-06 0.5526782776843104 1.802774470392629e-06 0.5594898819265107 1.802774735000954e-06 0.5645984056527484 \
1.802775001417509e-06 0.569709962982798 1.80277526193182e-06 0.5746801970751495 1.802775529021882e-06 0.5797469183389945 1.802775772159962e-06 0.5843213438768613 \
1.802776027852189e-06 0.5890994944692448 1.802776255671159e-06 0.5933243819692556 1.802776493215979e-06 0.5976999800355528 1.802776704606465e-06 0.6015679915939678 \
1.802776916747224e-06 0.6054277082074113 1.802777105936602e-06 0.6088479815213901 1.80277723709492e-06 0.6112112531841202 1.802777369391478e-06 0.6135871094428261 \
1.802777554614204e-06 0.6169015645304802 1.802777716636591e-06 0.6197943209800671 1.802777875055755e-06 0.6226100751126036 1.802778009167621e-06 0.6249846001944386 \
1.802778181488729e-06 0.6280247049765127 1.802778310427531e-06 0.6302937061188456 1.802778430805044e-06 0.6324061607157294 1.802778571333915e-06 0.634864734791624 \
1.802778764419407e-06 0.6382321981637986 1.802778914230185e-06 0.6408363654380513 1.802779081537779e-06 0.6437327988167145 1.802779262592003e-06 0.6468572757970242 \
1.802779465918433e-06 0.6503523798695617 1.802779648771588e-06 0.6534819287355287 1.802779819395834e-06 0.6563879501053153 1.802779996860074e-06 0.6594029650344411 \
1.802780162839024e-06 0.6622113135173925 1.802780320075814e-06 0.6648594636266301 1.802780460561866e-06 0.6672075432495704 1.802780604291994e-06 0.6695987751186935 \
1.802780737338985e-06 0.6718055529208897 1.802780879311128e-06 0.6741523780906628 1.802780999371661e-06 0.6761293215200647 1.802781144309748e-06 0.6785098354674278 \
1.802781260306798e-06 0.6804095298668216 1.802781379886685e-06 0.6823647593763783 1.80278147884666e-06 0.68397755359623 1.802781597355078e-06 0.6859039329668146 \
1.80278168439936e-06 0.6873150904607619 1.802781806410179e-06 0.6892866586554622 1.802781905332791e-06 0.6908817703737582 1.802781997228166e-06 0.6923536807698466 \
1.802782097196705e-06 0.6939486118486815 1.802782195442366e-06 0.6955126686751646 1.802782287156128e-06 0.6969676095571918 1.80278239128907e-06 0.698613189139943 \
1.802782527015812e-06 0.7007470979739818 1.802782681624274e-06 0.7031613517373301 1.802782816731986e-06 0.7052558942641604 1.802782963068532e-06 0.7075085519458914 \
1.802783091536073e-06 0.7094732734147607 1.802783215720207e-06 0.7113609898537658 1.802783325624507e-06 0.7130225953369277 1.802783442207576e-06 0.7147759898693785 \
1.802783542385406e-06 0.7162749667021007 1.802783679474215e-06 0.7183149847558421 1.802783799463242e-06 0.7200901405411056 1.80278391857669e-06 0.7218426783097279 \
1.802784045072077e-06 0.723693513465353 1.802784170939449e-06 0.7255245570057045 1.802784293560467e-06 0.7272980597885179 1.802784421177991e-06 0.7291334326655684 \
1.802784551426783e-06 0.7309957624152177 1.802784673019733e-06 0.73272442801297 1.802784811788425e-06 0.7346853525547948 1.802784912196869e-06 0.7360963845229137 \
1.802785015584257e-06 0.7375412410987998 1.8027851092447e-06 0.7388443755773992 1.802785220866296e-06 0.7403895158541485 1.802785307334899e-06 0.7415798421827293 \
1.80278540819801e-06 0.7429609798983192 1.802785540294732e-06 0.7447573558536402 1.802785649496034e-06 0.7462323422761349 1.802785754027664e-06 0.747635567415085 \
1.802785877674144e-06 0.7492836897664436 1.80278602637058e-06 0.7512497161812216 1.802786148251239e-06 0.7528480713857697 1.802786261855803e-06 0.7543274008692354 \
1.802786402375488e-06 0.7561429069656862 1.80278654356493e-06 0.7579511824827749 1.802786661311106e-06 0.7594470562859095 1.802786790000766e-06 0.7610693809796742 \
1.802786932555413e-06 0.7628512182523866 1.802787048411964e-06 0.7642872416835913 1.80278719417523e-06 0.7660789429779771 1.802787316007677e-06 0.7675637574673733 \
1.802787434476374e-06 0.7689965471136999 1.802787557264006e-06 0.7704700089613156 1.802787683416888e-06 0.7719718272910862 1.802787793785939e-06 0.7732757954107932 \
1.802787919217035e-06 0.7747465774777432 1.802788024698746e-06 0.775974259539018 1.802788157865176e-06 0.7775122819577122 1.802788280546631e-06 0.7789173428708996 \
1.802788415309674e-06 0.7804473432620218 1.802788525980962e-06 0.7816923373676121 1.802788635302591e-06 0.7829118427552927 1.802788770435025e-06 0.7844048889494442 \
1.80278892121405e-06 0.7860523747618094 1.802789061582958e-06 0.7875692293014268 1.802789181294483e-06 0.7888502570533434 1.802789319548823e-06 0.7903153082715967 \
1.802789442919159e-06 0.7916096503654788 1.802789588017784e-06 0.7931164937536124 1.802789727758043e-06 0.7945521172774316 1.802789854939466e-06 0.7958455533278409 \
1.80278997397922e-06 0.7970449251022731 1.802790086337411e-06 0.7981670522831598 1.80279019056619e-06 0.79919939674296 1.802790285905002e-06 0.8001364844871954 \
1.802790422193112e-06 0.8014634245741865 1.802790539085656e-06 0.8025894467082511 1.802790658725145e-06 0.8037305025474466 1.802790780606717e-06 0.8048811831579785 \
1.802790902985054e-06 0.8060245537852575 1.802791031013733e-06 0.8072081965553952 1.802791155658532e-06 0.8083483262222385 1.802791286157279e-06 0.8095291977395493 \
1.802791412617707e-06 0.8106611567088965 1.802791539743674e-06 0.8117869190804841 1.802791644861151e-06 0.8127087429624065 1.80279175011134e-06 0.8136235164943317 \
1.80279184125159e-06 0.8144090748259969 1.802791964669625e-06 0.8154632009865571 1.802792051748274e-06 0.8162003374872545 1.802792151070959e-06 0.8170344894488412 \
1.802792295992703e-06 0.8182390501293432 1.802792432261206e-06 0.8193582434421302 1.802792541723485e-06 0.8202477434185359 1.802792687843586e-06 0.8214214001843773 \
1.802792839202198e-06 0.8226208465286928 1.80279296500612e-06 0.8236052915965452 1.802793109416779e-06 0.824721541823094 1.802793234017729e-06 0.8256729463037898 \
1.802793384729791e-06 0.8268094083523665 1.80279352010105e-06 0.8278169867326588 1.802793645303979e-06 0.8287379047458127 1.802793762973362e-06 0.829593908450195 \
1.802793908801339e-06 0.8306418458276996 1.80279407529732e-06 0.8318207857986918 1.802794206154408e-06 0.8327345044534114 1.802794379603848e-06 0.833928356718921 \
1.802794547722322e-06 0.8350667646575466 1.802794717596124e-06 0.8361988603660855 1.802794898450753e-06 0.8373843006762304 1.802795041633135e-06 0.8383085120571983 \
1.802795155746479e-06 0.8390361588138326 1.802795285812469e-06 0.8398559950134801 1.802795387687705e-06 0.8404909448220066 1.802795504566998e-06 0.8412116130393378 \
1.802795641678929e-06 0.8420465258793415 1.802795839559572e-06 0.843231707656198 1.802796031345765e-06 0.8443585547012582 1.802796240708828e-06 0.8455646258450146 \
1.802796422822406e-06 0.846593677725298 1.802796619917178e-06 0.8476867969181797 1.802796793185875e-06 0.8486305714188691 1.802796976264561e-06 0.8496104335327738 \
1.802797147401587e-06 0.8505103231661706 1.802797322080438e-06 0.8514128411730317 1.802797497318728e-06 0.8523022053693007 1.802797673458367e-06 0.8531802340241421 \
1.802797863809624e-06 0.8541115036082744 1.80279805438677e-06 0.855025905954957 1.802798254818193e-06 0.8559685891497206 1.802798447410669e-06 0.8568563992305701 \
1.802798658273806e-06 0.8578086227668252 1.802798886187182e-06 0.8588150784816577 1.802799152217719e-06 0.8599606428795262 1.802799450738801e-06 0.8612090806949765 \
1.802799726692481e-06 0.8623286542354505 1.802800010954596e-06 0.8634483918036945 1.802800285103046e-06 0.8644969441068078 1.802800557392313e-06 0.8655088801415273 \
1.802800827558089e-06 0.8664846790737442 1.802801084736186e-06 0.8673881555543895 1.802801357299353e-06 0.868319368003445 1.802801633304697e-06 0.8692355072818493 \
1.802801903418629e-06 0.870106770567397 1.802802203245002e-06 0.8710447971670072 1.802802574222291e-06 0.8721640818024149 1.802802869154012e-06 0.8730224021943973 \
1.802803123432376e-06 0.873740732376842 1.802803421677207e-06 0.8745584461000401 1.802803695285219e-06 0.8752856917963749 1.802803931415444e-06 0.8758961959341748 \
1.802804171760979e-06 0.8765017794770257 1.802804394097168e-06 0.8770481951318053 1.80280458810245e-06 0.8775144010549708 1.802804917823793e-06 0.8782846129827527 \
1.802805072996819e-06 0.8786376896881318 1.802805390752407e-06 0.8793424631377607 1.802805569616983e-06 0.8797286397841958 1.802805912078462e-06 0.8804474051285093 \
1.802806096217817e-06 0.880822800830328 1.802806571118475e-06 0.881756283451624 1.802806738513154e-06 0.8820737784441692 1.8028072043462e-06 0.8829272622221894 \
1.802807385170493e-06 0.8832470363605239 1.802807879204793e-06 0.8840891816604841 1.802808020548669e-06 0.8843218944112644 1.802808626940585e-06 0.8852805359894154 \
1.802808779011766e-06 0.8855111592597558 1.802809425691436e-06 0.8864506941541785 1.802809553987642e-06 0.8866295550025313 1.802810202164815e-06 0.8874976172723908 \
1.802810331923675e-06 0.8876644392549727 1.802811100144497e-06 0.8886037370453904 1.802811229881009e-06 0.8887539063021698 1.802812083306654e-06 0.8896836309705964 \
1.802812226565087e-06 0.8898301468060963 1.802813212785821e-06 0.890764641901611 1.802813434267227e-06 0.8909571971396437 1.802814577308627e-06 0.8918770673440963 \
1.802814707298116e-06 0.8919774876506176 1.802816058923388e-06 0.8929731820841386 1.80281620928357e-06 0.89307657739048 1.802817689916169e-06 0.8939986636922405 \
1.802817928817934e-06 0.8941315911431026 1.802819693311632e-06 0.894999985510941 1.802820000994978e-06 0.8951330875684044 1.802822522266181e-06 0.8960612226716312 \
1.802822959317422e-06 0.8961978289811912 1.802826862729643e-06 0.8971619289239613 1.80282710951145e-06 0.8972094058147089 1.802834686001284e-06 0.8981998139535015 \
1.802834801913031e-06 0.8982099955090975 1.802853900445735e-06 0.8992062631372056 1.802854297888509e-06 0.8992194728667773 1.80300471332359e-06 0.9002121614362558 \
1.803004979381947e-06 0.9002436812458944 1.803010247532015e-06 0.8993470931706574 1.803010453902932e-06 0.899191170936528 1.803011932015742e-06 0.8982046351054961 \
1.803012112466398e-06 0.8981003355419954 1.803014334948061e-06 0.8971299612768925 1.803014541040575e-06 0.897079983173831 1.803024949306681e-06 0.8980580240048047 \
1.803025087164257e-06 0.8980839755683444 1.803031884513298e-06 0.8990685088718567 1.803032070084766e-06 0.8990874390200084 1.803528299258968e-06 0.9000706848616691 \
1.803528359054814e-06 0.9000975977971888 1.803529612605432e-06 0.9010828413531861 1.803529718298035e-06 0.9012097231395001 1.803530376428752e-06 0.9021613947651476 \
1.803530513611021e-06 0.9023918767045529 1.803531036637641e-06 0.9033649777562528 1.803531099501233e-06 0.9034908765919824 1.803531572096782e-06 0.904476514442582 \
1.803531623410595e-06 0.9045863669199017 1.803532089373931e-06 0.9055619780118375 1.803532121578392e-06 0.9056252631670594 1.803532838677129e-06 0.9066212416280413 \
1.803532923113402e-06 0.9066528951765993 1.803533523179781e-06 0.9059679814895146 1.803533643037393e-06 0.9055903401525059 1.803533774200172e-06 0.9050640446667092 \
1.803533909019925e-06 0.9043926011431642 1.803534057154984e-06 0.9034897747335404 1.803534194714335e-06 0.902493211317788 1.803534334926095e-06 0.9013135799985507 \
1.803534433588204e-06 0.9003872218501816 1.803534519272014e-06 0.8995148096066522 1.803534601836213e-06 0.8986166894493001 1.803534716618842e-06 0.8972773101170661 \
1.803534797717086e-06 0.8962642459447687 1.803534877134364e-06 0.8952218112132616 1.803534982588891e-06 0.8937633947192651 1.803535105230195e-06 0.8919606744930825 \
1.803535204954274e-06 0.890414036797163 1.803535375148685e-06 0.8876203405523397 1.803535521333776e-06 0.8850727273800474 1.803535689551925e-06 0.8819879035815887 \
1.803535861713021e-06 0.8786780617039783 1.803536046099114e-06 0.8749807502679057 1.803536230665458e-06 0.8711418063496947 1.803536414912943e-06 0.8671917613865908 \
1.803536600248607e-06 0.8631174608718694 1.803536774636335e-06 0.8592060069639053 1.803536957340271e-06 0.8550405244181323 1.803537132687366e-06 0.8509893565349284 \
1.803537315016877e-06 0.8467313026054767 1.803537505330306e-06 0.8422468264612591 1.803537675660435e-06 0.838204894125699 1.803537842184073e-06 0.8342320488410089 \
1.803538004754937e-06 0.830337741667393 1.80353815461616e-06 0.8267359097041467 1.803538305792179e-06 0.8230937075736249 1.803538494937653e-06 0.8185270080344306 \
1.803538640655707e-06 0.8150026134285653 1.803538815646674e-06 0.8107652770601156 1.803538964118217e-06 0.807166938184282 1.803539136005683e-06 0.8029987283123258 \
1.803539305073922e-06 0.7988973224349885 1.803539469252631e-06 0.7949140139776875 1.803539628580169e-06 0.7910485911592836 1.803539789029776e-06 0.7871568543472617 \
1.803539990849157e-06 0.7822630953020117 1.803540139296892e-06 0.7786646206504594 1.803540293464276e-06 0.77492821376164 1.803540430547636e-06 0.7716074476660475 \
1.803540539933082e-06 0.7689587163513494 1.803540645866538e-06 0.7663946531324515 1.803540772880885e-06 0.7633217481666642 1.803540887243854e-06 0.7605561828888391 \
1.803540990091676e-06 0.7580702160470256 1.803541111681992e-06 0.7551325442760125 1.803541222459267e-06 0.7524575925939972 1.803541339308092e-06 0.7496376180588871 \
1.803541450092818e-06 0.7469652567786068 1.803541568458919e-06 0.7441116745915923 1.803541693286014e-06 0.7411038668912771 1.80354184584781e-06 0.7374292753756717 \
1.803541979744798e-06 0.7342062928952946 1.803542100776237e-06 0.7312947572377408 1.803542264973752e-06 0.7273475399259534 1.803542442334699e-06 0.7230877912371642 \
1.803542624545107e-06 0.7187161681757385 1.803542805542372e-06 0.7143786395952922 1.803542986206316e-06 0.7100537072471783 1.803543176357883e-06 0.7055071781827296 \
1.803543364117777e-06 0.7010230964996226 1.803543564650881e-06 0.696237807975249 1.803543773336343e-06 0.6912646166759551 1.803543980979908e-06 0.6863227581165517 \
1.803544208547776e-06 0.6809140411171237 1.80354440082261e-06 0.6763521085712711 1.803544638087858e-06 0.6707310800019505 1.803544831366122e-06 0.6661595641347996 \
1.803545064098868e-06 0.6606646229758047 1.803545269656336e-06 0.6558174602470968 1.803545502009757e-06 0.6503484594495911 1.803545697011727e-06 0.6457674053103037 \
1.803545900240336e-06 0.6410004262200759 1.803546080092881e-06 0.6367906205544323 1.803546259199312e-06 0.6326052789263827 1.803546422576526e-06 0.628795088826817 \
1.80354659462593e-06 0.6247880828503264 1.803546758118769e-06 0.6209892715878097 1.803546933908587e-06 0.6169100951581823 1.803547115847573e-06 0.6126978430086294 \
1.803547304331305e-06 0.6083422542008314 1.803547510763727e-06 0.6035858951323969 1.803547690078389e-06 0.5994633272559844 1.803547887257256e-06 0.5949432360761027 \
1.803548096345397e-06 0.5901646611556908 1.80354830209466e-06 0.5854760387944159 1.803548542605348e-06 0.5800160304866983 1.803548715733449e-06 0.5760958285528379 \
1.803548880627452e-06 0.5723746772837877 1.803549061488026e-06 0.5683014035092815 1.803549218774123e-06 0.5647722902613652 1.803549387756918e-06 0.5609879409349005 \
1.803549567863379e-06 0.5569709657351898 1.803549720846506e-06 0.5535669615732179 1.80354985256095e-06 0.5506462283231492 1.803549999948651e-06 0.5473865746199473 \
1.803550087374242e-06 0.5454560063082221 1.803550172245481e-06 0.5435860258811447 1.803550270874694e-06 0.5414171943998213 1.803550342966855e-06 0.5398340751058975 \
1.803550440057874e-06 0.5377039800781129 1.803550525648258e-06 0.5358302678688993 1.803550590729134e-06 0.5344081412607664 1.803550714329502e-06 0.5317121235594142 \
1.803550808753772e-06 0.52965475734789 1.803550906276994e-06 0.5275349985745696 1.803551079137645e-06 0.5237893654184622 1.803551214133166e-06 0.5208709659121862 \
1.803551368316627e-06 0.5175498113398643 1.803551542781984e-06 0.5138002600288881 1.80355169458797e-06 0.510550000123414 1.803551840818953e-06 0.5074290310664136 \
1.803551984717826e-06 0.5043644611166801 1.803552127739669e-06 0.5013276181140283 1.803552223349517e-06 0.499301733014788 1.803552317793473e-06 0.4973032961550828 \
1.803552438849414e-06 0.4947494705229025 1.80355253372771e-06 0.4927525559781179 1.803552649558553e-06 0.4903172469328811 1.803552736822402e-06 0.4884854516151125 \
1.803552819252848e-06 0.4867593351188191 1.803552914660801e-06 0.484765406725184 1.803553015371081e-06 0.4826639978995959 1.803553112231473e-06 0.4806459052877932 \
1.803553250961224e-06 0.4777646955734051 1.803553386666086e-06 0.4749532752442271 1.803553587150809e-06 0.4708139964547478 1.803553802464962e-06 0.4663911383470885 \
1.803553984040267e-06 0.462674698484628 1.803554183012236e-06 0.4586189944293299 1.803554353577757e-06 0.455154096457448 1.803554527931445e-06 0.4516251957269069 \
1.803554696864699e-06 0.4482170126441485 1.80355486946186e-06 0.4447467276163349 1.80355505206819e-06 0.4410867902598327 1.803555240617055e-06 0.4373240875354826 \
1.803555434084593e-06 0.4334777823509549 1.803555642405232e-06 0.4293535036700135 1.803555856750462e-06 0.4251286740881063 1.803556082455792e-06 0.4207018662297695 \
1.80355630899916e-06 0.4162771402745992 1.803556571175911e-06 0.4111844468197049 1.803556820209735e-06 0.4063709766754009 1.803557121308432e-06 0.4005865607947761 \
1.80355741072925e-06 0.3950673729298416 1.803557718243529e-06 0.3892455819062323 1.803558040439924e-06 0.3831936848847286 1.803558368170407e-06 0.3770882112794804 \
1.803558700600163e-06 0.3709500980558715 1.80355903032917e-06 0.3649083177186754 1.803559351558758e-06 0.3590729273462687 1.803559682375082e-06 0.3531219177045733 \
1.803560024730645e-06 0.3470224718704957 1.803560324371677e-06 0.3417374346434491 1.803560654159242e-06 0.3359723367088904 1.803560981053185e-06 0.3303128110141857 \
1.803561319032532e-06 0.3245206193888226 1.803561628003696e-06 0.3192755432624759 1.803561952801668e-06 0.31382336954194 1.803562268431866e-06 0.3085864885517507 \
1.803562573419032e-06 0.3035810258414895 1.803562828757677e-06 0.2994330834535801 1.803563093620834e-06 0.295170851203172 1.803563380703519e-06 0.2905978071194348 \
1.803563603673297e-06 0.2870801635277143 1.803563803212566e-06 0.2839591363066187 1.803564012868579e-06 0.2807045410859125 1.803564193125121e-06 0.2779290029372279 \
1.803564355469842e-06 0.2754463208250681 1.803564505904815e-06 0.2731629026725527 1.803564656910124e-06 0.2708866524077067 1.803564853800715e-06 0.2679392949564011 \
1.803564984945479e-06 0.2659970646012914 1.803565109682017e-06 0.2641561221543183 1.80356526127406e-06 0.2619266655689588 1.803565357242231e-06 0.2605306204207966 \
1.803565453793599e-06 0.2591282589302421 1.803565578413389e-06 0.2573209601776467 1.803565720989923e-06 0.255257422470362 1.803565879923458e-06 0.25296979123958 \
1.803566012589525e-06 0.251062957019046 1.803566196158294e-06 0.2484301322588876 1.80356637739346e-06 0.2458327969660818 1.803566588907564e-06 0.2428051031600066 \
1.803566791497399e-06 0.2399069804317323 1.803566958053846e-06 0.2375282895552967 1.803567168273059e-06 0.2345337828133105 1.803567341690945e-06 0.2320692345528927 \
1.803567570533673e-06 0.2288260787734411 1.803567791168424e-06 0.2257162440502939 1.803567966830137e-06 0.2232503232699662 1.803568147290643e-06 0.2207258962977968 \
1.803568318047021e-06 0.2183528725291195 1.803568498243287e-06 0.2158619697278009 1.803568664973905e-06 0.2135675266585953 1.803568814095326e-06 0.2115251542210239 \
1.803568969905344e-06 0.2094125291275523 1.803569105085769e-06 0.2075875692769576 1.803569255167196e-06 0.2055694209972212 1.803569387612823e-06 0.2037957203154137 \
1.803569528157359e-06 0.2019220745191926 1.803569645226124e-06 0.2003748851744883 1.80356977493373e-06 0.1986681706274326 1.803569896991199e-06 0.1970700654731777 \
1.803570019534635e-06 0.1954731161836187 1.803570137553958e-06 0.1939418157697267 1.803570272576731e-06 0.1921981789937757 1.803570417201182e-06 0.1903420634523806 \
1.803570545551681e-06 0.1887049708672087 1.803570669186156e-06 0.1871351133418249 1.803570766736279e-06 0.1859021016257166 1.803570881809208e-06 0.1844539912642748 \
1.803570975507888e-06 0.1832809848801438 1.803571074292012e-06 0.1820493959460708 1.803571197226553e-06 0.1805230483556907 1.803571292980556e-06 0.1793400249325384 \
1.803571422068107e-06 0.177753298391591 1.803571524533477e-06 0.1764993061988986 1.803571622786974e-06 0.1753029542432101 1.803571742874186e-06 0.1738483570896001 \
1.803571845423405e-06 0.1726127298531683 1.803571955881064e-06 0.1712877101305652 1.803572084370928e-06 0.1697552709290656 1.803572175855769e-06 0.1686698090598139 \
1.803572280340358e-06 0.1674358120019214 1.803572355277094e-06 0.1665544493622226 1.803572444845591e-06 0.1655049734124585 1.8035724954106e-06 0.164914347906921 \
1.803572545388976e-06 0.1643318187475747 1.803572610358061e-06 0.163576534137217 1.803572645872028e-06 0.1631646263336159 1.803572718071202e-06 0.162329174921529 \
1.803572785200297e-06 0.1615546732967998 1.803572844430032e-06 0.160873195114598 1.80357288817563e-06 0.1603710314414745 1.803572935822458e-06 0.1598254649913795 \
1.803573006202993e-06 0.1590230739426561 1.803573088541159e-06 0.1580883269013631 1.803573166712759e-06 0.1572048664554128 1.803573248765708e-06 0.1562816770844126 \
1.803573341469331e-06 0.1552436243401225 1.803573464249494e-06 0.153877370231325 1.803573563395588e-06 0.1527810927807017 1.803573664895935e-06 0.1516651170047695 \
1.803573766171126e-06 0.1505582666538253 1.80357386266291e-06 0.1495093242781697 1.803573962080945e-06 0.1484346886615803 1.803574046381569e-06 0.1475281828465028 \
1.803574139320259e-06 0.1465342051547719 1.8035742219212e-06 0.1456551508734999 1.803574330687285e-06 0.1445034822456445 1.803574436330265e-06 0.1433917535370727 \
1.803574517989854e-06 0.1425365900703354 1.803574611735024e-06 0.1415598856352903 1.803574705302971e-06 0.1405903867550886 1.803574788187462e-06 0.139735765814107 \
1.803574876346636e-06 0.1388313836440244 1.803574956132722e-06 0.1380170907865772 1.803575049728122e-06 0.1370669869522621 1.803575139660646e-06 0.1361590166429519 \
1.803575210211042e-06 0.1354501541392388 1.803575279971219e-06 0.1347521119166949 1.803575394120126e-06 0.1336164586193709 1.80357547609874e-06 0.1328058651355588 \
1.803575563704042e-06 0.1319440719770354 1.803575663205238e-06 0.1309710196939938 1.803575772385241e-06 0.1299110174488692 1.803575874550573e-06 0.1289256009328031 \
1.803575982010779e-06 0.1278959836800649 1.803576102045057e-06 0.1267549558890445 1.803576196253091e-06 0.1258657925752028 1.803576327232195e-06 0.1246390638240933 \
1.803576426659896e-06 0.1237164070883829 1.803576535781582e-06 0.1227104370444639 1.80357664463475e-06 0.1217138859540913 1.803576736944153e-06 0.120874257454373 \
1.803576849784484e-06 0.1198547128626846 1.803576946796524e-06 0.118986084968971 1.803577051062872e-06 0.1180628196869088 1.803577160029802e-06 0.1171053395831002 \
1.803577259569368e-06 0.1162371554254778 1.803577376562078e-06 0.1152245300989246 1.803577463662868e-06 0.1144761644999183 1.80357757295452e-06 0.1135478691973115 \
1.803577654479582e-06 0.1128618460838699 1.803577754254576e-06 0.1120273350449922 1.803577871679726e-06 0.1110526766231405 1.803577973464844e-06 0.1102143708571793 \
1.803578061203792e-06 0.1094962336869811 1.8035781420033e-06 0.1088432886892514 1.803578228954319e-06 0.1081456845520918 1.803578309740945e-06 0.1075007757815706 \
1.803578399947511e-06 0.1067842832273628 1.803578490898266e-06 0.1060655611559195 1.80357857956879e-06 0.1053685613006139 1.80357867858361e-06 0.1045946508745568 \
1.803578772289787e-06 0.1038723470842792 1.803578866149063e-06 0.1031520741219857 1.803578966976511e-06 0.1023817709659086 1.803579071607409e-06 0.1015861061604995 \
1.803579195570165e-06 0.1006484085638475 1.803579292969478e-06 0.09991551135558702 1.803579413227425e-06 0.09901872452754552 1.8035795240953e-06 0.09819831936474602 \
1.803579628568336e-06 0.09742874659471555 1.803579745805045e-06 0.09656937225591002 1.803579847599366e-06 0.09582695326576983 1.803579945574917e-06 0.09511577589263259 \
1.803580086079406e-06 0.09410164141823299 1.803580191157202e-06 0.09334832721827611 1.803580289770019e-06 0.09264549593674179 1.803580382484827e-06 0.09198739948435641 \
1.803580468683212e-06 0.09137785861853052 1.803580562596188e-06 0.09071637432184691 1.803580659696933e-06 0.09003559055802626 1.803580769117988e-06 0.08927317549644689 \
1.803580870101537e-06 0.08857281843916648 1.803580963759483e-06 0.08792605868920525 1.803581037934155e-06 0.08741581771673042 1.803581175834007e-06 0.08647193599618339 \
1.803581248191011e-06 0.08597917321277694 1.803581383512214e-06 0.08506274029062395 1.803581469423819e-06 0.08448410751389913 1.803581614152054e-06 0.08351486081643937 \
1.803581710382619e-06 0.0828744112740944 1.803581798218398e-06 0.08229260392026354 1.803581914017306e-06 0.08152964121883956 1.803582029145757e-06 0.08077575264951149 \
1.80358214291219e-06 0.08003553900012179 1.803582283169683e-06 0.0791300282244784 1.803582424545716e-06 0.07822490276368012 1.803582574181757e-06 0.07727536491519127 \
1.803582718670613e-06 0.07636690312463701 1.803582869844724e-06 0.07542565384097814 1.803583019215544e-06 0.07450459906593411 1.803583168562251e-06 0.0735926433331697 \
1.803583328517767e-06 0.07262574717347114 1.803583484664678e-06 0.07169171823582712 1.803583659153112e-06 0.07065947636250877 1.803583828862219e-06 0.0696671357044583 \
1.803584014041303e-06 0.0685979885997255 1.80358421076238e-06 0.06747763456279594 1.8035844212802e-06 0.06629631776014881 1.803584643312255e-06 0.06507007089066431 \
1.803584873524276e-06 0.0638195278444372 1.803585116035382e-06 0.06252626147401 1.803585376689467e-06 0.06116236403900636 1.803585656588531e-06 0.05972739422233359 \
1.803585950172255e-06 0.05825544847408989 1.803586265108239e-06 0.05671370145268265 1.803586607914164e-06 0.05507846134953124 1.803586957380758e-06 0.0534565727116736 \
1.803587366284915e-06 0.05161746230842366 1.803587712949942e-06 0.05010669351290297 1.803588100364995e-06 0.04846839895323611 1.803588444582787e-06 0.04705645202362623 \
1.803588768009047e-06 0.04576625679949029 1.803589073054809e-06 0.04458093278443617 1.803589365916806e-06 0.04347099288378908 1.803589650057723e-06 0.04242242262004604 \
1.803589926078015e-06 0.04142902112907627 1.803590192930566e-06 0.04049015932812138 1.803590461822789e-06 0.03956531631184226 1.803590737883211e-06 0.03863769040165695 \
1.803591025478782e-06 0.03769451689421055 1.803591265044408e-06 0.03692662498323904 1.803591554211835e-06 0.03602084344675294 1.803591770003438e-06 0.03535960341037672 \
1.803591957720476e-06 0.03479599077274986 1.803592155849582e-06 0.03421285035004928 1.803592518724446e-06 0.03317032497347058 1.803592776866276e-06 0.03244834222605905 \
1.80359308657919e-06 0.0316030971185694 1.803593352049328e-06 0.03089664771451467 1.803593620168408e-06 0.03019941363307669 1.803593899042439e-06 0.02949128999862272 \
1.803594145228875e-06 0.02888043298519722 1.803594375860285e-06 0.02832033800396738 1.803594614150204e-06 0.02775711540944564 1.803594849157568e-06 0.02721270742060762 \
1.803595076940031e-06 0.02669509678424227 1.803595485552303e-06 0.02579039168486155 1.803595661854632e-06 0.02540904040268441 1.803596016332316e-06 0.02465798827491217 \
1.803596200203288e-06 0.02427641469830137 1.80359653515201e-06 0.02359448510613503 1.803596699060727e-06 0.02326678168937357 1.803597091331304e-06 0.02249905491676728 \
1.803597247322069e-06 0.02220010404946675 1.803597678925426e-06 0.02138321689778962 1.803597816314806e-06 0.0211255367654138 1.803598333123589e-06 0.02017559010600388 \
1.803598458659483e-06 0.01995091418019728 1.803598915901007e-06 0.01915998482559782 1.803599075046989e-06 0.01889493739859509 1.803599682285467e-06 0.01793263500095189 \
1.803599816822955e-06 0.01772934138481063 1.803600480086948e-06 0.01678091027541291 1.803600673410379e-06 0.01651856846389665 1.803601341067039e-06 0.01565087920017967 \
1.803601502655887e-06 0.01544858341705342 1.80360225789114e-06 0.01454101846553843 1.803602407452107e-06 0.01436800730673201 1.803603297789931e-06 0.01338293844200974 \
1.803603396447817e-06 0.01327873262558703 1.803604353121314e-06 0.01230993787860994 1.803604474231021e-06 0.01219243157195396 1.80360546572373e-06 0.01126376273051215 \
1.80360562925246e-06 0.01111855113153209 1.803606759174535e-06 0.01018247077230436 1.803606871621774e-06 0.01009565848301377 1.803608249445262e-06 0.009103273453806031 \
1.803608388390533e-06 0.009009747578659758 1.803609942788868e-06 0.008018073335410726 1.80361005485534e-06 0.00794673960805117 1.80361169983817e-06 0.006958154532207958 \
1.803611807090664e-06 0.006899512253112593 1.803613751584152e-06 0.005937533026687714 1.80361395848211e-06 0.005843834961138424 1.803616297369852e-06 0.00487227039639981 \
1.803616721356264e-06 0.004712306502041247 1.80361949358946e-06 0.003780857497341114 1.803619941898552e-06 0.003647790772321777 1.803623582397237e-06 0.00272553831825111 \
1.803624079053071e-06 0.002619503085887757 1.803629830173496e-06 0.001650572925599863 1.803630116955382e-06 0.001609446887446839 1.803635471944067e-06 0.0006353228983793809 \
1.803635677300692e-06 0.0005920420449145349 1.806282712074507e-06 -0.0002718533828215428 1.80628286795011e-06 -0.0004579010352009555 1.806283416265203e-06 -0.001326296959495401 \
1.806283529048879e-06 -0.001543805653187533 1.806283963541018e-06 -0.002491429791030493 1.806284039366175e-06 -0.002673591589873599 1.806284396016773e-06 -0.003590195133438418 \
1.806284523065853e-06 -0.003936807634339821 1.806284801566247e-06 -0.004716444651655622 1.80628490965073e-06 -0.005020876868076652 1.806285253249855e-06 -0.00592430224391268 \
1.80628536024372e-06 -0.006162325733041658 1.806286259614116e-06 -0.005653094509861465 1.806286438047545e-06 -0.004687598829536962 1.80628654377096e-06 -0.003940993102967527 \
1.806286668833738e-06 -0.002883597584075996 1.806286762417834e-06 -0.001971418478057775 1.806286840257396e-06 -0.001132968824455395 1.806286920329394e-06 -0.0001977429743171 \
1.806287042702204e-06 0.001370578777960296 1.806287160958077e-06 0.003041212838230153 1.806287279607187e-06 0.004860750887681821 1.806287393089626e-06 0.006730904986417607 \
1.806287496532764e-06 0.008536402178002854 1.806287611192018e-06 0.01064190690353853 1.806287801775811e-06 0.0143607330143792 1.806287935565949e-06 0.01711819191720031 \
1.806288085819515e-06 0.02033933849841947 1.806288240988762e-06 0.02378599874269359 1.806288396380811e-06 0.0273434151175349 1.806288544088042e-06 0.03080849965087477 \
1.806288693077668e-06 0.03437359286003162 1.806288848068751e-06 0.03814545786868043 1.806289007439365e-06 0.04208062121327779 1.806289172372775e-06 0.04620305710844342 \
1.806289347319104e-06 0.0506208066052034 1.806289526449176e-06 0.05518387280380205 1.806289716238431e-06 0.06005265756871143 1.8062899199354e-06 0.06530840376289772 \
1.806290139745932e-06 0.07100650943730057 1.806290371497376e-06 0.07703584544314998 1.806290619322673e-06 0.08349927754587044 1.806290890643603e-06 0.09058756662233436 \
1.806291185356381e-06 0.09829181712822582 1.806291510614029e-06 0.106792896697727 1.806291876859735e-06 0.1163551101154179 1.806292270156448e-06 0.1266079356677421 \
1.806292722809343e-06 0.1383809089651769 1.806293248524511e-06 0.1520098384503803 1.806293867738049e-06 0.1679979965193872 1.806294548482365e-06 0.1854865650013753 \
1.80629534215732e-06 0.2057488551561759 1.806296230922953e-06 0.2282732214494322 1.806297044312215e-06 0.2487218262351868 1.806297766061792e-06 0.2667261628598245 \
1.8062984017258e-06 0.282460740414376 1.806298973442562e-06 0.2965101025186013 1.806299508996846e-06 0.3095696210007924 1.806300012355259e-06 0.3217495654069301 \
1.806300488682701e-06 0.3331878525640654 1.806300962606306e-06 0.3444754071334732 1.806301420078024e-06 0.3552759747331513 1.806301886058294e-06 0.3661792384270033 \
1.806302335046104e-06 0.376592601923634 1.806302831152645e-06 0.3879857357798637 1.806303350914508e-06 0.3998002499051578 1.806303730319152e-06 0.4083447473225827 \
1.806304170327876e-06 0.4181679450526055 1.806304640096813e-06 0.4285466970600206 1.806305125617752e-06 0.4391589006481625 1.806305565065858e-06 0.4486701556983262 \
1.806305626818807e-06 0.4500002248264944 1.806305750324704e-06 0.4526540461147197 1.806305997336497e-06 0.4579447795386873 1.806306249931409e-06 0.463325462421476 \
1.806306447502524e-06 0.467511453725808 1.806306673074271e-06 0.4722681264242033 1.806306994642268e-06 0.4790073975813253 1.806307263421496e-06 0.4846013351959894 \
1.80630748207297e-06 0.4891262574467725 1.806307692176936e-06 0.4934547887280634 1.806307918582461e-06 0.4980921872304203 1.806308127687652e-06 0.5023516957637455 \
1.806308317089911e-06 0.5061927337048852 1.806308441251129e-06 0.5086969563931187 1.806308568006226e-06 0.5112441466129884 1.806308728004704e-06 0.5144514110933732 \
1.806308975647656e-06 0.5193914248715521 1.806309154234115e-06 0.5229351592435862 1.806309325187692e-06 0.5263079149198099 1.806309586537288e-06 0.5314455197962068 \
1.80630981260887e-06 0.5358634945234868 1.806310015740537e-06 0.5398188128751134 1.806310180971267e-06 0.5430252218652345 1.806310337758288e-06 0.5460612552756139 \
1.806310526914905e-06 0.5497137532216215 1.806310728782658e-06 0.5535976061995346 1.806310952933981e-06 0.5578986282275192 1.806311191316346e-06 0.5624617013850463 \
1.806311426077985e-06 0.566941985223824 1.80631165634869e-06 0.5713275351537204 1.806311862141324e-06 0.5752375533958141 1.806312067125538e-06 0.5791255875933676 \
1.806312309940779e-06 0.5837094709690289 1.806312564698362e-06 0.588493349632063 1.806312792926793e-06 0.5927514274590796 1.806313030765665e-06 0.5971656109489694 \
1.806313243043101e-06 0.6010807441713891 1.806313454836505e-06 0.6049674646600495 1.806313708720774e-06 0.6095919957414236 1.806313913314301e-06 0.6132953190650409 \
1.806314165037654e-06 0.6178178328453598 1.806314352827174e-06 0.6211736970442716 1.806314605700251e-06 0.6256587164710262 1.806314804109613e-06 0.6291560967673944 \
1.806314983842284e-06 0.6323071487074056 1.806315254113091e-06 0.6370161336915187 1.806315471396857e-06 0.6407803561788556 1.806315651923236e-06 0.6438916924996977 \
1.806315853084131e-06 0.6473460740030906 1.806316021667512e-06 0.650231451944099 1.80631622602572e-06 0.6537144072723954 1.806316371688778e-06 0.6561873372238678 \
1.806316536247377e-06 0.6589728476742622 1.806316705716593e-06 0.6618316558839334 1.806316859256675e-06 0.664412775690417 1.806317000490202e-06 0.6667750288922751 \
1.806317144066013e-06 0.6691685747430841 1.806317277296139e-06 0.6713840140331436 1.806317419196459e-06 0.6737368819239464 1.806317539430086e-06 0.6757233098298149 \
1.806317684081138e-06 0.6781085120392751 1.806317800299843e-06 0.6800197521569988 1.806317919382163e-06 0.6819757159594566 1.806318017960476e-06 0.6835903813535821 \
1.806318135558183e-06 0.6855122399681081 1.806318222994146e-06 0.6869376986921233 1.806318347740232e-06 0.6889650632873403 1.806318447547296e-06 0.6905825000046129 \
1.806318540037093e-06 0.6920753042469043 1.806318641321177e-06 0.6937043390836264 1.806318739114283e-06 0.695273833970533 1.806318830385074e-06 0.6967333967490603 \
1.806318932842905e-06 0.6983656370917724 1.806319065752135e-06 0.7004728611232253 1.806319220767541e-06 0.7029137789397926 1.806319355649227e-06 0.7050222373350452 \
1.806319501145018e-06 0.7072806469370021 1.806319628999685e-06 0.709252249158637 1.80631975345798e-06 0.7111597484283609 1.806319864783685e-06 0.7128563623504806 \
1.806319978813713e-06 0.7145852226468989 1.80632007932493e-06 0.7161013069709498 1.806320216526077e-06 0.7181590832501857 1.806320336471979e-06 0.7199473375636642 \
1.806320455641778e-06 0.7217141075019444 1.806320582586791e-06 0.7235855504531626 1.806320707354209e-06 0.7254141264975077 1.806320830849597e-06 0.7272133847865295 \
1.80632095763087e-06 0.7290498056238117 1.806321088220355e-06 0.730930225429108 1.806321210432258e-06 0.7326797786847141 1.806321347490271e-06 0.7346298644824388 \
1.806321448705626e-06 0.7360619656663578 1.806321553674562e-06 0.7375401619041119 1.806321645165995e-06 0.7388229997694907 1.806321758241356e-06 0.7404001534680551 \
1.80632184554224e-06 0.7416107338190071 1.80632195000557e-06 0.7430512000342341 1.806322080768703e-06 0.7448411286358657 1.8063221906822e-06 0.7463352048609909 \
1.806322295341958e-06 0.7477488743938407 1.80632241917362e-06 0.7494094725133206 1.806322567926971e-06 0.751387874302702 1.806322689842132e-06 0.7529958494242643 \
1.806322803696392e-06 0.7544867042370438 1.80632294419585e-06 0.7563117925204224 1.806323085519364e-06 0.7581313010100689 1.806323203298971e-06 0.7596352654099263 \
1.806323331697459e-06 0.7612620174900669 1.806323474021161e-06 0.7630496612437514 1.806323590410315e-06 0.7644991888858087 1.806323736133977e-06 0.7662987831554334 \
1.806323857913867e-06 0.7677897310961733 1.806323976478797e-06 0.7692300520321635 1.806324099092246e-06 0.7707078417740018 1.806324225543629e-06 0.77221964326554 \
1.806324335666584e-06 0.7735261258099556 1.806324461188726e-06 0.7750039859681491 1.806324566849672e-06 0.7762386743660952 1.806324702026829e-06 0.7778058706872942 \
1.806324825637345e-06 0.7792267957652825 1.806324955634725e-06 0.7807078764205345 1.806325068606223e-06 0.7819831642610904 1.806325176500111e-06 0.7831908181350914 \
1.806325313030793e-06 0.7847046126527283 1.806325463151702e-06 0.7863508260127218 1.806325605416006e-06 0.7878933964149381 1.806325724997519e-06 0.7891771019825847 \
1.806325861808649e-06 0.7906313890246753 1.806325984312413e-06 0.7919206245676671 1.806326128984341e-06 0.7934276941869095 1.806326269769414e-06 0.794878360380241 \
1.806326396585209e-06 0.796171745508174 1.806326515632602e-06 0.7973744708066829 1.806326627895563e-06 0.7984986270115709 1.806326732283333e-06 0.7995352562746869 \
1.806326827560395e-06 0.8004739840425704 1.806326963902891e-06 0.8018044219089175 1.80632708076796e-06 0.8029326473252685 1.806327200364489e-06 0.8040757482679398 \
1.806327322250299e-06 0.8052288531124292 1.806327444838559e-06 0.8063765489401953 1.806327572579618e-06 0.8075599074701925 1.806327697362526e-06 0.8087035441861687 \
1.8063278278629e-06 0.8098867241643505 1.806327954229597e-06 0.8110199871086299 1.806328081578389e-06 0.8121498004723215 1.806328186791179e-06 0.8130740322933268 \
1.806328291495184e-06 0.8139855427426806 1.80632838302539e-06 0.8147757515715357 1.80632850639836e-06 0.8158311616195392 1.806328593352408e-06 0.8165684017534872 \
1.806328692208245e-06 0.8173999442793862 1.806328836710884e-06 0.8186029267949408 1.806328973036572e-06 0.8197243345631372 1.806329082445008e-06 0.8206145128367788 \
1.806329228461948e-06 0.821788834531623 1.806329380203007e-06 0.8229927727264784 1.806329506119585e-06 0.8239792970156907 1.806329650568649e-06 0.8250971468990039 \
1.806329775264817e-06 0.8260503472050121 1.806329925878834e-06 0.8271873005969326 1.806330061249302e-06 0.8281959289694237 1.806330186472937e-06 0.8291179217777711 \
1.806330304128897e-06 0.8299746468143927 1.80633044991051e-06 0.8310230722388168 1.80633061639426e-06 0.8322027532553667 1.806330747215023e-06 0.8331167337813133 \
1.806330920675045e-06 0.834311196379941 1.806331088787841e-06 0.8354501125721271 1.806331258668969e-06 0.8365827385393307 1.806331439512627e-06 0.8377685497174457 \
1.806331582704692e-06 0.8386931238161603 1.806331696822189e-06 0.8394210074154138 1.806331826873799e-06 0.8402408682651782 1.806331928753516e-06 0.8408758513273116 \
1.806332045641139e-06 0.841596551294542 1.806332182786859e-06 0.8424315815669623 1.806332380696072e-06 0.8436167827761205 1.806332572515411e-06 0.8447436440637145 \
1.806332781866157e-06 0.8459494874145237 1.806332964017768e-06 0.8469786287449077 1.80633316110399e-06 0.8480715276019779 1.806333334356719e-06 0.8490148531186206 \
1.806333517450963e-06 0.8499943787178993 1.80633368858243e-06 0.8508936588199895 1.806333863270272e-06 0.8517955326875627 1.806334038504287e-06 0.8526841769874772 \
1.806334214641154e-06 0.8535614892404448 1.806334405008494e-06 0.8544920815553035 1.806334595580845e-06 0.8554057038167108 1.806334795976838e-06 0.8563474066245403 \
1.806334988566463e-06 0.8572344253714166 1.806335199466375e-06 0.858185963363946 1.806335427341862e-06 0.8591913103610016 1.806335693424718e-06 0.8603357477151101 \
1.806335991926854e-06 0.8615822374427254 1.806336267816323e-06 0.8627000332972231 1.806336552083492e-06 0.8638181192989086 1.806336826221443e-06 0.8648650323418529 \
1.806337098522366e-06 0.8658754039994767 1.806337368678562e-06 0.8668495780678541 1.806337625862699e-06 0.8677515347235455 1.806337898421613e-06 0.8686810999091764 \
1.806338174469331e-06 0.8695957110915412 1.806338444589598e-06 0.8704649939918846 1.806338744449489e-06 0.8714007440816277 1.806339115430114e-06 0.8725171209518352 \
1.806339410352536e-06 0.8733732402027278 1.806339664628271e-06 0.8740897163373675 1.806339962841735e-06 0.8749052413925265 1.806340236411346e-06 0.8756305047096297 \
1.806340472534748e-06 0.8762394088953867 1.806340712859886e-06 0.8768433401198644 1.806340935193821e-06 0.8773882060838187 1.806341129200254e-06 0.8778530214284207 \
1.806341458909681e-06 0.8786208714695904 1.80634161408109e-06 0.87897283049042 1.806341931723491e-06 0.8796750328643211 1.806342110604035e-06 0.8800599154915705 \
1.806342453064798e-06 0.8807759898408113 1.80634263726721e-06 0.8811501695110489 1.806343112296513e-06 0.8820806183873429 1.806343279683462e-06 0.8823969901232691 \
1.806343745459843e-06 0.8832471741583867 1.806343926299187e-06 0.8835657112976044 1.806344420308805e-06 0.8844044135654346 1.806344561623711e-06 0.8846360992458032 \
1.806345167867326e-06 0.8855901496945974 1.806345319942526e-06 0.8858196526512701 1.806345966662599e-06 0.8867549368993356 1.806346094949266e-06 0.8869330782847171 \
1.806346743158686e-06 0.8877977435561634 1.806346872882985e-06 0.8879638504720397 1.806347641302052e-06 0.8888993076310558 1.806347771073903e-06 0.8890488273083775 \
1.806348624736509e-06 0.8899738047157748 1.806348767761561e-06 0.8901192131187072 1.806349754067048e-06 0.8910487927319016 1.8063499755536e-06 0.8912403904783051 \
1.806351118378138e-06 0.8921548233216382 1.806351248258076e-06 0.8922544308366913 1.806352600758498e-06 0.8932425879319322 1.806352751041431e-06 0.8933452769452155 \
1.806354231575697e-06 0.8942627870546499 1.806354470485492e-06 0.8943950258099049 1.806356252518433e-06 0.8952625983306248 1.80635663826586e-06 0.895426813549116 \
1.806359040424079e-06 0.8963023915260389 1.806359515360048e-06 0.8964490046842035 1.806363433287164e-06 0.8974035634625627 1.806363903247409e-06 0.8974927205890085 \
1.806372272035387e-06 0.8984807567386782 1.806372492545714e-06 0.8984960697096243 1.806417072074292e-06 0.8994905034760702 1.806418273460191e-06 0.8995076493514624 \
1.806554083268694e-06 0.9004821828323031 1.806554262245419e-06 0.9005421539807538 1.806557707120337e-06 0.8996085030263692 1.806557879904192e-06 0.8994755022453073 \
1.806559206223899e-06 0.8985168769831137 1.806559392989208e-06 0.8983970610744239 1.806561177194233e-06 0.8974304740967198 1.806561389324515e-06 0.8973403978332656 \
1.806574730020299e-06 0.8983331062395279 1.806574843308144e-06 0.8983517458922662 1.806583546661241e-06 0.8993273409280406 1.80658409447182e-06 0.8993637478389299 \
1.807076621843715e-06 0.9003542216796759 1.807076717582566e-06 0.9004233209197793 1.807077660131942e-06 0.9014023545001312 1.807077822585254e-06 0.9016297223302431 \
1.8070783892915e-06 0.9025464066367429 1.807078496462212e-06 0.9027401250447874 1.807078889770564e-06 0.9035002370985188 1.807079022567928e-06 0.9037710185404622 \
1.807079402169034e-06 0.9045728679206633 1.80707953238378e-06 0.9048512534150681 1.807079993790073e-06 0.9057878278182891 1.807080113037131e-06 0.9060008176934132 \
1.807081542646165e-06 0.9050557440230738 1.807081626316292e-06 0.9046580283931719 1.807081751622122e-06 0.9039622140338933 1.80708185943629e-06 0.9032622438705011 \
1.807081978430637e-06 0.9023800387125585 1.807082093802854e-06 0.9014106868475621 1.807082183899751e-06 0.900578017289966 1.807082295347455e-06 0.8994526603282017 \
1.807082381426603e-06 0.8985125975436928 1.807082487392251e-06 0.8972736935213672 1.807082587160617e-06 0.8960214106762436 1.807082668156227e-06 0.8949470092681954 \
1.807082777804195e-06 0.8934133399212493 1.807082863391606e-06 0.8921520042367302 1.807082955514215e-06 0.8907345325087322 1.807083043733598e-06 0.8893220116766375 \
1.807083152508351e-06 0.8875100775672261 1.807083235401386e-06 0.8860780350921965 1.807083343975057e-06 0.8841400608632336 1.807083436201252e-06 0.8824412727986957 \
1.80708352082175e-06 0.8808423775446282 1.80708360666218e-06 0.8791839877465467 1.80708368587706e-06 0.8776224824828824 1.80708376196503e-06 0.8760960492665846 \
1.807083854301399e-06 0.874210837196514 1.807083914177735e-06 0.8729702140710593 1.807083971566019e-06 0.8717685933706794 1.807084033561192e-06 0.8704574090763495 \
1.807084096840043e-06 0.8691057216070059 1.807084146911381e-06 0.8680269866686803 1.807084196353533e-06 0.8669542389500936 1.80708426002324e-06 0.8655623656543436 \
1.807084335970659e-06 0.8638877358586781 1.807084384801671e-06 0.8628032002737418 1.807084433325624e-06 0.8617197496806845 1.807084509037347e-06 0.8600184098866027 \
1.807084576246125e-06 0.8584975010852487 1.807084618952631e-06 0.8575263577286506 1.807084662855204e-06 0.8565244243916033 1.807084750660351e-06 0.8545103166059256 \
1.807084813513519e-06 0.8530605771626394 1.807084872183177e-06 0.8517018597088126 1.807084908361778e-06 0.8508614974547222 1.807084943180258e-06 0.8500510151036469 \
1.807084978206243e-06 0.8492340038666518 1.807085048258213e-06 0.8475953578585981 1.807085096728698e-06 0.8464581214772323 1.807085140673499e-06 0.8454248116355969 \
1.807085186191255e-06 0.8443523575543517 1.807085250092166e-06 0.8428433081697474 1.807085316218539e-06 0.8412777165526386 1.807085421348608e-06 0.8387809254526315 \
1.807085509283283e-06 0.8366857089760468 1.807085588228565e-06 0.834800137446173 1.807085676393602e-06 0.8326899670047023 1.807085763209599e-06 0.8306078985741704 \
1.807085851101283e-06 0.8284959280419055 1.807085942350373e-06 0.8262996967350639 1.807086045112241e-06 0.8238226494465998 1.807086143615716e-06 0.8214450402687625 \
1.807086255948631e-06 0.8187302447322098 1.807086368922768e-06 0.8159967029774419 1.807086490210663e-06 0.8130591602364435 1.807086620717817e-06 0.8098958628758253 \
1.807086749763719e-06 0.8067658935936169 1.80708690323932e-06 0.8030416153605923 1.80708706852354e-06 0.799029304640783 1.807087236264744e-06 0.7949567682299736 \
1.807087432788334e-06 0.7901857478752816 1.807087637550659e-06 0.7852160332972318 1.807087850227715e-06 0.7800563994093253 1.807088050847662e-06 0.7751902022758907 \
1.807088251706389e-06 0.7703212856706637 1.807088401728407e-06 0.766686939713112 1.807088532263574e-06 0.7635264252913375 1.807088666681014e-06 0.7602735436595947 \
1.807088772876544e-06 0.7577048602246427 1.807088906182877e-06 0.754482067181252 1.807089013215803e-06 0.7518959494812111 1.807089156291704e-06 0.7484409822837247 \
1.807089320797846e-06 0.7444713482725677 1.807089441615092e-06 0.74155777711076 1.807089612721756e-06 0.7374334100931738 1.807089773612309e-06 0.733558046396253 \
1.80708999020493e-06 0.7283457217000903 1.807090183460631e-06 0.7236999380850822 1.807090362395765e-06 0.7194029726762079 1.807090529212387e-06 0.7154015770462002 \
1.807090715418352e-06 0.7109395231330657 1.807090903351593e-06 0.7064416825495208 1.807091069273699e-06 0.7024749886985119 1.807091261631787e-06 0.6978803202016938 \
1.807091402988682e-06 0.6945068232011449 1.807091559996444e-06 0.6907636199298515 1.807091755976089e-06 0.6860965106368763 1.807091918410194e-06 0.6822325558671515 \
1.807092079586376e-06 0.6784034260021697 1.807092271894574e-06 0.6738409413562468 1.807092489556454e-06 0.6686845685784016 1.807092737577756e-06 0.6628199086538362 \
1.807092915635219e-06 0.6586162961343578 1.807093164179028e-06 0.6527567611811057 1.807093366786271e-06 0.6479896840619462 1.807093536596938e-06 0.6440011601507294 \
1.807093695213124e-06 0.6402799599229552 1.807093833743559e-06 0.637035894415233 1.807093969951321e-06 0.6338503464729111 1.807094096262698e-06 0.6309003762865483 \
1.807094225721933e-06 0.6278810604265532 1.807094354053672e-06 0.6248911458464299 1.807094485383602e-06 0.6218374290191309 1.807094617410215e-06 0.6187713222160208 \
1.807094761570095e-06 0.6154276788919771 1.807094905778687e-06 0.6120888358645944 1.807095053433791e-06 0.6086753592300279 1.807095200490149e-06 0.6052842859263143 \
1.807095358304176e-06 0.6016504852589418 1.807095490909828e-06 0.5986039825107707 1.807095622374795e-06 0.5955897059985247 1.807095741804593e-06 0.5928552647156846 \
1.807095877873286e-06 0.5897484304797134 1.807095992801548e-06 0.5871283594046445 1.807096143912269e-06 0.5836892419704927 1.807096258561337e-06 0.5810871834776226 \
1.807096376499006e-06 0.5784138884735546 1.807096466280294e-06 0.576381560286313 1.807096556599689e-06 0.5743415774978985 1.807096623290559e-06 0.5728373329037385 \
1.807096688852372e-06 0.5713590910263378 1.807096739894496e-06 0.5702089751121119 1.807096801596215e-06 0.5688198806440578 1.807096864686071e-06 0.5674025889664359 \
1.807096929044424e-06 0.5659586381304559 1.807096982438223e-06 0.5647616504486359 1.807097075080806e-06 0.5626864159088959 1.807097151688078e-06 0.5609719030357503 \
1.80709720751314e-06 0.5597256439368602 1.807097276567267e-06 0.5581857825097393 1.807097383455392e-06 0.5558054549196561 1.807097461199017e-06 0.5540764009223496 \
1.807097562049117e-06 0.5518382286767042 1.807097687729972e-06 0.5490568313009737 1.807097787971657e-06 0.5468419758621708 1.80709789988934e-06 0.5443739014182352 \
1.807098003155247e-06 0.5421024366463116 1.807098122904589e-06 0.5394737463112931 1.807098224637469e-06 0.5372436950013484 1.807098340157213e-06 0.5347185748314579 \
1.807098455192299e-06 0.5322102907975605 1.807098581673211e-06 0.529456475824718 1.807098707047008e-06 0.5267350629320526 1.807098853862932e-06 0.5235577714138258 \
1.807098989426381e-06 0.5206304261698983 1.807099147124634e-06 0.5172373565578411 1.807099309443689e-06 0.5137528589513558 1.807099490267585e-06 0.5098871206809381 \
1.807099682715905e-06 0.5057874350093188 1.807099895621208e-06 0.5012700264709963 1.807100127802608e-06 0.4963634062180514 1.807100385093187e-06 0.4909555076455908 \
1.80710062471901e-06 0.4859407514401474 1.807100926434446e-06 0.479662588092526 1.8071012143538e-06 0.4737079198104491 1.807101527242619e-06 0.4672821326282255 \
1.807101846980824e-06 0.4607585360408045 1.807102186575984e-06 0.4538766993710576 1.807102513478483e-06 0.4472977926730654 1.807102849036864e-06 0.4405887635920606 \
1.807103166132787e-06 0.4342949501181722 1.807103500370541e-06 0.4277061431972559 1.807103851801663e-06 0.4208322784122511 1.807104166327818e-06 0.4147233751108969 \
1.807104489505308e-06 0.4084912998479469 1.807104930620066e-06 0.400057814108821 1.807105272736103e-06 0.3935812134363078 1.807105572680633e-06 0.3879522399691127 \
1.807105947811638e-06 0.3809760137481454 1.807106277555877e-06 0.3749002425561211 1.807106560798803e-06 0.3697269896098562 1.807106860945059e-06 0.3642865787664632 \
1.807107140547253e-06 0.3592589179584539 1.807107364323365e-06 0.3552676761685443 1.807107576103695e-06 0.3515151294490645 1.807107778537159e-06 0.3479514629380864 \
1.807107979628427e-06 0.3444362246481504 1.807108185342845e-06 0.3408632458568372 1.807108452965717e-06 0.3362478643926977 1.807108691897011e-06 0.3321601360780691 \
1.807108925403074e-06 0.3281974319442653 1.807109138868473e-06 0.3246000376975314 1.807109360246046e-06 0.3208952602338652 1.807109560209693e-06 0.3175728982722026 \
1.807109764482006e-06 0.3142073831356898 1.807109961828878e-06 0.3109812293225088 1.807110147201405e-06 0.3079732989686547 1.807110343307796e-06 0.3048147723336881 \
1.807110545584936e-06 0.3015820927993307 1.807110721243233e-06 0.2988007390096292 1.80711090711339e-06 0.295878328903569 1.807111114092782e-06 0.2926488196724605 \
1.807111299414374e-06 0.2897857719971084 1.807111494641182e-06 0.2867989994419413 1.807111650415531e-06 0.28443329608414 1.807111829172313e-06 0.2817356906084737 \
1.807112010203233e-06 0.2790344478478936 1.807112160100347e-06 0.2768142575519123 1.807112361143774e-06 0.273859574769726 1.807112510258904e-06 0.2716833853889438 \
1.807112648798333e-06 0.2696726034832688 1.807112800673409e-06 0.2674956304896134 1.807112915147537e-06 0.2658586287383957 1.807113046677468e-06 0.2639823142040156 \
1.807113172435956e-06 0.2622048582339201 1.807113276776362e-06 0.2607341604582348 1.807113389755722e-06 0.2591418073851619 1.807113506084246e-06 0.2575033437579446 \
1.807113649011667e-06 0.2554974228347739 1.807113762273172e-06 0.2539102348881249 1.807113896429905e-06 0.2520298733123076 1.807114006902709e-06 0.2504818583075984 \
1.807114162335285e-06 0.2483006006477398 1.807114303220383e-06 0.2463217957442577 1.807114454612954e-06 0.2441928603691365 1.807114609775034e-06 0.2420086586735095 \
1.807114739184283e-06 0.2401849910837116 1.807114873896376e-06 0.2382868210192302 1.807115011594201e-06 0.2363478190565156 1.807115129346217e-06 0.2346905900295477 \
1.80711528867041e-06 0.2324499447852502 1.807115425932636e-06 0.2305210708572645 1.807115566678993e-06 0.2285488733964877 1.807115672470167e-06 0.2270688194984586 \
1.807115802411564e-06 0.2252532503786337 1.807115902948028e-06 0.2238506847401111 1.807116005281736e-06 0.2224250970611539 1.807116079010317e-06 0.2214012665004395 \
1.80711615824426e-06 0.2203047212273054 1.807116229215507e-06 0.2193236206014474 1.807116280678535e-06 0.218612902325451 1.807116333626988e-06 0.2178825126218075 \
1.807116412781991e-06 0.2167921001391954 1.807116455054626e-06 0.2162104926182252 1.807116494899171e-06 0.2156628374086678 1.80711653812282e-06 0.2150692779925967 \
1.807116579029822e-06 0.2145080585354088 1.807116649152284e-06 0.2135474129702876 1.807116682837255e-06 0.2130867492099046 1.807116727666638e-06 0.212477723463 \
1.8071167865238e-06 0.2116792343136102 1.80711685130926e-06 0.2108017053965978 1.807116908790024e-06 0.2100241135398916 1.807116969219033e-06 0.209207737948094 \
1.807117066255463e-06 0.2078991976528634 1.807117150945123e-06 0.2067595417901527 1.807117259855885e-06 0.2052972881712416 1.807117356256692e-06 0.2040065614180294 \
1.807117451273329e-06 0.2027428333585779 1.807117554705127e-06 0.2013717100485363 1.807117649634473e-06 0.2001158751783069 1.807117752654899e-06 0.198757993281026 \
1.807117857737332e-06 0.1973779917312911 1.807117967046146e-06 0.1959482000350934 1.807118077489628e-06 0.1945091075764383 1.807118193779903e-06 0.1929996650696684 \
1.807118303709896e-06 0.1915811184357085 1.80711841337232e-06 0.1901717999899754 1.807118515088965e-06 0.1888694322720079 1.807118608043679e-06 0.1876837490531375 \
1.807118700772569e-06 0.1865049219968967 1.807118774458125e-06 0.1855719169757668 1.80711885729934e-06 0.1845269810791141 1.807118931885336e-06 0.1835895008849975 \
1.807119001608678e-06 0.1827150226754214 1.807119068327085e-06 0.1818808699270075 1.807119164170411e-06 0.1806871657728035 1.807119246877184e-06 0.1796611249561687 \
1.807119340441007e-06 0.1785035608809835 1.807119435337095e-06 0.1773351434884491 1.807119546707405e-06 0.1759704596301353 1.807119688349759e-06 0.1742450478777388 \
1.807119803596612e-06 0.1728486436789435 1.807119948144251e-06 0.1711076225712051 1.807120059739928e-06 0.1697708811114609 1.807120200958902e-06 0.1680898955975501 \
1.807120316696175e-06 0.1667201145354908 1.807120422656861e-06 0.1654722325850081 1.807120521416477e-06 0.164314417410061 1.80712061775965e-06 0.1631901152369615 \
1.807120706417402e-06 0.1621596955203892 1.807120831751673e-06 0.1607099933926625 1.807120926277088e-06 0.1596224416957933 1.80712102401604e-06 0.1585042187118262 \
1.807121132110917e-06 0.1572745454417887 1.807121226778604e-06 0.1562036643369483 1.807121334226451e-06 0.1549951394274829 1.807121425315495e-06 0.1539767092330788 \
1.807121532087207e-06 0.1527896463435911 1.807121635480473e-06 0.1516469620792683 1.807121746560957e-06 0.1504267727114754 1.807121835786939e-06 0.1494522115900035 \
1.807121921266868e-06 0.1485231035185812 1.807122005192055e-06 0.1476157397758405 1.807122074898619e-06 0.1468658175993407 1.807122153536697e-06 0.1460232248551682 \
1.807122231847954e-06 0.1451880611912267 1.807122302483827e-06 0.1444378248611795 1.807122387974695e-06 0.1435337156153706 1.807122475363672e-06 0.1426139614481139 \
1.807122556951186e-06 0.1417594571206545 1.807122654270137e-06 0.1407454482154784 1.807122734959659e-06 0.139910090776864 1.80712282574469e-06 0.1389752404035735 \
1.807122947088963e-06 0.1377336220260025 1.807123036138604e-06 0.13682812281983 1.807123134655454e-06 0.1358318692385875 1.807123221741723e-06 0.1349560640726983 \
1.807123332152611e-06 0.1338550874529322 1.807123420611433e-06 0.1329791517134813 1.807123521340026e-06 0.1319874611681985 1.80712362612958e-06 0.1309622419763913 \
1.807123720519813e-06 0.1300442429014473 1.807123817024605e-06 0.1291112112475518 1.807123916511258e-06 0.1281591654439075 1.807124002912429e-06 0.1273384721630967 \
1.80712409789256e-06 0.1264411177628728 1.807124202081388e-06 0.1254629331099751 1.807124311200138e-06 0.124445178694 1.807124405550594e-06 0.1235704029653004 \
1.807124517846343e-06 0.1225411084520107 1.807124613309696e-06 0.1216733466577494 1.807124717520587e-06 0.1207311846737792 1.807124806865944e-06 0.1199276649878674 \
1.807124877253217e-06 0.1192980345746366 1.807124952639251e-06 0.1186268760051257 1.807125028771421e-06 0.1179522201461119 1.807125097748918e-06 0.1173458504859956 \
1.807125180268091e-06 0.1166263596898966 1.807125252211578e-06 0.1160015972854393 1.807125334290304e-06 0.1152916772467617 1.80712541862478e-06 0.1145654108773922 \
1.807125496418619e-06 0.113898375935255 1.807125589183521e-06 0.1131065723182637 1.807125704787342e-06 0.1121254933399327 1.807125810692911e-06 0.1112341778178403 \
1.807125888349831e-06 0.1105854195321705 1.807125976646302e-06 0.1098504899494786 1.807126056703354e-06 0.1091866403929743 1.807126153629479e-06 0.1083861389179563 \
1.807126248864964e-06 0.1076031391441806 1.807126337436159e-06 0.1068780200140514 1.80712643874426e-06 0.1060523297458165 1.807126544289947e-06 0.1051963702337609 \
1.807126653484312e-06 0.1043160928234657 1.807126761601933e-06 0.1034503663302994 1.807126881519694e-06 0.1024949450012773 1.807126982881521e-06 0.1016914181115986 \
1.807127088891151e-06 0.100855068690839 1.80712721468278e-06 0.09986840123414902 1.807127344240085e-06 0.09885896724496235 1.80712747991544e-06 0.09780904711780367 \
1.807127655987304e-06 0.09645781830037269 1.807127819787824e-06 0.09521257997344186 1.807127982612565e-06 0.09398642071914091 1.8071280677512e-06 0.09334985726464029 \
1.807128137589223e-06 0.09282999162688726 1.807128207084828e-06 0.09231474740697931 1.807128281043488e-06 0.09176875214326782 1.807128377198375e-06 0.09106241641841166 \
1.807128451613741e-06 0.09051841344162129 1.807128529603309e-06 0.08995079828656057 1.807128606052139e-06 0.08939693755534793 1.807128693546224e-06 0.08876614459792892 \
1.807128795722934e-06 0.08803382885421264 1.807128884287322e-06 0.08740269463919083 1.80712899395281e-06 0.08662585268124241 1.807129110009217e-06 0.08580942306245626 \
1.807129251558034e-06 0.0848216759818637 1.807129384427017e-06 0.08390253510334872 1.807129525187328e-06 0.08293727564630923 1.807129674896948e-06 0.08192024575105315 \
1.807129810608835e-06 0.08100683753927941 1.807129952125717e-06 0.08006309454860433 1.80713008724759e-06 0.07917070961097784 1.807130228520028e-06 0.07824718349428782 \
1.80713037561292e-06 0.07729532867436953 1.807130527122786e-06 0.07632524417621221 1.8071306924985e-06 0.07527819040792309 1.80713085625969e-06 0.07425356708383206 \
1.807131032389632e-06 0.07316505371836476 1.80713122152861e-06 0.07201151367936541 1.807131432202233e-06 0.07074528708793332 1.807131651768855e-06 0.06944624562626683 \
1.807131886535262e-06 0.06808094281860989 1.8071321449277e-06 0.06660616301228137 1.80713243959236e-06 0.06496103773121734 1.807132743671683e-06 0.06330286177969326 \
1.807133104582163e-06 0.06138472526627536 1.807133440499035e-06 0.05964719353945821 1.807133880676406e-06 0.05743991201668189 1.807134259043809e-06 0.05560437501227136 \
1.807134701502771e-06 0.05352996728430704 1.807135055522916e-06 0.05192508193542229 1.807135442039672e-06 0.05022502935509546 1.807135786643729e-06 0.04875485597254389 \
1.807136108618665e-06 0.04741934964807833 1.807136412152492e-06 0.04619304551845941 1.807136707073488e-06 0.04503122626702559 1.807136989555767e-06 0.04394770877170886 \
1.807137266636177e-06 0.04291147062934708 1.807137532363668e-06 0.04194013461971725 1.807137803594355e-06 0.0409708748276704 1.807138079853372e-06 0.04000619535229137 \
1.807138369752594e-06 0.03901828782233653 1.807138598128987e-06 0.03825741181922668 1.807138903013054e-06 0.03726495139513845 1.80713911968491e-06 0.03657573971894532 \
1.807139311041637e-06 0.03597943984071691 1.807139509636156e-06 0.03537298232318693 1.807139839551497e-06 0.03438820140908775 1.80714008149717e-06 0.03368375433354889 \
1.807140396809222e-06 0.03278771666975258 1.807140666929207e-06 0.03203957074185158 1.80714092330088e-06 0.03134567005659093 1.807141203312881e-06 0.03060515313352298 \
1.807141448968657e-06 0.02997014710356035 1.807141681704302e-06 0.02938120249260199 1.807141924434299e-06 0.02878348292867495 1.807142161161563e-06 0.02821317433052753 \
1.807142389807974e-06 0.0276732289298247 1.807142807093634e-06 0.02671456010533928 1.807143002274328e-06 0.02627749693639509 1.807143383441411e-06 0.02544369227895442 \
1.807143560694233e-06 0.02506446942885681 1.807143903145688e-06 0.02434654114125227 1.80714405641412e-06 0.02403127656358269 1.807144431432584e-06 0.02327616399748992 \
1.807144569066725e-06 0.02300530455388665 1.807145053333359e-06 0.02207084195640928 1.80714517295276e-06 0.02184403312078184 1.807145589991563e-06 0.02106026682208277 \
1.807145733393791e-06 0.02079332360769017 1.807146254605172e-06 0.01984598817089831 1.807146382379043e-06 0.0196205814374062 1.807146966791416e-06 0.01863359713481367 \
1.807147139226823e-06 0.01835589372257288 1.807147743323573e-06 0.01743644241612937 1.807147904755214e-06 0.01720262545858322 1.807148544701434e-06 0.01631831686205014 \
1.8071487230176e-06 0.016083210242981 1.807149371001648e-06 0.01526127675881721 1.80714953625524e-06 0.01505930898173208 1.807150272557175e-06 0.01419381259610907 \
1.807150406833225e-06 0.01404154276213586 1.807151203932743e-06 0.01317592498067951 1.807151344530354e-06 0.01302934089458718 1.807152309873577e-06 0.0120661300044765 \
1.807152474212383e-06 0.01190857475316222 1.807153474943512e-06 0.01099048917119646 1.807153612213369e-06 0.01087009009405628 1.807154750907886e-06 0.009949273443646761 \
1.807154865085787e-06 0.009863136028526375 1.807156245730621e-06 0.008889755784408603 1.807156400087833e-06 0.00878832203975914 1.807157946582061e-06 0.00781340401000951 \
1.807158030943764e-06 0.007760176032106158 1.807159716371082e-06 0.006770348169342283 1.807159839899572e-06 0.00670487246831437 1.807161889714139e-06 0.005720970231232756 \
1.807162086114296e-06 0.005634691917282852 1.807164404793653e-06 0.004698942116576918 1.807164865407988e-06 0.004530544077955615 1.80716760550353e-06 0.003639937533647344 \
1.807168123648567e-06 0.00349159181499799 1.807172274289875e-06 0.002502201117031859 1.807172812139882e-06 0.002396807933581942 1.80717889437533e-06 0.001421603691354927 \
1.80717915335574e-06 0.001378272220758726 1.80718447611909e-06 0.0003814093765652445 1.807184589276134e-06 0.0003711807182531981 1.80983070639237e-06 -0.0004615907568095335 \
1.809830868831338e-06 -0.0006852153244161934 1.809831369832807e-06 -0.001554404032531494 1.80983145401537e-06 -0.001725199767551738 1.809831855538194e-06 -0.002626792336557519 \
1.809831944873161e-06 -0.002845673237760077 1.80983223146497e-06 -0.0035898660494722 1.809832359033499e-06 -0.003937855927128601 1.809832677745161e-06 -0.004830400105952924 \
1.809832791946313e-06 -0.00515011308870196 1.809833074346638e-06 -0.005887653497963378 1.809833204572857e-06 -0.006177415671381139 1.809834182925754e-06 -0.005220113099403402 \
1.809834370233287e-06 -0.004004368716724641 1.809834501677689e-06 -0.002901539130564616 1.809834607105242e-06 -0.001869327786897239 1.809834692822726e-06 -0.0009323217369615201 \
1.809834774749213e-06 4.151965372454519e-05 1.809834895786036e-06 0.001618129410352471 1.809834994714683e-06 0.003024565667809575 1.809835153111357e-06 0.005482561958548801 \
1.809835370558586e-06 0.00923691162542661 1.809835551780809e-06 0.0126653356758144 1.809835763874906e-06 0.01697021734206094 1.809835926898563e-06 0.02046388365739064 \
1.809836087520978e-06 0.02403759527126768 1.809836241061221e-06 0.02755862871109176 1.809836389117902e-06 0.031036270750196 1.809836538198811e-06 0.03460722192241437 \
1.809836692728722e-06 0.03837091703902212 1.809836853379538e-06 0.04234026030123839 1.809837018034218e-06 0.04645786783841532 1.809837194575117e-06 0.05091770581196236 \
1.809837373537969e-06 0.05547793877747508 1.809837564281134e-06 0.0603721650098247 1.809837769062163e-06 0.06565647483694508 1.809837989534449e-06 0.07137203566208646 \
1.809838222394174e-06 0.0774299331224613 1.80983847158165e-06 0.08392829098722057 1.809838744423777e-06 0.09105513637423955 1.809839041127577e-06 0.09880974921055499 \
1.809839368453968e-06 0.1073623706929605 1.809839738105355e-06 0.11701033799881 1.809840132977169e-06 0.1273002725707723 1.809840590815409e-06 0.1392030195235975 \
1.80984112262225e-06 0.1529832553757746 1.809841747860046e-06 0.1691182447448397 1.809842433607517e-06 0.1867241161332086 1.809843236003391e-06 0.2071957342970069 \
1.809844134802183e-06 0.2299563735557614 1.809844940415632e-06 0.2501946571168963 1.809845654166966e-06 0.2679877251922811 1.809846283728848e-06 0.2835633151515627 \
1.809846854092298e-06 0.2975737963344939 1.80984738504768e-06 0.3105173405876944 1.80984788683513e-06 0.3226580892822354 1.809848366129684e-06 0.3341673054699896 \
1.809848831685103e-06 0.3452566901045974 1.809849295481511e-06 0.3562094254686541 1.809849751229541e-06 0.3668794056881832 1.809850211449675e-06 0.3775613305945491 \
1.809850749733646e-06 0.3899285626759094 1.809851250584179e-06 0.4013172511919189 1.809851650806863e-06 0.4103337945930838 1.809852157667644e-06 0.421642452039157 \
1.809852643633856e-06 0.4323669409017459 1.809853043148568e-06 0.4410997362599856 1.809853453760627e-06 0.4500002277813482 1.80985388268706e-06 0.4592207708982954 \
1.809854284201442e-06 0.4677760623951868 1.809854591591889e-06 0.4742753916877908 1.809854941833647e-06 0.4816249679276425 1.80985529507385e-06 0.4889795533930016 \
1.80985554824443e-06 0.4942125642332652 1.80985578118832e-06 0.4989990073547648 1.809856022831611e-06 0.5039392821429431 1.809856247822229e-06 0.5085102868389438 \
1.809856439858337e-06 0.5123881070394828 1.809856624670034e-06 0.5161059569497825 1.80985684696035e-06 0.5205538992744256 1.809857013671757e-06 0.5238726938135662 \
1.809857230888352e-06 0.5281726418673847 1.809857433967244e-06 0.5321820613122353 1.809857611378699e-06 0.5356681922482178 1.809857799451086e-06 0.5393528234657015 \
1.809858035483265e-06 0.5439555888699217 1.809858301365289e-06 0.5491186112539347 1.809858523127178e-06 0.5534070305875756 1.809858803185033e-06 0.5588091140818973 \
1.809859046184818e-06 0.5634839438879177 1.809859321538161e-06 0.5687575845994758 1.809859566533501e-06 0.5734440561015828 1.80985980682772e-06 0.5780305526007354 \
1.809860047867023e-06 0.5826153106864888 1.809860305457841e-06 0.5874946531182738 1.809860540824618e-06 0.5919209497705462 1.809860772126727e-06 0.5962518282209535 \
1.809860994653448e-06 0.6003950532231523 1.809861203013056e-06 0.6042587207462122 1.80986144085487e-06 0.6086392006348278 1.809861651715085e-06 0.612499186772883 \
1.809861907322267e-06 0.617151767543529 1.809862106050033e-06 0.620751700070918 1.809862381682677e-06 0.6257066023742009 1.809862604438798e-06 0.6296824120643636 \
1.809862897809921e-06 0.6348814180513288 1.809863130579923e-06 0.6389753720667986 1.809863350781309e-06 0.6428252659334456 1.809863552051921e-06 0.6463216644290061 \
1.809863769340793e-06 0.6500784077528632 1.809863944056703e-06 0.6530842133917786 1.809864130321333e-06 0.6562672470877895 1.809864309060386e-06 0.6593113758161715 \
1.809864471764399e-06 0.6620700940033843 1.80986463703341e-06 0.6648583661366954 1.809864780301224e-06 0.6672607123132118 1.809864919531648e-06 0.669583864918244 \
1.809865059332214e-06 0.6719085596965743 1.809865194107422e-06 0.6741424479378803 1.809865321601663e-06 0.6762463034350935 1.809865454555775e-06 0.6784344250006583 \
1.809865576160125e-06 0.680430207161383 1.809865704573366e-06 0.6825336955632141 1.809865820340421e-06 0.6844241240890321 1.809865918381593e-06 0.686020684362688 \
1.8098660190777e-06 0.687656981754083 1.809866128831462e-06 0.689434454762776 1.809866245599418e-06 0.6913211166705923 1.809866336826191e-06 0.6927889453402305 \
1.809866446031605e-06 0.6945396927028351 1.809866547140326e-06 0.6961566646470493 1.809866642540618e-06 0.6976767415743361 1.809866752022642e-06 0.6994136821864276 \
1.809866886474277e-06 0.7015344809028976 1.809867035493214e-06 0.7038694457768003 1.809867164423232e-06 0.7058755144243859 1.809867311083691e-06 0.7081418729260142 \
1.809867437868072e-06 0.7100885084081828 1.809867562465961e-06 0.7119899232102255 1.809867674319728e-06 0.7136874821928206 1.809867787275692e-06 0.7153928249203609 \
1.809867887829089e-06 0.716903336497302 1.809868025110592e-06 0.7189542886859326 1.809868144979452e-06 0.7207346491296758 1.809868264162204e-06 0.7224952472954583 \
1.809868391164313e-06 0.7243608783177121 1.809868515712665e-06 0.726179956024653 1.809868639383676e-06 0.7279757435764195 1.809868765971953e-06 0.7298035010246171 \
1.809868896541188e-06 0.7316777339938921 1.809869019056222e-06 0.7334262671520465 1.809869155299713e-06 0.7353588786631546 1.809869256742486e-06 0.7367901064855561 \
1.809869362765969e-06 0.7382789144707947 1.809869453297152e-06 0.7395446819117977 1.809869567123378e-06 0.7411267287627761 1.80986965478496e-06 0.742338113895605 \
1.809869760680238e-06 0.7437932991468792 1.809869891033532e-06 0.7455718205320391 1.80987000160114e-06 0.7470699275523445 1.809870106271611e-06 0.7484790865773925 \
1.809870230233143e-06 0.7501360792234356 1.809870378790597e-06 0.752105598322839 1.809870500473193e-06 0.7537054667443914 1.809870614584882e-06 0.7551949470168074 \
1.809870755005483e-06 0.7570132059451244 1.809870896533543e-06 0.7588296197226846 1.809871014322813e-06 0.7603289862386273 1.809871142522635e-06 0.7619481626911874 \
1.809871284590468e-06 0.7637269294216019 1.809871401465576e-06 0.7651780119234867 1.809871547139362e-06 0.7669714049983392 1.809871668877809e-06 0.7684572223066155 \
1.809871787518301e-06 0.7698939375992205 1.809871909984594e-06 0.7713653733660819 1.809872036701684e-06 0.7728756341192486 1.809872146603679e-06 0.7741754302862822 \
1.809872272219022e-06 0.7756497674172792 1.809872378029431e-06 0.7768823528242577 1.809872514199553e-06 0.7784559787239111 1.809872638546601e-06 0.7798807766277074 \
1.809872765971877e-06 0.7813271999647126 1.809872880527956e-06 0.7826155184370988 1.809872987208226e-06 0.7838050786084815 1.809873125150823e-06 0.785328674235108 \
1.809873274600319e-06 0.7869612315653352 1.809873419452536e-06 0.7885256944569791 1.809873538888287e-06 0.7898026796320731 1.80987367431316e-06 0.7912364721526877 \
1.809873795807481e-06 0.7925100718437531 1.809873939166555e-06 0.7939977458315933 1.809874082600237e-06 0.7954699260458764 1.809874208411246e-06 0.7967479640295563 \
1.809874327457928e-06 0.7979459892863545 1.809874439471573e-06 0.7990632136113104 1.809874544263454e-06 0.8000996927221937 1.809874639456303e-06 0.8010335634530776 \
1.809874775866828e-06 0.8023587211299719 1.809874892679005e-06 0.8034813603122919 1.809875012140248e-06 0.8046180202255495 1.8098751341806e-06 0.8057672874017472 \
1.809875257080697e-06 0.8069126780167393 1.809875384200053e-06 0.8080849010520604 1.809875509341915e-06 0.8092265787736463 1.809875639893142e-06 0.8104047139317369 \
1.809875765969389e-06 0.811530109085512 1.809875893966049e-06 0.8126603425876329 1.809875999427297e-06 0.8135823118114501 1.809876102696598e-06 0.814477091043954 \
1.809876195349946e-06 0.8152732203909091 1.809876319044181e-06 0.8163262937528154 1.809876406664095e-06 0.8170655553659417 1.809876505330151e-06 0.8178914289762149 \
1.809876648877154e-06 0.819080619224994 1.809876784463306e-06 0.8201904093102529 1.809876893653288e-06 0.8210742465492874 1.809877041102747e-06 0.8222539401850584 \
1.809877191506449e-06 0.8234410273756358 1.809877316975412e-06 0.8244188977545531 1.809877461141395e-06 0.8255287290252299 1.80987758542996e-06 0.8264738611628292 \
1.809877735900256e-06 0.8276038147969816 1.809877871506614e-06 0.8286089145501508 1.809877996601616e-06 0.8295251220930787 1.809878114317453e-06 0.8303776282987162 \
1.809878260203052e-06 0.8314210189912619 1.809878426696148e-06 0.8325942517713072 1.809878557562851e-06 0.833503494447128 1.809878731007462e-06 0.8346911703335461 \
1.809878899140202e-06 0.8358239212093587 1.809879068993949e-06 0.8369500705213252 1.809879249886955e-06 0.838129582835239 1.809879393021216e-06 0.8390486258646698 \
1.809879507119162e-06 0.8397723391454259 1.809879637246322e-06 0.8405879656882547 1.809879739102179e-06 0.8412191375388212 1.809879855947599e-06 0.8419354178465567 \
1.809879992919396e-06 0.84276453896487 1.809880190759142e-06 0.843942473808897 1.809880382444629e-06 0.8450620046306492 1.809880591850993e-06 0.8462610422160779 \
1.809880773861877e-06 0.8472832413425977 1.809880970977333e-06 0.8483697584184032 1.809881144290447e-06 0.8493077402131245 1.809881327325656e-06 0.8502809338042043 \
1.809881498478783e-06 0.8511747489972419 1.809881673131736e-06 0.8520708361396651 1.809881848382891e-06 0.8529540285731302 1.809882024530391e-06 0.8538259128238825 \
1.809882214836778e-06 0.8547503816925358 1.809882405427748e-06 0.8556583881771193 1.809882605979791e-06 0.8565949481971697 1.809882798582588e-06 0.8574764650234362 \
1.809883009331288e-06 0.8584213553684483 1.809883237362185e-06 0.8594210644592908 1.809883503241952e-06 0.8605573106989262 1.809883801820094e-06 0.8617960322792503 \
1.809884077983729e-06 0.8629075153790151 1.809884362230229e-06 0.8640180616030438 1.809884636414231e-06 0.8650581816846495 1.80988490866944e-06 0.8660616517296992 \
1.809885178858914e-06 0.8670295451208139 1.809885436023238e-06 0.8679256252637404 1.809885708596972e-06 0.8688492356117473 1.809885984602435e-06 0.8697577927663542 \
1.809886254710518e-06 0.8706213441784563 1.809886554568938e-06 0.8715508809746347 1.809886925582816e-06 0.8726599440782473 1.809887220515529e-06 0.873510245983525 \
1.809887474800895e-06 0.8742218447789023 1.809887773044171e-06 0.8750318897722944 1.809888046640929e-06 0.8757523113099853 1.809888282767907e-06 0.8763571312809064 \
1.809888523107205e-06 0.876957042728428 1.809888745440861e-06 0.8774982514557473 1.809888939446794e-06 0.8779599514934209 1.809889269165228e-06 0.8787226653583874 \
1.809889424338019e-06 0.8790722725343518 1.809889742071409e-06 0.8797700114458387 1.80988992093906e-06 0.880152324917399 1.809890263400534e-06 0.8808637455080008 \
1.809890447552368e-06 0.8812353200296749 1.809890922478418e-06 0.8821594045029107 1.809891089871653e-06 0.8824737723885729 1.80989155569296e-06 0.8833186808430151 \
1.809891736520447e-06 0.883635209600208 1.809892230549786e-06 0.8844687288968743 1.809892371887773e-06 0.8846990198924604 1.809892978249103e-06 0.8856473543416146 \
1.809893130320955e-06 0.8858754372639542 1.809893777008947e-06 0.8868048391838264 1.809893905303109e-06 0.8869818633102416 1.809894553496582e-06 0.8878410756373726 \
1.809894683245133e-06 0.8880061989117775 1.809895451498601e-06 0.8889361126992519 1.809895581240625e-06 0.8890847997417872 1.809896434697557e-06 0.8900046759307325 \
1.809896577924673e-06 0.8901495209380393 1.809897564158077e-06 0.8910738355210844 1.809897785636141e-06 0.8912643084423501 1.809898928653688e-06 0.8921737958641509 \
1.809899058631989e-06 0.8922730011388891 1.809900410338988e-06 0.8932565980587214 1.809900560692342e-06 0.8933589605607284 1.809902041315768e-06 0.8942730372387374 \
1.80990228021907e-06 0.8944047337041336 1.809904061344227e-06 0.8952702388217941 1.809904447325594e-06 0.8954343910560414 1.809906848871634e-06 0.896309305076933 \
1.80990732380842e-06 0.8964562995603377 1.809911141970139e-06 0.8973944547681553 1.809911624459336e-06 0.897487269196476 1.809919510474849e-06 0.898471373493449 \
1.809920126637539e-06 0.8985180228791175 1.810015282612379e-06 0.899508178894561 1.810016773214557e-06 0.8995204306067698 1.81012806128874e-06 0.9005118233983579 \
1.810128237625743e-06 0.9005706457326812 1.810131860757067e-06 0.8996048713171836 1.810132041955094e-06 0.8994654179496379 1.81013335307657e-06 0.8985275682722235 \
1.810133534953976e-06 0.8984123497545736 1.81013535794417e-06 0.8974436520388238 1.810135517857424e-06 0.8973766233009967 1.810148668688723e-06 0.8983720910457982 \
1.810148779670276e-06 0.8983905835035384 1.810157601254383e-06 0.8993863063850064 1.810158148023847e-06 0.8994226481040219 1.81065071997668e-06 0.9003987622903815 \
1.810650789769165e-06 0.9004496773542636 1.810651622421929e-06 0.9012853800543292 1.810651748468094e-06 0.9014513953152168 1.810652328988957e-06 0.9023435091985418 \
1.810652469953212e-06 0.9025895326188698 1.810652869091291e-06 0.9033428289365844 1.810653019240831e-06 0.9036449200440446 1.810653462322153e-06 0.9045762589490434 \
1.810653619494256e-06 0.9049121924877023 1.810654065120987e-06 0.9058152254958243 1.810654163577326e-06 0.9059929146639856 1.81065558025872e-06 0.9052304871087643 \
1.810655711415865e-06 0.904616184869324 1.810655880423041e-06 0.9036290332250884 1.810656045714916e-06 0.9024406226812831 1.810656151980698e-06 0.9015554774641358 \
1.810656255417528e-06 0.9006052096506509 1.810656341184247e-06 0.8997486040545581 1.810656430678233e-06 0.8987887485205278 1.810656554922632e-06 0.8973492764100613 \
1.81065667300358e-06 0.8958624931586439 1.810656760219672e-06 0.8946938835082598 1.810656884526716e-06 0.8929289312882503 1.810656991510644e-06 0.8913158670103165 \
1.810657091342348e-06 0.8897378501708729 1.810657217633174e-06 0.8876466417139378 1.810657385821785e-06 0.884705368138502 1.810657541521538e-06 0.8818365157686672 \
1.810657738126367e-06 0.8780362649814708 1.810657921747616e-06 0.8743271923380105 1.81065813325501e-06 0.8698916163736473 1.81065831406481e-06 0.8659808238081558 \
1.810658498645858e-06 0.8618945354625286 1.810658671649854e-06 0.8579913311618118 1.810658857050504e-06 0.8537436868396935 1.810659036133651e-06 0.8495884889292737 \
1.810659219722713e-06 0.8452850234109005 1.810659386484418e-06 0.8413449312544377 1.810659554574996e-06 0.8373487193315756 1.810659717684167e-06 0.8334514816705533 \
1.810659872870403e-06 0.829729402178684 1.810660045969282e-06 0.8255639501984255 1.810660231959738e-06 0.8210763864673301 1.810660396580221e-06 0.8170961425007568 \
1.810660561450132e-06 0.8131038678717658 1.810660736782164e-06 0.8088537582860886 1.810660901208668e-06 0.8048648186953292 1.810661069844279e-06 0.8007719922541914 \
1.810661260647645e-06 0.7961398815555145 1.810661446171818e-06 0.7916360074082958 1.810661655100628e-06 0.7865651471012967 1.810661879917618e-06 0.7811107659751856 \
1.810662069732705e-06 0.77650678233121 1.810662271590188e-06 0.7716133355283564 1.810662415860827e-06 0.76811790639139 1.810662557504392e-06 0.7646880872338248 \
1.810662685202102e-06 0.7615975116975136 1.810662796247943e-06 0.7589113686396982 1.810662924810579e-06 0.7558028559024855 1.810663057376087e-06 0.7525995467138866 \
1.810663170697783e-06 0.7498629233610832 1.810663307032409e-06 0.7465723252212872 1.810663413431661e-06 0.7440058350410135 1.810663572650447e-06 0.7401674766516904 \
1.810663745028142e-06 0.7360137588823189 1.810663907275386e-06 0.7321074183421575 1.810664079624343e-06 0.7279612819449855 1.810664239010527e-06 0.7241302920521341 \
1.810664446815714e-06 0.7191408067115369 1.810664607355379e-06 0.7152908836069264 1.810664799844715e-06 0.7106793324906435 1.810664985361064e-06 0.7062404417184839 \
1.810665155237109e-06 0.7021802791355866 1.810665347106947e-06 0.6975984806629684 1.810665493330962e-06 0.6941099299715526 1.810665653617309e-06 0.6902897983225644 \
1.810665856006145e-06 0.6854719661536142 1.810666037294609e-06 0.681161582477689 1.810666206116036e-06 0.6771536053116509 1.810666391961911e-06 0.6727470762459599 \
1.810666597892751e-06 0.6678715161770782 1.810666765819558e-06 0.6639016226084196 1.810666926081261e-06 0.6601182542089066 1.810667164933735e-06 0.65448589698252 \
1.810667332694848e-06 0.6505369020837752 1.810667513768288e-06 0.6462813620835641 1.810667674923199e-06 0.642499550819208 1.81066782119046e-06 0.6390715923276049 \
1.810667959878569e-06 0.6358268652274862 1.810668089235615e-06 0.6328040340451749 1.81066821862017e-06 0.6297855584526113 1.81066834694149e-06 0.6267952385336898 \
1.810668477143629e-06 0.6237652412672913 1.810668606160073e-06 0.6207683673242944 1.810668744735633e-06 0.6175525629501428 1.81066889281122e-06 0.6141227553162802 \
1.810669079138505e-06 0.60981438109949 1.810669226822204e-06 0.6064079319686639 1.81066946198641e-06 0.600995965122186 1.810669654434141e-06 0.5965821560879089 \
1.810669895003955e-06 0.5910808370261941 1.810670064051325e-06 0.587228367631822 1.81067020171775e-06 0.5840969866928536 1.810670329822726e-06 0.581191110277254 \
1.810670443409422e-06 0.5786182870235701 1.810670534774226e-06 0.5765512826027382 1.810670624196113e-06 0.5745328691003393 1.810670691457846e-06 0.573016830490748 \
1.810670757478049e-06 0.5715297341779608 1.810670809531724e-06 0.5703577032508095 1.810670873770593e-06 0.5689124506700958 1.810670935307116e-06 0.5675311492520995 \
1.81067099958866e-06 0.5660899724818867 1.810671052779755e-06 0.5648985048860162 1.81067114512554e-06 0.5628316153148989 1.810671221701441e-06 0.5611191615154557 \
1.810671277545091e-06 0.5598732849310241 1.8106713468882e-06 0.5583285932816697 1.810671452739476e-06 0.5559733466166974 1.81067153043128e-06 0.5542469170533902 \
1.810671631029867e-06 0.5520159549745236 1.810671759063078e-06 0.5491849411292137 1.81067185856046e-06 0.5469885705929382 1.810671971125811e-06 0.544508366501287 \
1.810672074170131e-06 0.5422442603473754 1.810672194219017e-06 0.5396115972585003 1.810672295833426e-06 0.5373863339265779 1.810672411457693e-06 0.5348611538529422 \
1.810672526573874e-06 0.5323536236546169 1.810672653010918e-06 0.529604142030661 1.810672778525186e-06 0.5268822104345234 1.810672925204862e-06 0.5237112381511962 \
1.81067306087557e-06 0.5207845659358002 1.810673218641408e-06 0.5173942078023266 1.810673381063349e-06 0.5139116507621072 1.810673561971818e-06 0.5100482739823553 \
1.810673754563972e-06 0.5059503908118104 1.810673967555743e-06 0.5014368974673542 1.810674199988459e-06 0.4965308659362653 1.810674457509373e-06 0.49112491222925 \
1.810674697473551e-06 0.4861095397820235 1.810674998677905e-06 0.4798501326413723 1.810675286975534e-06 0.4738957353990632 1.810675600061861e-06 0.4674739717793394 \
1.810675919588141e-06 0.4609631488871989 1.810676259085406e-06 0.4540919149088484 1.810676585275518e-06 0.4475353831519197 1.81067692175678e-06 0.4408159131180407 \
1.810677238467587e-06 0.4345373385230166 1.81067757255266e-06 0.4279587671099637 1.810677924261528e-06 0.4210864038135054 1.810678238746378e-06 0.4149846225409808 \
1.810678562192836e-06 0.4087533091618546 1.810679003120948e-06 0.400331870031168 1.810679344916025e-06 0.3938679283557566 1.810679644350068e-06 0.3882534014213259 \
1.810680018872672e-06 0.3812944595528024 1.810680348250389e-06 0.375233915169682 1.810680631354694e-06 0.3700684563936956 1.810680931099705e-06 0.3646408765157301 \
1.810681210595549e-06 0.3596219010422631 1.810681434267487e-06 0.3556377385586224 1.810681645979194e-06 0.3518907610576284 1.810681848481927e-06 0.3483292724130969 \
1.810682049543475e-06 0.3448190020587957 1.810682255221383e-06 0.3412518188287665 1.81068247359686e-06 0.3374887625241871 1.810682717359256e-06 0.3333167726275162 \
1.810682944115829e-06 0.3294678078423895 1.810683164026801e-06 0.3257615367192951 1.810683382451408e-06 0.3221060038181086 1.810683586476418e-06 0.318715141566024 \
1.810683788334207e-06 0.3153870758963987 1.810683988657595e-06 0.3121102802474151 1.810684175271502e-06 0.309079115007194 1.810684372573108e-06 0.3058982938882217 \
1.810684581156335e-06 0.3025606704206737 1.810684786791057e-06 0.2992974534031506 1.810685011523137e-06 0.2957609785165763 1.810685228418979e-06 0.2923771984023277 \
1.810685436098331e-06 0.2891642611511841 1.810685667149177e-06 0.2856239464683982 1.810685841949429e-06 0.2829684481899911 1.810686021147604e-06 0.2802647299798244 \
1.81068619002212e-06 0.2777348429135014 1.810686418345393e-06 0.274348458173166 1.810686595082661e-06 0.2717528218126659 1.810686763365392e-06 0.2693020894036587 \
1.810686935832162e-06 0.2668230333489093 1.810687069934441e-06 0.264903804409765 1.810687215894446e-06 0.2628277003548514 1.810687354589946e-06 0.2608803500812688 \
1.810687476871551e-06 0.2591684246570544 1.810687610990381e-06 0.2572942758553639 1.810687740091486e-06 0.2554978336754472 1.81068785952522e-06 0.2538430842138498 \
1.810687986360419e-06 0.2520939183506197 1.810688106001441e-06 0.2504447954274527 1.810688255617635e-06 0.2483797066042054 1.810688390481146e-06 0.2465170278296022 \
1.81068852003856e-06 0.2447289494531232 1.810688677103379e-06 0.2425624627506451 1.810688801099014e-06 0.2408491463446025 1.810688941247149e-06 0.2389135279283614 \
1.81068907114005e-06 0.2371200701944942 1.81068919175767e-06 0.2354534357320198 1.810689354230601e-06 0.2332087289724075 1.810689500284699e-06 0.2311905595759856 \
1.810689638605484e-06 0.2292825126447264 1.810689746532702e-06 0.2277949627009887 1.810689877317609e-06 0.225993474229161 1.810689975823625e-06 0.22463752857886 \
1.810690079906972e-06 0.2232056532573264 1.810690152783836e-06 0.2222046546567725 1.810690234937313e-06 0.2210804129356655 1.810690302346398e-06 0.2201585377209549 \
1.810690349050661e-06 0.2195201149856669 1.81069039846802e-06 0.2188449488487562 1.810690489422163e-06 0.2176035744446363 1.810690555816576e-06 0.2166983392055156 \
1.810690602779869e-06 0.2160586379972232 1.810690653091075e-06 0.2153737902794619 1.810690712240425e-06 0.2145693142997165 1.810690755086328e-06 0.2139870779821451 \
1.810690798893629e-06 0.2133941263688522 1.810690868423894e-06 0.2124566309962414 1.810690955340708e-06 0.2112864027023158 1.810691036529563e-06 0.2101949018929156 \
1.810691122429026e-06 0.2090416531541652 1.810691216575207e-06 0.2077796428137634 1.810691308329081e-06 0.2065517647617813 1.810691403625517e-06 0.2052788208685862 \
1.810691500104208e-06 0.2039945431316728 1.81069160092949e-06 0.2026602783061639 1.810691696885502e-06 0.2013924147365721 1.810691799571213e-06 0.2000377255165624 \
1.810691902607566e-06 0.1986831378210229 1.810692012697906e-06 0.1972405340748948 1.810692121449794e-06 0.1958206085628783 1.810692241171749e-06 0.1942631948714586 \
1.810692351614651e-06 0.1928328887741874 1.810692459617459e-06 0.1914411844406488 1.810692584973803e-06 0.1898318066870429 1.810692677907979e-06 0.1886434908940876 \
1.810692756278755e-06 0.1876443873000938 1.810692832918829e-06 0.1866698667869858 1.810692915430143e-06 0.1856249297118943 1.810692984939759e-06 0.1847473639743596 \
1.810693050895387e-06 0.1839166514106665 1.810693115162722e-06 0.1831089953192083 1.810693227146207e-06 0.1817072258029639 1.810693321200173e-06 0.1805353135896268 \
1.810693428841935e-06 0.1791985758407087 1.810693535314993e-06 0.1778827552324552 1.81069365530692e-06 0.1764073736674057 1.810693793359545e-06 0.174720142305475 \
1.8106939095201e-06 0.1733081217455876 1.810694071616903e-06 0.1713503924599185 1.810694186705419e-06 0.1699688234017716 1.810694326691019e-06 0.1682987764548305 \
1.810694443897094e-06 0.1669083002780509 1.810694554816447e-06 0.1655990025649634 1.810694652444933e-06 0.1644521190704843 1.810694747295481e-06 0.1633427224865242 \
1.810694863349893e-06 0.161991523106341 1.810694954898444e-06 0.1609305136382055 1.81069505100742e-06 0.1598214181625073 1.810695145225553e-06 0.1587403933520305 \
1.810695238726156e-06 0.1576732160104884 1.810695332323478e-06 0.1566104070550305 1.810695428005016e-06 0.1555300824433628 1.810695518592921e-06 0.1545132165873678 \
1.810695609606078e-06 0.1534969984004868 1.810695705154555e-06 0.1524358767948732 1.810695795820268e-06 0.1514342506187442 1.810695898892631e-06 0.1503020548964867 \
1.81069597134408e-06 0.1495100717445464 1.810696050444872e-06 0.148649146151682 1.810696124993091e-06 0.1478424742503694 1.8106961960245e-06 0.1470770917224498 \
1.810696268788981e-06 0.1462962409077327 1.810696343406157e-06 0.1454990959398698 1.810696413389118e-06 0.1447543557055888 1.810696487550038e-06 0.143968261688537 \
1.810696541295377e-06 0.1434005634796054 1.810696594578932e-06 0.1428396203849428 1.81069665977469e-06 0.1421555039833398 1.810696731080731e-06 0.141411576573238 \
1.810696795450793e-06 0.1407432786314442 1.810696868802754e-06 0.1399847409254479 1.81069692942032e-06 0.1393607073002494 1.810697015453804e-06 0.1384787080092832 \
1.81069709140482e-06 0.1377037134581418 1.810697181372726e-06 0.1367902106004182 1.810697263099684e-06 0.1359645165492482 1.810697345789661e-06 0.1351360437760365 \
1.810697428345969e-06 0.1343145513298757 1.810697533908124e-06 0.1332698421778018 1.810697615775408e-06 0.1324642397250402 1.810697713142868e-06 0.1315110876582503 \
1.810697803143728e-06 0.130634908321232 1.810697891113988e-06 0.1297829978838479 1.810697974043842e-06 0.1289892226181523 1.810698048280934e-06 0.1282822873521282 \
1.810698147931993e-06 0.1273377645104763 1.810698243687052e-06 0.1264350619688987 1.810698330534456e-06 0.1256206895242312 1.810698420535994e-06 0.1247808744623497 \
1.810698500868674e-06 0.1240346855852102 1.810698587562703e-06 0.1232365419604467 1.810698686393032e-06 0.1223331159004786 1.81069877647517e-06 0.1215131568528167 \
1.810698886718427e-06 0.1205141992263624 1.810698973949866e-06 0.1197275966302077 1.810699042523e-06 0.1191120727131645 1.810699127185392e-06 0.1183553887582162 \
1.810699193692874e-06 0.1177634990399222 1.810699265148799e-06 0.1171309945267847 1.810699334822604e-06 0.1165184920865242 1.810699412159692e-06 0.1158409171037389 \
1.810699507902974e-06 0.1150054407698888 1.810699579157887e-06 0.1143861389207103 1.81069964652742e-06 0.1138025718558601 1.810699714964191e-06 0.113211685696446 \
1.810699790554542e-06 0.1125613765304429 1.810699881296388e-06 0.1117840233035959 1.810699964000116e-06 0.1110788257213999 1.810700077599187e-06 0.1101151050704521 \
1.810700187474899e-06 0.1091895325357105 1.810700279674213e-06 0.1084169374841771 1.810700403623544e-06 0.1073835127717347 1.810700491987867e-06 0.1066505015902263 \
1.810700631446837e-06 0.1055001025916527 1.810700730743538e-06 0.1046863788921388 1.81070082339359e-06 0.1039306459201802 1.810700933598102e-06 0.1030359883605075 \
1.810701018892542e-06 0.1023467905686673 1.810701103793345e-06 0.101663637589173 1.810701186744308e-06 0.1009989740617136 1.81070130925421e-06 0.1000225794851696 \
1.810701431196062e-06 0.09905761200121259 1.810701557818349e-06 0.09806258992746317 1.810701670630472e-06 0.09718220909187772 1.810701815205956e-06 0.09606278874246346 \
1.810701952919884e-06 0.09500564015228773 1.810702069610674e-06 0.09411672853020667 1.810702197354241e-06 0.0931507147971556 1.810702297018758e-06 0.09240236948627445 \
1.810702376452637e-06 0.09180921593916676 1.810702475187935e-06 0.09107599640376031 1.810702553063239e-06 0.09050081472416407 1.810702634529155e-06 0.08990210528957472 \
1.810702709246463e-06 0.0893557072655629 1.8107027897762e-06 0.08876971652456604 1.810702908608526e-06 0.08791061481419053 1.810702998269062e-06 0.08726673116015753 \
1.810703103183109e-06 0.08651800316437093 1.810703234657666e-06 0.08558693768262025 1.810703395765802e-06 0.08445695903909305 1.810703535947497e-06 0.08348350561263763 \
1.810703684450103e-06 0.08246223579158835 1.810703821170292e-06 0.08153124812726546 1.810703961182002e-06 0.08058696725890066 1.810704098179202e-06 0.07967195061625794 \
1.810704236789813e-06 0.07875532825288725 1.8107043812627e-06 0.07780967510081127 1.810704528808937e-06 0.07685421131041187 1.810704686312648e-06 0.07584560580436887 \
1.810704850707884e-06 0.07480523464991846 1.810705018799982e-06 0.07375451744755303 1.810705199799341e-06 0.07263751640721161 1.810705398512623e-06 0.07142823309373261 \
1.810705611921415e-06 0.07014922396308329 1.8107058380853e-06 0.06881630383186611 1.810706078645622e-06 0.06742468841361035 1.810706356206535e-06 0.06585179211508728 \
1.810706653410938e-06 0.06420523370201831 1.810706971711662e-06 0.06248365192299224 1.810707361695962e-06 0.06043183534616462 1.810707760522748e-06 0.05839861031494715 \
1.810708202994687e-06 0.05621846258761681 1.81070858797559e-06 0.05438828987170503 1.810709000022182e-06 0.05249218901100536 1.810709351759698e-06 0.05092353490091287 \
1.810709687264349e-06 0.04946969867921969 1.810709997763244e-06 0.04816021644386199 1.810710291700064e-06 0.04695194805701195 1.810710584430997e-06 0.04577883625507727 \
1.810710859274204e-06 0.04470700909733757 1.810711133117927e-06 0.04366353526031765 1.810711398807687e-06 0.04267398813878486 1.810711674116703e-06 0.04167180388267511 \
1.810711958673621e-06 0.04066026046469497 1.810712254971736e-06 0.03963283340811159 1.810712513847121e-06 0.03875659098599576 1.810712741803527e-06 0.03800131046948733 \
1.810712960528722e-06 0.03729095380188759 1.810713180383449e-06 0.03659437723507575 1.810713521249513e-06 0.03554043311314246 1.810713797290394e-06 0.03470953269536187 \
1.810714090721169e-06 0.03384790442147732 1.810714373289092e-06 0.03303898052111545 1.810714628198528e-06 0.03232625790162248 1.810714908882988e-06 0.03155947796597136 \
1.810715154716382e-06 0.03090318379665042 1.81071538687767e-06 0.03029616297556957 1.810715627215008e-06 0.02968398395812225 1.810715862851843e-06 0.02909722707395018 \
1.810716091063021e-06 0.0285403787496557 1.810716507835749e-06 0.02755138287878544 1.810716702361127e-06 0.02710176794309662 1.810717088601532e-06 0.02623051698020805 \
1.810717267770925e-06 0.0258356865503758 1.810717618998109e-06 0.02507792837274256 1.810717786904156e-06 0.0247229612172224 1.810718171166812e-06 0.02392944198669211 \
1.810718286448541e-06 0.02369675911063252 1.810718728496378e-06 0.02282172072611499 1.810718950311652e-06 0.02239223679446916 1.810719473931311e-06 0.02139838041889957 \
1.810719629293819e-06 0.02110714647916685 1.810720146999887e-06 0.02015295207761772 1.810720272033152e-06 0.01992792118872039 1.810720796234659e-06 0.01901759738223179 \
1.810720932454034e-06 0.01879045572456909 1.81072153873049e-06 0.01783210191617334 1.810721705739623e-06 0.01758082406519646 1.810722348947266e-06 0.01666064795441237 \
1.810722528091535e-06 0.0164167113061686 1.810723218250269e-06 0.01551958953683085 1.810723381870153e-06 0.01531511209162885 1.81072414235084e-06 0.01440332854054019 \
1.810724289392963e-06 0.01423371673427115 1.810725107264621e-06 0.01333087949608782 1.810725226813134e-06 0.01320411419549955 1.810726142674655e-06 0.01227329163592313 \
1.810726284027572e-06 0.01213544173166964 1.810727232503148e-06 0.01124488043697059 1.810727391142586e-06 0.01110230805801717 1.81072857354363e-06 0.01011356759191894 \
1.81072867164402e-06 0.01003725601038859 1.81072993325548e-06 0.009120360285939955 1.81073006766933e-06 0.009028655389366201 1.810731608240655e-06 0.008043892937307966 \
1.810731689273999e-06 0.007992925041580451 1.810733277867931e-06 0.007023242357651564 1.810733410759078e-06 0.006948518507451114 1.81073538746242e-06 0.005952856104192286 \
1.810735569200568e-06 0.005869662958407677 1.810737671554228e-06 0.004980929874643355 1.810738112345997e-06 0.004810448874467742 1.810740767560855e-06 0.003892108290451164 \
1.810741244140394e-06 0.003745909362026665 1.810744882222615e-06 0.00279447349697209 1.81074540774606e-06 0.002678838783887205 1.810751013810845e-06 0.001700248310874221 \
1.810751324898547e-06 0.001653333728976835 1.810756459226246e-06 0.0006858192122199529 1.810756653206019e-06 0.0006440832883579712 1.813404576914862e-06 -0.0002037173203380238 \
1.813404741115283e-06 -0.0003889174928863678 1.813405314458091e-06 -0.001270938904608877 1.813405389392278e-06 -0.001411855863724778 1.813405849976055e-06 -0.002393592696522268 \
1.813405961916807e-06 -0.002660411672198376 1.813406215188795e-06 -0.003300974950034667 1.813406381572099e-06 -0.003745951779090856 1.813406676567869e-06 -0.004566571567208835 \
1.813406788055442e-06 -0.00488071790655901 1.813407067428216e-06 -0.005641221413069743 1.813407188386555e-06 -0.005938820066262044 1.813408282339388e-06 -0.005180465225493313 \
1.813408406471631e-06 -0.004410796826645887 1.813408530879049e-06 -0.003456122327429311 1.813408650435428e-06 -0.002364170815481491 1.813408748579805e-06 -0.001341064316055312 \
1.813408855004127e-06 -0.0001052154991983786 1.813408967239972e-06 0.001336046702817826 1.813409102195821e-06 0.003249882807978809 1.813409224782331e-06 0.005149402351921401 \
1.813409413644245e-06 0.008353592055059769 1.813409554826578e-06 0.01094873860302964 1.813409708187922e-06 0.01393943619118621 1.813409851561426e-06 0.01687898420971235 \
1.813410005752867e-06 0.02017576688295359 1.813410161892825e-06 0.02363796584892512 1.813410317618878e-06 0.02719811802828209 1.813410465112557e-06 0.03065407560139007 \
1.813410613784323e-06 0.03420778369279751 1.813410769114407e-06 0.03798436241030867 1.813410927740287e-06 0.04189786275883118 1.813411092673448e-06 0.0460171220807938 \
1.813411267096336e-06 0.05041857973200652 1.813411446085736e-06 0.05497510627343041 1.813411635385597e-06 0.05982852266675163 1.813411838393603e-06 0.06506368941101938 \
1.813412057870669e-06 0.07075025585284363 1.81341228893533e-06 0.07675903373893865 1.813412535995649e-06 0.08319974270080552 1.813412806420637e-06 0.0902619122132732 \
1.813413099984324e-06 0.09793335781011638 1.813413424033306e-06 0.1064001814721126 1.813413788254856e-06 0.1159066558703892 1.813414180806326e-06 0.1261372395632307 \
1.813414630304251e-06 0.1378252442462487 1.813415153096483e-06 0.1513754922073403 1.813415766694219e-06 0.1672157090591849 1.813416444455093e-06 0.184625848284817 \
1.813417232720212e-06 0.2047487967247964 1.813418115553071e-06 0.22712469896725 1.813418933839029e-06 0.2476994923478653 1.813419661268608e-06 0.2658503723959502 \
1.813420301381636e-06 0.2817009601644404 1.81342087568535e-06 0.2958213763442377 1.813421413251317e-06 0.3089396094373287 1.813421917248776e-06 0.3211464104224903 \
1.81342239337143e-06 0.3325930942309646 1.813422871259445e-06 0.3439912352478621 1.813423324592551e-06 0.3547121966731367 1.813423795885259e-06 0.3657614311162562 \
1.813424238561084e-06 0.3760518588326446 1.813424757059872e-06 0.3879885572071845 1.813425284221992e-06 0.3999987293386327 1.813425663131623e-06 0.4085537955782026 \
1.813426193047166e-06 0.4204060347738258 1.813426622963746e-06 0.429919877745455 1.813427076664521e-06 0.4398653393542544 1.813427543378037e-06 0.4500002271552926 \
1.813427981059267e-06 0.4594210430579985 1.813428389021531e-06 0.468120704286539 1.813428708454564e-06 0.4748816926501604 1.813429080589836e-06 0.4826992142337162 \
1.813429315571977e-06 0.4876010339127531 1.813429549178225e-06 0.4924491904621348 1.813429797190648e-06 0.4975647713404599 1.813430095592078e-06 0.5036796627825791 \
1.81343035194848e-06 0.5088948470128004 1.81343056424179e-06 0.5131878547336713 1.813430758259862e-06 0.5170959594548015 1.813430905246394e-06 0.5200432695146362 \
1.813431059224404e-06 0.523118600542271 1.813431277106154e-06 0.5274469616807909 1.81343153021048e-06 0.5324525256580425 1.813431740049324e-06 0.5365797337241586 \
1.813431951502633e-06 0.5407247601751553 1.813432233709534e-06 0.5462280430697679 1.813432463254817e-06 0.5506821559930507 1.813432679151023e-06 0.5548604062613707 \
1.813432961372541e-06 0.560308769190463 1.813433212680268e-06 0.5651538146135803 1.81343351034116e-06 0.5708625224168123 1.81343376056806e-06 0.5756519166658941 \
1.813434016931555e-06 0.5805516059354519 1.81343425734157e-06 0.585116682128892 1.813434515521386e-06 0.5900038400537884 1.813434739113591e-06 0.5942175703762435 \
1.813434977623163e-06 0.5986919452581434 1.813435185207861e-06 0.6025689278491061 1.813435401730486e-06 0.6065904171332736 1.813435651033092e-06 0.6111939272561876 \
1.813435856106534e-06 0.6149609706257601 1.81343610737886e-06 0.6195555361399968 1.813436310600886e-06 0.6232455818254186 1.813436507472791e-06 0.6267987644955494 \
1.813436700764307e-06 0.630267737067843 1.813436955542762e-06 0.6348113783570861 1.813437185753374e-06 0.638887973644319 1.813437403107185e-06 0.6427143472883045 \
1.813437701512907e-06 0.6479268061885751 1.813437916915757e-06 0.6516657345437264 1.813438118139475e-06 0.6551344108237934 1.813438293060983e-06 0.6581323437428509 \
1.813438458126254e-06 0.6609495238976936 1.813438627594774e-06 0.6638251431769452 1.813438779731612e-06 0.666392827642013 1.813438917642298e-06 0.6687037209181631 \
1.813439066478412e-06 0.6711867545200138 1.813439194593014e-06 0.6733159837320549 1.813439337815827e-06 0.6756849429836936 1.813439459090077e-06 0.6776819274526149 \
1.813439596688762e-06 0.6799401191146522 1.813439716069216e-06 0.6818929034138137 1.813439863176962e-06 0.6842914131385206 1.813439980378628e-06 0.6861933934268433 \
1.813440073884205e-06 0.6877071857403232 1.813440164873897e-06 0.6891752279197846 1.813440267615961e-06 0.6908280855439021 1.813440369133525e-06 0.6924555900607121 \
1.813440487516631e-06 0.6943444167618776 1.813440599637217e-06 0.6961264383846065 1.813440717192718e-06 0.6979868779962457 1.813440902343005e-06 0.7008959348649784 \
1.813441033535213e-06 0.7029413755586562 1.813441169703753e-06 0.7050491462541959 1.813441291222456e-06 0.7069171228306749 1.813441431145468e-06 0.7090538254196674 \
1.813441535088117e-06 0.7106315721465845 1.8134416462491e-06 0.712309798010818 1.813441750508965e-06 0.7138759052437967 1.813441880147056e-06 0.7158124745844324 \
1.813441977077769e-06 0.7172526339884565 1.813442116000004e-06 0.7193052800722975 1.813442235549292e-06 0.7210612846995991 1.813442355121865e-06 0.7228080613301419 \
1.813442480897243e-06 0.7246353354365959 1.813442607615586e-06 0.7264656873164689 1.813442729655437e-06 0.728218443613998 1.81344285780388e-06 0.7300486655261287 \
1.813442987872205e-06 0.7318956587421809 1.813443108863227e-06 0.7336041830685722 1.813443249633811e-06 0.7355801168346318 1.81344335060338e-06 0.7369898206659778 \
1.813443452204237e-06 0.7384020079314992 1.813443548224548e-06 0.7397310783624924 1.813443659137403e-06 0.7412570822736337 1.81344374678503e-06 0.7424563811251772 \
1.8134438466394e-06 0.7438154404043728 1.813443981404538e-06 0.7456370856934184 1.813444097699018e-06 0.747198032089633 1.813444201190815e-06 0.7485782798032956 \
1.813444325446263e-06 0.7502239458264747 1.813444470359203e-06 0.7521280942578691 1.813444588339771e-06 0.753666143975803 1.813444707270879e-06 0.7552056331692281 \
1.813444846850418e-06 0.7569980918234445 1.813444991202808e-06 0.7588357421297242 1.813445109263616e-06 0.7603265096672839 1.813445234085335e-06 0.7618908200857619 \
1.813445373916531e-06 0.7636286950759973 1.813445498679428e-06 0.7651662633748356 1.813445642192898e-06 0.7669199865864609 1.813445762878376e-06 0.7683824344671055 \
1.813445883722124e-06 0.7698356273746885 1.813446003367048e-06 0.7712633747646481 1.813446133074687e-06 0.7727989859455529 1.81344624181849e-06 0.7740766298596218 \
1.813446364466226e-06 0.7755070372682662 1.813446474242911e-06 0.7767778749889983 1.813446603267025e-06 0.7782599816788072 1.813446735043344e-06 0.7797610257751375 \
1.81344684835592e-06 0.7810403609326458 1.813446969441862e-06 0.7823954393038701 1.813447073314495e-06 0.7835479431998941 1.813447215597517e-06 0.785111775748914 \
1.813447363800666e-06 0.7867227488076519 1.813447522694201e-06 0.7884297907063792 1.813447642887223e-06 0.7897074707829422 1.81344779245393e-06 0.7912811323018302 \
1.813447916569147e-06 0.7925734175081853 1.813448042273444e-06 0.7938699048627912 1.813448145219011e-06 0.7949224966762399 1.813448259590165e-06 0.7960823495211882 \
1.813448372064409e-06 0.7972131756542409 1.813448462336983e-06 0.7981137961420948 1.813448551677879e-06 0.7989989930139054 1.813448676903817e-06 0.800229513878344 \
1.81344878467518e-06 0.8012785338618679 1.813448914342978e-06 0.8025281307685926 1.813449035722257e-06 0.8036855380110038 1.813449152278057e-06 0.8047859282369955 \
1.813449273083453e-06 0.80591497746663 1.813449405708758e-06 0.8071413435168892 1.813449527502378e-06 0.8082555056211007 1.813449654106103e-06 0.8094015704683005 \
1.813449779719621e-06 0.8105266036187198 1.813449899211046e-06 0.8115857443778658 1.813450037409299e-06 0.8127973981963581 1.813450146908547e-06 0.8137473213416323 \
1.813450231056662e-06 0.8144713378799666 1.81345035186072e-06 0.8155017394983226 1.813450447369557e-06 0.8163089346032877 1.81345058366036e-06 0.8174496006492775 \
1.813450726424414e-06 0.8186303638797883 1.813450860857535e-06 0.8197292014569521 1.813450970729519e-06 0.8206175763825388 1.813451114629136e-06 0.8217677661037901 \
1.81345126795672e-06 0.8229768690765377 1.813451395805574e-06 0.8239722812379519 1.813451536202905e-06 0.8250521595273246 1.813451662107844e-06 0.8260088941474263 \
1.81345181672401e-06 0.8271688948348412 1.813451949079339e-06 0.8281489842609937 1.813452075346168e-06 0.8290730392392056 1.813452193006695e-06 0.8299245984162376 \
1.813452341409092e-06 0.8309852945996649 1.81345250860326e-06 0.8321626230293395 1.813452641380571e-06 0.8330844501529713 1.813452814281768e-06 0.8342675727345584 \
1.813452982699062e-06 0.8354015168591284 1.813453152193536e-06 0.8365246342267009 1.813453333630418e-06 0.8377070668209077 1.813453476186559e-06 0.8386219603417975 \
1.81345359009745e-06 0.8393441765511721 1.813453720973658e-06 0.8401643924869071 1.813453822596633e-06 0.8407940582489307 1.813453939036871e-06 0.8415078269750864 \
1.813454074330057e-06 0.8423269142909066 1.813454271595159e-06 0.8435017451489455 1.813454462114483e-06 0.844614933042255 1.813454672039296e-06 0.8458175693076773 \
1.813454852817827e-06 0.8468334846981137 1.813455050185846e-06 0.8479221976595614 1.81345522404434e-06 0.8488638701886076 1.813455406558583e-06 0.8498353939890455 \
1.813455577902693e-06 0.8507314120859523 1.813455752248258e-06 0.8516272398309612 1.813455927651258e-06 0.8525125793730954 1.813456103896448e-06 0.8533864315694911 \
1.813456293665326e-06 0.8543099749208749 1.813456484423344e-06 0.8552205033559714 1.81345668621255e-06 0.8561646193034282 1.813456878916116e-06 0.8570482883232282 \
1.813457088356793e-06 0.8579892478796384 1.813457318098559e-06 0.8589986827500428 1.813457583567511e-06 0.8601360945383778 1.813457882213855e-06 0.8613786760148464 \
1.813458160601222e-06 0.8625023989005415 1.813458444791177e-06 0.8636161469557806 1.813458719285784e-06 0.8646608622318305 1.81345899137728e-06 0.8656672252055042 \
1.813459261593727e-06 0.8666387059277968 1.813459518761914e-06 0.8675381145236246 1.813459791320979e-06 0.8684653318325959 1.81346006734232e-06 0.8693777905953765 \
1.813460337484171e-06 0.8702455402709716 1.813460637231955e-06 0.8711796653984102 1.813461008105812e-06 0.872294745819888 1.813461303028797e-06 0.8731503023941 \
1.813461557284845e-06 0.8738665406311316 1.813461855515577e-06 0.8746822274488602 1.813462129133901e-06 0.8754080260278182 1.813462365269549e-06 0.8760175227551726 \
1.813462605621406e-06 0.876622281264788 1.813462827963785e-06 0.8771680781109068 1.813463021968128e-06 0.8776338860468618 1.813463351691207e-06 0.8784037109613512 \
1.81346350686397e-06 0.8787567114621292 1.813463824616497e-06 0.879461652496718 1.813464003481858e-06 0.8798480920375044 1.813464345943324e-06 0.8805675499479563 \
1.813464530084847e-06 0.8809434933546246 1.813465004990284e-06 0.8818790560183651 1.813465172384703e-06 0.8821975058309585 1.813465638216128e-06 0.8830540251881659 \
1.813465819040967e-06 0.8833751042472839 1.813466313074347e-06 0.8842212008576973 1.813466454417055e-06 0.884455124402366 1.813467060806836e-06 0.8854193259359495 \
1.813467212878983e-06 0.8856514227360587 1.81346785955747e-06 0.8865980751852495 1.813467987853824e-06 0.8867785329419297 1.813468635979926e-06 0.8876550049536978 \
1.813468765772447e-06 0.8878236738033012 1.813469544034094e-06 0.8887860366092379 1.813469659025973e-06 0.8889208282599539 1.813470514758392e-06 0.8898661633196656 \
1.813470660021537e-06 0.8900169066926564 1.813471645777722e-06 0.8909664261264102 1.813471866882863e-06 0.8911622482549515 1.813473011997306e-06 0.8921020388386462 \
1.813473143207264e-06 0.8922053928944147 1.813474330865799e-06 0.8931033243919096 1.813474484486091e-06 0.8932130731307282 1.813475894522803e-06 0.8941348173026452 \
1.813476117329622e-06 0.8942660193790342 1.81347779802033e-06 0.8951452796684343 1.813478125641509e-06 0.8952966652167414 1.813480355582631e-06 0.8961896554712738 \
1.813480908496592e-06 0.8963788593752812 1.813484476711123e-06 0.8973573335043913 1.813484800223538e-06 0.8974284307984646 1.813491156631826e-06 0.8984120886469452 \
1.813491705534673e-06 0.8984686671268907 1.813544207609024e-06 0.8994658645395698 1.813544850637886e-06 0.8994692460188505 1.813736989308519e-06 0.9004073346715066 \
1.81373719072249e-06 0.9004708280105613 1.813741150500432e-06 0.8995366825576255 1.813741334527229e-06 0.8993953949813248 1.813742651124504e-06 0.8984641879157507 \
1.813742823168359e-06 0.8983566564859006 1.813744719544653e-06 0.8973720929359315 1.813744893250842e-06 0.897304621671452 1.813757467177875e-06 0.8982933655523699 \
1.813757552368112e-06 0.8983081509245614 1.813765819241151e-06 0.8993078551592517 1.813766293960572e-06 0.8993433667976791 1.814259794870011e-06 0.9002974142054325 \
1.814259914349735e-06 0.9003767372269074 1.814260807172786e-06 0.9012336455299185 1.814260953429422e-06 0.901423267690772 1.814261548322101e-06 0.9023325668564308 \
1.814261683292918e-06 0.9025673929107925 1.814262187968707e-06 0.9035294259428087 1.814262320579608e-06 0.9038000271808221 1.814262721206972e-06 0.9046475051114249 \
1.814262865572371e-06 0.9049556543240072 1.81426328869358e-06 0.9058123566484279 1.814263384150638e-06 0.9059850892484415 1.814264808709454e-06 0.9052205906349737 \
1.814264933747309e-06 0.9046352442223391 1.814265060157898e-06 0.9039223775493039 1.814265162806642e-06 0.9032486771507763 1.814265290021932e-06 0.9022944222362175 \
1.814265408867758e-06 0.9012801950564071 1.814265506520237e-06 0.9003603330664713 1.814265588522258e-06 0.8995243596151602 1.814265668185821e-06 0.8986589236008835 \
1.814265778963989e-06 0.8973708307079206 1.814265880140003e-06 0.8961049472956977 1.814265963084475e-06 0.8950067229086057 1.814266071529892e-06 0.8934921260891034 \
1.81426617999385e-06 0.8918872687155874 1.814266275049989e-06 0.8904106867557802 1.814266395922641e-06 0.8884444419111864 1.814266516699262e-06 0.8863849482818795 \
1.814266629744433e-06 0.8843763393508186 1.814266732915182e-06 0.8824794505619851 1.814266818515338e-06 0.8808620855018965 1.814266892989399e-06 0.8794251273161163 \
1.814266987312942e-06 0.8775673968166831 1.814267075773858e-06 0.8757888800524039 1.814267154846869e-06 0.8741711975775893 1.814267248834224e-06 0.872216793437976 \
1.814267330179529e-06 0.8704993514258973 1.814267425093555e-06 0.8684673705816817 1.814267518136275e-06 0.8664480751909672 1.814267614922069e-06 0.8643215060814092 \
1.814267738217441e-06 0.8615778533848952 1.814267851664452e-06 0.859022019682563 1.814267977516491e-06 0.8561558571929792 1.814268100844635e-06 0.8533196845306243 \
1.814268230022926e-06 0.850323637950593 1.814268370619783e-06 0.8470370034914 1.814268479399504e-06 0.8444782910716596 1.814268614459257e-06 0.8412850455921466 \
1.814268724119566e-06 0.8386804253780991 1.814268853299345e-06 0.8356002443501571 1.814268979483175e-06 0.8325812421138936 1.81426910657353e-06 0.8295317031556502 \
1.814269235595804e-06 0.826427745883674 1.814269344676045e-06 0.8237985689995477 1.814269484526701e-06 0.8204223029647078 1.814269623954893e-06 0.8170507778356514 \
1.814269756708524e-06 0.8138366863616762 1.814269886777199e-06 0.8106848159989707 1.814270010472645e-06 0.8076853837479523 1.814270147427035e-06 0.8043627031572629 \
1.814270261138882e-06 0.8016030849198694 1.814270388615922e-06 0.7985086235398901 1.814270499416994e-06 0.7958187897651571 1.814270618603452e-06 0.7929254985494992 \
1.814270731982508e-06 0.7901733724735396 1.814270866292901e-06 0.7869138859547327 1.814270973387169e-06 0.7843152933129034 1.814271089404311e-06 0.7815009627552112 \
1.814271218595275e-06 0.778367508739124 1.81427131620771e-06 0.7760002683782802 1.814271421787151e-06 0.773440790716327 1.81427153046932e-06 0.7708069008430674 \
1.814271632885583e-06 0.7683258101021144 1.814271726279241e-06 0.7660641808432364 1.814271845835017e-06 0.7631702213567544 1.814271938307379e-06 0.7609327305817616 \
1.814272030945494e-06 0.7586922094322426 1.814272129370309e-06 0.7563124992069843 1.814272237347961e-06 0.7537030947613649 1.814272333616474e-06 0.7513778334636231 \
1.814272419872877e-06 0.7492952979736797 1.814272522736666e-06 0.7468128004450286 1.814272601580994e-06 0.744910856519283 1.814272702387036e-06 0.7424801602439853 \
1.814272836915276e-06 0.7392377693660663 1.814272974140136e-06 0.7359316755186537 1.814273117619987e-06 0.7324773442723981 1.814273266044177e-06 0.7289066083419234 \
1.814273409305472e-06 0.7254625447335662 1.814273549382451e-06 0.7220977259655398 1.814273705808317e-06 0.7183435968963056 1.814273830210067e-06 0.715360858370426 \
1.814273951271848e-06 0.7124600029613375 1.81427410478411e-06 0.7087850045121084 1.814274239566055e-06 0.7055614325718365 1.814274365665088e-06 0.7025479112911024 \
1.814274508839371e-06 0.6991289103945657 1.814274628921163e-06 0.6962626602560111 1.814274758155491e-06 0.6931807499479741 1.814274864640539e-06 0.6906432840523983 \
1.814274976916361e-06 0.6879696524977363 1.814275073251648e-06 0.6856773754336868 1.81427517606134e-06 0.683232326200841 1.814275270865193e-06 0.6809792012818872 \
1.814275376187123e-06 0.6784784437814733 1.814275484625777e-06 0.6759058899658261 1.814275583635057e-06 0.673558569590366 1.81427570039165e-06 0.6707929011939652 \
1.814275808476928e-06 0.6682347329991606 1.814275918483136e-06 0.6656332609774134 1.814276004570978e-06 0.6635992664604092 1.814276134166118e-06 0.6605400273835189 \
1.814276226767366e-06 0.6583552307294462 1.814276322555092e-06 0.6560965362104854 1.814276407507078e-06 0.6540950852804182 1.814276526801602e-06 0.6512869789851043 \
1.81427661407154e-06 0.6492343850333612 1.814276704778561e-06 0.6471030993779646 1.814276805943536e-06 0.6447280068361273 1.814276885774359e-06 0.6428551652550211 \
1.814276974560194e-06 0.6407732405330839 1.81427705225042e-06 0.6389536101386547 1.814277114019368e-06 0.6375081226244841 1.814277177784013e-06 0.6360167668935747 \
1.814277241018233e-06 0.634538653569437 1.814277280258806e-06 0.6336218002627473 1.814277320897828e-06 0.6326726453797233 1.814277400982362e-06 0.6308039353694699 \
1.814277470886542e-06 0.6291742390428672 1.814277521523257e-06 0.6279942052995945 1.814277560272899e-06 0.6270914175114127 1.814277599267879e-06 0.6261832343283663 \
1.814277643882627e-06 0.6251445623164014 1.814277686739083e-06 0.6241478292286105 1.814277737053687e-06 0.6229782634938205 1.814277788990864e-06 0.6217719122409077 \
1.814277874058449e-06 0.6197972300178722 1.814277934038866e-06 0.6184052992407258 1.814278023826075e-06 0.61632338076978 1.814278100290156e-06 0.6145529519516876 \
1.814278179854447e-06 0.6127119801362371 1.814278260891059e-06 0.6108383709630588 1.814278350105381e-06 0.6087775861620425 1.814278440965394e-06 0.6066826282541496 \
1.814278528184102e-06 0.6046739453334793 1.814278621957293e-06 0.6025158549334848 1.814278723642756e-06 0.6001788642681311 1.814278823240848e-06 0.5978941858483342 \
1.814278935095889e-06 0.5953317151711254 1.814279051129026e-06 0.5926772450523136 1.814279172750132e-06 0.5899020947998995 1.814279277133946e-06 0.5875236635596754 \
1.814279421924166e-06 0.5842296531729801 1.814279534584126e-06 0.5816734289694181 1.814279643596094e-06 0.5792035939892568 1.814279736075537e-06 0.5771100174076607 \
1.814279829526176e-06 0.5749994714793375 1.81427992185204e-06 0.5729181236728181 1.814279994438741e-06 0.571283073141143 1.814280050392967e-06 0.5700232888304386 \
1.814280111461248e-06 0.5686498830286455 1.814280209950764e-06 0.5664400707212188 1.814280273162208e-06 0.5650238531380825 1.814280333588177e-06 0.5636708824310654 \
1.81428041053656e-06 0.5619492451093103 1.814280473695101e-06 0.5605380106414651 1.81428056200871e-06 0.558569506627369 1.814280633210033e-06 0.5569845302974165 \
1.814280719745787e-06 0.555060151797141 1.81428084109856e-06 0.5523665438352664 1.814280969027808e-06 0.5495364947125975 1.814281067158439e-06 0.5473694328713704 \
1.814281180282434e-06 0.5448752016832871 1.814281282350254e-06 0.5426314425864434 1.814281401299124e-06 0.5400217272291628 1.814281504386832e-06 0.5377630705755105 \
1.814281618593986e-06 0.5352670017334624 1.814281732009658e-06 0.532794946211756 1.814281859080713e-06 0.5300302694710822 1.814281982900802e-06 0.5273426867079006 \
1.814282127689607e-06 0.5242103332418484 1.81428226351311e-06 0.5212782585303676 1.814282418567968e-06 0.5179428401013338 1.814282579419853e-06 0.5144913885072363 \
1.8142827581493e-06 0.5106699876709851 1.81428294832834e-06 0.5066200804011861 1.814283158230362e-06 0.5021665212646098 1.814283386936347e-06 0.4973332357952056 \
1.814283640864285e-06 0.4919960258408594 1.81428388179775e-06 0.4869529241725989 1.814284177960236e-06 0.4807889695952298 1.814284467957623e-06 0.4747910561470179 \
1.814284774200956e-06 0.4684976697011882 1.814285094876887e-06 0.4619520863481486 1.814285422744054e-06 0.4553041925245184 1.814285762989109e-06 0.4484521981997251 \
1.814286088414654e-06 0.4419418052309769 1.814286410321802e-06 0.4355465312739703 1.814286740535907e-06 0.4290298934287748 1.814287096528499e-06 0.4220583188787752 \
1.814287415406929e-06 0.4158579595363656 1.814287752858691e-06 0.4093433989943853 1.814288180725407e-06 0.4011531841887147 1.814288529437355e-06 0.3945419525178304 \
1.814288837073319e-06 0.388759214407489 1.814289216899811e-06 0.3816861832573664 1.814289548089372e-06 0.3755780492082042 1.814289831697452e-06 0.370391509977049 \
1.814290142516397e-06 0.3647512908748707 1.814290421833004e-06 0.3597258263082204 1.814290648329152e-06 0.3556836811642302 1.814290864011538e-06 0.3518598964090484 \
1.814291061295543e-06 0.3483842179544538 1.814291266280002e-06 0.3447988491770444 1.814291478501966e-06 0.3411119200457455 1.814291733807154e-06 0.33670771290924 \
1.814291975329403e-06 0.3325734463267218 1.814292206706731e-06 0.3286464933807047 1.814292421559231e-06 0.3250253651850565 1.814292642118388e-06 0.3213332986541765 \
1.814292843544355e-06 0.3179852906236645 1.814293046612606e-06 0.3146379646143546 1.814293244508215e-06 0.3114011111455273 1.814293431469302e-06 0.3083651674074345 \
1.814293625269521e-06 0.3052406640298299 1.814293829186134e-06 0.3019773030815858 1.814294008255468e-06 0.2991336297844484 1.814294243846324e-06 0.2954229173226265 \
1.814294444650423e-06 0.2922868215109002 1.814294645829315e-06 0.2891696385850206 1.814294869639057e-06 0.2857334090862961 1.814295034201803e-06 0.2832271910241367 \
1.814295211129189e-06 0.2805503385691353 1.814295396922194e-06 0.2777610713150803 1.81429557873767e-06 0.2750538970423583 1.814295757762463e-06 0.2724132377985424 \
1.814295925107616e-06 0.2699606650006489 1.814296085536534e-06 0.2676371805838822 1.814296208110285e-06 0.2658719571410424 1.814296357874814e-06 0.2637236906090554 \
1.81429648557194e-06 0.2619099339733745 1.814296592880312e-06 0.2603957336038235 1.814296708880974e-06 0.2587625259947361 1.81429681918957e-06 0.2572125806747212 \
1.814296945068767e-06 0.2554509781935611 1.814297060550618e-06 0.2538402638894013 1.814297195131521e-06 0.2519757335310172 1.814297307194775e-06 0.2504255755821768 \
1.814297457534134e-06 0.2483447107137444 1.814297597159989e-06 0.2464124269747185 1.814297743051809e-06 0.2444035064209518 1.814297876012447e-06 0.2425734862730615 \
1.814297999574161e-06 0.2408709992523319 1.814298146783853e-06 0.2388417729476062 1.814298263370682e-06 0.2372355665500016 1.814298402825831e-06 0.23532008003217 \
1.814298537000301e-06 0.2334768281602104 1.814298662976757e-06 0.2317465561243653 1.81429878237616e-06 0.2301094434087779 1.814298877230585e-06 0.2288105340759602 \
1.814298990368184e-06 0.2272617792622066 1.814299070684642e-06 0.2261626001158484 1.814299158249698e-06 0.2249657246820506 1.814299283786835e-06 0.2232507767215072 \
1.814299389480543e-06 0.2218101326756785 1.814299479135054e-06 0.2205921574607158 1.814299549986253e-06 0.2196300825522397 1.814299593014782e-06 0.2190460135436258 \
1.814299635305326e-06 0.2184724035808872 1.814299677647042e-06 0.2178984240735344 1.814299749842461e-06 0.2169203674089526 1.814299792235817e-06 0.2163464205126744 \
1.814299827490656e-06 0.2158693585303403 1.814299871682239e-06 0.2152716287340076 1.814299941290466e-06 0.2143309212991285 1.814299975633796e-06 0.2138672544767182 \
1.814300020093325e-06 0.2132698436071631 1.814300087771806e-06 0.2123628126304402 1.814300174199065e-06 0.2112058698236149 1.814300248835667e-06 0.2102078598594563 \
1.814300330137675e-06 0.2091219706754807 1.814300427015059e-06 0.2078300362310651 1.814300552998548e-06 0.2061528795789772 1.814300655533384e-06 0.2047906894256944 \
1.814300757016901e-06 0.2034500128132261 1.814300858082597e-06 0.202119416354989 1.814300954696816e-06 0.2008491615811921 1.814301056661239e-06 0.1995112314821507 \
1.814301163383483e-06 0.1981153840927639 1.814301271788623e-06 0.1967018790395962 1.814301383782779e-06 0.1952465002768531 1.814301496249907e-06 0.1937897263683151 \
1.814301608323246e-06 0.1923454332378671 1.81430171621572e-06 0.1909603537828802 1.814301817598649e-06 0.1896629368444172 1.814301909236098e-06 0.1884941330679491 \
1.814302003211707e-06 0.1872990757663449 1.814302074478072e-06 0.1863957871745983 1.81430215115336e-06 0.1854271890400033 1.814302254812475e-06 0.184122202819407 \
1.814302328479595e-06 0.1831974022686171 1.814302401825496e-06 0.1822796569444652 1.814302515215845e-06 0.1808667181969195 1.814302603074485e-06 0.1797760932362061 \
1.814302686923162e-06 0.1787387947787487 1.81430281588559e-06 0.1771515524267008 1.814302917772084e-06 0.1759040172436072 1.814303023472791e-06 0.1746156056808686 \
1.814303125120866e-06 0.1733818993219825 1.814303255982584e-06 0.1718019019596718 1.814303363179221e-06 0.1705140034701537 1.814303492508118e-06 0.168969083715685 \
1.81430360420461e-06 0.167642098072289 1.814303704535188e-06 0.1664555496840579 1.814303800335743e-06 0.1653276075899142 1.814303911148015e-06 0.1640289617085985 \
1.814303998548296e-06 0.1630090521997956 1.814304109869413e-06 0.1617156184952586 1.814304202821272e-06 0.1606409001560029 1.81430429039415e-06 0.1596330843918451 \
1.814304392025023e-06 0.1584700928658864 1.814304476479078e-06 0.1575086241734052 1.814304551583457e-06 0.1566573095634876 1.8143046294057e-06 0.1557789554714152 \
1.814304709763569e-06 0.1548759612316424 1.814304810818399e-06 0.1537464547857493 1.814304893251962e-06 0.1528311848879565 1.814304985556514e-06 0.1518114053368895 \
1.814305062490987e-06 0.150965812476358 1.814305145413557e-06 0.1500585909391909 1.814305216944298e-06 0.1492793026301012 1.814305313327797e-06 0.1482344968214558 \
1.814305383556283e-06 0.1474766665551334 1.814305466536561e-06 0.1465853655470201 1.814305527978824e-06 0.1459298106834085 1.814305599661209e-06 0.1451677491870439 \
1.814305668289752e-06 0.1444408762699853 1.814305718558261e-06 0.1439102090153988 1.814305766138067e-06 0.143409423336876 1.814305820187418e-06 0.1428423132663369 \
1.814305879529516e-06 0.1422216078256897 1.814305947564923e-06 0.1415124633834424 1.814306023828345e-06 0.1407207186008814 1.814306092108144e-06 0.1400161356079559 \
1.814306186894323e-06 0.1390460813732662 1.814306276448135e-06 0.1381341561933974 1.814306348133609e-06 0.1374075731330657 1.814306432085017e-06 0.1365606113096345 \
1.814306497397472e-06 0.1359045398875483 1.814306558840598e-06 0.1352895588344758 1.814306633117097e-06 0.1345490408254265 1.814306695327357e-06 0.1339328028964004 \
1.814306763298365e-06 0.133265236037424 1.814306822505405e-06 0.1326856657519672 1.814306895177878e-06 0.1319767402814105 1.814306970197987e-06 0.1312477270463112 \
1.81430705565141e-06 0.1304208267333309 1.81430714175175e-06 0.1295914604616623 1.814307241877205e-06 0.1286317929389105 1.814307323166875e-06 0.127857435971709 \
1.814307424934223e-06 0.1268981149578782 1.814307509182182e-06 0.1261072369695883 1.814307607998911e-06 0.1251836587365037 1.814307680839455e-06 0.1245055382686853 \
1.814307760865543e-06 0.1237631876254407 1.814307831351338e-06 0.1231117958237987 1.81430790388176e-06 0.1224439308288319 1.814307981350756e-06 0.1217331219782777 \
1.814308088702104e-06 0.1207554316575004 1.814308189340119e-06 0.1198442997624752 1.814308261927673e-06 0.1191899427853172 1.814308330759514e-06 0.1185715582611356 \
1.814308396546334e-06 0.1179824683205609 1.814308466175131e-06 0.1173610347366148 1.814308536558877e-06 0.1167350538439435 1.814308611737249e-06 0.1160688810594495 \
1.814308715991484e-06 0.1151493019715505 1.814308791126138e-06 0.114489769343061 1.814308860041223e-06 0.1138870655592168 1.814308923246094e-06 0.1133369146236164 \
1.81430899278746e-06 0.1127339156958381 1.814309050088964e-06 0.1122385190692166 1.814309121730019e-06 0.1116210355509516 1.814309179565092e-06 0.1111240709857579 \
1.814309251686527e-06 0.1105063809580559 1.81430931410261e-06 0.1099736279351742 1.814309398424131e-06 0.1092565349771765 1.8143094660201e-06 0.1086842173446869 \
1.814309574816032e-06 0.1077671916889585 1.814309679126564e-06 0.1068924975608609 1.814309758614772e-06 0.1062289053282379 1.814309846183182e-06 0.1055008617114655 \
1.814309909639535e-06 0.1049752776433979 1.814309971350652e-06 0.10446579874651 1.814310075190416e-06 0.103612238268202 1.814310157871117e-06 0.1029362225408096 \
1.814310256339144e-06 0.1021348761715451 1.814310340785582e-06 0.101450818648051 1.814310457263062e-06 0.1005121841703865 1.814310591996507e-06 0.09943411943161744 \
1.814310728066044e-06 0.0983541971400249 1.814310842385451e-06 0.09745369041838402 1.814310927852596e-06 0.09678457778867394 1.814311038134269e-06 0.09592640631053104 \
1.814311118922622e-06 0.09530159220710262 1.814311218473493e-06 0.09453592511176086 1.814311308421543e-06 0.09384821103094763 1.814311380924943e-06 0.09329669945188329 \
1.814311462667009e-06 0.09267796846073476 1.814311590787244e-06 0.09171467366828615 1.814311672199308e-06 0.09110674702409056 1.814311746631215e-06 0.09055373306570065 \
1.814311821605099e-06 0.08999936228352182 1.814311901024074e-06 0.08941505746347288 1.814312009684932e-06 0.08862052380504259 1.814312104044903e-06 0.08793517800096999 \
1.814312193440026e-06 0.08728987318634121 1.814312300205742e-06 0.086524181682867 1.814312418708182e-06 0.08568073755029131 1.814312560233253e-06 0.08468224831562859 \
1.814312693371676e-06 0.08375174214918565 1.814312834217007e-06 0.08277682112810406 1.814312983268988e-06 0.08175525972387458 1.814313119066717e-06 0.08083369778093191 \
1.814313260523232e-06 0.0798830809748103 1.814313395783147e-06 0.07898330517332906 1.814313537164988e-06 0.07805242629322809 1.814313684232761e-06 0.07709434677344783 \
1.814313835960902e-06 0.07611680364043326 1.814314001309203e-06 0.07506403321855706 1.814314165176721e-06 0.07403332863189842 1.814314341490648e-06 0.07293832728335037 \
1.81431453092575e-06 0.07177777688466977 1.814314741692455e-06 0.07050569389938771 1.814314961464952e-06 0.06920150027616521 1.814315196433104e-06 0.06783224552442871 \
1.814315455333654e-06 0.06635227408830123 1.814315750264117e-06 0.06470266364809808 1.814316054610178e-06 0.06304001691994518 1.814316416556457e-06 0.06111393619706453 \
1.814316732684212e-06 0.05947639552636011 1.814317174006677e-06 0.0572596911373907 1.814317487572719e-06 0.05573556853365672 1.814317911072189e-06 0.0537382660685313 \
1.814318255024042e-06 0.05216649213267931 1.81431859526531e-06 0.05065508790922631 1.8143189061029e-06 0.04931137323461653 1.814319200574802e-06 0.04807062469528345 \
1.814319494274299e-06 0.04686392507224969 1.814319769145535e-06 0.04576537019482012 1.814320044685701e-06 0.04468949010490332 1.81432030977623e-06 0.04367785045825667 \
1.814320586533311e-06 0.04264571401740119 1.814320869801436e-06 0.04161414314527601 1.814321167794735e-06 0.04055545327485047 1.814321427280131e-06 0.03965542606183669 \
1.814321657303569e-06 0.03887446236327848 1.814321876995156e-06 0.03814321686473518 1.814322101935296e-06 0.0374128399305801 1.81432242218897e-06 0.0363978329183388 \
1.81432270998682e-06 0.03550963653148703 1.814322986382154e-06 0.03467738358988744 1.814323270201283e-06 0.03384352473043348 1.814323508310587e-06 0.03315996078327022 \
1.814323792621371e-06 0.03236211345273886 1.81432403453322e-06 0.03169864947531036 1.814324269673394e-06 0.03106710921041438 1.814324511380923e-06 0.03043352335444016 \
1.814324748333856e-06 0.02982731501219571 1.814324978676274e-06 0.02925002048968134 1.814325192426852e-06 0.02872465224286764 1.814325398273815e-06 0.02822791768061097 \
1.814325790610838e-06 0.02730524204782691 1.814325979002849e-06 0.02687312495148303 1.814326354614307e-06 0.02603163971789 1.814326529081082e-06 0.02564950258131362 \
1.814326953015541e-06 0.02474274850847508 1.814327073769958e-06 0.02449086781212801 1.814327544020721e-06 0.02353384026002922 1.814327693235786e-06 0.02323677291035493 \
1.814328086867998e-06 0.02246740853134286 1.814328257894342e-06 0.02213909006726131 1.814328745173274e-06 0.02121869533024997 1.814328887220983e-06 0.02095326544309953 \
1.814329420237252e-06 0.01997576278857772 1.814329542401289e-06 0.01975737097014436 1.814330064559033e-06 0.01885981776906158 1.814330235137336e-06 0.01857989792133653 \
1.814330722450399e-06 0.01781360777737795 1.814330893973322e-06 0.01755501440977742 1.81433151376008e-06 0.01666567753024489 1.814331684684406e-06 0.0164316648397145 \
1.814332390235396e-06 0.01551160061118263 1.814332552852409e-06 0.01530799450170666 1.814333309745899e-06 0.01439879525764199 1.814333450662544e-06 0.01423641007536438 \
1.814334350661384e-06 0.01324361033368418 1.814334438010634e-06 0.01315122959105692 1.814335342363989e-06 0.01223321097894121 1.814335479555938e-06 0.01209984223734439 \
1.814336450212214e-06 0.01118944790767422 1.814336578130092e-06 0.01107451071402888 1.814337728540039e-06 0.01011008206277823 1.814337822342075e-06 0.01003687265682024 \
1.814339078387887e-06 0.009120584045805383 1.8143392159292e-06 0.009026502753623255 1.814340774683602e-06 0.008029670037698805 1.814340858486287e-06 0.007977066150721189 \
1.814342463865106e-06 0.00699828665725172 1.81434257476345e-06 0.006935886594503895 1.814344507009824e-06 0.005959177461785255 1.814344686714759e-06 0.005876661013304485 \
1.814346798505876e-06 0.004981749118765498 1.814347141291011e-06 0.004848482978762325 1.814349654457045e-06 0.003966891390423618 1.814350124178715e-06 0.003819799497680527 \
1.814353764494989e-06 0.002847564273158896 1.814354280232175e-06 0.002731633924241866 1.814359622062014e-06 0.001773027297371861 1.814359907382299e-06 0.001729522787584184 \
1.814365136030129e-06 0.0007540451492352357 1.814365310176696e-06 0.0007162692714263865 1.817013698769002e-06 -0.0001123232525192561 1.81701387179429e-06 -0.0002901710972538241 \
1.817014491546044e-06 -0.001202022686018724 1.817014580115221e-06 -0.001365806793032466 1.817014941086355e-06 -0.002110727959526865 1.81701506578065e-06 -0.002395793696299351 \
1.817015429622531e-06 -0.003299857180474864 1.817015600898199e-06 -0.003758114451912169 1.817015894896038e-06 -0.004576312838821549 1.817016005104443e-06 -0.004886880824040592 \
1.817016283358441e-06 -0.005643955697619643 1.81701640463225e-06 -0.00594200199557267 1.817017498254348e-06 -0.00517389603226481 1.817017621358228e-06 -0.004409713243767066 \
1.817017744826303e-06 -0.003462788751204457 1.8170178649921e-06 -0.002366010162083454 1.817017962853768e-06 -0.001346276287748183 1.817018069556104e-06 -0.0001076498664581183 \
1.817018181397488e-06 0.001328007358939307 1.817018317371855e-06 0.003256083960376262 1.817018439401011e-06 0.00514709866632534 1.817018627817289e-06 0.008343062029134115 \
1.817018768805819e-06 0.01093380316938193 1.817018921577522e-06 0.01391176330477175 1.81701906428015e-06 0.01683596409946878 1.817019218632387e-06 0.02013443377634912 \
1.817019374426043e-06 0.02358734537610087 1.81701953048334e-06 0.02715365164079262 1.81701967788774e-06 0.03060642997674319 1.817019826504485e-06 0.03415780069914553 \
1.817019981925701e-06 0.03793559522944389 1.817020140311532e-06 0.04184227512730877 1.817020305251154e-06 0.04596085539464361 1.817020479500423e-06 0.05035714787605008 \
1.817020658443539e-06 0.05491177248689325 1.817020847583032e-06 0.0597604232635115 1.81702105036361e-06 0.06498910043066243 1.817021269735637e-06 0.07067233091134768 \
1.817021500572133e-06 0.07667464705993039 1.817021747383969e-06 0.0831083675499642 1.81702201751608e-06 0.09016243555275107 1.817022310704188e-06 0.0978236474935409 \
1.817022634359626e-06 0.1062798466079799 1.817022997926912e-06 0.1157689210849182 1.81702339022043e-06 0.1259925151671456 1.817023838699915e-06 0.1376538644086695 \
1.8170243603994e-06 0.1511757390224034 1.817024972772044e-06 0.1669844191341421 1.817025649417359e-06 0.1843663871188266 1.817026436327649e-06 0.2044554566749352 \
1.817027317548744e-06 0.2267919980918504 1.817028137292384e-06 0.2474048556006221 1.817028865745328e-06 0.2655829647002126 1.817029507221317e-06 0.2814688958417333 \
1.817030083144485e-06 0.2956305456066151 1.817030620401302e-06 0.3087428400511723 1.817031124292597e-06 0.3209487846516751 1.817031601896145e-06 0.3324328152479784 \
1.817032080019379e-06 0.343838772307344 1.817032532118228e-06 0.3545331600964184 1.817033003884519e-06 0.365596737404158 1.81703344758136e-06 0.3759140547845509 \
1.817033969549897e-06 0.3879344734281669 1.81703449708783e-06 0.399956933836353 1.817034876602574e-06 0.4085271910771138 1.817035405564174e-06 0.4203606102508351 \
1.817035874883255e-06 0.4307444005277802 1.817036310038791e-06 0.4402814026247405 1.817036757516117e-06 0.4500002273945978 1.817037197539592e-06 0.4594737646471725 \
1.817037600841335e-06 0.4680814138276727 1.817037919241101e-06 0.4748254127722248 1.817038289219015e-06 0.4826007100982719 1.817038525472097e-06 0.4875314737878706 \
1.817038760543493e-06 0.4924129045770672 1.817039011882831e-06 0.4975994385012801 1.817039318269865e-06 0.5038799449729535 1.817039575228319e-06 0.5091120301871851 \
1.817039783702615e-06 0.5133309170973237 1.817039984084905e-06 0.5173683849445317 1.817040126478606e-06 0.5202244049244739 1.817040275403071e-06 0.5231993726577677 \
1.817040486949329e-06 0.5274019882470222 1.817040713006952e-06 0.5318780389403845 1.817040907549333e-06 0.5357103559602913 1.817041096681229e-06 0.539423417888626 \
1.817041326128277e-06 0.5439012399750046 1.817041508634083e-06 0.5474563135343053 1.817041745996952e-06 0.5520623276458133 1.81704201499126e-06 0.5572695987004129 \
1.81704226390171e-06 0.5620706638085723 1.817042507918531e-06 0.5667633705755619 1.817042780273744e-06 0.5719926523718327 1.817043041669873e-06 0.5769928369418796 \
1.817043299301279e-06 0.5819084237686675 1.817043546144628e-06 0.586601202059797 1.817043791890354e-06 0.5912552023551558 1.817044018467874e-06 0.5955288021520931 \
1.817044249620064e-06 0.5998646534936181 1.817044455900444e-06 0.6037202012184053 1.817044684021204e-06 0.6079592993751251 1.817044906401185e-06 0.6120725203834017 \
1.817045133377667e-06 0.6162454422471376 1.817045348430617e-06 0.6201823359462864 1.81704557780019e-06 0.6243500782103125 1.817045846823065e-06 0.6292041961704016 \
1.817046069836712e-06 0.6331993632081415 1.817046282091289e-06 0.6369772451758789 1.817046493488879e-06 0.6407176358819484 1.817046693558109e-06 0.644236566349866 \
1.817046923151958e-06 0.6482486956559365 1.817047163988886e-06 0.6524328529570182 1.817047345738273e-06 0.6555667906748446 1.8170475342865e-06 0.6588018260593631 \
1.817047687366139e-06 0.6614154033769962 1.817047859374421e-06 0.6643352515471471 1.817048009547239e-06 0.6668697017322168 1.817048146064529e-06 0.6691578850264722 \
1.817048295693716e-06 0.6716547631652277 1.817048423434085e-06 0.673777752640997 1.817048563020222e-06 0.6760856948620949 1.81704868725891e-06 0.6781310478824312 \
1.817048818408749e-06 0.6802827752320969 1.817048942850093e-06 0.6823179209931315 1.817049080080915e-06 0.6845542421253382 1.817049200329086e-06 0.6865048414796368 \
1.817049341660529e-06 0.6887891282595083 1.817049441991641e-06 0.6904033553735033 1.817049563109342e-06 0.6923460943304175 1.817049653886878e-06 0.6937948943079848 \
1.817049751145344e-06 0.6953408241330762 1.817049847353224e-06 0.6968660703265798 1.817049935967068e-06 0.6982647859968389 1.817050033255091e-06 0.6997938110311075 \
1.817050165723729e-06 0.7018622871835729 1.817050320913928e-06 0.7042674555997347 1.817050458791879e-06 0.7063866855441746 1.817050603646153e-06 0.7085960165693863 \
1.81705073070791e-06 0.7105202221428537 1.81705085539347e-06 0.7123960184768648 1.817050968098846e-06 0.7140814553427599 1.81705107988919e-06 0.7157437310299281 \
1.81705118066784e-06 0.7172341607972841 1.817051317946295e-06 0.7192525454101454 1.817051437630367e-06 0.7210013704967912 1.817051557059838e-06 0.7227365757678518 \
1.81705168394306e-06 0.7245692610776365 1.817051808360712e-06 0.7263556789600311 1.817051932093536e-06 0.728121726658988 1.817052058689063e-06 0.7299181396522603 \
1.817052189074464e-06 0.7317573312219798 1.817052311884284e-06 0.7334798522758219 1.817052447320059e-06 0.7353678990088863 1.817052548609838e-06 0.7367723836293941 \
1.817052656232334e-06 0.7382576460517265 1.817052745760416e-06 0.7394878879617913 1.817052860308785e-06 0.7410528648863303 1.817052948337041e-06 0.7422487366778059 \
1.817053055415107e-06 0.7436953530868765 1.8170531854801e-06 0.7454403311053276 1.817053296759795e-06 0.7469230742113165 1.817053401378355e-06 0.7483084058091373 \
1.81705352546134e-06 0.7499400420429273 1.817053673762168e-06 0.7518749696944975 1.817053795162033e-06 0.7534462209622173 1.81705390960278e-06 0.7549170836379747 \
1.817054049940098e-06 0.7567069362027918 1.817054191702981e-06 0.7584995177563068 1.817054309503919e-06 0.759977341175643 1.817054437480785e-06 0.761570846386187 \
1.817054579183209e-06 0.7633205808366864 1.817054696694522e-06 0.7647599110190483 1.817054842299791e-06 0.7665289162262866 1.817054963994099e-06 0.7679951561698679 \
1.817055082724709e-06 0.7694149786178283 1.817055205011304e-06 0.7708662727382939 1.81705533205582e-06 0.77236234268503 1.817055441699792e-06 0.7736439866494906 \
1.817055567386704e-06 0.7751025186690397 1.817055673401805e-06 0.776323977486031 1.817055808987772e-06 0.7778743028704433 1.817055933950769e-06 0.7792913979962601 \
1.817056059856921e-06 0.7807070123991936 1.817056175124167e-06 0.7819915514687489 1.81705628142864e-06 0.7831664991275713 1.817056419833432e-06 0.7846822315516878 \
1.817056569129882e-06 0.7862997378875561 1.817056714637327e-06 0.7878588534534761 1.817056834041839e-06 0.7891257303126159 1.817056969134663e-06 0.7905455128963393 \
1.817057090387826e-06 0.7918076974797237 1.817057233381105e-06 0.7932816011184505 1.81705737758541e-06 0.7947523458802197 1.817057503122239e-06 0.7960199014141693 \
1.817057622168612e-06 0.7972110037065316 1.817057734104495e-06 0.7983213107123885 1.817057838976047e-06 0.7993531099923881 1.817057934226459e-06 0.8002831901653534 \
1.817058070569704e-06 0.8016020813281191 1.817058187393835e-06 0.8027203407102198 1.817058306798445e-06 0.803852171037294 1.817058428905249e-06 0.8049980820693966 \
1.81705855186025e-06 0.8061401395390313 1.817058678828951e-06 0.8073073595000361 1.81705880406856e-06 0.8084467645495962 1.817058934640955e-06 0.8096220968518901 \
1.817059060631473e-06 0.8107441738369082 1.817059188817385e-06 0.8118738099374113 1.817059294347114e-06 0.8127947795787664 1.817059397218887e-06 0.8136847278655364 \
1.817059490214057e-06 0.8144826950388273 1.817059614010659e-06 0.8155354283166244 1.817059701978917e-06 0.8162769513478326 1.817059800709988e-06 0.8171027376706747 \
1.817059943975142e-06 0.8182889948057973 1.817060079253827e-06 0.8193962136425846 1.817060188368449e-06 0.8202800249700468 1.817060336451758e-06 0.8214657808291811 \
1.817060486222685e-06 0.8226492530953341 1.817060611457285e-06 0.8236267526687548 1.817060755448703e-06 0.8247372275730155 1.817060879504774e-06 0.8256825756473101 \
1.817061029968032e-06 0.8268152483647575 1.817061165678884e-06 0.8278240064655301 1.817061290697392e-06 0.828742521381556 1.817061408452322e-06 0.8295983347934622 \
1.817061554429135e-06 0.8306466023667578 1.817061720938452e-06 0.8318251482734692 1.817061851861028e-06 0.8327390940956469 1.817062025288466e-06 0.8339327615268647 \
1.817062193435348e-06 0.8350717495747054 1.817062363270277e-06 0.8362042975620877 1.817062544195048e-06 0.8373912937861997 1.817062687293307e-06 0.8383160748488641 \
1.817062801379198e-06 0.8390446117604563 1.817062931553184e-06 0.8398665237782376 1.817063033394266e-06 0.8405024977857931 1.817063150213615e-06 0.8412243379523001 \
1.817063287078045e-06 0.8420597162999857 1.817063484876668e-06 0.8432475311273343 1.81706367648074e-06 0.8443767279905872 1.817063885921221e-06 0.8455874169714939 \
1.817064067846852e-06 0.8466193100105236 1.817064264979957e-06 0.8477171434207121 1.817064438329848e-06 0.8486653666163242 1.817064621329232e-06 0.8496493024239481 \
1.817064792495495e-06 0.8505537352954988 1.817064967127282e-06 0.8514606693963016 1.817065142389669e-06 0.8523550102558151 1.817065318541784e-06 0.8532381479010797 \
1.817065508812824e-06 0.8541746551565574 1.817065699414774e-06 0.85509499218684 1.817065900062401e-06 0.8560449689899254 1.817066092672966e-06 0.8569390259424264 \
1.817066303330652e-06 0.8578972157030333 1.817066531456051e-06 0.8589122247267402 1.817066797213368e-06 0.8600655879592763 1.817067095837813e-06 0.8613244245924475 \
1.817067372169332e-06 0.862454900702886 1.81706765640239e-06 0.8635842083919951 1.817067930614306e-06 0.8646423892283146 1.817068202842372e-06 0.8656634505877856 \
1.817068473051191e-06 0.8666487272755322 1.817068730204067e-06 0.8675609437488442 1.817069002786335e-06 0.868501515423508 1.817069278771335e-06 0.8694269133137555 \
1.817069548872911e-06 0.8703069289141475 1.817069848734863e-06 0.8712546000783432 1.817070219768993e-06 0.8723856543073821 1.817070514706753e-06 0.8732530157608677 \
1.817070768997535e-06 0.8739790309043101 1.817071067254951e-06 0.8748056771600844 1.817071340863485e-06 0.8755409825400007 1.817071576991549e-06 0.8761583495732972 \
1.81707181733693e-06 0.876770807053994 1.817072039670212e-06 0.8773233906735478 1.81707223367596e-06 0.8777948466981503 1.817072563398506e-06 0.8785737911727464 \
1.817072718571944e-06 0.8789308835864816 1.817073036347473e-06 0.8796437246174529 1.81707321520917e-06 0.8800342982281311 1.817073557671047e-06 0.8807611334253193 \
1.817073741799519e-06 0.8811407335605206 1.817074216677856e-06 0.8820849466541889 1.817074384074053e-06 0.8824061830950772 1.817074849915456e-06 0.8832696475595492 \
1.817075030737665e-06 0.8835931319180218 1.817075524775914e-06 0.8844450822729043 1.817075666124327e-06 0.8846804878101884 1.817076272457385e-06 0.8856498028150036 \
1.817076424526725e-06 0.8858829444029697 1.8170770712152e-06 0.8868329272509302 1.817077199509723e-06 0.8870138524519416 1.817077847626928e-06 0.8878919388991984 \
1.817077977425791e-06 0.8880607713689423 1.817078755627481e-06 0.8890227771434612 1.817078870684414e-06 0.8891574578072456 1.817079726342848e-06 0.8901003239091128 \
1.817079871707615e-06 0.8902505899439886 1.81708085746403e-06 0.8911948786459364 1.81708107856904e-06 0.8913892999646706 1.817082223696019e-06 0.8923206810037944 \
1.817082354912618e-06 0.892422953350996 1.817083696124267e-06 0.8934189515818408 1.817083847523211e-06 0.8935240845833778 1.817085328961459e-06 0.8944568913393511 \
1.817085567840892e-06 0.8945912088657246 1.817087337161074e-06 0.8954685138428928 1.81708772631084e-06 0.895637400736999 1.817090119976627e-06 0.896526474291006 \
1.81709059568945e-06 0.8966764365754722 1.817094011699057e-06 0.8975478548673914 1.817094658849072e-06 0.8976786076740833 1.817102137013678e-06 0.8986646932675814 \
1.817102809590796e-06 0.8987192862546014 1.817195253995367e-06 0.8997188196574962 1.817195917228051e-06 0.8997241906476866 1.817385126389945e-06 0.900686595210158 \
1.817385288462789e-06 0.9007292695325627 1.817387933983676e-06 0.8998161167154269 1.817388102533154e-06 0.8996881690130656 1.817389379285545e-06 0.8987393243250013 \
1.817389581451881e-06 0.8986030018074492 1.817391189561267e-06 0.8976721249252815 1.817391381667192e-06 0.8975774045828077 1.817406495049839e-06 0.8985726115129884 \
1.817406683108756e-06 0.8986004060702872 1.817417988037767e-06 0.8995874924221801 1.817418361423516e-06 0.8996034751727418 1.817907373786698e-06 0.9005892719715856 \
1.817907484554897e-06 0.9006868984798269 1.817908237227259e-06 0.9015617873136611 1.817908339021945e-06 0.9017086238768567 1.81790887442049e-06 0.9025814930725723 \
1.817908976929663e-06 0.9027670217776843 1.817909369148481e-06 0.9035254014384071 1.817909509991429e-06 0.9038129158713877 1.817909951028881e-06 0.9047472953155866 \
1.817910136514484e-06 0.9051402477015744 1.817910652827601e-06 0.9061269394579334 1.817910737502694e-06 0.9062564181617988 1.817911972174744e-06 0.9053011091537977 \
1.817912129388156e-06 0.9045688862145235 1.817912321204817e-06 0.9034162411061901 1.817912488045348e-06 0.9021712267446264 1.817912635003746e-06 0.9008824031243315 \
1.817912749119942e-06 0.8997575350477262 1.817912878992032e-06 0.8983446880789033 1.81791299010955e-06 0.8970273815442567 1.817913082914029e-06 0.8958483937359277 \
1.817913171236719e-06 0.8946639786015808 1.817913274417478e-06 0.8932058048613533 1.817913366625413e-06 0.8918333298588224 1.81791345419561e-06 0.8904732289418564 \
1.817913568189076e-06 0.8886245408236838 1.8179137299935e-06 0.8858564722885236 1.817913914992117e-06 0.8825005184224666 1.817914107151785e-06 0.8788219124347386 \
1.817914308599138e-06 0.874780227084481 1.817914515009728e-06 0.8704697801294994 1.81791470018168e-06 0.8664790122147591 1.817914884689405e-06 0.862405115500708 \
1.817915057841296e-06 0.8585071391690239 1.817915242887321e-06 0.8542751393552932 1.817915420261524e-06 0.8501657390392787 1.817915597007955e-06 0.8460284987362284 \
1.817915763166606e-06 0.8421077870518131 1.817915925211044e-06 0.8382599993991456 1.817916091783925e-06 0.8342839555277276 1.817916250437662e-06 0.8304816347052207 \
1.817916441313687e-06 0.8258903812682129 1.817916616297259e-06 0.8216694867670907 1.817916786243392e-06 0.8175615830390965 1.817916951419567e-06 0.8135626411663678 \
1.817917124611674e-06 0.8093650119631921 1.817917295673877e-06 0.8052155696745213 1.817917463774914e-06 0.801136095357175 1.817917654109863e-06 0.7965156511928794 \
1.817917837691806e-06 0.7920591698039 1.817918045682732e-06 0.7870113041480956 1.817918268259242e-06 0.7816114142545842 1.817918457674258e-06 0.7770174196885687 \
1.817918650984654e-06 0.7723312127316435 1.81791879443024e-06 0.7688556734481145 1.81791894385359e-06 0.7652374066097742 1.817919063006063e-06 0.7623536300085233 \
1.817919175722544e-06 0.7596269484184472 1.817919284997451e-06 0.7569846861296079 1.817919421027209e-06 0.753697254849378 1.817919533823024e-06 0.750972995067179 \
1.81791965602098e-06 0.7480232093637929 1.817919767605752e-06 0.7453311011793381 1.817919892312215e-06 0.7423241425761796 1.817920046694167e-06 0.7386034578119585 \
1.817920213478233e-06 0.7345862494782525 1.817920430642921e-06 0.7293605768817599 1.81792062520351e-06 0.7246835946359503 1.817920785534395e-06 0.7208333202545074 \
1.817920960959998e-06 0.7166251500492028 1.817921150723573e-06 0.7120779400724765 1.817921339451897e-06 0.7075610435995559 1.817921521273264e-06 0.7032145396962334 \
1.817921705870676e-06 0.6988062725207448 1.817921842953811e-06 0.6955348514212173 1.817921996242049e-06 0.6918805091472418 1.817922191613795e-06 0.6872279990818534 \
1.817922347770547e-06 0.6835136309588888 1.817922505722766e-06 0.6797605476340507 1.81792270397403e-06 0.6750570282453686 1.817922897319928e-06 0.6704763548785364 \
1.817923133825274e-06 0.6648822204491218 1.817923320030377e-06 0.6604858901039825 1.817923557652698e-06 0.6548824851665868 1.817923744451452e-06 0.6504854738275335 \
1.817923925009211e-06 0.6462424706993735 1.817924088085156e-06 0.6424159959781919 1.81792423269672e-06 0.6390271817202816 1.81792437329907e-06 0.6357379642635244 \
1.817924500108657e-06 0.632774906490579 1.817924632245193e-06 0.6296924762754078 1.817924758489144e-06 0.6267508340255646 1.817924889752774e-06 0.6236963630311418 \
1.817925018850514e-06 0.6206978048938425 1.817925158276179e-06 0.6174624210713571 1.817925306646171e-06 0.6140261568477932 1.81792550120306e-06 0.6095278574984737 \
1.817925644648937e-06 0.6062198040692683 1.817925879109183e-06 0.6008245134060309 1.817926051007495e-06 0.5968818013610552 1.817926263928033e-06 0.5920102583789468 \
1.817926436394651e-06 0.5880775912131976 1.817926566719197e-06 0.5851108450968721 1.817926698275517e-06 0.5821241897920357 1.817926808505599e-06 0.5796262478458715 \
1.817926904159846e-06 0.5774603558442819 1.817927003393806e-06 0.5752182923213994 1.817927086311907e-06 0.5733484809858778 1.817927165227534e-06 0.5715706040143225 \
1.817927228156309e-06 0.5701535626562365 1.817927293664786e-06 0.5686800671140783 1.817927374150839e-06 0.5668736364148982 1.817927424016846e-06 0.5657560592102344 \
1.817927473205615e-06 0.5646541775062763 1.817927534675401e-06 0.5632780399140616 1.817927582596929e-06 0.5622058085646952 1.817927633441648e-06 0.5610687758404553 \
1.817927692541903e-06 0.5597501790023616 1.81792775115623e-06 0.5584442118409422 1.817927826782323e-06 0.5567607189607793 1.817927897341035e-06 0.5551915720267918 \
1.817927986471042e-06 0.5532116467156011 1.81792807569462e-06 0.5512351177508077 1.81792816099823e-06 0.5493490637975145 1.817928248625197e-06 0.5474138635528197 \
1.81792834562712e-06 0.545274424894262 1.817928449972891e-06 0.5429792414815097 1.817928566264315e-06 0.5404269323775457 1.817928672601932e-06 0.5380963700835184 \
1.817928784310815e-06 0.5356536306660374 1.817928896605295e-06 0.5332047801427824 1.817929023802854e-06 0.5304364255197962 1.817929146572528e-06 0.5277698476303582 \
1.817929288796925e-06 0.5246912237717902 1.817929425160057e-06 0.5217463069543907 1.817929577381123e-06 0.5184691491721333 1.817929737017329e-06 0.5150420887864461 \
1.817929912992521e-06 0.5112761258030903 1.817930101501109e-06 0.5072591542828934 1.81793030856769e-06 0.5028616940969075 1.817930533509662e-06 0.4981043078903621 \
1.817930784905619e-06 0.4928144328841237 1.817931021331185e-06 0.4878598554762091 1.817931318494919e-06 0.4816683149127979 1.817931609172211e-06 0.4756487143466775 \
1.817931917027196e-06 0.469313240945046 1.817932230852953e-06 0.4628991126846517 1.817932559994313e-06 0.4562163541974347 1.817932893372419e-06 0.4494927613461197 \
1.817933224999028e-06 0.4428490490857003 1.817933546548425e-06 0.4364504708187015 1.817933874224238e-06 0.4299742838549845 1.81793422184386e-06 0.4231546934710667 \
1.817934555065174e-06 0.4166645133789623 1.817934900974402e-06 0.4099771621835854 1.817935346388221e-06 0.4014400148089548 1.817935704178092e-06 0.3946500490499754 \
1.817936018334912e-06 0.3887397205534429 1.817936402745391e-06 0.3815756289527631 1.817936732720036e-06 0.3754830843203271 1.817937017930125e-06 0.3702633801070484 \
1.817937326220382e-06 0.3646649204592909 1.817937606017443e-06 0.3596257204303125 1.817937832011793e-06 0.3555880084110294 1.817938046849747e-06 0.3517755993421203 \
1.81793824528482e-06 0.3482769933469286 1.817938449224337e-06 0.3447071465415313 1.817938659760396e-06 0.3410461989361561 1.817938916734521e-06 0.3366091000429626 \
1.817939157995129e-06 0.3324763702393667 1.817939389568845e-06 0.3285420159269506 1.817939604222291e-06 0.3249208057821749 1.817939825046275e-06 0.3212218866489027 \
1.817940026292867e-06 0.3178749657716667 1.81794022938212e-06 0.3145250552959265 1.817940427226991e-06 0.3112865758726304 1.817940614079937e-06 0.3082497660855442 \
1.817940808016662e-06 0.3051208532403978 1.817941011761317e-06 0.30185834615803 1.817941190488583e-06 0.2990186060348319 1.817941428134378e-06 0.2952727068736475 \
1.817941627896611e-06 0.2921508861588616 1.817941829525427e-06 0.2890253490052915 1.817942054991885e-06 0.285561995332 1.817942221086285e-06 0.2830312764183137 \
1.817942399705387e-06 0.2803277612349699 1.817942581409588e-06 0.2775983111934518 1.817942770043305e-06 0.2747882307029562 1.817942947466508e-06 0.2721695222189568 \
1.817943124659645e-06 0.2695724116247911 1.81794328473156e-06 0.2672552081803913 1.817943405132238e-06 0.2655193337608355 1.817943552958303e-06 0.2633957862580221 \
1.817943681588075e-06 0.2615692882062232 1.817943783793658e-06 0.2601227034409412 1.817943902028939e-06 0.2584516051170885 1.8179440224823e-06 0.2567534139348401 \
1.817944146190618e-06 0.2550183706610066 1.817944264442643e-06 0.2533694204037282 1.817944392295773e-06 0.2515887492000971 1.817944512581604e-06 0.249915736161692 \
1.81794466526121e-06 0.2477917697339537 1.817944800173988e-06 0.2459264316518071 1.81794492881341e-06 0.2441493177932957 1.817945086528788e-06 0.2419705448111171 \
1.817945213210091e-06 0.2402201997919771 1.817945348536158e-06 0.2383592392624043 1.817945487448727e-06 0.2364550510890953 1.817945605221031e-06 0.2348405558720491 \
1.817945764491849e-06 0.2326580599570062 1.817945901013704e-06 0.2307878375452989 1.81794604224565e-06 0.2288626996658652 1.817946148058693e-06 0.2274220928889542 \
1.81794627840164e-06 0.2256484734765637 1.817946378112453e-06 0.2242944442559471 1.817946480933888e-06 0.2228991027388591 1.817946554349542e-06 0.2219046249368765 \
1.817946634181104e-06 0.2208265149641777 1.817946704228335e-06 0.2198809561195558 1.817946754631426e-06 0.2192009305305119 1.817946806883225e-06 0.2184966408607167 \
1.817946886120743e-06 0.2174292050927151 1.817946927964696e-06 0.2168658036437602 1.817946967304648e-06 0.216336351877609 1.817947010340057e-06 0.2157575332679269 \
1.817947054507484e-06 0.2151638767852215 1.817947128273223e-06 0.2141731338947761 1.817947163785221e-06 0.2136967174286463 1.817947211500021e-06 0.2130606706933813 \
1.817947272229561e-06 0.2122518321687151 1.817947340486786e-06 0.2113438957752176 1.817947413008566e-06 0.2103801801047663 1.817947485683193e-06 0.2094152724966429 \
1.817947593999181e-06 0.2079788886429202 1.817947691670323e-06 0.20668564243436 1.817947803221819e-06 0.2052110974836689 1.817947901757253e-06 0.2039136008387587 \
1.817948005250393e-06 0.2025572972554956 1.817948101152127e-06 0.2013021587886929 1.817948203780057e-06 0.1999606878451601 1.81794830660317e-06 0.1986207062101238 \
1.817948416722797e-06 0.1971897063011611 1.817948525418353e-06 0.1957815523781236 1.817948645095582e-06 0.1942360962608612 1.81794875537326e-06 0.192818053470401 \
1.81794886343648e-06 0.1914343471929882 1.817948988535148e-06 0.1898375077741012 1.817949078504981e-06 0.1886931806549971 1.817949157191935e-06 0.1876950225942949 \
1.817949234476806e-06 0.1867173468865102 1.817949320985382e-06 0.1856271834369256 1.817949419934593e-06 0.1843848109964498 1.817949490443458e-06 0.1835017733581451 \
1.817949561894511e-06 0.1826096997732476 1.817949667039846e-06 0.1813018727451555 1.817949746279475e-06 0.1803200401832796 1.817949827363369e-06 0.1793174195483187 \
1.81794992085531e-06 0.1781663090788374 1.817950021631284e-06 0.1769308188703378 1.817950171343388e-06 0.175105380089017 1.817950287132704e-06 0.1737009932372819 \
1.81795043813808e-06 0.1718807311127691 1.8179505492465e-06 0.1705485445502526 1.817950691372958e-06 0.168854666407182 1.817950809031379e-06 0.167460358327668 \
1.817950913935975e-06 0.1662230887079887 1.817951008998573e-06 0.1651069099307241 1.817951102429828e-06 0.1640147999883682 1.81795120347649e-06 0.1628388413495604 \
1.817951299823398e-06 0.1617223204899406 1.817951396975644e-06 0.1606011553546776 1.817951480024216e-06 0.1596469772300165 1.81795159006187e-06 0.1583897228513109 \
1.817951672364432e-06 0.1574542248873526 1.817951777364141e-06 0.156267858580057 1.81795185506021e-06 0.1553950893374849 1.817951937879688e-06 0.1544690878994293 \
1.817952019541594e-06 0.1535604570452941 1.817952108890884e-06 0.152571060794856 1.81795218460332e-06 0.1517364980793458 1.817952267165934e-06 0.1508307726525361 \
1.817952343747367e-06 0.1499942554682341 1.817952412035253e-06 0.1492531084507001 1.817952505402265e-06 0.1482449401818621 1.817952574555677e-06 0.1475015570698688 \
1.817952650180008e-06 0.1466917482325688 1.817952711729128e-06 0.1460354497178591 1.817952778977892e-06 0.1453208357145237 1.817952850039892e-06 0.1445684785944268 \
1.81795292553732e-06 0.143772322008306 1.81795298444886e-06 0.1431546944759192 1.81795306112247e-06 0.1423563022825049 1.817953141443211e-06 0.1415233898163201 \
1.817953214594519e-06 0.1407682091691316 1.817953308750941e-06 0.139800669784813 1.817953380355125e-06 0.1390684367429364 1.8179534538159e-06 0.1383201464810226 \
1.817953537327651e-06 0.1374732033664194 1.817953626806795e-06 0.1365744208092838 1.8179536918717e-06 0.1359252211013016 1.817953803997723e-06 0.1348115665849295 \
1.817953869183863e-06 0.1341670699454539 1.817953939222108e-06 0.1334770515823289 1.817953999527163e-06 0.1328849371768329 1.817954054537987e-06 0.1323464455745446 \
1.817954142654965e-06 0.1314871014507438 1.817954183441259e-06 0.131090685705856 1.81795428714401e-06 0.1300923774523848 1.81795433045658e-06 0.1296773144713907 \
1.817954391675178e-06 0.1290920262082728 1.817954436511897e-06 0.1286643765206081 1.817954524107923e-06 0.127831527987147 1.817954565661879e-06 0.1274377589706847 \
1.817954625523389e-06 0.1268718307679372 1.817954697367115e-06 0.1261946708524367 1.817954753579841e-06 0.1256664967939027 1.81795481606734e-06 0.125081039250218 \
1.817954890295323e-06 0.1243877959456236 1.817954964976328e-06 0.1236954937854857 1.817955052159541e-06 0.1228905551604285 1.817955120558092e-06 0.1222610287411191 \
1.817955201128775e-06 0.1215216597888775 1.817955282424256e-06 0.120778012781285 1.817955349340781e-06 0.1201677797529914 1.817955432157725e-06 0.1194156054679852 \
1.817955491346448e-06 0.1188799972037829 1.817955557267448e-06 0.1182853617472536 1.817955637141491e-06 0.1175675408705869 1.81795571363729e-06 0.1168828806096336 \
1.8179557950994e-06 0.1161574242846086 1.817955893570281e-06 0.1152852106851665 1.81795596868063e-06 0.114622623867465 1.81795607166842e-06 0.1137180076826871 \
1.817956145852371e-06 0.1130691786503039 1.817956243471825e-06 0.1122190343868764 1.81795633928278e-06 0.1113890351962442 1.817956435131205e-06 0.110562946039519 \
1.817956516069412e-06 0.1098685209805978 1.817956604452683e-06 0.1091134439098378 1.817956703052661e-06 0.108274944429282 1.817956775836865e-06 0.1076586405352824 \
1.817956865109775e-06 0.1069058608836731 1.817956927091788e-06 0.1063852406583179 1.817956989684955e-06 0.1058613310701875 1.817957074907104e-06 0.105150777260444 \
1.817957180369478e-06 0.1042758147594986 1.817957260199961e-06 0.1036167065755082 1.817957340914214e-06 0.1029530974056021 1.817957423527949e-06 0.1022768941101355 \
1.817957493972562e-06 0.1017026162492672 1.817957597231928e-06 0.1008648142128753 1.817957670072053e-06 0.1002767039768694 1.817957755712335e-06 0.09958839426015198 \
1.817957874514072e-06 0.09863954321822334 1.817957942151898e-06 0.09810250133474645 1.81795801190202e-06 0.09755100310752296 1.817958089237e-06 0.09694230106952094 \
1.817958181657254e-06 0.09621870517595056 1.817958253354782e-06 0.09566033062548993 1.817958339171942e-06 0.09499542738017568 1.817958441597192e-06 0.09420660575030523 \
1.817958534892083e-06 0.09349264652734962 1.817958631208556e-06 0.09276005482712441 1.817958708110817e-06 0.09217843893134048 1.817958801590805e-06 0.09147541043939374 \
1.817958880833232e-06 0.09088281005358793 1.817958995455426e-06 0.0900310686188453 1.817959125063686e-06 0.08907580221142102 1.817959258320876e-06 0.08810234090122065 \
1.817959402350766e-06 0.08705990691030199 1.817959559518909e-06 0.08593388720602639 1.817959709295387e-06 0.08487214151476249 1.817959871762978e-06 0.08373303262435308 \
1.817960014942984e-06 0.08273971668837025 1.817960167622107e-06 0.0816913199659166 1.817960301891878e-06 0.08077856892457436 1.817960443644155e-06 0.07982444400446118 \
1.817960578643816e-06 0.07892500874648442 1.817960720601213e-06 0.07798882638923543 1.817960867448644e-06 0.07703088995320664 1.817961019894053e-06 0.07604750978240994 \
1.817961185112776e-06 0.07499422991502351 1.817961349250621e-06 0.07396067809208305 1.817961526112024e-06 0.07286119333145537 1.81796171645358e-06 0.07169407515132428 \
1.817961927410093e-06 0.07042030845332216 1.817962147819231e-06 0.0691121699798517 1.817962383344393e-06 0.06773900533435212 1.817962643793767e-06 0.0662496528900723 \
1.817962939459177e-06 0.06459579389282195 1.817963244581463e-06 0.06292902455725519 1.817963609576024e-06 0.06098725515092194 1.817964004456839e-06 0.05894944116461652 \
1.817964410847493e-06 0.05692211719668253 1.817964826573035e-06 0.05491854459141238 1.817965189379358e-06 0.0532251207245777 1.817965533980648e-06 0.05166301626031383 \
1.81796584916051e-06 0.05027284652491828 1.817966144689875e-06 0.04900240867073854 1.817966442670382e-06 0.04775344010203557 1.817966718469172e-06 0.04662857640242725 \
1.817966997243768e-06 0.04551884372531381 1.817967261178638e-06 0.04449205559535935 1.817967537201376e-06 0.04344260531795661 1.81796781615763e-06 0.04240676967887352 \
1.817968129850963e-06 0.04127097799875453 1.81796836585125e-06 0.04043636567030678 1.817968621645987e-06 0.03955075129286261 1.817968881769487e-06 0.03867033103466553 \
1.817969151904759e-06 0.03778142289416799 1.817969431124747e-06 0.03688501536902895 1.817969712963396e-06 0.03600226561751176 1.817969989839066e-06 0.03515600409566183 \
1.817970268932665e-06 0.03432349610146775 1.817970501810272e-06 0.03364444121149882 1.817970785646989e-06 0.03283527291840588 1.817971025751923e-06 0.03216626441466421 \
1.817971265550746e-06 0.0315119836023277 1.81797150482792e-06 0.03087436846876356 1.817971740084942e-06 0.03026290129608995 1.817971971011964e-06 0.02967475842909434 \
1.817972186001007e-06 0.02913788335257221 1.817972588155459e-06 0.02816043724496065 1.817972786878278e-06 0.02768988489927659 1.817973160561294e-06 0.0268265706552881 \
1.817973347359617e-06 0.02640514011949098 1.817973694919304e-06 0.02563810810034544 1.817973816848767e-06 0.0253740445387235 1.817974199320207e-06 0.02456430406701914 \
1.817974370028237e-06 0.02421180751242828 1.817974827125621e-06 0.02328894863848502 1.817975012758007e-06 0.0229225623309489 1.81797537621526e-06 0.02221803970155307 \
1.817975596582612e-06 0.02179832126591805 1.817976054308969e-06 0.02093867417890744 1.817976189728599e-06 0.02068687731869814 1.817976719624047e-06 0.01972418011126781 \
1.817976838945017e-06 0.01951377505543128 1.817977404730696e-06 0.01856069823426573 1.817977569110437e-06 0.0182962226476828 1.817978187655734e-06 0.01735107502432094 \
1.817978357709933e-06 0.01710418363667701 1.817978889842166e-06 0.01636278834442301 1.817979086926142e-06 0.01610013864443424 1.817979810045215e-06 0.01517806887136661 \
1.817979974675381e-06 0.01497647803580381 1.817980723800768e-06 0.01409711804523418 1.81798085710012e-06 0.01394643716836554 1.817981717353759e-06 0.01301449210748497 \
1.817981852457379e-06 0.01287422877142914 1.81798279503482e-06 0.01193816285908547 1.817982958630574e-06 0.01178202925388569 1.817983959987201e-06 0.0108653384673985 \
1.817984097529988e-06 0.01074500730514941 1.817985319636371e-06 0.009765086624518643 1.817985426589084e-06 0.00968516078425012 1.817986830780577e-06 0.008707372520026449 \
1.817986935611284e-06 0.008639312158696611 1.817988470448246e-06 0.00767719340797631 1.817988565731547e-06 0.007617466071856052 1.817990174528868e-06 0.006680264535635283 \
1.817990308605608e-06 0.006609506832171614 1.817992405618559e-06 0.005610918814474722 1.817992636163191e-06 0.005510783990371394 1.817994959158435e-06 0.004586584533412417 \
1.817995440488638e-06 0.004413562233393853 1.817998278050269e-06 0.003511943147855551 1.817998822969955e-06 0.003360532104877318 1.818002947178351e-06 0.002408309874554541 \
1.818003490902011e-06 0.002305347543005144 1.818009362191237e-06 0.001333291345955189 1.818009605056421e-06 0.001286469439319215 1.818023932948772e-06 0.0002880570268237783 \
1.818024077507414e-06 0.0002853642807229123 1.820661356428513e-06 -0.0006859155495331031 1.82066149598365e-06 -0.000901903561740745 1.820662005077582e-06 -0.001859438188174024 \
1.820662094565085e-06 -0.002052812934985279 1.820662457959945e-06 -0.00291126965001638 1.820662548982015e-06 -0.003143482006111167 1.820662914420052e-06 -0.004127275145644371 \
1.820663024680619e-06 -0.004436819103926468 1.820663336727774e-06 -0.005309594399865315 1.820663439442621e-06 -0.005584800160857357 1.820663803290477e-06 -0.006384516484886619 \
1.820663968081208e-06 -0.006586298968823262 1.820664547677408e-06 -0.005791490933239759 1.820664722787551e-06 -0.004914057272375438 1.820664839479485e-06 -0.004132845175365214 \
1.82066496606409e-06 -0.003100877896798674 1.820665067873013e-06 -0.002132773363901063 1.820665188361723e-06 -0.0008283127610571584 1.820665278808799e-06 0.0002599396317828252 \
1.82066537669893e-06 0.001541559978017447 1.820665475763239e-06 0.002943971508909197 1.820665646570516e-06 0.005594911825788154 1.820665868338539e-06 0.00944046646559993 \
1.820666064242384e-06 0.01317281463966807 1.820666223123766e-06 0.01639870563256729 1.820666387552263e-06 0.01989779506365397 1.820666541918293e-06 0.02331070396473752 \
1.820666700690818e-06 0.02693200463312963 1.820666847428777e-06 0.03036422445567413 1.820666996052748e-06 0.0339113704936035 1.820667151667245e-06 0.03768995713197771 \
1.820667308909259e-06 0.04156499463828727 1.820667473802057e-06 0.04567927910670353 1.820667647221578e-06 0.05005184210758699 1.820667825915293e-06 0.05459761989277153 \
1.820668014531131e-06 0.05943075613080645 1.820668215431273e-06 0.06460909294799391 1.820668434888064e-06 0.0702927970720964 1.820668664434351e-06 0.07626037976612585 \
1.820668910133291e-06 0.08266408948881369 1.82066917869823e-06 0.08967663153997742 1.820669470040144e-06 0.09728936802005522 1.820669791708172e-06 0.1056939239977524 \
1.820670152022263e-06 0.1150987971742611 1.820670543001701e-06 0.1252892839303718 1.820670986416517e-06 0.1368209045172546 1.820671502729604e-06 0.1502062239570841 \
1.820672108934821e-06 0.16586000516691 1.820672780191848e-06 0.1831102247110778 1.820673559691505e-06 0.20301830483439 1.820674432001388e-06 0.2251413938832897 \
1.820675262336713e-06 0.2460320778586349 1.820675993667063e-06 0.264292249712138 1.820676641612843e-06 0.280346965484095 1.820677224923317e-06 0.29469740877147 \
1.820677760655584e-06 0.3077798509628869 1.820678263914169e-06 0.3199778888071559 1.82067874911767e-06 0.3316516836183861 1.820679228040375e-06 0.3430829066939081 \
1.820679674471008e-06 0.3536501814456421 1.820680148800718e-06 0.3647819492304352 1.820680597991712e-06 0.3752331958288908 1.820681088463969e-06 0.3865396207984229 \
1.820681617036722e-06 0.3985997842463301 1.820681988181062e-06 0.4069920784971888 1.820682515935418e-06 0.4188173133762567 1.820682978292178e-06 0.4290642331729484 \
1.820683450624318e-06 0.4394285229343968 1.820683932409041e-06 0.4498981261869666 1.820683965448159e-06 0.4506126593745911 1.820684003207152e-06 0.45142837879914 \
1.820684078725137e-06 0.4530572051633331 1.820684229761107e-06 0.4563088938659436 1.820684437280373e-06 0.460764549126051 1.820684625319184e-06 0.4647825567212808 \
1.820684844328398e-06 0.469441659996985 1.820685087159409e-06 0.4745824626509371 1.820685386935037e-06 0.4808894567257585 1.820685624728187e-06 0.4858624696070272 \
1.820685887949588e-06 0.4913374535260851 1.820686148847132e-06 0.4967277906005185 1.82068637840122e-06 0.5014431429135263 1.820686601461413e-06 0.506003872007333 \
1.820686803037404e-06 0.5100983586086808 1.820686951867463e-06 0.51310967141356 1.820687196178516e-06 0.5180317772556589 1.820687328783749e-06 0.5206893064287169 \
1.820687468140331e-06 0.5234717264876519 1.820687679105724e-06 0.5276623644271943 1.820687853979606e-06 0.5311266030493931 1.820688122027852e-06 0.5364094032095129 \
1.82068831705351e-06 0.5402319029111832 1.820688496615017e-06 0.5437361368949839 1.820688747571146e-06 0.5486228351952749 1.820689024979257e-06 0.5540035987981641 \
1.820689308928559e-06 0.5594901708581531 1.82068956456585e-06 0.5644152233389156 1.820689855548069e-06 0.570006772487656 1.820690115853754e-06 0.5749917787111524 \
1.820690384297874e-06 0.5801232573974072 1.820690627063004e-06 0.5847450403362237 1.820690883594205e-06 0.5896146675871002 1.820691109757648e-06 0.59388771440121 \
1.820691347099143e-06 0.5983512154742827 1.82069155648786e-06 0.6022720321566808 1.820691770260628e-06 0.6062574570422776 1.820692023713469e-06 0.6109557890491497 \
1.820692226567816e-06 0.6146943332140289 1.820692419372338e-06 0.6182333111593361 1.820692609677365e-06 0.6217090173923294 1.820692800335854e-06 0.6251694921350958 \
1.82069300291378e-06 0.6288260100903066 1.820693265662542e-06 0.6335359534764116 1.820693494630232e-06 0.6376100987349322 1.820693714577867e-06 0.6414991146358265 \
1.82069394026254e-06 0.6454625140719233 1.820694149149966e-06 0.6491091855837361 1.820694370803585e-06 0.652957810138281 1.82069455569301e-06 0.6561429680377227 \
1.820694745707564e-06 0.6594017273991298 1.820694895862686e-06 0.6619630641908443 1.820695070740593e-06 0.6649292185271485 1.820695216461309e-06 0.6673855496832628 \
1.820695352493841e-06 0.6696641287411549 1.820695500856121e-06 0.672138295335571 1.820695630303833e-06 0.6742883907026684 1.820695764169531e-06 0.6764996355878535 \
1.82069589251393e-06 0.6786115243545502 1.820696017902058e-06 0.6806677490053815 1.820696147367755e-06 0.6827843190971332 1.82069627834897e-06 0.6849171426143115 \
1.820696426722072e-06 0.6873221141612875 1.820696534784827e-06 0.6890667486235877 1.820696663316499e-06 0.6911333958680312 1.820696798756283e-06 0.6933004139195943 \
1.820696923690607e-06 0.6952876996714908 1.820697049447875e-06 0.6972799977491608 1.820697155963766e-06 0.6989584331773744 1.820697273081655e-06 0.7007929859467624 \
1.820697391621401e-06 0.7026383448210159 1.820697514924797e-06 0.704545102273978 1.820697618097696e-06 0.7061304255463237 1.820697769068859e-06 0.7084341141567283 \
1.820697885323065e-06 0.7101955266062138 1.820698015883454e-06 0.7121605601685687 1.820698134445982e-06 0.7139335830373704 1.820698240519852e-06 0.7155108922888329 \
1.820698340544791e-06 0.716990346352101 1.820698477870006e-06 0.719009255813789 1.820698596531362e-06 0.7207429633399333 1.820698718230586e-06 0.7225107522614664 \
1.820698843413151e-06 0.7243181860083944 1.820698965432965e-06 0.7260693242762759 1.820699093464718e-06 0.7278954552757622 1.820699217946458e-06 0.7296603419865877 \
1.820699346245781e-06 0.7314685590147565 1.820699473339584e-06 0.7332489547570846 1.820699599364423e-06 0.7350034830462163 1.82069970210311e-06 0.7364262918236342 \
1.820699816775855e-06 0.7380063527755659 1.820699898181918e-06 0.7391232259175492 1.820700017381438e-06 0.7407496908814458 1.820700110023778e-06 0.7420059782745783 \
1.820700248182835e-06 0.7438668850244906 1.820700379238334e-06 0.7456179978167152 1.820700509370502e-06 0.7473439783685625 1.820700614344577e-06 0.7487266533969134 \
1.820700753484419e-06 0.7505456565005918 1.820700907428719e-06 0.7525407731682957 1.820701029372999e-06 0.7541080835708853 1.820701176919359e-06 0.7559892974429111 \
1.820701298924537e-06 0.7575320275232224 1.820701447624466e-06 0.7593968175435225 1.820701581671092e-06 0.7610632318338031 1.820701703924347e-06 0.7625711443351471 \
1.820701816790257e-06 0.763953046884334 1.820701959641224e-06 0.7656882893306027 1.820702086364119e-06 0.7672149413549471 1.820702202168994e-06 0.7685995877768005 \
1.820702331910823e-06 0.7701390587657672 1.82070244764921e-06 0.7715019052061673 1.820702570601637e-06 0.7729391548276606 1.820702688317297e-06 0.7743051053122872 \
1.820702794287273e-06 0.7755262985206828 1.820702910698467e-06 0.7768586864857919 1.8207030173164e-06 0.7780703956921795 1.82070312951512e-06 0.7793369495935717 \
1.820703216183689e-06 0.7803089322889447 1.820703319569181e-06 0.7814603789665585 1.820703432733432e-06 0.7827108149434853 1.820703538380715e-06 0.783868819044773 \
1.820703647720273e-06 0.7850578567336689 1.820703754897288e-06 0.786214126597127 1.820703884303365e-06 0.7875981444497275 1.82070399672075e-06 0.7887899291890393 \
1.82070412010849e-06 0.7900869036018625 1.820704237558825e-06 0.7913106402786101 1.820704381085744e-06 0.7927918312347375 1.820704496005322e-06 0.7939667362870242 \
1.820704634727735e-06 0.7953719780830618 1.820704772759875e-06 0.7967562205547866 1.820704882253029e-06 0.7978444364842524 1.820704983271459e-06 0.7988406866985471 \
1.82070508435942e-06 0.7998302780396641 1.820705216746616e-06 0.8011146558616069 1.820705335472037e-06 0.8022550163876687 1.820705457256542e-06 0.8034134048507504 \
1.820705576346336e-06 0.8045351524060473 1.820705697550853e-06 0.8056657048884367 1.820705829194664e-06 0.8068811249615274 1.820705952212703e-06 0.8080052413861453 \
1.820706079823023e-06 0.8091594649786741 1.820706210891683e-06 0.8103325925767672 1.820706334212046e-06 0.8114249716726942 1.82070644213631e-06 0.8123719892944993 \
1.820706549931703e-06 0.8133095350680949 1.820706631652631e-06 0.8140147772069938 1.820706748520247e-06 0.815015186305849 1.820706839581256e-06 0.8157880755829442 \
1.820706973749887e-06 0.8169164295805346 1.82070711832076e-06 0.8181184617099191 1.820707251823126e-06 0.8192158725965917 1.820707361789037e-06 0.8201107352847025 \
1.820707505654697e-06 0.8212684563313245 1.820707658960262e-06 0.8224861772268215 1.820707786698555e-06 0.8234883060891934 1.820707927340891e-06 0.8245786478120171 \
1.820708053124455e-06 0.8255423809867173 1.820708207742427e-06 0.8267124309768116 1.820708340154193e-06 0.8277017767197102 1.820708466433798e-06 0.8286345641820314 \
1.820708584064113e-06 0.8294941055817234 1.820708732230976e-06 0.8305638349826423 1.820708899375221e-06 0.8317531470681401 1.820709031993881e-06 0.832683775428688 \
1.820709204938569e-06 0.8338803479528284 1.820709373325224e-06 0.8350269493631071 1.820709542859754e-06 0.8361634673386688 1.820709724228909e-06 0.8373596561587384 \
1.820709866861491e-06 0.8382862741713709 1.820709980797339e-06 0.8390176620397163 1.820710111571134e-06 0.8398476357987267 1.820710213225074e-06 0.8404856735008092 \
1.820710329718802e-06 0.8412091703399448 1.820710465236349e-06 0.8420405885319162 1.820710662580143e-06 0.8432318270427018 1.820710853245141e-06 0.8443612543037786 \
1.82071106310198e-06 0.8455804035625291 1.820711244039104e-06 0.8466117334714958 1.820711441374591e-06 0.8477160230260256 1.820711615161427e-06 0.8486711109012058 \
1.820711797742881e-06 0.8496572451898022 1.820711969062461e-06 0.850566499179887 1.820712143447507e-06 0.8514760798656241 1.820712318831052e-06 0.8523748177975867 \
1.820712495063209e-06 0.8532619682996843 1.820712684901452e-06 0.8542000584728613 1.820712875637665e-06 0.8551245802328369 1.820713077434399e-06 0.856083442102113 \
1.820713270127775e-06 0.8569809170305027 1.820713479756076e-06 0.857937542729613 1.82071370919384e-06 0.8589615588718806 1.82071397499048e-06 0.8601183337444025 \
1.820714273565707e-06 0.8613802063570262 1.820714551467221e-06 0.8625196921548358 1.820714835677695e-06 0.8636511027355716 1.820715110089482e-06 0.8647118800460076 \
1.820715382252364e-06 0.8657341977214618 1.820715652421455e-06 0.8667205537246333 1.820715909616139e-06 0.8676338760342862 1.82071618215581e-06 0.868575115807136 \
1.820716458190291e-06 0.8695013130444248 1.820716728342986e-06 0.8703818891200001 1.820717028049787e-06 0.8713292845176382 1.820717398867258e-06 0.8724597217497643 \
1.820717693785921e-06 0.8733269024855727 1.820717948030199e-06 0.8740525764960509 1.820718246254198e-06 0.8748787854419284 1.820718519878969e-06 0.8756137195941651 \
1.820718756017958e-06 0.8762307200963571 1.820718996373686e-06 0.8768427579093606 1.820719218719338e-06 0.8773949085683344 1.820719412723072e-06 0.877865919014753 \
1.820719742447196e-06 0.878644045115768 1.820719897619855e-06 0.8790007149587372 1.820720215373248e-06 0.879712598742095 1.820720394238605e-06 0.8801026384247937 \
1.820720736700093e-06 0.8808283583858193 1.820720920841292e-06 0.8812073588304842 1.820721395746114e-06 0.8821499412898334 1.820721563140601e-06 0.8824705695712217 \
1.820722028971889e-06 0.8833323038036038 1.820722209796771e-06 0.8836551183393088 1.820722703830028e-06 0.8845051821644966 1.820722845172603e-06 0.8847400410050358 \
1.820723451563118e-06 0.8857071861637142 1.820723603635685e-06 0.8859397703602404 1.820724250313758e-06 0.8868873789663725 1.820724378610246e-06 0.8870678433440622 \
1.820725026723245e-06 0.8879435266410994 1.820725156528523e-06 0.8881118897635528 1.820725934785608e-06 0.8890711781604964 1.820726049780422e-06 0.8892053868933587 \
1.820726905511062e-06 0.8901454611437621 1.820727050777629e-06 0.8902951528450479 1.820728036533732e-06 0.8912364417375994 1.820728257640946e-06 0.8914302300078862 \
1.820729402752027e-06 0.892358484239638 1.820729533960174e-06 0.8924604119362172 1.820730875263369e-06 0.8934531785430913 1.82073102665103e-06 0.8935579568409697 \
1.820732508109867e-06 0.8944876667405802 1.820732746990229e-06 0.894621531696939 1.820734516461986e-06 0.8954958910368339 1.820734905568823e-06 0.8956641700186337 \
1.820737299334232e-06 0.8965498195158238 1.820737774894223e-06 0.8966991754584082 1.820741837950387e-06 0.8976977719002629 1.820742329424408e-06 0.8977905759376156 \
1.820750645951487e-06 0.8987839664765119 1.820751565805377e-06 0.8988472044554419 1.820877770945903e-06 0.8998441026240215 1.820878784754255e-06 0.8998514601858095 \
1.821070497347411e-06 0.8990059056521554 1.821070727348974e-06 0.8988405173838494 1.821072342221535e-06 0.8978439928078279 1.821072519935388e-06 0.8977495532019018 \
1.821089285710428e-06 0.8987316330193963 1.821089421698825e-06 0.8987497732072308 1.821104884427938e-06 0.8997471920221268 1.82110515229253e-06 0.8997526389354535 \
1.821588977619798e-06 0.9006560548284696 1.821589098408998e-06 0.9007687033315858 1.821589886180037e-06 0.9017381658104292 1.821590020318756e-06 0.901943163319478 \
1.82159051393353e-06 0.9027850367016239 1.821590658833145e-06 0.9030569221572713 1.82159105464053e-06 0.9038490360455199 1.821591174436184e-06 0.9041001886668685 \
1.821591558609717e-06 0.9049189780371781 1.821591670731365e-06 0.9051556495331843 1.821592178052335e-06 0.9061253139956988 1.821592272051191e-06 0.90626859229291 \
1.821593430700898e-06 0.9055667778886739 1.821593533663832e-06 0.9051589876696525 1.8215936175067e-06 0.9047707260375384 1.821593751246752e-06 0.9040404158978201 \
1.821593851964133e-06 0.9033957423200318 1.821593959579919e-06 0.9026166239542108 1.821594077153173e-06 0.9016533104038295 1.821594165418223e-06 0.90085556431878 \
1.821594285051691e-06 0.8996698288011099 1.821594382373389e-06 0.8986166602050341 1.821594493390827e-06 0.8973222354192386 1.821594595500415e-06 0.8960407982554908 \
1.821594678931815e-06 0.8949326975987755 1.821594783112882e-06 0.8934749428758865 1.821594874199646e-06 0.8921321265381427 1.821594966740432e-06 0.8907058396397178 \
1.82159506189443e-06 0.8891776325191247 1.821595176449407e-06 0.88725933118288 1.821595265292509e-06 0.8857137884271823 1.82159536353169e-06 0.8839502506198179 \
1.821595448901864e-06 0.8823735982707064 1.821595529802107e-06 0.8808434949738935 1.821595602763399e-06 0.8794355441897157 1.821595669782045e-06 0.8781198554636557 \
1.821595738393124e-06 0.8767515715160701 1.821595821888036e-06 0.8750591081124355 1.821595884015366e-06 0.8737811510706814 1.821595946997964e-06 0.8724704924326797 \
1.821596042153715e-06 0.8704632161180945 1.821596142764353e-06 0.8683077530860182 1.821596222643544e-06 0.8665738309361769 1.821596306905814e-06 0.8647250601592834 \
1.821596386016074e-06 0.8629723295901451 1.821596448831519e-06 0.8615696597604833 1.821596536288553e-06 0.8596016864744445 1.821596602182084e-06 0.8581079708060287 \
1.821596670243626e-06 0.856556281928966 1.821596719556134e-06 0.8554267461646872 1.821596774792923e-06 0.85415654045335 1.821596815532529e-06 0.8532164928603474 \
1.821596861834283e-06 0.8521450198670055 1.821596892048343e-06 0.8514441160591502 1.821596921089625e-06 0.8507691938976955 1.82159695172822e-06 0.8500558939662993 \
1.821597013005409e-06 0.8486254874746039 1.821597066077972e-06 0.8473828229799116 1.821597119733165e-06 0.8461232012188223 1.821597182390447e-06 0.8446482873934593 \
1.821597245673395e-06 0.8431545995644786 1.821597336171269e-06 0.8410121009440262 1.821597433169049e-06 0.8387078554355326 1.82159751614655e-06 0.8367307351423475 \
1.821597598150905e-06 0.8347721678896715 1.821597687219306e-06 0.8326403548070889 1.821597771732643e-06 0.8306135893189693 1.821597862591523e-06 0.8284303722590877 \
1.821597954526378e-06 0.8262176456275642 1.821598056957308e-06 0.8237486178045141 1.82159815707534e-06 0.8213320995840899 1.821598271896223e-06 0.8185572053828121 \
1.82159838410276e-06 0.8158423448209959 1.821598509096305e-06 0.8128151787794674 1.821598640356713e-06 0.8096337870015397 1.821598785627755e-06 0.8061104108175116 \
1.821598940135368e-06 0.8023613213197434 1.821599111575989e-06 0.7981999722344618 1.821599275625781e-06 0.794217661721315 1.821599460041203e-06 0.7897413884478564 \
1.821599666533577e-06 0.7847307375046715 1.82159985602742e-06 0.7801344622909899 1.821600049421182e-06 0.775444374634302 1.821600249988037e-06 0.7705834242206392 \
1.821600397552439e-06 0.7670092004965298 1.821600527563889e-06 0.7638619034739171 1.821600662428303e-06 0.7605987503374771 1.821600768918754e-06 0.7580234999254772 \
1.821600900608547e-06 0.7548403390839162 1.821601007032976e-06 0.7522693550468039 1.821601150211605e-06 0.7488125398635642 1.821601311338716e-06 0.7449250928176189 \
1.821601429565533e-06 0.7420746008290786 1.821601599798354e-06 0.7379721584775248 1.821601765724623e-06 0.7339761998059781 1.821601985266954e-06 0.7286940862104242 \
1.821602178454078e-06 0.724050920820232 1.821602353368041e-06 0.719851304223293 1.821602520315139e-06 0.7158476177432674 1.8216027078061e-06 0.711355754450834 \
1.821602895234537e-06 0.7068709122373377 1.821603063571096e-06 0.7028473835914892 1.82160325640163e-06 0.6982428782038785 1.821603396451377e-06 0.694901318858167 \
1.821603552708666e-06 0.6911769338170629 1.821603746878113e-06 0.6865540563080536 1.821603905984601e-06 0.6827702245679255 1.821604064344632e-06 0.679008548037742 \
1.82160425966174e-06 0.6743756772263459 1.821604470090519e-06 0.6693917663527935 1.821604722792664e-06 0.6634173774538097 1.821604902460615e-06 0.6591769455535931 \
1.821605154037489e-06 0.6532475027332399 1.821605354410306e-06 0.6485340174553987 1.821605526064158e-06 0.6445032789616798 1.821605684756275e-06 0.6407814961122935 \
1.821605823964202e-06 0.637522316374186 1.821605960288252e-06 0.6343349641335875 1.821606087501276e-06 0.6313646237382058 1.821606216993833e-06 0.6283457899522861 \
1.821606344985121e-06 0.6253646753452949 1.82160647605963e-06 0.6223174651643489 1.821606606771705e-06 0.6192830747181834 1.821606749379757e-06 0.6159760732208495 \
1.821606892103235e-06 0.612672916206165 1.821607044651036e-06 0.6091471600588 1.821607189155024e-06 0.6058158037532523 1.821607353173272e-06 0.6020406322262999 \
1.821607490637933e-06 0.5988837056407329 1.821607625454949e-06 0.5957940466067043 1.821607746953592e-06 0.5930134750293682 1.821607885803896e-06 0.5898448108574432 \
1.821607999450713e-06 0.5872554148224447 1.821608150860885e-06 0.5838116422847746 1.82160826457956e-06 0.5812320812748947 1.821608383992651e-06 0.5785269636915771 \
1.821608472673178e-06 0.5765205397309219 1.821608563818269e-06 0.5744630259469776 1.821608629157144e-06 0.5729901393713442 1.821608693626847e-06 0.5715377831648228 \
1.821608744447459e-06 0.5703933076453638 1.821608803422398e-06 0.569066051987989 1.821608870867106e-06 0.5675516747474645 1.821608937959298e-06 0.5660472084764079 \
1.821608990879742e-06 0.5648615894615425 1.821609086527225e-06 0.5627204246953637 1.821609143708361e-06 0.5614413394337 1.821609197510977e-06 0.5602399192081799 \
1.821609259253082e-06 0.5588634520375642 1.821609345086214e-06 0.5569525037715509 1.821609427781861e-06 0.5551133137453282 1.821609553910589e-06 0.552313430559463 \
1.821609689009664e-06 0.5493247407981657 1.821609787329828e-06 0.5471534914294828 1.82160989990789e-06 0.5446716589975775 1.821610002452305e-06 0.5424173856211837 \
1.821610122561131e-06 0.5397821662853191 1.821610224248782e-06 0.5375541863492928 1.821610339752745e-06 0.5350300289250629 1.821610454643861e-06 0.5325260225312031 \
1.821610581121134e-06 0.5297740207092871 1.821610706338329e-06 0.5270565158317848 1.821610853184312e-06 0.5238798967507053 1.821610988642446e-06 0.5209557060405445 \
1.821611146203054e-06 0.5175672114705414 1.821611308357229e-06 0.5140875588169389 1.821611489068307e-06 0.5102248342695275 1.82161168131606e-06 0.5061308236654174 \
1.821611894038323e-06 0.5016182665703952 1.821612125943484e-06 0.4967183500883584 1.821612383137188e-06 0.4913135654247419 1.821612622690498e-06 0.4863004534671564 \
1.821612924620373e-06 0.4800178499336004 1.821613212386814e-06 0.4740665530855001 1.821613525189057e-06 0.4676409412178996 1.821613845020806e-06 0.4611139840073785 \
1.821614184657409e-06 0.4542292677834274 1.821614511873228e-06 0.4476411633207955 1.821614847034797e-06 0.4409363684817221 1.821615164291457e-06 0.4346351592989786 \
1.821615498111436e-06 0.4280489847791872 1.82161584979678e-06 0.4211625252737479 1.821616163864498e-06 0.4150547397555842 1.821616486893702e-06 0.4088175946446666 \
1.821616927873099e-06 0.4003732788922496 1.821617270275942e-06 0.3938810608698495 1.82161757072383e-06 0.3882325136127223 1.821617946053401e-06 0.3812375944419973 \
1.82161827612863e-06 0.3751439175705365 1.821618559406411e-06 0.3699597784791666 1.821618859913772e-06 0.3645020109013299 1.821619139561233e-06 0.3594637112692664 \
1.821619363423524e-06 0.3554634414471464 1.821619575274513e-06 0.35170280677964 1.821619777623113e-06 0.3481338771034005 1.821619978758139e-06 0.3446120049995081 \
1.821620184535656e-06 0.3410324794262659 1.82162044551437e-06 0.3365252478245505 1.821620685004553e-06 0.3324209773202946 1.821620917679624e-06 0.3284665339262754 \
1.821621131761216e-06 0.3248537323113044 1.821621352906983e-06 0.3211475567840967 1.821621553789873e-06 0.3178053707831449 1.821621757181075e-06 0.3144500223650613 \
1.821621954849488e-06 0.3112139453100684 1.821622141093175e-06 0.3081862077816076 1.821622336074257e-06 0.3050391973134606 1.821622539536502e-06 0.3017803754370622 \
1.821622717477407e-06 0.2989521325826759 1.821622953201112e-06 0.2952356640875101 1.821623151333965e-06 0.2921385263640672 1.821623352678033e-06 0.2890160050544278 \
1.821623576967229e-06 0.2855690750291008 1.821623741897129e-06 0.2830551950838826 1.821623919525814e-06 0.2803657404651576 1.821624103924961e-06 0.2775946687427531 \
1.821624287746306e-06 0.2748547260732712 1.821624466202978e-06 0.2722194282383935 1.821624638103246e-06 0.2696976713509589 1.821624798643653e-06 0.2673699088296289 \
1.821624920125711e-06 0.265617282026588 1.821625073047238e-06 0.2634201198254058 1.821625200480934e-06 0.2616085083773952 1.821625304654605e-06 0.2601317890528609 \
1.821625421559081e-06 0.2584775571399547 1.821625536570573e-06 0.2568557450124987 1.821625660932803e-06 0.2551103168403305 1.821625776507086e-06 0.2534925198640895 \
1.821625910614607e-06 0.2516172680784447 1.821626025601848e-06 0.2500177396912131 1.821626179351445e-06 0.2478798443778067 1.821626316154646e-06 0.2459790966208961 \
1.821626450740453e-06 0.2441094379339017 1.821626606604589e-06 0.2419575875351012 1.821626731253411e-06 0.2402378086535915 1.821626870468935e-06 0.2383186229544463 \
1.82162700069296e-06 0.236525770455347 1.8216271210458e-06 0.2348769158236033 1.821627256439084e-06 0.233027137746051 1.821627407644063e-06 0.2309620730808924 \
1.821627542400533e-06 0.2291249940296414 1.82162764708672e-06 0.2277003186426776 1.821627769622861e-06 0.2260366668203369 1.82162790456742e-06 0.2242086518061946 \
1.821627999683167e-06 0.2229209267876512 1.821628114943222e-06 0.2213657311907907 1.821628197476202e-06 0.2202562617028589 1.821628268681533e-06 0.2192992955643472 \
1.821628317389017e-06 0.2186449771734718 1.821628364583973e-06 0.2180112263680214 1.821628411132791e-06 0.2173864029843717 1.821628464521355e-06 0.2166701476649976 \
1.821628501898025e-06 0.2161690444847812 1.821628539283138e-06 0.2156680710113931 1.821628579604508e-06 0.2151283464800275 1.821628650854647e-06 0.2141753141901174 \
1.821628685068904e-06 0.2137180869447317 1.821628731463534e-06 0.2131018213873352 1.821628791907201e-06 0.2122998083652294 1.82162886091012e-06 0.2113853596849882 \
1.821628926205072e-06 0.210520730631805 1.821628994183195e-06 0.2096212333552783 1.821629110629525e-06 0.2080823984153433 1.821629200551713e-06 0.2068957989735914 \
1.82162930821762e-06 0.2054771097790837 1.821629404278935e-06 0.2042146625011118 1.821629507657509e-06 0.2028641889872041 1.821629604342544e-06 0.2016026287683381 \
1.821629707152396e-06 0.2002625524503448 1.821629807912368e-06 0.1989526210414513 1.821629919058034e-06 0.1975116692735505 1.821630026097528e-06 0.1961279675313261 \
1.821630144004064e-06 0.1946083430154048 1.821630252114387e-06 0.1932197128021231 1.821630361412987e-06 0.1918224631760269 1.821630482044739e-06 0.1902849927564414 \
1.821630576945331e-06 0.1890796997295432 1.82163070550625e-06 0.18745262875399 1.821630798541038e-06 0.1862801166370808 1.821630900937594e-06 0.1849947785893032 \
1.821630988904886e-06 0.1838942174288659 1.821631087175557e-06 0.182668828510528 1.821631183776179e-06 0.1814691026470878 1.821631270414692e-06 0.1803971466393716 \
1.821631356823704e-06 0.1793305247657973 1.821631452660814e-06 0.1781527189679156 1.821631557387688e-06 0.1768710765218302 1.821631703199975e-06 0.1750963017969037 \
1.821631819167907e-06 0.1736923427161618 1.821631975631711e-06 0.1718092975148396 1.82163208681163e-06 0.1704786474822015 1.821632227061631e-06 0.1688098560703619 \
1.821632350073035e-06 0.1673544160765056 1.821632456564033e-06 0.1661007559767333 1.821632552889491e-06 0.1649724583647661 1.821632650322958e-06 0.1638357962207703 \
1.821632754176237e-06 0.1626293386330815 1.82163284597681e-06 0.1615673458739011 1.821632944364525e-06 0.1604337426303964 1.82163302728317e-06 0.1594828374885931 \
1.821633122651503e-06 0.1583950132920943 1.821633205213851e-06 0.1574587876231885 1.821633307798537e-06 0.1563016192679324 1.821633384076854e-06 0.1554454316211293 \
1.821633472662479e-06 0.1544557264474612 1.821633544831984e-06 0.1536532700165102 1.821633626541473e-06 0.1527486200895024 1.821633700220281e-06 0.1519363404455653 \
1.821633780440409e-06 0.1510573496788611 1.821633852168484e-06 0.1502755532525617 1.821633920425463e-06 0.149534520573691 1.821634018141422e-06 0.1484788062294206 \
1.821634087591606e-06 0.147731872792437 1.821634170343085e-06 0.1468455801890639 1.821634230379995e-06 0.1462052652532956 1.821634300618658e-06 0.1454587420502366 \
1.821634372046193e-06 0.1447037411390827 1.821634452559695e-06 0.1438588888651768 1.821634515822599e-06 0.1431977449412327 1.821634593496578e-06 0.1423892845091393 \
1.821634682806343e-06 0.141463758692191 1.821634752169929e-06 0.1407479403162204 1.821634850118149e-06 0.1397418416088305 1.821634940462669e-06 0.1388188591118084 \
1.821635026242994e-06 0.1379520826379384 1.821635093896779e-06 0.1372719511642241 1.821635160204629e-06 0.1366075914250998 1.821635238824321e-06 0.1358227655030745 \
1.82163531951923e-06 0.135020537018139 1.821635377921894e-06 0.1344419857224206 1.821635438674417e-06 0.1338420332148588 1.821635532580729e-06 0.1329184183639811 \
1.821635574978232e-06 0.1325029080242558 1.821635654222426e-06 0.1317336600863391 1.821635694592584e-06 0.1313430593815061 1.821635784293463e-06 0.130477658168832 \
1.82163582324155e-06 0.1301029732927899 1.821635918857236e-06 0.1291862249441596 1.821635957741065e-06 0.1288146335111444 1.821636050975841e-06 0.1279263274670414 \
1.82163611931843e-06 0.1272775968534341 1.821636171639285e-06 0.1267823325594629 1.821636253739999e-06 0.1260075984242486 1.821636324903378e-06 0.1253406747583812 \
1.821636402856366e-06 0.1246136378429537 1.821636481976102e-06 0.1238779526756392 1.821636560619333e-06 0.1231489004754178 1.821636640654241e-06 0.122409328367501 \
1.821636702388658e-06 0.1218405706457005 1.82163677598364e-06 0.1211645344030958 1.821636859363458e-06 0.120401093559758 1.821636923460189e-06 0.1198161795466899 \
1.821636992898777e-06 0.119184869057559 1.821637065921715e-06 0.1185234239195788 1.821637150796627e-06 0.1177582144838446 1.821637230159478e-06 0.117046673033812 \
1.821637314893136e-06 0.1162898833629492 1.821637405604425e-06 0.1154830714735263 1.821637481187503e-06 0.1148135241260771 1.821637546915428e-06 0.1142333070693714 \
1.821637606975201e-06 0.1137047561823949 1.821637676580917e-06 0.1130943456353956 1.821637742999968e-06 0.1125141752866663 1.821637822411231e-06 0.1118230150855203 \
1.821637912674161e-06 0.1110406875128299 1.821637981718461e-06 0.1104447270551955 1.82163805627358e-06 0.1098035355921305 1.821638144757501e-06 0.1090456469739195 \
1.821638223865648e-06 0.1083709350695736 1.821638293734029e-06 0.1077773127978274 1.821638374743399e-06 0.1070920034756896 1.821638430948212e-06 0.106618206733547 \
1.821638493607492e-06 0.1060916009495399 1.821638558754098e-06 0.105545887371837 1.821638630089726e-06 0.1049504956797945 1.821638750386101e-06 0.1039516085561449 \
1.821638801939673e-06 0.103525508500865 1.821638857088741e-06 0.1030709598036589 1.821638947785925e-06 0.1023262935955709 1.821639030175778e-06 0.1016530765296615 \
1.821639125755585e-06 0.1008759670630478 1.821639232965152e-06 0.1000092507657299 1.821639336624558e-06 0.09917656019160864 1.821639422832161e-06 0.09848810438956324 \
1.821639509074386e-06 0.09780303991321163 1.82163958861546e-06 0.09717448010577609 1.821639668628333e-06 0.09654538840876434 1.821639759916661e-06 0.09583163072761708 \
1.821639841662079e-06 0.09519620281310773 1.821639930588917e-06 0.09450872319168514 1.821640020366224e-06 0.09381864801001834 1.821640097328872e-06 0.09323024625953365 \
1.821640187653689e-06 0.0925435244861572 1.821640251462415e-06 0.09206084550525626 1.821640323925982e-06 0.09151514907748673 1.821640388054635e-06 0.09103438864950099 \
1.821640466302011e-06 0.09045054736970405 1.821640566003292e-06 0.08971110930136832 1.821640640056443e-06 0.08916512281998501 1.821640726664978e-06 0.08852997392441805 \
1.821640872964685e-06 0.08746544055362569 1.821640983676948e-06 0.08666684197409438 1.821641093986626e-06 0.08587717033461532 1.821641236182269e-06 0.08486839672072237 \
1.82164137623472e-06 0.08388450488753585 1.821641518880534e-06 0.08289222299161547 1.821641667651249e-06 0.08186778387581196 1.821641804363935e-06 0.08093569403044946 \
1.821641946484565e-06 0.07997640434545976 1.821642081061545e-06 0.07907728405019222 1.821642221281423e-06 0.07814997945867638 1.821642369028229e-06 0.07718353387841098 \
1.821642518982415e-06 0.07621348085094087 1.821642683698247e-06 0.07516037195605636 1.821642847284363e-06 0.07412732798506308 1.821643021932716e-06 0.07303837372665309 \
1.821643208986408e-06 0.07188781219077654 1.821643418972926e-06 0.0706159374129187 1.821643637046174e-06 0.06931715807027321 1.821643870366327e-06 0.06795188046253516 \
1.821644124845881e-06 0.0664909822812602 1.82164441780254e-06 0.06484528303377844 1.821644719953089e-06 0.06318745987130532 1.821645057674791e-06 0.06138078634948794 \
1.821645452783393e-06 0.05932807220464856 1.821645820234636e-06 0.05747953410674719 1.821646237842402e-06 0.05544691527644593 1.821646582838376e-06 0.0538196438399016 \
1.821646933380665e-06 0.05221302159193914 1.821647248341029e-06 0.0508087490907442 1.821647547582395e-06 0.049508488261462 1.821647846948247e-06 0.04824029756235761 \
1.821648122190958e-06 0.04710512226277328 1.821648405654524e-06 0.04596497870754415 1.821648667254946e-06 0.04493681260994405 1.821648944707071e-06 0.04387103439794762 \
1.821649220766506e-06 0.04283531238677037 1.821649529036243e-06 0.04170718945545093 1.821649751468863e-06 0.0409114719535993 1.821650039009947e-06 0.03990505631995635 \
1.821650275242879e-06 0.0390969788355163 1.821650593704555e-06 0.03803800466874574 1.821650844115589e-06 0.03722710566490722 1.821651167100391e-06 0.03620720400565681 \
1.821651425436406e-06 0.03541203096995557 1.821651715410284e-06 0.03454066075983582 1.821651945205102e-06 0.0338658635512188 1.821652230100443e-06 0.03304787219836024 \
1.821652469846563e-06 0.03237513696606491 1.821652710481132e-06 0.03171392889024889 1.821652949599619e-06 0.03107212555077287 1.82165318553853e-06 0.03045460689686571 \
1.821653416367391e-06 0.02986254663395104 1.821653631393918e-06 0.02932175456294728 1.82165403355976e-06 0.0283374222946415 1.82165423211788e-06 0.02786401170979088 \
1.821654605819066e-06 0.02699470773596776 1.821654792632261e-06 0.02657042318767052 1.821655138633508e-06 0.02580176906824739 1.821655260576946e-06 0.02553595448027303 \
1.821655643429963e-06 0.02472011952872977 1.821655803864149e-06 0.02438657631284594 1.821656246865303e-06 0.02348572425118655 1.821656417479344e-06 0.02314627247835563 \
1.82165673805594e-06 0.02251902970747987 1.821656938340868e-06 0.0221336684630111 1.821657385278801e-06 0.02128811173678137 1.821657513222916e-06 0.02104854104185888 \
1.821658001100276e-06 0.02014826272243131 1.821658136077553e-06 0.01990454278080647 1.821658618329071e-06 0.0190640092473091 1.821658780655186e-06 0.01879235028057063 \
1.821659267049527e-06 0.01801148170254873 1.821659430077186e-06 0.01776103207540622 1.821660110298876e-06 0.01676849304257711 1.821660249382614e-06 0.01657541006259178 \
1.821660981877148e-06 0.01560782569993242 1.82166114077078e-06 0.01540693214221847 1.821661923851867e-06 0.01445869962397344 1.821662069644422e-06 0.01428952172302696 \
1.821662920425781e-06 0.01334248985256295 1.821663031529053e-06 0.01322388191882306 1.821663964823416e-06 0.0122699293983148 1.821664098661466e-06 0.01213902814618388 \
1.821665057199482e-06 0.01123495036716388 1.821665178316551e-06 0.01112486091825863 1.821666300400348e-06 0.01017270671243764 1.821666405901602e-06 0.01008921053061839 \
1.821667734976014e-06 0.009112307258623473 1.821667855180288e-06 0.009029744095492466 1.821669403542048e-06 0.008036808760534916 1.821669484329818e-06 0.007986285493236449 \
1.821671055209352e-06 0.007024564730313319 1.821671122625551e-06 0.006986095570813155 1.821673043392229e-06 0.006001386377072119 1.821673230194113e-06 0.005914747648762168 \
1.82167554560806e-06 0.0049318160947762 1.821675945134908e-06 0.004777795182599986 1.821678508944408e-06 0.003889929704329555 1.821679007815328e-06 0.003736330440833864 \
1.821682637539317e-06 0.002784984367379526 1.821683188233292e-06 0.002663729254427667 1.821688586673671e-06 0.001711392372544448 1.821688899941243e-06 0.001662511220227468 \
1.821693892233791e-06 0.0006970413096974805 1.821694076252826e-06 0.0006571176749162138 1.824342555395609e-06 -0.0002691198397987355 1.824342711454572e-06 -0.0004551674219448388 \
1.824343259438427e-06 -0.001322174727784445 1.82434337237642e-06 -0.001539785040943742 1.82434380163135e-06 -0.002474302920374066 1.824343907888515e-06 -0.002730173903076456 \
1.824344190690666e-06 -0.003454402452283872 1.82434430428521e-06 -0.003760966378165151 1.824344642839789e-06 -0.004705104513819927 1.82434475526375e-06 -0.005021586953003071 \
1.82434508354165e-06 -0.005887841248467669 1.824345191080172e-06 -0.006130875888161453 1.824346071006203e-06 -0.005789627805322099 1.82434624621225e-06 -0.004910736584223327 \
1.824346363043013e-06 -0.004127745010746014 1.824346489910137e-06 -0.00309221842859156 1.824346591442863e-06 -0.002125750314016509 1.824346712864133e-06 -0.0008095618968406578 \
1.824346803029046e-06 0.0002767910803854594 1.824346900212695e-06 0.001550247908954045 1.82434699828696e-06 0.002938803805678211 1.824347165508045e-06 0.005530627736217106 \
1.824347387813323e-06 0.009378371294171852 1.824347573551714e-06 0.01290572951649239 1.824347797633049e-06 0.01747895571448658 1.824347957277782e-06 0.02091945933227325 \
1.824348121767111e-06 0.02459614091902196 1.824348271591569e-06 0.0280452875125503 1.824348420991461e-06 0.03156498790849799 1.824348570522767e-06 0.03515592969144176 \
1.824348724602661e-06 0.03891669635189081 1.824348886786809e-06 0.0429309674228065 1.824349053210035e-06 0.0470989728378523 1.824349229143508e-06 0.05154884981278444 \
1.824349410271779e-06 0.05616867911875007 1.824349602402704e-06 0.06110225049351239 1.824349810098117e-06 0.0664648391313285 1.824350032018198e-06 0.07222051812179281 \
1.82435026721968e-06 0.07834079218654426 1.824350519405989e-06 0.08491829088081257 1.824350795545224e-06 0.09213111703448683 1.824351096666701e-06 0.1000001933597138 \
1.824351428586562e-06 0.1086702418150647 1.82435180590533e-06 0.1185147411083515 1.824352204195386e-06 0.1288888856248832 1.824352673503706e-06 0.1410822143415975 \
1.824353219529231e-06 0.1552200475789812 1.824353854489538e-06 0.1715918832733369 1.824354553890129e-06 0.1895291194622146 1.824355372129055e-06 0.2103807608661494 \
1.824356277823022e-06 0.2332840710921665 1.824357067334088e-06 0.253091928008631 1.824357771092905e-06 0.2706124241987875 1.824358388943719e-06 0.2858796548825839 \
1.824358954567131e-06 0.2997575097153312 1.824359476302405e-06 0.3124620269501652 1.824359974086121e-06 0.3244932238414255 1.824360457724081e-06 0.3360954048923613 \
1.824360914598215e-06 0.3469667650518959 1.824361387439109e-06 0.3581213589834248 1.824361827052466e-06 0.3684065070151987 1.824362314929562e-06 0.379719432411247 \
1.824362845729984e-06 0.3919028193132517 1.824363343625359e-06 0.4032143644097119 1.824363775002613e-06 0.41292177789323 1.824364261889801e-06 0.4237731225600331 \
1.824364761989243e-06 0.4348012155672935 1.824365106609934e-06 0.4423321287141763 1.824365460003777e-06 0.4500000647748709 1.824365887773617e-06 0.4592134948422093 \
1.824366279634688e-06 0.4675816212925634 1.824366579929044e-06 0.4739471552041949 1.824366921860125e-06 0.4811428413521782 1.82436726519457e-06 0.4883132334011818 \
1.824367525955058e-06 0.4937215836208605 1.824367768011587e-06 0.4987106167174703 1.824368034010055e-06 0.5041617362307154 1.824368293498239e-06 0.5094435946950286 \
1.82436848341454e-06 0.5132872703533161 1.824368698649141e-06 0.5176241792560061 1.8243688371999e-06 0.5204025546691405 1.824368982080679e-06 0.5232962183003332 \
1.824369195494746e-06 0.5275364624051522 1.82436939751936e-06 0.5315382148201082 1.824369590248024e-06 0.5353370730264509 1.824369775503404e-06 0.5389735557287745 \
1.824369952500928e-06 0.5424323215059959 1.824370261764263e-06 0.5484573594957171 1.82437052291231e-06 0.5535233414883098 1.82437082473148e-06 0.5593562770234363 \
1.824371080160122e-06 0.5642781701956761 1.824371372515619e-06 0.5698968483756405 1.824371631969813e-06 0.5748654731717864 1.82437190208979e-06 0.5800301911327002 \
1.824372144100348e-06 0.5846380733684551 1.824372401610146e-06 0.5895273573494454 1.824372628054483e-06 0.5938057549890672 1.824372864942965e-06 0.5982619499065401 \
1.824373074987873e-06 0.6021962733001386 1.824373287918585e-06 0.6061670177072124 1.824373541397282e-06 0.6108668889270118 1.824373744692931e-06 0.6146150465592417 \
1.824373936381114e-06 0.6181346807088086 1.824374125007478e-06 0.6215812235468744 1.824374312325416e-06 0.6249823889551316 1.824374517937406e-06 0.6286953279350977 \
1.824374767760625e-06 0.6331759959753138 1.824374971572403e-06 0.6368063379741715 1.824375179211121e-06 0.6404826298163093 1.824375371862737e-06 0.6438748386876914 \
1.82437561647481e-06 0.6481531432733096 1.824375864373313e-06 0.6524620620600715 1.824376044208219e-06 0.6555644139995785 1.824376234982255e-06 0.6588391718544121 \
1.824376388158437e-06 0.6614554104590837 1.824376559827147e-06 0.6643705886591137 1.824376710293968e-06 0.6669108747194671 1.824376846897971e-06 0.6692010654183506 \
1.824376996338372e-06 0.6716954191563786 1.824377124072523e-06 0.6738189269502312 1.82437726394477e-06 0.6761323074508511 1.824377388021905e-06 0.6781756764962316 \
1.82437751938327e-06 0.6803315871556701 1.824377643554731e-06 0.6823627547057004 1.824377781331592e-06 0.6846081866267727 1.824377901575812e-06 0.6865586181592046 \
1.824378043628417e-06 0.6888545186016138 1.824378143856122e-06 0.6904668682779994 1.824378265160113e-06 0.6924123325129877 1.824378356135388e-06 0.6938641504265992 \
1.824378453518671e-06 0.695411869780077 1.824378550601538e-06 0.6969507228893711 1.824378639884158e-06 0.6983595753378042 1.824378737855943e-06 0.699898781449533 \
1.82437886813103e-06 0.7019319515314388 1.824379021543255e-06 0.7043083163565919 1.824379157109067e-06 0.7063909659299702 1.824379301449562e-06 0.708591461371511 \
1.824379427320445e-06 0.710496752775434 1.824379552347831e-06 0.712376488910674 1.824379666630191e-06 0.7140841686551523 1.824379777613335e-06 0.7157331888171029 \
1.824379877308404e-06 0.7172065512867005 1.824380014352622e-06 0.7192196995505324 1.824380133379834e-06 0.7209572005600779 1.824380253677943e-06 0.7227029412191364 \
1.824380380176863e-06 0.7245276185835638 1.824380504108467e-06 0.7263044524160376 1.8243806283948e-06 0.7280754330070212 1.824380754759953e-06 0.7298652243312684 \
1.824380884571694e-06 0.7316925631262517 1.824381008410214e-06 0.7334254795816325 1.8243811411911e-06 0.735272086289578 1.824381242042306e-06 0.7366670415914529 \
1.824381355233975e-06 0.738224777043618 1.824381442019956e-06 0.7394137384482823 1.824381558645253e-06 0.7410021813026957 1.82438164793451e-06 0.7422110784210975 \
1.824381759111394e-06 0.7437075443329063 1.824381888370157e-06 0.7454347509364776 1.824382002229194e-06 0.7469455276109591 1.824382106633406e-06 0.74832188588007 \
1.824382231000437e-06 0.7499498655229884 1.824382378240616e-06 0.7518616907275563 1.824382498520907e-06 0.753411006437983 1.824382614425446e-06 0.7548933175676444 \
1.82438275450129e-06 0.7566706674475765 1.82438289711296e-06 0.7584645678799224 1.824383015067203e-06 0.7599365027959469 1.824383141883712e-06 0.7615071445339606 \
1.824383282766856e-06 0.7632375905494565 1.824383402560354e-06 0.7646969139886852 1.82438354751921e-06 0.7664484133613445 1.824383669077996e-06 0.7679052725436226 \
1.82438378811749e-06 0.7693214142140735 1.824383909748853e-06 0.7707575700077021 1.824384037717831e-06 0.772256936813787 1.824384146933014e-06 0.7735272422640712 \
1.824384271823892e-06 0.774969549136603 1.824384378939953e-06 0.7761978171588899 1.824384512193147e-06 0.7777146071439789 1.824384639296593e-06 0.7791497354387434 \
1.824384761047568e-06 0.7805132846941326 1.824384877632151e-06 0.7818078758210534 1.824384983459753e-06 0.7829735233300771 1.824385122825895e-06 0.7844949153190801 \
1.824385271897694e-06 0.786105286864636 1.824385419626362e-06 0.7876841235632186 1.824385538932239e-06 0.7889471147195867 1.824385672939052e-06 0.7903527806482344 \
1.824385793365227e-06 0.791604423795974 1.824385934910404e-06 0.7930616786923709 1.824386082336416e-06 0.7945638089648995 1.824386206810925e-06 0.7958198087139573 \
1.824386325854918e-06 0.7970105506108808 1.824386437445201e-06 0.7981174590942314 1.82438654267449e-06 0.7991530841216606 1.824386638185594e-06 0.8000862307887144 \
1.824386774247547e-06 0.8014036057482816 1.824386891123681e-06 0.8025237700417888 1.824387010277353e-06 0.8036549841722296 1.824387132589548e-06 0.8048050501807249 \
1.824387255861622e-06 0.8059526272620129 1.824387382358398e-06 0.8071184350969989 1.824387507861062e-06 0.8082633544790385 1.824387638586967e-06 0.8094437311890262 \
1.824387764154939e-06 0.8105658358439867 1.824387893209803e-06 0.8117072367686948 1.82438799906596e-06 0.8126345588578442 1.824388100234836e-06 0.8135133322873783 \
1.824388194854656e-06 0.8143286754242188 1.82438831913574e-06 0.8153900871385379 1.824388408847426e-06 0.816149614585347 1.82438850788495e-06 0.8169816577628611 \
1.824388645662827e-06 0.8181280288377792 1.824388780198677e-06 0.81923501721715 1.824388888604944e-06 0.8201180631035904 1.824389038518447e-06 0.8213254631869725 \
1.824389189097025e-06 0.8225223201378843 1.82438931459218e-06 0.8235077122548546 1.824389458438707e-06 0.8246238332260477 1.82438958302197e-06 0.8255790649890803 \
1.824389731875191e-06 0.8267066458678887 1.824389868023775e-06 0.827725029289517 1.824389993047602e-06 0.8286494160599757 1.824390110754582e-06 0.8295103773055483 \
1.82439025639358e-06 0.8305630309532103 1.824390422774875e-06 0.8317484146982921 1.824390553358564e-06 0.8326660250626342 1.824390726880675e-06 0.8338683097812621 \
1.824390895002577e-06 0.8350147136930499 1.82439106486518e-06 0.8361549927788252 1.824391245766883e-06 0.8373497079260466 1.824391388876165e-06 0.8382806519784776 \
1.824391502965127e-06 0.839013953006387 1.824391633127603e-06 0.8398410866028793 1.824391734972734e-06 0.8404811280669765 1.82439185179894e-06 0.8412075886390841 \
1.82439198869038e-06 0.8420483852080155 1.824392186497604e-06 0.843243620449199 1.82439237812275e-06 0.8443797466267589 1.824392587554618e-06 0.8455974227529048 \
1.8243927695013e-06 0.8466352798309468 1.824392966630154e-06 0.8477391449715804 1.824393139971014e-06 0.8486924050423899 1.824393322979321e-06 0.8496814535024207 \
1.824393494142355e-06 0.8505903669473519 1.82439366877945e-06 0.851501688465695 1.824393844039281e-06 0.8524001683007644 1.82439402018973e-06 0.8532872510191711 \
1.824394210470029e-06 0.8542278331088334 1.82439440106916e-06 0.8551519386507073 1.824394601692395e-06 0.8561055033533737 1.82439479430095e-06 0.8570028516027762 \
1.824395004981641e-06 0.8579644845832216 1.824395233083109e-06 0.8589827023971403 1.824395498871091e-06 0.860139640227508 1.824395797483852e-06 0.8614018215255795 \
1.824396073772491e-06 0.8625348754565382 1.82439635800901e-06 0.8636666213345715 1.82439663221378e-06 0.8647267940813509 1.824396904448638e-06 0.8657495569722869 \
1.82439717465278e-06 0.8667361702337206 1.82439743180839e-06 0.867649441901348 1.824397704388604e-06 0.8685908808535525 1.82439798037489e-06 0.8695169452638583 \
1.824398250477721e-06 0.870397355937691 1.824398550334798e-06 0.8713451925332844 1.824398921362456e-06 0.8724761722512941 1.824399216299766e-06 0.8733433185969293 \
1.824399470589206e-06 0.8740690226522811 1.824399768845991e-06 0.874895168896023 1.824400042455427e-06 0.8756299040683481 1.824400278583914e-06 0.8762466977562872 \
1.824400518929827e-06 0.8768585021646264 1.824400741263492e-06 0.8774104263690854 1.824400935269169e-06 0.8778812671168952 1.824401264991885e-06 0.8786590883967833 \
1.824401420165319e-06 0.8790156160651978 1.824401737941389e-06 0.8797272612331356 1.824401916803032e-06 0.8801171459162566 1.824402259264861e-06 0.8808425821290963 \
1.82440244339302e-06 0.881221400612852 1.824402918270754e-06 0.8821634994206867 1.824403085666965e-06 0.8824839765989225 1.824403551508905e-06 0.8833452998114757 \
1.824403732330957e-06 0.8836679564577563 1.824404226369383e-06 0.8845176198113115 1.824404367718007e-06 0.8847523712107549 1.824404974052073e-06 0.8857188576377059 \
1.824405126121396e-06 0.8859512996759633 1.824405772809558e-06 0.8868983431897121 1.82440590110417e-06 0.8870786909355212 1.824406549221232e-06 0.8879538337624689 \
1.824406679020295e-06 0.8881220828502663 1.824407457223772e-06 0.8890807033877333 1.824407572278734e-06 0.8892148977954012 1.824408427940206e-06 0.8901543051721961 \
1.824408573301076e-06 0.8903040038307473 1.824409559057127e-06 0.8912446482480114 1.824409780162496e-06 0.8914382978987679 1.824410925289423e-06 0.8923659558950503 \
1.824411056506439e-06 0.8924678262926897 1.824412397715013e-06 0.8934599079028542 1.824412549114272e-06 0.8935646301988298 1.824414030551995e-06 0.8944937559627255 \
1.824414269431373e-06 0.8946275407274444 1.824416038746979e-06 0.8955013787854181 1.824416427898191e-06 0.8956696032899972 1.824418821561142e-06 0.8965547188539188 \
1.82441929727014e-06 0.8967039926079825 1.82442336043021e-06 0.8977020505850396 1.824423851854269e-06 0.8977948037134476 1.824432168453822e-06 0.898787348739254 \
1.82443308835295e-06 0.8988506593152591 1.82457657358348e-06 0.8998476076348748 1.824577692016456e-06 0.8998537475785264 1.824782783635956e-06 0.898985773748599 \
1.824783010725457e-06 0.8988224379910277 1.824784620332255e-06 0.8978282360369357 1.824784797740799e-06 0.8977338482811539 1.824801704889099e-06 0.8987315468430059 \
1.824801814328198e-06 0.8987460089186867 1.824817595049444e-06 0.8997418097871094 1.824817891375339e-06 0.8997476966799167 1.825301325027745e-06 0.9007060148833608 \
1.825301454078085e-06 0.9008313386292994 1.82530210422793e-06 0.9016292186224167 1.825302293723661e-06 0.9019133038041363 1.82530279694564e-06 0.9027675859898705 \
1.825302932418299e-06 0.9030208676018907 1.825303332877016e-06 0.9038195223753869 1.825303464814953e-06 0.9040958310886574 1.825303866030016e-06 0.9049509627747726 \
1.825303964290194e-06 0.9051582028152527 1.825304430164004e-06 0.9060587574877488 1.825304591662727e-06 0.9063060456044927 1.82530573567525e-06 0.9055153668657776 \
1.825305880654596e-06 0.9049059606760256 1.825306059207353e-06 0.9039396653125833 1.825306239402631e-06 0.9027054491383806 1.82530638209356e-06 0.9015369228101149 \
1.825306499253164e-06 0.9004524619440171 1.825306588234525e-06 0.8995505656965809 1.825306679878178e-06 0.8985529714258781 1.82530681299011e-06 0.8969831049011855 \
1.825306906711193e-06 0.8957895978311226 1.825306997850002e-06 0.8945634483845346 1.825307111142313e-06 0.8929516940777753 1.825307214251226e-06 0.8913998138690341 \
1.825307310518406e-06 0.8898830246517148 1.825307429655523e-06 0.8879200664089764 1.825307598240771e-06 0.8849885378698126 1.825307760012273e-06 0.8820195265790133 \
1.825307953231332e-06 0.8782956415026882 1.825308138794443e-06 0.8745571577041361 1.825308349060748e-06 0.8701566079887386 1.825308531309788e-06 0.8662213066841463 \
1.825308716173183e-06 0.8621339172744639 1.82530888885833e-06 0.8582419637438897 1.825309074966403e-06 0.8539816046497358 1.825309252782491e-06 0.849858603441091 \
1.825309433499072e-06 0.8456251963850057 1.825309598637331e-06 0.8417258760277182 1.825309763911433e-06 0.837798995916667 1.825309927159096e-06 0.8339004324287677 \
1.825310085749369e-06 0.8300982805770993 1.825310262673771e-06 0.8258418712800655 1.825310459187584e-06 0.8211009660847696 1.825310626744125e-06 0.8170498602679914 \
1.825310793484544e-06 0.8130123908857781 1.825310967908061e-06 0.8087844286215062 1.825311137277684e-06 0.8046757316210446 1.825311305476778e-06 0.8005936994537799 \
1.825311494325046e-06 0.7960093488074458 1.825311685140882e-06 0.7913773844868103 1.825311893523092e-06 0.7863203192056716 1.825312119942597e-06 0.7808277108969495 \
1.825312309142794e-06 0.7762391340290878 1.825312519289483e-06 0.7711455503222944 1.825312668057987e-06 0.7675418410361046 1.825312799050976e-06 0.7643705172588006 \
1.825312936616212e-06 0.7610417440783073 1.825313042367441e-06 0.7584842184275663 1.825313177141075e-06 0.7552262509102785 1.8253132889738e-06 0.7525244432456109 \
1.825313418408964e-06 0.7493992292091655 1.825313573597688e-06 0.7456545577979357 1.82531368523344e-06 0.7429626190147979 1.825313844808055e-06 0.7391166470929011 \
1.825314020129688e-06 0.7348935218456193 1.825314232505151e-06 0.7297828120356423 1.825314425387679e-06 0.7251458607116523 1.825314582088971e-06 0.7213823872711312 \
1.825314768763662e-06 0.716903961299824 1.825314957650011e-06 0.7123775767926828 1.825315148534203e-06 0.70780884692282 1.825315335282138e-06 0.7033444557767304 \
1.825315518366954e-06 0.698972331957095 1.825315655685935e-06 0.6956951921588121 1.825315808928892e-06 0.6920418367118417 1.825316004057543e-06 0.6873949992893974 \
1.825316161351872e-06 0.6836535194673684 1.825316320746467e-06 0.6798660670227984 1.82531651649026e-06 0.6752219404489795 1.825316708689394e-06 0.6706682621108646 \
1.825316943641022e-06 0.6651105611269369 1.82531713111727e-06 0.6606839627962382 1.825317368354404e-06 0.6550894036851447 1.825317557534366e-06 0.6506361170423679 \
1.825317738150178e-06 0.6463915264929231 1.825317901844741e-06 0.6425504277539856 1.82531804639615e-06 0.6391628119244788 1.82531818686792e-06 0.6358764726647652 \
1.825318313968707e-06 0.6329064225879303 1.825318446276183e-06 0.6298198307262635 1.825318572863229e-06 0.626870110582017 1.825318703443497e-06 0.62383130535404 \
1.825318832712896e-06 0.6208285625908692 1.825318971819793e-06 0.6176004736356133 1.825319120330103e-06 0.6141606483517721 1.825319309878658e-06 0.6097777958748198 \
1.825319455581914e-06 0.6064170107178907 1.825319690632478e-06 0.601007464699683 1.825319873631749e-06 0.5968099615921 1.825320097973422e-06 0.5916778694808832 \
1.825320269146671e-06 0.5877753019413697 1.825320401480491e-06 0.5847634284691802 1.82532053327703e-06 0.5817721407249107 1.825320639820933e-06 0.5793579518205488 \
1.825320735711292e-06 0.5771868999037388 1.825320828211542e-06 0.5750974572268882 1.825320920638905e-06 0.5730134868920421 1.825320993067211e-06 0.5713818265150021 \
1.825321048796317e-06 0.5701269325864891 1.825321109905404e-06 0.5687522410723198 1.82532120667008e-06 0.5665806864277688 1.825321268161594e-06 0.5652027770813386 \
1.825321327214216e-06 0.5638802801505602 1.825321402840882e-06 0.5621878686488651 1.82532146986366e-06 0.5606896577364279 1.825321543460769e-06 0.5590483558003441 \
1.825321611066772e-06 0.5575429304381756 1.825321727135829e-06 0.5549610936632026 1.825321827342234e-06 0.5527359403974305 1.825321939349424e-06 0.5502565947066531 \
1.825322033841475e-06 0.5481686943853854 1.825322154996172e-06 0.5454955387196141 1.825322255183939e-06 0.5432910220514219 1.825322371174451e-06 0.5407443765731218 \
1.825322478878288e-06 0.5383833065966291 1.825322588456977e-06 0.5359861028148916 1.82532270057842e-06 0.5335400310751951 1.825322827515604e-06 0.5307765704644959 \
1.825322949665123e-06 0.5281221248815906 1.825323089426038e-06 0.525095489155881 1.825323226564154e-06 0.522132778766487 1.825323376529244e-06 0.5189020692106626 \
1.825323535302247e-06 0.5154923220538846 1.825323709327904e-06 0.511765695450105 1.825323896158028e-06 0.5077823379664483 1.825324101125993e-06 0.5034264211640872 \
1.825324323834942e-06 0.4987133299464507 1.825324576739139e-06 0.4933874474923696 1.825324811693046e-06 0.4884604410272814 1.825325107961308e-06 0.4822828691822955 \
1.825325397751266e-06 0.4762763831984252 1.825325704087085e-06 0.4699660956099861 1.825326016405612e-06 0.4635767846525711 1.825326354971068e-06 0.4566963260653934 \
1.825326678082485e-06 0.4501741115777416 1.825327016477788e-06 0.4433881855507311 1.825327340309053e-06 0.4369378830387565 1.825327664703474e-06 0.4305204627449936 \
1.82532800763776e-06 0.4237851826852676 1.825328346918578e-06 0.4171698123421442 1.825328686393212e-06 0.4105997181257849 1.825329129505058e-06 0.4020958655332711 \
1.825329491573227e-06 0.3952155038183801 1.825329812124964e-06 0.3891775711374149 1.825330199059534e-06 0.3819561902961204 1.825330526929795e-06 0.3758957719299574 \
1.825330812088851e-06 0.3706704968427373 1.825331130457646e-06 0.3648820026298218 1.825331413288573e-06 0.3597820188690578 1.825331641977337e-06 0.3556924369094372 \
1.825331859870141e-06 0.3518226517641353 1.825332055119486e-06 0.3483769517668343 1.825332262027586e-06 0.344751588202948 1.825332476824342e-06 0.3410137651016431 \
1.825332729050892e-06 0.3366564674340092 1.825332971046205e-06 0.3325077909124976 1.825333201898484e-06 0.3285822460490526 1.825333416746675e-06 0.3249550452085373 \
1.825333637103364e-06 0.3212604562488142 1.825333838674264e-06 0.3179050685021769 1.82533404175821e-06 0.3145531374773136 1.825334239655597e-06 0.3113121771742085 \
1.825334426754836e-06 0.3082694484595072 1.825334620655179e-06 0.3051385396431291 1.825334825703514e-06 0.3018527636900292 1.825335005938266e-06 0.2989872106339772 \
1.825335241836277e-06 0.2952669081535775 1.825335443123827e-06 0.2921198200609627 1.825335644514631e-06 0.2889965001417216 1.825335869163794e-06 0.2855437159941698 \
1.825336034543768e-06 0.2830223598911593 1.825336212348105e-06 0.280330186126118 1.825336396004319e-06 0.277570343839212 1.825336581246076e-06 0.2748090658167894 \
1.825336759391454e-06 0.2721781298892599 1.825336932983517e-06 0.2696316866093095 1.82533709334837e-06 0.267306655456324 1.825337214459552e-06 0.2655585721882695 \
1.82533736765434e-06 0.2633570345323199 1.825337494985789e-06 0.2615475749425888 1.825337598313628e-06 0.2600830587034867 1.825337715638424e-06 0.2584225376281647 \
1.825337833445381e-06 0.2567591557214636 1.825337957409147e-06 0.2550199666844239 1.825338074393314e-06 0.2533821414201824 1.825338205189442e-06 0.2515535495016885 \
1.825338322399552e-06 0.2499173892700276 1.825338475652676e-06 0.2477853623028658 1.825338611183197e-06 0.2459029165157107 1.825338742864406e-06 0.244074199323236 \
1.825338899457317e-06 0.2419017673596028 1.825339024653875e-06 0.2401755227310949 1.825339160371501e-06 0.2383060149301216 1.825339292798663e-06 0.2364844144139329 \
1.825339412772324e-06 0.2348355337769661 1.825339575820161e-06 0.232606585912384 1.825339714627252e-06 0.230713852557009 1.825339853100972e-06 0.2288300961780371 \
1.825339958645721e-06 0.2273962817971701 1.825340087007401e-06 0.2256537837490921 1.825340191135024e-06 0.2242444877898851 1.825340291651026e-06 0.222886569499566 \
1.825340366695402e-06 0.2218745444235658 1.825340444028457e-06 0.2208349692306942 1.825340518791637e-06 0.2198305887827458 1.825340596755314e-06 0.218785487158918 \
1.825340651621824e-06 0.2180503923904892 1.8253407081186e-06 0.2172938400168352 1.825340751572119e-06 0.2167123195211523 1.825340791613165e-06 0.2161767335077376 \
1.825340830852113e-06 0.2156521099473339 1.82534087172635e-06 0.2151058606261434 1.82534092587884e-06 0.2143825797409383 1.825340964295971e-06 0.2138698309421548 \
1.825341003584678e-06 0.2133480458229882 1.825341065121386e-06 0.2125332203444249 1.825341127098915e-06 0.2117131287842428 1.825341183575664e-06 0.2109664019951111 \
1.825341248207254e-06 0.2101124842966758 1.825341343715876e-06 0.2088522205996687 1.825341431031607e-06 0.207701294711168 1.825341527641208e-06 0.2064291756790013 \
1.825341624870762e-06 0.2051510266126755 1.825341725717823e-06 0.2038307158897115 1.825341826317594e-06 0.2025192706911573 1.825341922808891e-06 0.2012627769767186 \
