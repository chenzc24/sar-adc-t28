1.114311038134269e-06 0.09592640631053104 1.114311118922622e-06 0.09530159220710262 1.114311218473493e-06 0.09453592511176086 1.114311308421543e-06 0.09384821103094763 \
1.114311380924943e-06 0.09329669945188329 1.114311462667009e-06 0.09267796846073476 1.114311590787244e-06 0.09171467366828615 1.114311672199308e-06 0.09110674702409056 \
1.114311746631215e-06 0.09055373306570065 1.114311821605099e-06 0.08999936228352182 1.114311901024075e-06 0.08941505746347288 1.114312009684932e-06 0.08862052380504259 \
1.114312104044903e-06 0.08793517800096999 1.114312193440026e-06 0.08728987318634121 1.114312300205743e-06 0.086524181682867 1.114312418708183e-06 0.08568073755029131 \
1.114312560233253e-06 0.08468224831562859 1.114312693371676e-06 0.08375174214918565 1.114312834217007e-06 0.08277682112810406 1.114312983268988e-06 0.08175525972387458 \
1.114313119066718e-06 0.08083369778093191 1.114313260523232e-06 0.0798830809748103 1.114313395783147e-06 0.07898330517332906 1.114313537164988e-06 0.07805242629322809 \
1.114313684232761e-06 0.07709434677344783 1.114313835960902e-06 0.07611680364043326 1.114314001309203e-06 0.07506403321855706 1.114314165176721e-06 0.07403332863189842 \
1.114314341490649e-06 0.07293832728335037 1.114314530925751e-06 0.07177777688466977 1.114314741692455e-06 0.07050569389938771 1.114314961464952e-06 0.06920150027616521 \
1.114315196433104e-06 0.06783224552442871 1.114315455333654e-06 0.06635227408830123 1.114315750264117e-06 0.06470266364809808 1.114316054610178e-06 0.06304001691994518 \
1.114316416556457e-06 0.06111393619706453 1.114316732684212e-06 0.05947639552636011 1.114317174006677e-06 0.0572596911373907 1.11431748757272e-06 0.05573556853365672 \
1.114317911072189e-06 0.0537382660685313 1.114318255024043e-06 0.05216649213267931 1.11431859526531e-06 0.05065508790922631 1.1143189061029e-06 0.04931137323461653 \
1.114319200574802e-06 0.04807062469528345 1.114319494274299e-06 0.04686392507224969 1.114319769145536e-06 0.04576537019482012 1.114320044685701e-06 0.04468949010490332 \
1.11432030977623e-06 0.04367785045825667 1.114320586533311e-06 0.04264571401740119 1.114320869801436e-06 0.04161414314527601 1.114321167794735e-06 0.04055545327485047 \
1.114321427280131e-06 0.03965542606183669 1.114321657303569e-06 0.03887446236327848 1.114321876995156e-06 0.03814321686473518 1.114322101935296e-06 0.0374128399305801 \
1.11432242218897e-06 0.0363978329183388 1.11432270998682e-06 0.03550963653148703 1.114322986382154e-06 0.03467738358988744 1.114323270201283e-06 0.03384352473043348 \
1.114323508310586e-06 0.03315996078327022 1.114323792621371e-06 0.03236211345273886 1.114324034533221e-06 0.03169864947531036 1.114324269673394e-06 0.03106710921041438 \
1.114324511380923e-06 0.03043352335444016 1.114324748333857e-06 0.02982731501219571 1.114324978676274e-06 0.02925002048968134 1.114325192426852e-06 0.02872465224286764 \
1.114325398273815e-06 0.02822791768061097 1.114325790610838e-06 0.02730524204782691 1.114325979002849e-06 0.02687312495148303 1.114326354614307e-06 0.02603163971789 \
1.114326529081082e-06 0.02564950258131362 1.114326953015541e-06 0.02474274850847508 1.114327073769958e-06 0.02449086781212801 1.114327544020721e-06 0.02353384026002922 \
1.114327693235786e-06 0.02323677291035493 1.114328086867998e-06 0.02246740853134286 1.114328257894342e-06 0.02213909006726131 1.114328745173274e-06 0.02121869533024997 \
1.114328887220983e-06 0.02095326544309953 1.114329420237252e-06 0.01997576278857772 1.114329542401289e-06 0.01975737097014436 1.114330064559034e-06 0.01885981776906158 \
1.114330235137336e-06 0.01857989792133653 1.114330722450399e-06 0.01781360777737795 1.114330893973323e-06 0.01755501440977742 1.11433151376008e-06 0.01666567753024489 \
1.114331684684406e-06 0.0164316648397145 1.114332390235396e-06 0.01551160061118263 1.114332552852409e-06 0.01530799450170666 1.114333309745899e-06 0.01439879525764199 \
1.114333450662544e-06 0.01423641007536438 1.114334350661384e-06 0.01324361033368418 1.114334438010635e-06 0.01315122959105692 1.114335342363989e-06 0.01223321097894121 \
1.114335479555938e-06 0.01209984223734439 1.114336450212214e-06 0.01118944790767422 1.114336578130092e-06 0.01107451071402888 1.114337728540039e-06 0.01011008206277823 \
1.114337822342075e-06 0.01003687265682024 1.114339078387887e-06 0.009120584045805383 1.114339215929201e-06 0.009026502753623255 1.114340774683602e-06 0.008029670037698805 \
1.114340858486287e-06 0.007977066150721189 1.114342463865106e-06 0.00699828665725172 1.11434257476345e-06 0.006935886594503895 1.114344507009824e-06 0.005959177461785255 \
1.11434468671476e-06 0.005876661013304485 1.114346798505876e-06 0.004981749118765498 1.114347141291012e-06 0.004848482978762325 1.114349654457045e-06 0.003966891390423618 \
1.114350124178715e-06 0.003819799497680527 1.11435376449499e-06 0.002847564273158896 1.114354280232175e-06 0.002731633924241866 1.114359622062014e-06 0.001773027297371861 \
1.114359907382299e-06 0.001729522787584184 1.114365136030129e-06 0.0007540451492352357 1.114365310176696e-06 0.0007162692714263865 1.117013698769002e-06 -0.0001123232525192561 \
1.11701387179429e-06 -0.0002901710972538241 1.117014491546044e-06 -0.001202022686018724 1.117014580115221e-06 -0.001365806793032466 1.117014941086355e-06 -0.002110727959526865 \
1.11701506578065e-06 -0.002395793696299351 1.117015429622531e-06 -0.003299857180474864 1.1170156008982e-06 -0.003758114451912169 1.117015894896038e-06 -0.004576312838821549 \
1.117016005104443e-06 -0.004886880824040592 1.117016283358441e-06 -0.005643955697619643 1.11701640463225e-06 -0.00594200199557267 1.117017498254348e-06 -0.00517389603226481 \
1.117017621358228e-06 -0.004409713243767066 1.117017744826303e-06 -0.003462788751204457 1.1170178649921e-06 -0.002366010162083454 1.117017962853768e-06 -0.001346276287748183 \
1.117018069556104e-06 -0.0001076498664581183 1.117018181397488e-06 0.001328007358939307 1.117018317371855e-06 0.003256083960376262 1.117018439401011e-06 0.00514709866632534 \
1.117018627817289e-06 0.008343062029134115 1.117018768805819e-06 0.01093380316938193 1.117018921577523e-06 0.01391176330477175 1.117019064280151e-06 0.01683596409946878 \
1.117019218632387e-06 0.02013443377634912 1.117019374426043e-06 0.02358734537610087 1.11701953048334e-06 0.02715365164079262 1.11701967788774e-06 0.03060642997674319 \
1.117019826504485e-06 0.03415780069914553 1.117019981925702e-06 0.03793559522944389 1.117020140311532e-06 0.04184227512730877 1.117020305251154e-06 0.04596085539464361 \
1.117020479500423e-06 0.05035714787605008 1.117020658443539e-06 0.05491177248689325 1.117020847583032e-06 0.0597604232635115 1.11702105036361e-06 0.06498910043066243 \
1.117021269735637e-06 0.07067233091134768 1.117021500572133e-06 0.07667464705993039 1.117021747383969e-06 0.0831083675499642 1.11702201751608e-06 0.09016243555275107 \
1.117022310704188e-06 0.0978236474935409 1.117022634359626e-06 0.1062798466079799 1.117022997926912e-06 0.1157689210849182 1.11702339022043e-06 0.1259925151671456 \
1.117023838699915e-06 0.1376538644086695 1.1170243603994e-06 0.1511757390224034 1.117024972772044e-06 0.1669844191341421 1.117025649417359e-06 0.1843663871188266 \
1.11702643632765e-06 0.2044554566749352 1.117027317548744e-06 0.2267919980918504 1.117028137292384e-06 0.2474048556006221 1.117028865745328e-06 0.2655829647002126 \
1.117029507221317e-06 0.2814688958417333 1.117030083144485e-06 0.2956305456066151 1.117030620401302e-06 0.3087428400511723 1.117031124292597e-06 0.3209487846516751 \
1.117031601896145e-06 0.3324328152479784 1.117032080019379e-06 0.343838772307344 1.117032532118228e-06 0.3545331600964184 1.117033003884519e-06 0.365596737404158 \
1.11703344758136e-06 0.3759140547845509 1.117033969549898e-06 0.3879344734281669 1.11703449708783e-06 0.399956933836353 1.117034876602574e-06 0.4085271910771138 \
1.117035405564175e-06 0.4203606102508351 1.117035874883255e-06 0.4307444005277802 1.117036310038791e-06 0.4402814026247405 1.117036757516117e-06 0.4500002273945978 \
1.117037197539592e-06 0.4594737646471725 1.117037600841335e-06 0.4680814138276727 1.117037919241101e-06 0.4748254127722248 1.117038289219015e-06 0.4826007100982719 \
1.117038525472097e-06 0.4875314737878706 1.117038760543493e-06 0.4924129045770672 1.117039011882831e-06 0.4975994385012801 1.117039318269866e-06 0.5038799449729535 \
1.117039575228319e-06 0.5091120301871851 1.117039783702615e-06 0.5133309170973237 1.117039984084905e-06 0.5173683849445317 1.117040126478606e-06 0.5202244049244739 \
1.117040275403072e-06 0.5231993726577677 1.117040486949329e-06 0.5274019882470222 1.117040713006952e-06 0.5318780389403845 1.117040907549333e-06 0.5357103559602913 \
1.117041096681229e-06 0.539423417888626 1.117041326128277e-06 0.5439012399750046 1.117041508634083e-06 0.5474563135343053 1.117041745996952e-06 0.5520623276458133 \
1.11704201499126e-06 0.5572695987004129 1.11704226390171e-06 0.5620706638085723 1.117042507918531e-06 0.5667633705755619 1.117042780273744e-06 0.5719926523718327 \
1.117043041669873e-06 0.5769928369418796 1.117043299301279e-06 0.5819084237686675 1.117043546144628e-06 0.586601202059797 1.117043791890354e-06 0.5912552023551558 \
1.117044018467874e-06 0.5955288021520931 1.117044249620064e-06 0.5998646534936181 1.117044455900444e-06 0.6037202012184053 1.117044684021204e-06 0.6079592993751251 \
1.117044906401185e-06 0.6120725203834017 1.117045133377667e-06 0.6162454422471376 1.117045348430617e-06 0.6201823359462864 1.11704557780019e-06 0.6243500782103125 \
1.117045846823065e-06 0.6292041961704016 1.117046069836712e-06 0.6331993632081415 1.117046282091289e-06 0.6369772451758789 1.117046493488879e-06 0.6407176358819484 \
1.117046693558109e-06 0.644236566349866 1.117046923151958e-06 0.6482486956559365 1.117047163988886e-06 0.6524328529570182 1.117047345738273e-06 0.6555667906748446 \
1.1170475342865e-06 0.6588018260593631 1.117047687366139e-06 0.6614154033769962 1.117047859374421e-06 0.6643352515471471 1.11704800954724e-06 0.6668697017322168 \
1.117048146064529e-06 0.6691578850264722 1.117048295693716e-06 0.6716547631652277 1.117048423434085e-06 0.673777752640997 1.117048563020223e-06 0.6760856948620949 \
1.11704868725891e-06 0.6781310478824312 1.11704881840875e-06 0.6802827752320969 1.117048942850093e-06 0.6823179209931315 1.117049080080916e-06 0.6845542421253382 \
1.117049200329086e-06 0.6865048414796368 1.117049341660529e-06 0.6887891282595083 1.117049441991641e-06 0.6904033553735033 1.117049563109343e-06 0.6923460943304175 \
1.117049653886878e-06 0.6937948943079848 1.117049751145343e-06 0.6953408241330762 1.117049847353224e-06 0.6968660703265798 1.117049935967068e-06 0.6982647859968389 \
1.117050033255091e-06 0.6997938110311075 1.117050165723729e-06 0.7018622871835729 1.117050320913928e-06 0.7042674555997347 1.117050458791879e-06 0.7063866855441746 \
1.117050603646153e-06 0.7085960165693863 1.11705073070791e-06 0.7105202221428537 1.11705085539347e-06 0.7123960184768648 1.117050968098846e-06 0.7140814553427599 \
1.117051079889191e-06 0.7157437310299281 1.11705118066784e-06 0.7172341607972841 1.117051317946295e-06 0.7192525454101454 1.117051437630367e-06 0.7210013704967912 \
1.117051557059838e-06 0.7227365757678518 1.11705168394306e-06 0.7245692610776365 1.117051808360712e-06 0.7263556789600311 1.117051932093537e-06 0.728121726658988 \
1.117052058689063e-06 0.7299181396522603 1.117052189074464e-06 0.7317573312219798 1.117052311884284e-06 0.7334798522758219 1.117052447320059e-06 0.7353678990088863 \
1.117052548609838e-06 0.7367723836293941 1.117052656232334e-06 0.7382576460517265 1.117052745760416e-06 0.7394878879617913 1.117052860308785e-06 0.7410528648863303 \
1.117052948337041e-06 0.7422487366778059 1.117053055415107e-06 0.7436953530868765 1.1170531854801e-06 0.7454403311053276 1.117053296759795e-06 0.7469230742113165 \
1.117053401378355e-06 0.7483084058091373 1.11705352546134e-06 0.7499400420429273 1.117053673762169e-06 0.7518749696944975 1.117053795162033e-06 0.7534462209622173 \
1.11705390960278e-06 0.7549170836379747 1.117054049940098e-06 0.7567069362027918 1.117054191702981e-06 0.7584995177563068 1.117054309503919e-06 0.759977341175643 \
1.117054437480785e-06 0.761570846386187 1.117054579183209e-06 0.7633205808366864 1.117054696694523e-06 0.7647599110190483 1.117054842299792e-06 0.7665289162262866 \
1.117054963994099e-06 0.7679951561698679 1.117055082724709e-06 0.7694149786178283 1.117055205011304e-06 0.7708662727382939 1.11705533205582e-06 0.77236234268503 \
1.117055441699792e-06 0.7736439866494906 1.117055567386705e-06 0.7751025186690397 1.117055673401805e-06 0.776323977486031 1.117055808987772e-06 0.7778743028704433 \
1.117055933950769e-06 0.7792913979962601 1.117056059856921e-06 0.7807070123991936 1.117056175124167e-06 0.7819915514687489 1.11705628142864e-06 0.7831664991275713 \
1.117056419833432e-06 0.7846822315516878 1.117056569129882e-06 0.7862997378875561 1.117056714637327e-06 0.7878588534534761 1.117056834041839e-06 0.7891257303126159 \
1.117056969134663e-06 0.7905455128963393 1.117057090387826e-06 0.7918076974797237 1.117057233381105e-06 0.7932816011184505 1.11705737758541e-06 0.7947523458802197 \
1.117057503122239e-06 0.7960199014141693 1.117057622168612e-06 0.7972110037065316 1.117057734104495e-06 0.7983213107123885 1.117057838976047e-06 0.7993531099923881 \
1.117057934226459e-06 0.8002831901653534 1.117058070569705e-06 0.8016020813281191 1.117058187393835e-06 0.8027203407102198 1.117058306798445e-06 0.803852171037294 \
1.117058428905249e-06 0.8049980820693966 1.11705855186025e-06 0.8061401395390313 1.117058678828951e-06 0.8073073595000361 1.11705880406856e-06 0.8084467645495962 \
1.117058934640955e-06 0.8096220968518901 1.117059060631473e-06 0.8107441738369082 1.117059188817386e-06 0.8118738099374113 1.117059294347114e-06 0.8127947795787664 \
1.117059397218887e-06 0.8136847278655364 1.117059490214057e-06 0.8144826950388273 1.11705961401066e-06 0.8155354283166244 1.117059701978917e-06 0.8162769513478326 \
1.117059800709988e-06 0.8171027376706747 1.117059943975142e-06 0.8182889948057973 1.117060079253827e-06 0.8193962136425846 1.117060188368449e-06 0.8202800249700468 \
1.117060336451758e-06 0.8214657808291811 1.117060486222685e-06 0.8226492530953341 1.117060611457285e-06 0.8236267526687548 1.117060755448703e-06 0.8247372275730155 \
1.117060879504774e-06 0.8256825756473101 1.117061029968032e-06 0.8268152483647575 1.117061165678884e-06 0.8278240064655301 1.117061290697392e-06 0.828742521381556 \
1.117061408452322e-06 0.8295983347934622 1.117061554429135e-06 0.8306466023667578 1.117061720938452e-06 0.8318251482734692 1.117061851861028e-06 0.8327390940956469 \
1.117062025288466e-06 0.8339327615268647 1.117062193435348e-06 0.8350717495747054 1.117062363270277e-06 0.8362042975620877 1.117062544195048e-06 0.8373912937861997 \
1.117062687293307e-06 0.8383160748488641 1.117062801379198e-06 0.8390446117604563 1.117062931553184e-06 0.8398665237782376 1.117063033394266e-06 0.8405024977857931 \
1.117063150213615e-06 0.8412243379523001 1.117063287078045e-06 0.8420597162999857 1.117063484876668e-06 0.8432475311273343 1.11706367648074e-06 0.8443767279905872 \
1.117063885921222e-06 0.8455874169714939 1.117064067846852e-06 0.8466193100105236 1.117064264979957e-06 0.8477171434207121 1.117064438329848e-06 0.8486653666163242 \
1.117064621329232e-06 0.8496493024239481 1.117064792495495e-06 0.8505537352954988 1.117064967127282e-06 0.8514606693963016 1.117065142389669e-06 0.8523550102558151 \
1.117065318541785e-06 0.8532381479010797 1.117065508812824e-06 0.8541746551565574 1.117065699414775e-06 0.85509499218684 1.117065900062401e-06 0.8560449689899254 \
1.117066092672966e-06 0.8569390259424264 1.117066303330652e-06 0.8578972157030333 1.117066531456051e-06 0.8589122247267402 1.117066797213368e-06 0.8600655879592763 \
1.117067095837813e-06 0.8613244245924475 1.117067372169332e-06 0.862454900702886 1.11706765640239e-06 0.8635842083919951 1.117067930614306e-06 0.8646423892283146 \
1.117068202842372e-06 0.8656634505877856 1.117068473051191e-06 0.8666487272755322 1.117068730204067e-06 0.8675609437488442 1.117069002786335e-06 0.868501515423508 \
1.117069278771335e-06 0.8694269133137555 1.117069548872911e-06 0.8703069289141475 1.117069848734863e-06 0.8712546000783432 1.117070219768993e-06 0.8723856543073821 \
1.117070514706754e-06 0.8732530157608677 1.117070768997536e-06 0.8739790309043101 1.117071067254951e-06 0.8748056771600844 1.117071340863485e-06 0.8755409825400007 \
1.11707157699155e-06 0.8761583495732972 1.11707181733693e-06 0.876770807053994 1.117072039670212e-06 0.8773233906735478 1.11707223367596e-06 0.8777948466981503 \
1.117072563398506e-06 0.8785737911727464 1.117072718571944e-06 0.8789308835864816 1.117073036347473e-06 0.8796437246174529 1.11707321520917e-06 0.8800342982281311 \
1.117073557671047e-06 0.8807611334253193 1.117073741799519e-06 0.8811407335605206 1.117074216677856e-06 0.8820849466541889 1.117074384074053e-06 0.8824061830950772 \
1.117074849915456e-06 0.8832696475595492 1.117075030737665e-06 0.8835931319180218 1.117075524775914e-06 0.8844450822729043 1.117075666124327e-06 0.8846804878101884 \
1.117076272457385e-06 0.8856498028150036 1.117076424526725e-06 0.8858829444029697 1.1170770712152e-06 0.8868329272509302 1.117077199509723e-06 0.8870138524519416 \
1.117077847626928e-06 0.8878919388991984 1.117077977425792e-06 0.8880607713689423 1.117078755627481e-06 0.8890227771434612 1.117078870684414e-06 0.8891574578072456 \
1.117079726342848e-06 0.8901003239091128 1.117079871707616e-06 0.8902505899439886 1.11708085746403e-06 0.8911948786459364 1.11708107856904e-06 0.8913892999646706 \
1.117082223696019e-06 0.8923206810037944 1.117082354912619e-06 0.892422953350996 1.117083696124267e-06 0.8934189515818408 1.117083847523211e-06 0.8935240845833778 \
1.117085328961459e-06 0.8944568913393511 1.117085567840892e-06 0.8945912088657246 1.117087337161074e-06 0.8954685138428928 1.11708772631084e-06 0.895637400736999 \
1.117090119976628e-06 0.896526474291006 1.11709059568945e-06 0.8966764365754722 1.117094011699057e-06 0.8975478548673914 1.117094658849072e-06 0.8976786076740833 \
1.117102137013678e-06 0.8986646932675814 1.117102809590796e-06 0.8987192862546014 1.117195253995367e-06 0.8997188196574962 1.117195917228051e-06 0.8997241906476866 \
1.117385126389945e-06 0.900686595210158 1.117385288462789e-06 0.9007292695325627 1.117387933983676e-06 0.8998161167154269 1.117388102533154e-06 0.8996881690130656 \
1.117389379285545e-06 0.8987393243250013 1.117389581451881e-06 0.8986030018074492 1.117391189561267e-06 0.8976721249252815 1.117391381667192e-06 0.8975774045828077 \
1.117406495049839e-06 0.8985726115129884 1.117406683108756e-06 0.8986004060702872 1.117417988037768e-06 0.8995874924221801 1.117418361423516e-06 0.8996034751727418 \
1.117907373786698e-06 0.9005892719715856 1.117907484554898e-06 0.9006868984798269 1.117908237227259e-06 0.9015617873136611 1.117908339021946e-06 0.9017086238768567 \
1.11790887442049e-06 0.9025814930725723 1.117908976929663e-06 0.9027670217776843 1.117909369148482e-06 0.9035254014384071 1.117909509991429e-06 0.9038129158713877 \
1.117909951028881e-06 0.9047472953155866 1.117910136514484e-06 0.9051402477015744 1.117910652827601e-06 0.9061269394579334 1.117910737502694e-06 0.9062564181617988 \
1.117911972174744e-06 0.9053011091537977 1.117912129388156e-06 0.9045688862145235 1.117912321204817e-06 0.9034162411061901 1.117912488045348e-06 0.9021712267446264 \
1.117912635003746e-06 0.9008824031243315 1.117912749119943e-06 0.8997575350477262 1.117912878992032e-06 0.8983446880789033 1.11791299010955e-06 0.8970273815442567 \
1.117913082914029e-06 0.8958483937359277 1.117913171236719e-06 0.8946639786015808 1.117913274417478e-06 0.8932058048613533 1.117913366625413e-06 0.8918333298588224 \
1.11791345419561e-06 0.8904732289418564 1.117913568189077e-06 0.8886245408236838 1.1179137299935e-06 0.8858564722885236 1.117913914992118e-06 0.8825005184224666 \
1.117914107151785e-06 0.8788219124347386 1.117914308599139e-06 0.874780227084481 1.117914515009728e-06 0.8704697801294994 1.117914700181681e-06 0.8664790122147591 \
1.117914884689405e-06 0.862405115500708 1.117915057841296e-06 0.8585071391690239 1.117915242887321e-06 0.8542751393552932 1.117915420261525e-06 0.8501657390392787 \
1.117915597007955e-06 0.8460284987362284 1.117915763166606e-06 0.8421077870518131 1.117915925211044e-06 0.8382599993991456 1.117916091783925e-06 0.8342839555277276 \
1.117916250437662e-06 0.8304816347052207 1.117916441313687e-06 0.8258903812682129 1.117916616297259e-06 0.8216694867670907 1.117916786243393e-06 0.8175615830390965 \
1.117916951419567e-06 0.8135626411663678 1.117917124611674e-06 0.8093650119631921 1.117917295673877e-06 0.8052155696745213 1.117917463774914e-06 0.801136095357175 \
1.117917654109863e-06 0.7965156511928794 1.117917837691806e-06 0.7920591698039 1.117918045682732e-06 0.7870113041480956 1.117918268259242e-06 0.7816114142545842 \
1.117918457674258e-06 0.7770174196885687 1.117918650984654e-06 0.7723312127316435 1.117918794430241e-06 0.7688556734481145 1.117918943853591e-06 0.7652374066097742 \
1.117919063006063e-06 0.7623536300085233 1.117919175722544e-06 0.7596269484184472 1.117919284997451e-06 0.7569846861296079 1.117919421027209e-06 0.753697254849378 \
1.117919533823024e-06 0.750972995067179 1.11791965602098e-06 0.7480232093637929 1.117919767605753e-06 0.7453311011793381 1.117919892312216e-06 0.7423241425761796 \
1.117920046694167e-06 0.7386034578119585 1.117920213478233e-06 0.7345862494782525 1.117920430642921e-06 0.7293605768817599 1.11792062520351e-06 0.7246835946359503 \
1.117920785534395e-06 0.7208333202545074 1.117920960959998e-06 0.7166251500492028 1.117921150723573e-06 0.7120779400724765 1.117921339451897e-06 0.7075610435995559 \
1.117921521273264e-06 0.7032145396962334 1.117921705870676e-06 0.6988062725207448 1.117921842953811e-06 0.6955348514212173 1.117921996242049e-06 0.6918805091472418 \
1.117922191613795e-06 0.6872279990818534 1.117922347770547e-06 0.6835136309588888 1.117922505722766e-06 0.6797605476340507 1.11792270397403e-06 0.6750570282453686 \
1.117922897319928e-06 0.6704763548785364 1.117923133825274e-06 0.6648822204491218 1.117923320030378e-06 0.6604858901039825 1.117923557652698e-06 0.6548824851665868 \
1.117923744451452e-06 0.6504854738275335 1.117923925009211e-06 0.6462424706993735 1.117924088085156e-06 0.6424159959781919 1.117924232696721e-06 0.6390271817202816 \
1.117924373299071e-06 0.6357379642635244 1.117924500108657e-06 0.632774906490579 1.117924632245193e-06 0.6296924762754078 1.117924758489145e-06 0.6267508340255646 \
1.117924889752774e-06 0.6236963630311418 1.117925018850514e-06 0.6206978048938425 1.117925158276179e-06 0.6174624210713571 1.117925306646171e-06 0.6140261568477932 \
1.11792550120306e-06 0.6095278574984737 1.117925644648937e-06 0.6062198040692683 1.117925879109183e-06 0.6008245134060309 1.117926051007495e-06 0.5968818013610552 \
1.117926263928033e-06 0.5920102583789468 1.117926436394651e-06 0.5880775912131976 1.117926566719198e-06 0.5851108450968721 1.117926698275517e-06 0.5821241897920357 \
1.117926808505599e-06 0.5796262478458715 1.117926904159847e-06 0.5774603558442819 1.117927003393806e-06 0.5752182923213994 1.117927086311908e-06 0.5733484809858778 \
1.117927165227534e-06 0.5715706040143225 1.117927228156309e-06 0.5701535626562365 1.117927293664786e-06 0.5686800671140783 1.117927374150839e-06 0.5668736364148982 \
1.117927424016847e-06 0.5657560592102344 1.117927473205615e-06 0.5646541775062763 1.117927534675401e-06 0.5632780399140616 1.117927582596929e-06 0.5622058085646952 \
1.117927633441648e-06 0.5610687758404553 1.117927692541903e-06 0.5597501790023616 1.11792775115623e-06 0.5584442118409422 1.117927826782323e-06 0.5567607189607793 \
1.117927897341035e-06 0.5551915720267918 1.117927986471042e-06 0.5532116467156011 1.11792807569462e-06 0.5512351177508077 1.11792816099823e-06 0.5493490637975145 \
1.117928248625197e-06 0.5474138635528197 1.11792834562712e-06 0.545274424894262 1.117928449972891e-06 0.5429792414815097 1.117928566264315e-06 0.5404269323775457 \
1.117928672601932e-06 0.5380963700835184 1.117928784310815e-06 0.5356536306660374 1.117928896605295e-06 0.5332047801427824 1.117929023802854e-06 0.5304364255197962 \
1.117929146572528e-06 0.5277698476303582 1.117929288796924e-06 0.5246912237717902 1.117929425160057e-06 0.5217463069543907 1.117929577381123e-06 0.5184691491721333 \
1.117929737017329e-06 0.5150420887864461 1.117929912992521e-06 0.5112761258030903 1.117930101501109e-06 0.5072591542828934 1.11793030856769e-06 0.5028616940969075 \
1.117930533509662e-06 0.4981043078903621 1.117930784905619e-06 0.4928144328841237 1.117931021331185e-06 0.4878598554762091 1.117931318494919e-06 0.4816683149127979 \
1.117931609172211e-06 0.4756487143466775 1.117931917027196e-06 0.469313240945046 1.117932230852953e-06 0.4628991126846517 1.117932559994313e-06 0.4562163541974347 \
1.11793289337242e-06 0.4494927613461197 1.117933224999028e-06 0.4428490490857003 1.117933546548425e-06 0.4364504708187015 1.117933874224238e-06 0.4299742838549845 \
1.11793422184386e-06 0.4231546934710667 1.117934555065174e-06 0.4166645133789623 1.117934900974402e-06 0.4099771621835854 1.117935346388221e-06 0.4014400148089548 \
1.117935704178092e-06 0.3946500490499754 1.117936018334912e-06 0.3887397205534429 1.117936402745392e-06 0.3815756289527631 1.117936732720036e-06 0.3754830843203271 \
1.117937017930125e-06 0.3702633801070484 1.117937326220382e-06 0.3646649204592909 1.117937606017443e-06 0.3596257204303125 1.117937832011793e-06 0.3555880084110294 \
1.117938046849748e-06 0.3517755993421203 1.11793824528482e-06 0.3482769933469286 1.117938449224337e-06 0.3447071465415313 1.117938659760396e-06 0.3410461989361561 \
1.117938916734521e-06 0.3366091000429626 1.117939157995129e-06 0.3324763702393667 1.117939389568845e-06 0.3285420159269506 1.117939604222291e-06 0.3249208057821749 \
1.117939825046275e-06 0.3212218866489027 1.117940026292867e-06 0.3178749657716667 1.11794022938212e-06 0.3145250552959265 1.117940427226991e-06 0.3112865758726304 \
1.117940614079937e-06 0.3082497660855442 1.117940808016663e-06 0.3051208532403978 1.117941011761317e-06 0.30185834615803 1.117941190488583e-06 0.2990186060348319 \
1.117941428134378e-06 0.2952727068736475 1.117941627896611e-06 0.2921508861588616 1.117941829525427e-06 0.2890253490052915 1.117942054991886e-06 0.285561995332 \
1.117942221086285e-06 0.2830312764183137 1.117942399705387e-06 0.2803277612349699 1.117942581409588e-06 0.2775983111934518 1.117942770043305e-06 0.2747882307029562 \
1.117942947466508e-06 0.2721695222189568 1.117943124659646e-06 0.2695724116247911 1.117943284731561e-06 0.2672552081803913 1.117943405132238e-06 0.2655193337608355 \
1.117943552958303e-06 0.2633957862580221 1.117943681588075e-06 0.2615692882062232 1.117943783793658e-06 0.2601227034409412 1.117943902028939e-06 0.2584516051170885 \
1.1179440224823e-06 0.2567534139348401 1.117944146190618e-06 0.2550183706610066 1.117944264442643e-06 0.2533694204037282 1.117944392295773e-06 0.2515887492000971 \
1.117944512581604e-06 0.249915736161692 1.11794466526121e-06 0.2477917697339537 1.117944800173988e-06 0.2459264316518071 1.11794492881341e-06 0.2441493177932957 \
1.117945086528788e-06 0.2419705448111171 1.117945213210091e-06 0.2402201997919771 1.117945348536158e-06 0.2383592392624043 1.117945487448727e-06 0.2364550510890953 \
1.117945605221031e-06 0.2348405558720491 1.117945764491849e-06 0.2326580599570062 1.117945901013704e-06 0.2307878375452989 1.11794604224565e-06 0.2288626996658652 \
1.117946148058693e-06 0.2274220928889542 1.11794627840164e-06 0.2256484734765637 1.117946378112453e-06 0.2242944442559471 1.117946480933888e-06 0.2228991027388591 \
1.117946554349542e-06 0.2219046249368765 1.117946634181104e-06 0.2208265149641777 1.117946704228335e-06 0.2198809561195558 1.117946754631426e-06 0.2192009305305119 \
1.117946806883225e-06 0.2184966408607167 1.117946886120743e-06 0.2174292050927151 1.117946927964696e-06 0.2168658036437602 1.117946967304648e-06 0.216336351877609 \
1.117947010340057e-06 0.2157575332679269 1.117947054507484e-06 0.2151638767852215 1.117947128273224e-06 0.2141731338947761 1.117947163785221e-06 0.2136967174286463 \
1.117947211500021e-06 0.2130606706933813 1.117947272229561e-06 0.2122518321687151 1.117947340486787e-06 0.2113438957752176 1.117947413008566e-06 0.2103801801047663 \
1.117947485683193e-06 0.2094152724966429 1.117947593999181e-06 0.2079788886429202 1.117947691670323e-06 0.20668564243436 1.117947803221819e-06 0.2052110974836689 \
1.117947901757253e-06 0.2039136008387587 1.117948005250393e-06 0.2025572972554956 1.117948101152128e-06 0.2013021587886929 1.117948203780057e-06 0.1999606878451601 \
1.11794830660317e-06 0.1986207062101238 1.117948416722797e-06 0.1971897063011611 1.117948525418353e-06 0.1957815523781236 1.117948645095582e-06 0.1942360962608612 \
1.117948755373261e-06 0.192818053470401 1.117948863436481e-06 0.1914343471929882 1.117948988535148e-06 0.1898375077741012 1.117949078504982e-06 0.1886931806549971 \
1.117949157191935e-06 0.1876950225942949 1.117949234476806e-06 0.1867173468865102 1.117949320985383e-06 0.1856271834369256 1.117949419934593e-06 0.1843848109964498 \
1.117949490443458e-06 0.1835017733581451 1.117949561894511e-06 0.1826096997732476 1.117949667039846e-06 0.1813018727451555 1.117949746279476e-06 0.1803200401832796 \
1.117949827363369e-06 0.1793174195483187 1.11794992085531e-06 0.1781663090788374 1.117950021631285e-06 0.1769308188703378 1.117950171343388e-06 0.175105380089017 \
1.117950287132704e-06 0.1737009932372819 1.11795043813808e-06 0.1718807311127691 1.1179505492465e-06 0.1705485445502526 1.117950691372958e-06 0.168854666407182 \
1.117950809031379e-06 0.167460358327668 1.117950913935975e-06 0.1662230887079887 1.117951008998573e-06 0.1651069099307241 1.117951102429828e-06 0.1640147999883682 \
1.11795120347649e-06 0.1628388413495604 1.117951299823398e-06 0.1617223204899406 1.117951396975644e-06 0.1606011553546776 1.117951480024216e-06 0.1596469772300165 \
1.11795159006187e-06 0.1583897228513109 1.117951672364432e-06 0.1574542248873526 1.117951777364141e-06 0.156267858580057 1.11795185506021e-06 0.1553950893374849 \
1.117951937879689e-06 0.1544690878994293 1.117952019541594e-06 0.1535604570452941 1.117952108890884e-06 0.152571060794856 1.11795218460332e-06 0.1517364980793458 \
1.117952267165934e-06 0.1508307726525361 1.117952343747367e-06 0.1499942554682341 1.117952412035253e-06 0.1492531084507001 1.117952505402265e-06 0.1482449401818621 \
1.117952574555677e-06 0.1475015570698688 1.117952650180008e-06 0.1466917482325688 1.117952711729129e-06 0.1460354497178591 1.117952778977892e-06 0.1453208357145237 \
1.117952850039892e-06 0.1445684785944268 1.11795292553732e-06 0.143772322008306 1.11795298444886e-06 0.1431546944759192 1.11795306112247e-06 0.1423563022825049 \
1.117953141443212e-06 0.1415233898163201 1.11795321459452e-06 0.1407682091691316 1.117953308750941e-06 0.139800669784813 1.117953380355125e-06 0.1390684367429364 \
1.1179534538159e-06 0.1383201464810226 1.117953537327651e-06 0.1374732033664194 1.117953626806795e-06 0.1365744208092838 1.1179536918717e-06 0.1359252211013016 \
1.117953803997723e-06 0.1348115665849295 1.117953869183864e-06 0.1341670699454539 1.117953939222108e-06 0.1334770515823289 1.117953999527163e-06 0.1328849371768329 \
1.117954054537987e-06 0.1323464455745446 1.117954142654965e-06 0.1314871014507438 1.11795418344126e-06 0.131090685705856 1.11795428714401e-06 0.1300923774523848 \
1.11795433045658e-06 0.1296773144713907 1.117954391675178e-06 0.1290920262082728 1.117954436511897e-06 0.1286643765206081 1.117954524107923e-06 0.127831527987147 \
1.117954565661879e-06 0.1274377589706847 1.117954625523389e-06 0.1268718307679372 1.117954697367115e-06 0.1261946708524367 1.117954753579841e-06 0.1256664967939027 \
1.11795481606734e-06 0.125081039250218 1.117954890295323e-06 0.1243877959456236 1.117954964976328e-06 0.1236954937854857 1.117955052159541e-06 0.1228905551604285 \
1.117955120558092e-06 0.1222610287411191 1.117955201128775e-06 0.1215216597888775 1.117955282424256e-06 0.120778012781285 1.117955349340781e-06 0.1201677797529914 \
1.117955432157726e-06 0.1194156054679852 1.117955491346448e-06 0.1188799972037829 1.117955557267448e-06 0.1182853617472536 1.117955637141492e-06 0.1175675408705869 \
1.11795571363729e-06 0.1168828806096336 1.117955795099401e-06 0.1161574242846086 1.117955893570281e-06 0.1152852106851665 1.11795596868063e-06 0.114622623867465 \
1.11795607166842e-06 0.1137180076826871 1.117956145852372e-06 0.1130691786503039 1.117956243471825e-06 0.1122190343868764 1.11795633928278e-06 0.1113890351962442 \
1.117956435131205e-06 0.110562946039519 1.117956516069412e-06 0.1098685209805978 1.117956604452683e-06 0.1091134439098378 1.117956703052662e-06 0.108274944429282 \
1.117956775836866e-06 0.1076586405352824 1.117956865109775e-06 0.1069058608836731 1.117956927091788e-06 0.1063852406583179 1.117956989684956e-06 0.1058613310701875 \
1.117957074907104e-06 0.105150777260444 1.117957180369478e-06 0.1042758147594986 1.11795726019996e-06 0.1036167065755082 1.117957340914214e-06 0.1029530974056021 \
1.117957423527949e-06 0.1022768941101355 1.117957493972562e-06 0.1017026162492672 1.117957597231928e-06 0.1008648142128753 1.117957670072053e-06 0.1002767039768694 \
1.117957755712335e-06 0.09958839426015198 1.117957874514073e-06 0.09863954321822334 1.117957942151898e-06 0.09810250133474645 1.11795801190202e-06 0.09755100310752296 \
1.117958089237e-06 0.09694230106952094 1.117958181657254e-06 0.09621870517595056 1.117958253354782e-06 0.09566033062548993 1.117958339171942e-06 0.09499542738017568 \
1.117958441597192e-06 0.09420660575030523 1.117958534892083e-06 0.09349264652734962 1.117958631208557e-06 0.09276005482712441 1.117958708110818e-06 0.09217843893134048 \
1.117958801590805e-06 0.09147541043939374 1.117958880833232e-06 0.09088281005358793 1.117958995455426e-06 0.0900310686188453 1.117959125063686e-06 0.08907580221142102 \
1.117959258320877e-06 0.08810234090122065 1.117959402350766e-06 0.08705990691030199 1.11795955951891e-06 0.08593388720602639 1.117959709295387e-06 0.08487214151476249 \
1.117959871762979e-06 0.08373303262435308 1.117960014942984e-06 0.08273971668837025 1.117960167622107e-06 0.0816913199659166 1.117960301891878e-06 0.08077856892457436 \
1.117960443644156e-06 0.07982444400446118 1.117960578643816e-06 0.07892500874648442 1.117960720601214e-06 0.07798882638923543 1.117960867448644e-06 0.07703088995320664 \
1.117961019894053e-06 0.07604750978240994 1.117961185112776e-06 0.07499422991502351 1.117961349250621e-06 0.07396067809208305 1.117961526112024e-06 0.07286119333145537 \
1.11796171645358e-06 0.07169407515132428 1.117961927410093e-06 0.07042030845332216 1.117962147819232e-06 0.0691121699798517 1.117962383344393e-06 0.06773900533435212 \
1.117962643793767e-06 0.0662496528900723 1.117962939459177e-06 0.06459579389282195 1.117963244581463e-06 0.06292902455725519 1.117963609576024e-06 0.06098725515092194 \
1.117964004456839e-06 0.05894944116461652 1.117964410847493e-06 0.05692211719668253 1.117964826573035e-06 0.05491854459141238 1.117965189379358e-06 0.0532251207245777 \
1.117965533980648e-06 0.05166301626031383 1.11796584916051e-06 0.05027284652491828 1.117966144689875e-06 0.04900240867073854 1.117966442670382e-06 0.04775344010203557 \
1.117966718469173e-06 0.04662857640242725 1.117966997243768e-06 0.04551884372531381 1.117967261178638e-06 0.04449205559535935 1.117967537201377e-06 0.04344260531795661 \
1.11796781615763e-06 0.04240676967887352 1.117968129850963e-06 0.04127097799875453 1.11796836585125e-06 0.04043636567030678 1.117968621645987e-06 0.03955075129286261 \
1.117968881769487e-06 0.03867033103466553 1.117969151904759e-06 0.03778142289416799 1.117969431124747e-06 0.03688501536902895 1.117969712963396e-06 0.03600226561751176 \
1.117969989839066e-06 0.03515600409566183 1.117970268932665e-06 0.03432349610146775 1.117970501810273e-06 0.03364444121149882 1.117970785646989e-06 0.03283527291840588 \
1.117971025751924e-06 0.03216626441466421 1.117971265550746e-06 0.0315119836023277 1.11797150482792e-06 0.03087436846876356 1.117971740084942e-06 0.03026290129608995 \
1.117971971011964e-06 0.02967475842909434 1.117972186001007e-06 0.02913788335257221 1.11797258815546e-06 0.02816043724496065 1.117972786878278e-06 0.02768988489927659 \
1.117973160561295e-06 0.0268265706552881 1.117973347359617e-06 0.02640514011949098 1.117973694919304e-06 0.02563810810034544 1.117973816848767e-06 0.0253740445387235 \
1.117974199320208e-06 0.02456430406701914 1.117974370028237e-06 0.02421180751242828 1.117974827125621e-06 0.02328894863848502 1.117975012758007e-06 0.0229225623309489 \
1.11797537621526e-06 0.02221803970155307 1.117975596582612e-06 0.02179832126591805 1.11797605430897e-06 0.02093867417890744 1.117976189728599e-06 0.02068687731869814 \
1.117976719624047e-06 0.01972418011126781 1.117976838945017e-06 0.01951377505543128 1.117977404730696e-06 0.01856069823426573 1.117977569110437e-06 0.0182962226476828 \
1.117978187655734e-06 0.01735107502432094 1.117978357709933e-06 0.01710418363667701 1.117978889842166e-06 0.01636278834442301 1.117979086926142e-06 0.01610013864443424 \
1.117979810045215e-06 0.01517806887136661 1.117979974675381e-06 0.01497647803580381 1.117980723800768e-06 0.01409711804523418 1.11798085710012e-06 0.01394643716836554 \
1.117981717353759e-06 0.01301449210748497 1.117981852457379e-06 0.01287422877142914 1.11798279503482e-06 0.01193816285908547 1.117982958630574e-06 0.01178202925388569 \
1.117983959987201e-06 0.0108653384673985 1.117984097529988e-06 0.01074500730514941 1.117985319636371e-06 0.009765086624518643 1.117985426589084e-06 0.00968516078425012 \
1.117986830780577e-06 0.008707372520026449 1.117986935611284e-06 0.008639312158696611 1.117988470448246e-06 0.00767719340797631 1.117988565731547e-06 0.007617466071856052 \
1.117990174528868e-06 0.006680264535635283 1.117990308605608e-06 0.006609506832171614 1.117992405618559e-06 0.005610918814474722 1.117992636163191e-06 0.005510783990371394 \
1.117994959158435e-06 0.004586584533412417 1.117995440488638e-06 0.004413562233393853 1.117998278050269e-06 0.003511943147855551 1.117998822969955e-06 0.003360532104877318 \
1.118002947178352e-06 0.002408309874554541 1.118003490902011e-06 0.002305347543005144 1.118009362191237e-06 0.001333291345955189 1.118009605056421e-06 0.001286469439319215 \
1.118023932948772e-06 0.0002880570268237783 1.118024077507414e-06 0.0002853642807229123 1.120661356428513e-06 -0.0006859155495331031 1.12066149598365e-06 -0.000901903561740745 \
1.120662005077583e-06 -0.001859438188174024 1.120662094565085e-06 -0.002052812934985279 1.120662457959945e-06 -0.00291126965001638 1.120662548982015e-06 -0.003143482006111167 \
1.120662914420052e-06 -0.004127275145644371 1.120663024680619e-06 -0.004436819103926468 1.120663336727774e-06 -0.005309594399865315 1.120663439442621e-06 -0.005584800160857357 \
1.120663803290477e-06 -0.006384516484886619 1.120663968081209e-06 -0.006586298968823262 1.120664547677408e-06 -0.005791490933239759 1.120664722787551e-06 -0.004914057272375438 \
1.120664839479485e-06 -0.004132845175365214 1.120664966064091e-06 -0.003100877896798674 1.120665067873012e-06 -0.002132773363901063 1.120665188361723e-06 -0.0008283127610571584 \
1.120665278808799e-06 0.0002599396317828252 1.12066537669893e-06 0.001541559978017447 1.12066547576324e-06 0.002943971508909197 1.120665646570516e-06 0.005594911825788154 \
1.120665868338539e-06 0.00944046646559993 1.120666064242384e-06 0.01317281463966807 1.120666223123766e-06 0.01639870563256729 1.120666387552263e-06 0.01989779506365397 \
1.120666541918294e-06 0.02331070396473752 1.120666700690818e-06 0.02693200463312963 1.120666847428777e-06 0.03036422445567413 1.120666996052748e-06 0.0339113704936035 \
1.120667151667245e-06 0.03768995713197771 1.120667308909259e-06 0.04156499463828727 1.120667473802058e-06 0.04567927910670353 1.120667647221578e-06 0.05005184210758699 \
1.120667825915293e-06 0.05459761989277153 1.120668014531131e-06 0.05943075613080645 1.120668215431274e-06 0.06460909294799391 1.120668434888064e-06 0.0702927970720964 \
1.120668664434351e-06 0.07626037976612585 1.120668910133291e-06 0.08266408948881369 1.12066917869823e-06 0.08967663153997742 1.120669470040144e-06 0.09728936802005522 \
1.120669791708172e-06 0.1056939239977524 1.120670152022263e-06 0.1150987971742611 1.120670543001701e-06 0.1252892839303718 1.120670986416517e-06 0.1368209045172546 \
1.120671502729605e-06 0.1502062239570841 1.120672108934821e-06 0.16586000516691 1.120672780191848e-06 0.1831102247110778 1.120673559691505e-06 0.20301830483439 \
1.120674432001389e-06 0.2251413938832897 1.120675262336714e-06 0.2460320778586349 1.120675993667063e-06 0.264292249712138 1.120676641612843e-06 0.280346965484095 \
1.120677224923317e-06 0.29469740877147 1.120677760655584e-06 0.3077798509628869 1.120678263914169e-06 0.3199778888071559 1.12067874911767e-06 0.3316516836183861 \
1.120679228040375e-06 0.3430829066939081 1.120679674471008e-06 0.3536501814456421 1.120680148800718e-06 0.3647819492304352 1.120680597991712e-06 0.3752331958288908 \
1.12068108846397e-06 0.3865396207984229 1.120681617036723e-06 0.3985997842463301 1.120681988181062e-06 0.4069920784971888 1.120682515935418e-06 0.4188173133762567 \
1.120682978292178e-06 0.4290642331729484 1.120683450624318e-06 0.4394285229343968 1.120683932409041e-06 0.4498981261869666 1.120683965448159e-06 0.4506126593745911 \
1.120684003207152e-06 0.45142837879914 1.120684078725137e-06 0.4530572051633331 1.120684229761107e-06 0.4563088938659436 1.120684437280372e-06 0.460764549126051 \
1.120684625319184e-06 0.4647825567212808 1.120684844328398e-06 0.469441659996985 1.120685087159409e-06 0.4745824626509371 1.120685386935037e-06 0.4808894567257585 \
1.120685624728187e-06 0.4858624696070272 1.120685887949588e-06 0.4913374535260851 1.120686148847133e-06 0.4967277906005185 1.12068637840122e-06 0.5014431429135263 \
1.120686601461413e-06 0.506003872007333 1.120686803037404e-06 0.5100983586086808 1.120686951867463e-06 0.51310967141356 1.120687196178516e-06 0.5180317772556589 \
1.120687328783749e-06 0.5206893064287169 1.120687468140331e-06 0.5234717264876519 1.120687679105724e-06 0.5276623644271943 1.120687853979606e-06 0.5311266030493931 \
1.120688122027852e-06 0.5364094032095129 1.12068831705351e-06 0.5402319029111832 1.120688496615017e-06 0.5437361368949839 1.120688747571146e-06 0.5486228351952749 \
1.120689024979257e-06 0.5540035987981641 1.120689308928559e-06 0.5594901708581531 1.12068956456585e-06 0.5644152233389156 1.12068985554807e-06 0.570006772487656 \
1.120690115853754e-06 0.5749917787111524 1.120690384297874e-06 0.5801232573974072 1.120690627063004e-06 0.5847450403362237 1.120690883594205e-06 0.5896146675871002 \
1.120691109757648e-06 0.59388771440121 1.120691347099143e-06 0.5983512154742827 1.12069155648786e-06 0.6022720321566808 1.120691770260628e-06 0.6062574570422776 \
1.120692023713469e-06 0.6109557890491497 1.120692226567816e-06 0.6146943332140289 1.120692419372338e-06 0.6182333111593361 1.120692609677365e-06 0.6217090173923294 \
1.120692800335854e-06 0.6251694921350958 1.12069300291378e-06 0.6288260100903066 1.120693265662542e-06 0.6335359534764116 1.120693494630232e-06 0.6376100987349322 \
1.120693714577867e-06 0.6414991146358265 1.12069394026254e-06 0.6454625140719233 1.120694149149966e-06 0.6491091855837361 1.120694370803585e-06 0.652957810138281 \
1.120694555693011e-06 0.6561429680377227 1.120694745707565e-06 0.6594017273991298 1.120694895862686e-06 0.6619630641908443 1.120695070740593e-06 0.6649292185271485 \
1.12069521646131e-06 0.6673855496832628 1.120695352493842e-06 0.6696641287411549 1.120695500856121e-06 0.672138295335571 1.120695630303834e-06 0.6742883907026684 \
1.120695764169531e-06 0.6764996355878535 1.12069589251393e-06 0.6786115243545502 1.120696017902059e-06 0.6806677490053815 1.120696147367755e-06 0.6827843190971332 \
1.12069627834897e-06 0.6849171426143115 1.120696426722072e-06 0.6873221141612875 1.120696534784827e-06 0.6890667486235877 1.1206966633165e-06 0.6911333958680312 \
1.120696798756283e-06 0.6933004139195943 1.120696923690607e-06 0.6952876996714908 1.120697049447875e-06 0.6972799977491608 1.120697155963766e-06 0.6989584331773744 \
1.120697273081655e-06 0.7007929859467624 1.120697391621401e-06 0.7026383448210159 1.120697514924798e-06 0.704545102273978 1.120697618097696e-06 0.7061304255463237 \
1.120697769068859e-06 0.7084341141567283 1.120697885323065e-06 0.7101955266062138 1.120698015883454e-06 0.7121605601685687 1.120698134445982e-06 0.7139335830373704 \
1.120698240519852e-06 0.7155108922888329 1.120698340544792e-06 0.716990346352101 1.120698477870007e-06 0.719009255813789 1.120698596531362e-06 0.7207429633399333 \
1.120698718230586e-06 0.7225107522614664 1.120698843413151e-06 0.7243181860083944 1.120698965432965e-06 0.7260693242762759 1.120699093464719e-06 0.7278954552757622 \
1.120699217946458e-06 0.7296603419865877 1.120699346245781e-06 0.7314685590147565 1.120699473339584e-06 0.7332489547570846 1.120699599364423e-06 0.7350034830462163 \
1.12069970210311e-06 0.7364262918236342 1.120699816775856e-06 0.7380063527755659 1.120699898181918e-06 0.7391232259175492 1.120700017381438e-06 0.7407496908814458 \
1.120700110023778e-06 0.7420059782745783 1.120700248182835e-06 0.7438668850244906 1.120700379238334e-06 0.7456179978167152 1.120700509370502e-06 0.7473439783685625 \
1.120700614344577e-06 0.7487266533969134 1.120700753484419e-06 0.7505456565005918 1.120700907428719e-06 0.7525407731682957 1.120701029372999e-06 0.7541080835708853 \
1.120701176919359e-06 0.7559892974429111 1.120701298924537e-06 0.7575320275232224 1.120701447624467e-06 0.7593968175435225 1.120701581671092e-06 0.7610632318338031 \
1.120701703924347e-06 0.7625711443351471 1.120701816790257e-06 0.763953046884334 1.120701959641225e-06 0.7656882893306027 1.120702086364119e-06 0.7672149413549471 \
1.120702202168994e-06 0.7685995877768005 1.120702331910823e-06 0.7701390587657672 1.120702447649211e-06 0.7715019052061673 1.120702570601637e-06 0.7729391548276606 \
1.120702688317297e-06 0.7743051053122872 1.120702794287273e-06 0.7755262985206828 1.120702910698467e-06 0.7768586864857919 1.1207030173164e-06 0.7780703956921795 \
1.12070312951512e-06 0.7793369495935717 1.12070321618369e-06 0.7803089322889447 1.120703319569181e-06 0.7814603789665585 1.120703432733433e-06 0.7827108149434853 \
1.120703538380716e-06 0.783868819044773 1.120703647720273e-06 0.7850578567336689 1.120703754897288e-06 0.786214126597127 1.120703884303365e-06 0.7875981444497275 \
1.120703996720751e-06 0.7887899291890393 1.12070412010849e-06 0.7900869036018625 1.120704237558825e-06 0.7913106402786101 1.120704381085744e-06 0.7927918312347375 \
1.120704496005322e-06 0.7939667362870242 1.120704634727735e-06 0.7953719780830618 1.120704772759875e-06 0.7967562205547866 1.12070488225303e-06 0.7978444364842524 \
1.120704983271459e-06 0.7988406866985471 1.12070508435942e-06 0.7998302780396641 1.120705216746616e-06 0.8011146558616069 1.120705335472037e-06 0.8022550163876687 \
1.120705457256542e-06 0.8034134048507504 1.120705576346336e-06 0.8045351524060473 1.120705697550853e-06 0.8056657048884367 1.120705829194664e-06 0.8068811249615274 \
1.120705952212703e-06 0.8080052413861453 1.120706079823023e-06 0.8091594649786741 1.120706210891683e-06 0.8103325925767672 1.120706334212046e-06 0.8114249716726942 \
1.12070644213631e-06 0.8123719892944993 1.120706549931703e-06 0.8133095350680949 1.120706631652631e-06 0.8140147772069938 1.120706748520247e-06 0.815015186305849 \
1.120706839581256e-06 0.8157880755829442 1.120706973749887e-06 0.8169164295805346 1.12070711832076e-06 0.8181184617099191 1.120707251823127e-06 0.8192158725965917 \
1.120707361789037e-06 0.8201107352847025 1.120707505654698e-06 0.8212684563313245 1.120707658960262e-06 0.8224861772268215 1.120707786698555e-06 0.8234883060891934 \
1.120707927340891e-06 0.8245786478120171 1.120708053124456e-06 0.8255423809867173 1.120708207742427e-06 0.8267124309768116 1.120708340154194e-06 0.8277017767197102 \
1.120708466433798e-06 0.8286345641820314 1.120708584064113e-06 0.8294941055817234 1.120708732230976e-06 0.8305638349826423 1.120708899375221e-06 0.8317531470681401 \
1.120709031993881e-06 0.832683775428688 1.120709204938569e-06 0.8338803479528284 1.120709373325224e-06 0.8350269493631071 1.120709542859754e-06 0.8361634673386688 \
1.120709724228909e-06 0.8373596561587384 1.120709866861491e-06 0.8382862741713709 1.12070998079734e-06 0.8390176620397163 1.120710111571134e-06 0.8398476357987267 \
1.120710213225074e-06 0.8404856735008092 1.120710329718803e-06 0.8412091703399448 1.120710465236349e-06 0.8420405885319162 1.120710662580143e-06 0.8432318270427018 \
1.120710853245141e-06 0.8443612543037786 1.12071106310198e-06 0.8455804035625291 1.120711244039104e-06 0.8466117334714958 1.120711441374591e-06 0.8477160230260256 \
1.120711615161427e-06 0.8486711109012058 1.120711797742881e-06 0.8496572451898022 1.120711969062461e-06 0.850566499179887 1.120712143447507e-06 0.8514760798656241 \
1.120712318831052e-06 0.8523748177975867 1.120712495063209e-06 0.8532619682996843 1.120712684901452e-06 0.8542000584728613 1.120712875637665e-06 0.8551245802328369 \
1.120713077434399e-06 0.856083442102113 1.120713270127775e-06 0.8569809170305027 1.120713479756076e-06 0.857937542729613 1.12071370919384e-06 0.8589615588718806 \
1.12071397499048e-06 0.8601183337444025 1.120714273565708e-06 0.8613802063570262 1.120714551467221e-06 0.8625196921548358 1.120714835677695e-06 0.8636511027355716 \
1.120715110089482e-06 0.8647118800460076 1.120715382252364e-06 0.8657341977214618 1.120715652421456e-06 0.8667205537246333 1.120715909616139e-06 0.8676338760342862 \
1.12071618215581e-06 0.868575115807136 1.120716458190291e-06 0.8695013130444248 1.120716728342986e-06 0.8703818891200001 1.120717028049788e-06 0.8713292845176382 \
1.120717398867258e-06 0.8724597217497643 1.120717693785921e-06 0.8733269024855727 1.120717948030199e-06 0.8740525764960509 1.120718246254198e-06 0.8748787854419284 \
1.120718519878969e-06 0.8756137195941651 1.120718756017959e-06 0.8762307200963571 1.120718996373686e-06 0.8768427579093606 1.120719218719338e-06 0.8773949085683344 \
1.120719412723072e-06 0.877865919014753 1.120719742447196e-06 0.878644045115768 1.120719897619855e-06 0.8790007149587372 1.120720215373248e-06 0.879712598742095 \
1.120720394238605e-06 0.8801026384247937 1.120720736700093e-06 0.8808283583858193 1.120720920841293e-06 0.8812073588304842 1.120721395746114e-06 0.8821499412898334 \
1.120721563140601e-06 0.8824705695712217 1.120722028971889e-06 0.8833323038036038 1.120722209796771e-06 0.8836551183393088 1.120722703830028e-06 0.8845051821644966 \
1.120722845172603e-06 0.8847400410050358 1.120723451563118e-06 0.8857071861637142 1.120723603635685e-06 0.8859397703602404 1.120724250313758e-06 0.8868873789663725 \
1.120724378610247e-06 0.8870678433440622 1.120725026723245e-06 0.8879435266410994 1.120725156528523e-06 0.8881118897635528 1.120725934785608e-06 0.8890711781604964 \
1.120726049780423e-06 0.8892053868933587 1.120726905511062e-06 0.8901454611437621 1.120727050777629e-06 0.8902951528450479 1.120728036533732e-06 0.8912364417375994 \
1.120728257640946e-06 0.8914302300078862 1.120729402752027e-06 0.892358484239638 1.120729533960174e-06 0.8924604119362172 1.120730875263369e-06 0.8934531785430913 \
1.12073102665103e-06 0.8935579568409697 1.120732508109867e-06 0.8944876667405802 1.120732746990229e-06 0.894621531696939 1.120734516461986e-06 0.8954958910368339 \
1.120734905568824e-06 0.8956641700186337 1.120737299334232e-06 0.8965498195158238 1.120737774894223e-06 0.8966991754584082 1.120741837950387e-06 0.8976977719002629 \
1.120742329424408e-06 0.8977905759376156 1.120750645951487e-06 0.8987839664765119 1.120751565805377e-06 0.8988472044554419 1.120877770945903e-06 0.8998441026240215 \
1.120878784754255e-06 0.8998514601858095 1.121070497347411e-06 0.8990059056521554 1.121070727348974e-06 0.8988405173838494 1.121072342221535e-06 0.8978439928078279 \
1.121072519935389e-06 0.8977495532019018 1.121089285710428e-06 0.8987316330193963 1.121089421698825e-06 0.8987497732072308 1.121104884427938e-06 0.8997471920221268 \
1.12110515229253e-06 0.8997526389354535 1.121588977619798e-06 0.9006560548284696 1.121589098408999e-06 0.9007687033315858 1.121589886180037e-06 0.9017381658104292 \
1.121590020318756e-06 0.901943163319478 1.12159051393353e-06 0.9027850367016239 1.121590658833145e-06 0.9030569221572713 1.12159105464053e-06 0.9038490360455199 \
1.121591174436184e-06 0.9041001886668685 1.121591558609717e-06 0.9049189780371781 1.121591670731365e-06 0.9051556495331843 1.121592178052336e-06 0.9061253139956988 \
1.121592272051192e-06 0.90626859229291 1.121593430700898e-06 0.9055667778886739 1.121593533663832e-06 0.9051589876696525 1.121593617506701e-06 0.9047707260375384 \
1.121593751246752e-06 0.9040404158978201 1.121593851964133e-06 0.9033957423200318 1.121593959579919e-06 0.9026166239542108 1.121594077153173e-06 0.9016533104038295 \
1.121594165418223e-06 0.90085556431878 1.121594285051691e-06 0.8996698288011099 1.121594382373389e-06 0.8986166602050341 1.121594493390828e-06 0.8973222354192386 \
1.121594595500415e-06 0.8960407982554908 1.121594678931815e-06 0.8949326975987755 1.121594783112883e-06 0.8934749428758865 1.121594874199646e-06 0.8921321265381427 \
1.121594966740432e-06 0.8907058396397178 1.12159506189443e-06 0.8891776325191247 1.121595176449407e-06 0.88725933118288 1.121595265292509e-06 0.8857137884271823 \
1.121595363531691e-06 0.8839502506198179 1.121595448901865e-06 0.8823735982707064 1.121595529802107e-06 0.8808434949738935 1.1215956027634e-06 0.8794355441897157 \
1.121595669782045e-06 0.8781198554636557 1.121595738393124e-06 0.8767515715160701 1.121595821888036e-06 0.8750591081124355 1.121595884015366e-06 0.8737811510706814 \
1.121595946997964e-06 0.8724704924326797 1.121596042153715e-06 0.8704632161180945 1.121596142764353e-06 0.8683077530860182 1.121596222643545e-06 0.8665738309361769 \
1.121596306905814e-06 0.8647250601592834 1.121596386016074e-06 0.8629723295901451 1.121596448831519e-06 0.8615696597604833 1.121596536288554e-06 0.8596016864744445 \
1.121596602182084e-06 0.8581079708060287 1.121596670243627e-06 0.856556281928966 1.121596719556134e-06 0.8554267461646872 1.121596774792924e-06 0.85415654045335 \
1.121596815532529e-06 0.8532164928603474 1.121596861834283e-06 0.8521450198670055 1.121596892048343e-06 0.8514441160591502 1.121596921089625e-06 0.8507691938976955 \
1.12159695172822e-06 0.8500558939662993 1.12159701300541e-06 0.8486254874746039 1.121597066077972e-06 0.8473828229799116 1.121597119733165e-06 0.8461232012188223 \
1.121597182390447e-06 0.8446482873934593 1.121597245673395e-06 0.8431545995644786 1.121597336171269e-06 0.8410121009440262 1.121597433169049e-06 0.8387078554355326 \
1.12159751614655e-06 0.8367307351423475 1.121597598150905e-06 0.8347721678896715 1.121597687219307e-06 0.8326403548070889 1.121597771732643e-06 0.8306135893189693 \
1.121597862591523e-06 0.8284303722590877 1.121597954526378e-06 0.8262176456275642 1.121598056957309e-06 0.8237486178045141 1.12159815707534e-06 0.8213320995840899 \
1.121598271896223e-06 0.8185572053828121 1.12159838410276e-06 0.8158423448209959 1.121598509096305e-06 0.8128151787794674 1.121598640356713e-06 0.8096337870015397 \
1.121598785627755e-06 0.8061104108175116 1.121598940135368e-06 0.8023613213197434 1.121599111575989e-06 0.7981999722344618 1.121599275625781e-06 0.794217661721315 \
1.121599460041203e-06 0.7897413884478564 1.121599666533577e-06 0.7847307375046715 1.12159985602742e-06 0.7801344622909899 1.121600049421183e-06 0.775444374634302 \
1.121600249988037e-06 0.7705834242206392 1.121600397552439e-06 0.7670092004965298 1.12160052756389e-06 0.7638619034739171 1.121600662428303e-06 0.7605987503374771 \
1.121600768918754e-06 0.7580234999254772 1.121600900608547e-06 0.7548403390839162 1.121601007032976e-06 0.7522693550468039 1.121601150211605e-06 0.7488125398635642 \
1.121601311338716e-06 0.7449250928176189 1.121601429565533e-06 0.7420746008290786 1.121601599798354e-06 0.7379721584775248 1.121601765724623e-06 0.7339761998059781 \
1.121601985266954e-06 0.7286940862104242 1.121602178454078e-06 0.724050920820232 1.121602353368041e-06 0.719851304223293 1.121602520315139e-06 0.7158476177432674 \
1.1216027078061e-06 0.711355754450834 1.121602895234537e-06 0.7068709122373377 1.121603063571096e-06 0.7028473835914892 1.12160325640163e-06 0.6982428782038785 \
1.121603396451378e-06 0.694901318858167 1.121603552708666e-06 0.6911769338170629 1.121603746878113e-06 0.6865540563080536 1.121603905984602e-06 0.6827702245679255 \
1.121604064344632e-06 0.679008548037742 1.12160425966174e-06 0.6743756772263459 1.121604470090519e-06 0.6693917663527935 1.121604722792665e-06 0.6634173774538097 \
1.121604902460615e-06 0.6591769455535931 1.121605154037489e-06 0.6532475027332399 1.121605354410306e-06 0.6485340174553987 1.121605526064158e-06 0.6445032789616798 \
1.121605684756275e-06 0.6407814961122935 1.121605823964202e-06 0.637522316374186 1.121605960288252e-06 0.6343349641335875 1.121606087501276e-06 0.6313646237382058 \
1.121606216993834e-06 0.6283457899522861 1.121606344985121e-06 0.6253646753452949 1.12160647605963e-06 0.6223174651643489 1.121606606771705e-06 0.6192830747181834 \
1.121606749379757e-06 0.6159760732208495 1.121606892103236e-06 0.612672916206165 1.121607044651037e-06 0.6091471600588 1.121607189155025e-06 0.6058158037532523 \
1.121607353173272e-06 0.6020406322262999 1.121607490637933e-06 0.5988837056407329 1.121607625454949e-06 0.5957940466067043 1.121607746953592e-06 0.5930134750293682 \
1.121607885803897e-06 0.5898448108574432 1.121607999450713e-06 0.5872554148224447 1.121608150860885e-06 0.5838116422847746 1.12160826457956e-06 0.5812320812748947 \
1.121608383992651e-06 0.5785269636915771 1.121608472673178e-06 0.5765205397309219 1.121608563818269e-06 0.5744630259469776 1.121608629157145e-06 0.5729901393713442 \
1.121608693626847e-06 0.5715377831648228 1.121608744447459e-06 0.5703933076453638 1.121608803422398e-06 0.569066051987989 1.121608870867106e-06 0.5675516747474645 \
1.121608937959298e-06 0.5660472084764079 1.121608990879742e-06 0.5648615894615425 1.121609086527225e-06 0.5627204246953637 1.121609143708362e-06 0.5614413394337 \
1.121609197510977e-06 0.5602399192081799 1.121609259253082e-06 0.5588634520375642 1.121609345086214e-06 0.5569525037715509 1.121609427781862e-06 0.5551133137453282 \
1.121609553910589e-06 0.552313430559463 1.121609689009665e-06 0.5493247407981657 1.121609787329828e-06 0.5471534914294828 1.12160989990789e-06 0.5446716589975775 \
1.121610002452305e-06 0.5424173856211837 1.121610122561131e-06 0.5397821662853191 1.121610224248782e-06 0.5375541863492928 1.121610339752746e-06 0.5350300289250629 \
1.121610454643861e-06 0.5325260225312031 1.121610581121134e-06 0.5297740207092871 1.12161070633833e-06 0.5270565158317848 1.121610853184312e-06 0.5238798967507053 \
1.121610988642446e-06 0.5209557060405445 1.121611146203055e-06 0.5175672114705414 1.121611308357229e-06 0.5140875588169389 1.121611489068307e-06 0.5102248342695275 \
1.12161168131606e-06 0.5061308236654174 1.121611894038323e-06 0.5016182665703952 1.121612125943484e-06 0.4967183500883584 1.121612383137188e-06 0.4913135654247419 \
1.121612622690498e-06 0.4863004534671564 1.121612924620373e-06 0.4800178499336004 1.121613212386814e-06 0.4740665530855001 1.121613525189057e-06 0.4676409412178996 \
1.121613845020806e-06 0.4611139840073785 1.121614184657409e-06 0.4542292677834274 1.121614511873228e-06 0.4476411633207955 1.121614847034797e-06 0.4409363684817221 \
1.121615164291458e-06 0.4346351592989786 1.121615498111436e-06 0.4280489847791872 1.12161584979678e-06 0.4211625252737479 1.121616163864498e-06 0.4150547397555842 \
1.121616486893702e-06 0.4088175946446666 1.121616927873099e-06 0.4003732788922496 1.121617270275942e-06 0.3938810608698495 1.121617570723831e-06 0.3882325136127223 \
1.121617946053401e-06 0.3812375944419973 1.12161827612863e-06 0.3751439175705365 1.121618559406411e-06 0.3699597784791666 1.121618859913772e-06 0.3645020109013299 \
1.121619139561233e-06 0.3594637112692664 1.121619363423524e-06 0.3554634414471464 1.121619575274513e-06 0.35170280677964 1.121619777623113e-06 0.3481338771034005 \
1.121619978758139e-06 0.3446120049995081 1.121620184535657e-06 0.3410324794262659 1.121620445514371e-06 0.3365252478245505 1.121620685004553e-06 0.3324209773202946 \
1.121620917679624e-06 0.3284665339262754 1.121621131761216e-06 0.3248537323113044 1.121621352906983e-06 0.3211475567840967 1.121621553789873e-06 0.3178053707831449 \
1.121621757181075e-06 0.3144500223650613 1.121621954849487e-06 0.3112139453100684 1.121622141093175e-06 0.3081862077816076 1.121622336074257e-06 0.3050391973134606 \
1.121622539536502e-06 0.3017803754370622 1.121622717477408e-06 0.2989521325826759 1.121622953201112e-06 0.2952356640875101 1.121623151333966e-06 0.2921385263640672 \
1.121623352678033e-06 0.2890160050544278 1.12162357696723e-06 0.2855690750291008 1.121623741897129e-06 0.2830551950838826 1.121623919525814e-06 0.2803657404651576 \
1.121624103924961e-06 0.2775946687427531 1.121624287746306e-06 0.2748547260732712 1.121624466202979e-06 0.2722194282383935 1.121624638103246e-06 0.2696976713509589 \
1.121624798643653e-06 0.2673699088296289 1.121624920125712e-06 0.265617282026588 1.121625073047239e-06 0.2634201198254058 1.121625200480934e-06 0.2616085083773952 \
1.121625304654605e-06 0.2601317890528609 1.121625421559082e-06 0.2584775571399547 1.121625536570573e-06 0.2568557450124987 1.121625660932803e-06 0.2551103168403305 \
1.121625776507087e-06 0.2534925198640895 1.121625910614607e-06 0.2516172680784447 1.121626025601849e-06 0.2500177396912131 1.121626179351445e-06 0.2478798443778067 \
1.121626316154646e-06 0.2459790966208961 1.121626450740453e-06 0.2441094379339017 1.121626606604589e-06 0.2419575875351012 1.121626731253411e-06 0.2402378086535915 \
1.121626870468935e-06 0.2383186229544463 1.12162700069296e-06 0.236525770455347 1.121627121045801e-06 0.2348769158236033 1.121627256439084e-06 0.233027137746051 \
1.121627407644063e-06 0.2309620730808924 1.121627542400533e-06 0.2291249940296414 1.12162764708672e-06 0.2277003186426776 1.121627769622861e-06 0.2260366668203369 \
1.12162790456742e-06 0.2242086518061946 1.121627999683167e-06 0.2229209267876512 1.121628114943222e-06 0.2213657311907907 1.121628197476202e-06 0.2202562617028589 \
1.121628268681533e-06 0.2192992955643472 1.121628317389017e-06 0.2186449771734718 1.121628364583973e-06 0.2180112263680214 1.121628411132791e-06 0.2173864029843717 \
1.121628464521355e-06 0.2166701476649976 1.121628501898025e-06 0.2161690444847812 1.121628539283138e-06 0.2156680710113931 1.121628579604508e-06 0.2151283464800275 \
1.121628650854648e-06 0.2141753141901174 1.121628685068904e-06 0.2137180869447317 1.121628731463535e-06 0.2131018213873352 1.121628791907201e-06 0.2122998083652294 \
1.12162886091012e-06 0.2113853596849882 1.121628926205072e-06 0.210520730631805 1.121628994183195e-06 0.2096212333552783 1.121629110629525e-06 0.2080823984153433 \
1.121629200551714e-06 0.2068957989735914 1.12162930821762e-06 0.2054771097790837 1.121629404278935e-06 0.2042146625011118 1.121629507657509e-06 0.2028641889872041 \
1.121629604342544e-06 0.2016026287683381 1.121629707152397e-06 0.2002625524503448 1.121629807912368e-06 0.1989526210414513 1.121629919058035e-06 0.1975116692735505 \
1.121630026097528e-06 0.1961279675313261 1.121630144004064e-06 0.1946083430154048 1.121630252114387e-06 0.1932197128021231 1.121630361412988e-06 0.1918224631760269 \
1.121630482044739e-06 0.1902849927564414 1.121630576945331e-06 0.1890796997295432 1.12163070550625e-06 0.18745262875399 1.121630798541038e-06 0.1862801166370808 \
1.121630900937595e-06 0.1849947785893032 1.121630988904886e-06 0.1838942174288659 1.121631087175557e-06 0.182668828510528 1.121631183776179e-06 0.1814691026470878 \
1.121631270414692e-06 0.1803971466393716 1.121631356823704e-06 0.1793305247657973 1.121631452660814e-06 0.1781527189679156 1.121631557387688e-06 0.1768710765218302 \
1.121631703199975e-06 0.1750963017969037 1.121631819167907e-06 0.1736923427161618 1.121631975631711e-06 0.1718092975148396 1.12163208681163e-06 0.1704786474822015 \
1.121632227061631e-06 0.1688098560703619 1.121632350073035e-06 0.1673544160765056 1.121632456564034e-06 0.1661007559767333 1.121632552889492e-06 0.1649724583647661 \
1.121632650322958e-06 0.1638357962207703 1.121632754176237e-06 0.1626293386330815 1.12163284597681e-06 0.1615673458739011 1.121632944364525e-06 0.1604337426303964 \
1.12163302728317e-06 0.1594828374885931 1.121633122651503e-06 0.1583950132920943 1.121633205213852e-06 0.1574587876231885 1.121633307798537e-06 0.1563016192679324 \
1.121633384076854e-06 0.1554454316211293 1.121633472662479e-06 0.1544557264474612 1.121633544831984e-06 0.1536532700165102 1.121633626541473e-06 0.1527486200895024 \
1.121633700220281e-06 0.1519363404455653 1.121633780440409e-06 0.1510573496788611 1.121633852168484e-06 0.1502755532525617 1.121633920425463e-06 0.149534520573691 \
1.121634018141422e-06 0.1484788062294206 1.121634087591606e-06 0.147731872792437 1.121634170343085e-06 0.1468455801890639 1.121634230379995e-06 0.1462052652532956 \
1.121634300618659e-06 0.1454587420502366 1.121634372046193e-06 0.1447037411390827 1.121634452559695e-06 0.1438588888651768 1.121634515822599e-06 0.1431977449412327 \
1.121634593496578e-06 0.1423892845091393 1.121634682806343e-06 0.141463758692191 1.121634752169929e-06 0.1407479403162204 1.121634850118149e-06 0.1397418416088305 \
1.121634940462669e-06 0.1388188591118084 1.121635026242994e-06 0.1379520826379384 1.121635093896779e-06 0.1372719511642241 1.121635160204629e-06 0.1366075914250998 \
1.121635238824321e-06 0.1358227655030745 1.12163531951923e-06 0.135020537018139 1.121635377921894e-06 0.1344419857224206 1.121635438674417e-06 0.1338420332148588 \
1.121635532580729e-06 0.1329184183639811 1.121635574978232e-06 0.1325029080242558 1.121635654222426e-06 0.1317336600863391 1.121635694592585e-06 0.1313430593815061 \
1.121635784293463e-06 0.130477658168832 1.12163582324155e-06 0.1301029732927899 1.121635918857236e-06 0.1291862249441596 1.121635957741065e-06 0.1288146335111444 \
1.121636050975841e-06 0.1279263274670414 1.12163611931843e-06 0.1272775968534341 1.121636171639285e-06 0.1267823325594629 1.121636253739999e-06 0.1260075984242486 \
1.121636324903378e-06 0.1253406747583812 1.121636402856366e-06 0.1246136378429537 1.121636481976102e-06 0.1238779526756392 1.121636560619333e-06 0.1231489004754178 \
1.121636640654242e-06 0.122409328367501 1.121636702388658e-06 0.1218405706457005 1.12163677598364e-06 0.1211645344030958 1.121636859363458e-06 0.120401093559758 \
1.121636923460189e-06 0.1198161795466899 1.121636992898777e-06 0.119184869057559 1.121637065921715e-06 0.1185234239195788 1.121637150796627e-06 0.1177582144838446 \
1.121637230159478e-06 0.117046673033812 1.121637314893136e-06 0.1162898833629492 1.121637405604425e-06 0.1154830714735263 1.121637481187504e-06 0.1148135241260771 \
1.121637546915428e-06 0.1142333070693714 1.121637606975201e-06 0.1137047561823949 1.121637676580917e-06 0.1130943456353956 1.121637742999968e-06 0.1125141752866663 \
1.121637822411231e-06 0.1118230150855203 1.121637912674161e-06 0.1110406875128299 1.121637981718461e-06 0.1104447270551955 1.12163805627358e-06 0.1098035355921305 \
1.121638144757501e-06 0.1090456469739195 1.121638223865648e-06 0.1083709350695736 1.121638293734029e-06 0.1077773127978274 1.121638374743399e-06 0.1070920034756896 \
1.121638430948213e-06 0.106618206733547 1.121638493607492e-06 0.1060916009495399 1.121638558754098e-06 0.105545887371837 1.121638630089726e-06 0.1049504956797945 \
1.121638750386101e-06 0.1039516085561449 1.121638801939674e-06 0.103525508500865 1.121638857088742e-06 0.1030709598036589 1.121638947785926e-06 0.1023262935955709 \
1.121639030175778e-06 0.1016530765296615 1.121639125755586e-06 0.1008759670630478 1.121639232965152e-06 0.1000092507657299 1.121639336624558e-06 0.09917656019160864 \
1.121639422832161e-06 0.09848810438956324 1.121639509074386e-06 0.09780303991321163 1.121639588615461e-06 0.09717448010577609 1.121639668628333e-06 0.09654538840876434 \
1.121639759916661e-06 0.09583163072761708 1.121639841662079e-06 0.09519620281310773 1.121639930588917e-06 0.09450872319168514 1.121640020366224e-06 0.09381864801001834 \
1.121640097328872e-06 0.09323024625953365 1.121640187653689e-06 0.0925435244861572 1.121640251462415e-06 0.09206084550525626 1.121640323925983e-06 0.09151514907748673 \
1.121640388054635e-06 0.09103438864950099 1.121640466302011e-06 0.09045054736970405 1.121640566003292e-06 0.08971110930136832 1.121640640056444e-06 0.08916512281998501 \
1.121640726664979e-06 0.08852997392441805 1.121640872964685e-06 0.08746544055362569 1.121640983676948e-06 0.08666684197409438 1.121641093986626e-06 0.08587717033461532 \
1.121641236182269e-06 0.08486839672072237 1.12164137623472e-06 0.08388450488753585 1.121641518880534e-06 0.08289222299161547 1.121641667651249e-06 0.08186778387581196 \
1.121641804363935e-06 0.08093569403044946 1.121641946484565e-06 0.07997640434545976 1.121642081061545e-06 0.07907728405019222 1.121642221281423e-06 0.07814997945867638 \
1.121642369028229e-06 0.07718353387841098 1.121642518982415e-06 0.07621348085094087 1.121642683698247e-06 0.07516037195605636 1.121642847284363e-06 0.07412732798506308 \
1.121643021932716e-06 0.07303837372665309 1.121643208986408e-06 0.07188781219077654 1.121643418972926e-06 0.0706159374129187 1.121643637046174e-06 0.06931715807027321 \
1.121643870366327e-06 0.06795188046253516 1.121644124845882e-06 0.0664909822812602 1.12164441780254e-06 0.06484528303377844 1.121644719953089e-06 0.06318745987130532 \
1.121645057674792e-06 0.06138078634948794 1.121645452783393e-06 0.05932807220464856 1.121645820234636e-06 0.05747953410674719 1.121646237842402e-06 0.05544691527644593 \
1.121646582838376e-06 0.0538196438399016 1.121646933380665e-06 0.05221302159193914 1.121647248341029e-06 0.0508087490907442 1.121647547582395e-06 0.049508488261462 \
1.121647846948248e-06 0.04824029756235761 1.121648122190958e-06 0.04710512226277328 1.121648405654525e-06 0.04596497870754415 1.121648667254946e-06 0.04493681260994405 \
1.121648944707071e-06 0.04387103439794762 1.121649220766506e-06 0.04283531238677037 1.121649529036243e-06 0.04170718945545093 1.121649751468863e-06 0.0409114719535993 \
1.121650039009947e-06 0.03990505631995635 1.12165027524288e-06 0.0390969788355163 1.121650593704555e-06 0.03803800466874574 1.121650844115589e-06 0.03722710566490722 \
1.121651167100391e-06 0.03620720400565681 1.121651425436406e-06 0.03541203096995557 1.121651715410285e-06 0.03454066075983582 1.121651945205103e-06 0.0338658635512188 \
1.121652230100444e-06 0.03304787219836024 1.121652469846563e-06 0.03237513696606491 1.121652710481132e-06 0.03171392889024889 1.121652949599619e-06 0.03107212555077287 \
1.12165318553853e-06 0.03045460689686571 1.121653416367391e-06 0.02986254663395104 1.121653631393919e-06 0.02932175456294728 1.12165403355976e-06 0.0283374222946415 \
1.12165423211788e-06 0.02786401170979088 1.121654605819066e-06 0.02699470773596776 1.121654792632261e-06 0.02657042318767052 1.121655138633508e-06 0.02580176906824739 \
1.121655260576946e-06 0.02553595448027303 1.121655643429963e-06 0.02472011952872977 1.121655803864149e-06 0.02438657631284594 1.121656246865303e-06 0.02348572425118655 \
1.121656417479345e-06 0.02314627247835563 1.121656738055941e-06 0.02251902970747987 1.121656938340868e-06 0.0221336684630111 1.121657385278801e-06 0.02128811173678137 \
1.121657513222917e-06 0.02104854104185888 1.121658001100276e-06 0.02014826272243131 1.121658136077553e-06 0.01990454278080647 1.121658618329071e-06 0.0190640092473091 \
1.121658780655186e-06 0.01879235028057063 1.121659267049527e-06 0.01801148170254873 1.121659430077186e-06 0.01776103207540622 1.121660110298877e-06 0.01676849304257711 \
1.121660249382614e-06 0.01657541006259178 1.121660981877148e-06 0.01560782569993242 1.12166114077078e-06 0.01540693214221847 1.121661923851867e-06 0.01445869962397344 \
1.121662069644422e-06 0.01428952172302696 1.121662920425781e-06 0.01334248985256295 1.121663031529053e-06 0.01322388191882306 1.121663964823417e-06 0.0122699293983148 \
1.121664098661466e-06 0.01213902814618388 1.121665057199482e-06 0.01123495036716388 1.121665178316551e-06 0.01112486091825863 1.121666300400349e-06 0.01017270671243764 \
1.121666405901602e-06 0.01008921053061839 1.121667734976014e-06 0.009112307258623473 1.121667855180288e-06 0.009029744095492466 1.121669403542048e-06 0.008036808760534916 \
1.121669484329818e-06 0.007986285493236449 1.121671055209352e-06 0.007024564730313319 1.121671122625551e-06 0.006986095570813155 1.12167304339223e-06 0.006001386377072119 \
1.121673230194113e-06 0.005914747648762168 1.121675545608061e-06 0.0049318160947762 1.121675945134907e-06 0.004777795182599986 1.121678508944408e-06 0.003889929704329555 \
1.121679007815328e-06 0.003736330440833864 1.121682637539317e-06 0.002784984367379526 1.121683188233292e-06 0.002663729254427667 1.121688586673671e-06 0.001711392372544448 \
1.121688899941243e-06 0.001662511220227468 1.121693892233791e-06 0.0006970413096974805 1.121694076252826e-06 0.0006571176749162138 1.12434255539561e-06 -0.0002691198397987355 \
1.124342711454572e-06 -0.0004551674219448388 1.124343259438427e-06 -0.001322174727784445 1.12434337237642e-06 -0.001539785040943742 1.12434380163135e-06 -0.002474302920374066 \
1.124343907888515e-06 -0.002730173903076456 1.124344190690667e-06 -0.003454402452283872 1.12434430428521e-06 -0.003760966378165151 1.124344642839789e-06 -0.004705104513819927 \
1.12434475526375e-06 -0.005021586953003071 1.124345083541651e-06 -0.005887841248467669 1.124345191080172e-06 -0.006130875888161453 1.124346071006203e-06 -0.005789627805322099 \
1.12434624621225e-06 -0.004910736584223327 1.124346363043013e-06 -0.004127745010746014 1.124346489910137e-06 -0.00309221842859156 1.124346591442863e-06 -0.002125750314016509 \
1.124346712864133e-06 -0.0008095618968406578 1.124346803029046e-06 0.0002767910803854594 1.124346900212696e-06 0.001550247908954045 1.12434699828696e-06 0.002938803805678211 \
1.124347165508045e-06 0.005530627736217106 1.124347387813323e-06 0.009378371294171852 1.124347573551714e-06 0.01290572951649239 1.124347797633049e-06 0.01747895571448658 \
1.124347957277782e-06 0.02091945933227325 1.124348121767111e-06 0.02459614091902196 1.124348271591569e-06 0.0280452875125503 1.124348420991461e-06 0.03156498790849799 \
1.124348570522767e-06 0.03515592969144176 1.124348724602661e-06 0.03891669635189081 1.124348886786809e-06 0.0429309674228065 1.124349053210035e-06 0.0470989728378523 \
1.124349229143508e-06 0.05154884981278444 1.124349410271779e-06 0.05616867911875007 1.124349602402705e-06 0.06110225049351239 1.124349810098117e-06 0.0664648391313285 \
1.124350032018198e-06 0.07222051812179281 1.12435026721968e-06 0.07834079218654426 1.124350519405989e-06 0.08491829088081257 1.124350795545224e-06 0.09213111703448683 \
1.124351096666701e-06 0.1000001933597138 1.124351428586562e-06 0.1086702418150647 1.12435180590533e-06 0.1185147411083515 1.124352204195387e-06 0.1288888856248832 \
1.124352673503707e-06 0.1410822143415975 1.124353219529231e-06 0.1552200475789812 1.124353854489538e-06 0.1715918832733369 1.124354553890129e-06 0.1895291194622146 \
1.124355372129055e-06 0.2103807608661494 1.124356277823022e-06 0.2332840710921665 1.124357067334088e-06 0.253091928008631 1.124357771092906e-06 0.2706124241987875 \
1.124358388943719e-06 0.2858796548825839 1.124358954567131e-06 0.2997575097153312 1.124359476302405e-06 0.3124620269501652 1.124359974086121e-06 0.3244932238414255 \
1.124360457724081e-06 0.3360954048923613 1.124360914598215e-06 0.3469667650518959 1.124361387439109e-06 0.3581213589834248 1.124361827052466e-06 0.3684065070151987 \
1.124362314929562e-06 0.379719432411247 1.124362845729985e-06 0.3919028193132517 1.124363343625359e-06 0.4032143644097119 1.124363775002613e-06 0.41292177789323 \
1.124364261889801e-06 0.4237731225600331 1.124364761989243e-06 0.4348012155672935 1.124365106609934e-06 0.4423321287141763 1.124365460003778e-06 0.4500000647748709 \
1.124365887773617e-06 0.4592134948422093 1.124366279634688e-06 0.4675816212925634 1.124366579929045e-06 0.4739471552041949 1.124366921860125e-06 0.4811428413521782 \
1.12436726519457e-06 0.4883132334011818 1.124367525955058e-06 0.4937215836208605 1.124367768011588e-06 0.4987106167174703 1.124368034010056e-06 0.5041617362307154 \
1.124368293498239e-06 0.5094435946950286 1.12436848341454e-06 0.5132872703533161 1.124368698649141e-06 0.5176241792560061 1.1243688371999e-06 0.5204025546691405 \
1.124368982080679e-06 0.5232962183003332 1.124369195494746e-06 0.5275364624051522 1.12436939751936e-06 0.5315382148201082 1.124369590248024e-06 0.5353370730264509 \
1.124369775503404e-06 0.5389735557287745 1.124369952500928e-06 0.5424323215059959 1.124370261764263e-06 0.5484573594957171 1.124370522912311e-06 0.5535233414883098 \
1.124370824731481e-06 0.5593562770234363 1.124371080160122e-06 0.5642781701956761 1.124371372515619e-06 0.5698968483756405 1.124371631969813e-06 0.5748654731717864 \
1.12437190208979e-06 0.5800301911327002 1.124372144100348e-06 0.5846380733684551 1.124372401610146e-06 0.5895273573494454 1.124372628054483e-06 0.5938057549890672 \
1.124372864942966e-06 0.5982619499065401 1.124373074987873e-06 0.6021962733001386 1.124373287918585e-06 0.6061670177072124 1.124373541397282e-06 0.6108668889270118 \
1.124373744692931e-06 0.6146150465592417 1.124373936381114e-06 0.6181346807088086 1.124374125007478e-06 0.6215812235468744 1.124374312325416e-06 0.6249823889551316 \
1.124374517937406e-06 0.6286953279350977 1.124374767760625e-06 0.6331759959753138 1.124374971572403e-06 0.6368063379741715 1.124375179211121e-06 0.6404826298163093 \
1.124375371862737e-06 0.6438748386876914 1.124375616474811e-06 0.6481531432733096 1.124375864373314e-06 0.6524620620600715 1.124376044208219e-06 0.6555644139995785 \
1.124376234982255e-06 0.6588391718544121 1.124376388158437e-06 0.6614554104590837 1.124376559827147e-06 0.6643705886591137 1.124376710293968e-06 0.6669108747194671 \
1.124376846897971e-06 0.6692010654183506 1.124376996338372e-06 0.6716954191563786 1.124377124072523e-06 0.6738189269502312 1.12437726394477e-06 0.6761323074508511 \
1.124377388021905e-06 0.6781756764962316 1.12437751938327e-06 0.6803315871556701 1.124377643554731e-06 0.6823627547057004 1.124377781331592e-06 0.6846081866267727 \
1.124377901575812e-06 0.6865586181592046 1.124378043628417e-06 0.6888545186016138 1.124378143856122e-06 0.6904668682779994 1.124378265160113e-06 0.6924123325129877 \
1.124378356135388e-06 0.6938641504265992 1.124378453518671e-06 0.695411869780077 1.124378550601538e-06 0.6969507228893711 1.124378639884158e-06 0.6983595753378042 \
1.124378737855943e-06 0.699898781449533 1.12437886813103e-06 0.7019319515314388 1.124379021543255e-06 0.7043083163565919 1.124379157109067e-06 0.7063909659299702 \
1.124379301449562e-06 0.708591461371511 1.124379427320445e-06 0.710496752775434 1.124379552347831e-06 0.712376488910674 1.124379666630191e-06 0.7140841686551523 \
1.124379777613335e-06 0.7157331888171029 1.124379877308405e-06 0.7172065512867005 1.124380014352622e-06 0.7192196995505324 1.124380133379835e-06 0.7209572005600779 \
1.124380253677943e-06 0.7227029412191364 1.124380380176863e-06 0.7245276185835638 1.124380504108467e-06 0.7263044524160376 1.1243806283948e-06 0.7280754330070212 \
1.124380754759953e-06 0.7298652243312684 1.124380884571695e-06 0.7316925631262517 1.124381008410214e-06 0.7334254795816325 1.124381141191101e-06 0.735272086289578 \
1.124381242042306e-06 0.7366670415914529 1.124381355233975e-06 0.738224777043618 1.124381442019956e-06 0.7394137384482823 1.124381558645253e-06 0.7410021813026957 \
1.12438164793451e-06 0.7422110784210975 1.124381759111394e-06 0.7437075443329063 1.124381888370158e-06 0.7454347509364776 1.124382002229194e-06 0.7469455276109591 \
1.124382106633406e-06 0.74832188588007 1.124382231000437e-06 0.7499498655229884 1.124382378240616e-06 0.7518616907275563 1.124382498520907e-06 0.753411006437983 \
1.124382614425446e-06 0.7548933175676444 1.12438275450129e-06 0.7566706674475765 1.12438289711296e-06 0.7584645678799224 1.124383015067203e-06 0.7599365027959469 \
1.124383141883712e-06 0.7615071445339606 1.124383282766856e-06 0.7632375905494565 1.124383402560354e-06 0.7646969139886852 1.124383547519211e-06 0.7664484133613445 \
1.124383669077996e-06 0.7679052725436226 1.12438378811749e-06 0.7693214142140735 1.124383909748853e-06 0.7707575700077021 1.124384037717832e-06 0.772256936813787 \
1.124384146933014e-06 0.7735272422640712 1.124384271823892e-06 0.774969549136603 1.124384378939953e-06 0.7761978171588899 1.124384512193147e-06 0.7777146071439789 \
1.124384639296593e-06 0.7791497354387434 1.124384761047568e-06 0.7805132846941326 1.124384877632151e-06 0.7818078758210534 1.124384983459753e-06 0.7829735233300771 \
1.124385122825895e-06 0.7844949153190801 1.124385271897694e-06 0.786105286864636 1.124385419626362e-06 0.7876841235632186 1.12438553893224e-06 0.7889471147195867 \
1.124385672939052e-06 0.7903527806482344 1.124385793365227e-06 0.791604423795974 1.124385934910404e-06 0.7930616786923709 1.124386082336417e-06 0.7945638089648995 \
1.124386206810925e-06 0.7958198087139573 1.124386325854918e-06 0.7970105506108808 1.124386437445202e-06 0.7981174590942314 1.124386542674491e-06 0.7991530841216606 \
1.124386638185594e-06 0.8000862307887144 1.124386774247548e-06 0.8014036057482816 1.124386891123682e-06 0.8025237700417888 1.124387010277354e-06 0.8036549841722296 \
1.124387132589548e-06 0.8048050501807249 1.124387255861622e-06 0.8059526272620129 1.124387382358398e-06 0.8071184350969989 1.124387507861062e-06 0.8082633544790385 \
1.124387638586967e-06 0.8094437311890262 1.124387764154939e-06 0.8105658358439867 1.124387893209804e-06 0.8117072367686948 1.124387999065961e-06 0.8126345588578442 \
1.124388100234837e-06 0.8135133322873783 1.124388194854657e-06 0.8143286754242188 1.12438831913574e-06 0.8153900871385379 1.124388408847426e-06 0.816149614585347 \
1.12438850788495e-06 0.8169816577628611 1.124388645662827e-06 0.8181280288377792 1.124388780198677e-06 0.81923501721715 1.124388888604944e-06 0.8201180631035904 \
1.124389038518447e-06 0.8213254631869725 1.124389189097025e-06 0.8225223201378843 1.12438931459218e-06 0.8235077122548546 1.124389458438707e-06 0.8246238332260477 \
1.124389583021971e-06 0.8255790649890803 1.124389731875191e-06 0.8267066458678887 1.124389868023775e-06 0.827725029289517 1.124389993047602e-06 0.8286494160599757 \
1.124390110754582e-06 0.8295103773055483 1.12439025639358e-06 0.8305630309532103 1.124390422774875e-06 0.8317484146982921 1.124390553358565e-06 0.8326660250626342 \
1.124390726880675e-06 0.8338683097812621 1.124390895002578e-06 0.8350147136930499 1.12439106486518e-06 0.8361549927788252 1.124391245766883e-06 0.8373497079260466 \
1.124391388876165e-06 0.8382806519784776 1.124391502965127e-06 0.839013953006387 1.124391633127604e-06 0.8398410866028793 1.124391734972734e-06 0.8404811280669765 \
1.12439185179894e-06 0.8412075886390841 1.12439198869038e-06 0.8420483852080155 1.124392186497604e-06 0.843243620449199 1.124392378122751e-06 0.8443797466267589 \
1.124392587554618e-06 0.8455974227529048 1.1243927695013e-06 0.8466352798309468 1.124392966630154e-06 0.8477391449715804 1.124393139971014e-06 0.8486924050423899 \
1.124393322979321e-06 0.8496814535024207 1.124393494142356e-06 0.8505903669473519 1.124393668779451e-06 0.851501688465695 1.124393844039281e-06 0.8524001683007644 \
1.12439402018973e-06 0.8532872510191711 1.12439421047003e-06 0.8542278331088334 1.12439440106916e-06 0.8551519386507073 1.124394601692395e-06 0.8561055033533737 \
1.12439479430095e-06 0.8570028516027762 1.124395004981641e-06 0.8579644845832216 1.124395233083109e-06 0.8589827023971403 1.124395498871092e-06 0.860139640227508 \
1.124395797483852e-06 0.8614018215255795 1.124396073772491e-06 0.8625348754565382 1.12439635800901e-06 0.8636666213345715 1.12439663221378e-06 0.8647267940813509 \
1.124396904448638e-06 0.8657495569722869 1.12439717465278e-06 0.8667361702337206 1.124397431808391e-06 0.867649441901348 1.124397704388604e-06 0.8685908808535525 \
1.12439798037489e-06 0.8695169452638583 1.124398250477721e-06 0.870397355937691 1.124398550334798e-06 0.8713451925332844 1.124398921362456e-06 0.8724761722512941 \
1.124399216299767e-06 0.8733433185969293 1.124399470589206e-06 0.8740690226522811 1.12439976884599e-06 0.874895168896023 1.124400042455427e-06 0.8756299040683481 \
1.124400278583914e-06 0.8762466977562872 1.124400518929827e-06 0.8768585021646264 1.124400741263492e-06 0.8774104263690854 1.124400935269169e-06 0.8778812671168952 \
1.124401264991885e-06 0.8786590883967833 1.124401420165319e-06 0.8790156160651978 1.124401737941389e-06 0.8797272612331356 1.124401916803032e-06 0.8801171459162566 \
1.124402259264861e-06 0.8808425821290963 1.124402443393021e-06 0.881221400612852 1.124402918270754e-06 0.8821634994206867 1.124403085666965e-06 0.8824839765989225 \
1.124403551508905e-06 0.8833452998114757 1.124403732330958e-06 0.8836679564577563 1.124404226369383e-06 0.8845176198113115 1.124404367718007e-06 0.8847523712107549 \
1.124404974052072e-06 0.8857188576377059 1.124405126121396e-06 0.8859512996759633 1.124405772809558e-06 0.8868983431897121 1.12440590110417e-06 0.8870786909355212 \
1.124406549221232e-06 0.8879538337624689 1.124406679020295e-06 0.8881220828502663 1.124407457223772e-06 0.8890807033877333 1.124407572278734e-06 0.8892148977954012 \
1.124408427940207e-06 0.8901543051721961 1.124408573301076e-06 0.8903040038307473 1.124409559057127e-06 0.8912446482480114 1.124409780162496e-06 0.8914382978987679 \
1.124410925289423e-06 0.8923659558950503 1.124411056506439e-06 0.8924678262926897 1.124412397715013e-06 0.8934599079028542 1.124412549114272e-06 0.8935646301988298 \
1.124414030551995e-06 0.8944937559627255 1.124414269431373e-06 0.8946275407274444 1.124416038746979e-06 0.8955013787854181 1.124416427898191e-06 0.8956696032899972 \
1.124418821561142e-06 0.8965547188539188 1.12441929727014e-06 0.8967039926079825 1.12442336043021e-06 0.8977020505850396 1.124423851854269e-06 0.8977948037134476 \
1.124432168453822e-06 0.898787348739254 1.12443308835295e-06 0.8988506593152591 1.12457657358348e-06 0.8998476076348748 1.124577692016456e-06 0.8998537475785264 \
1.124782783635956e-06 0.898985773748599 1.124783010725457e-06 0.8988224379910277 1.124784620332255e-06 0.8978282360369357 1.124784797740799e-06 0.8977338482811539 \
1.1248017048891e-06 0.8987315468430059 1.124801814328198e-06 0.8987460089186867 1.124817595049444e-06 0.8997418097871094 1.124817891375339e-06 0.8997476966799167 \
1.125301325027745e-06 0.9007060148833608 1.125301454078085e-06 0.9008313386292994 1.12530210422793e-06 0.9016292186224167 1.125302293723661e-06 0.9019133038041363 \
1.12530279694564e-06 0.9027675859898705 1.125302932418299e-06 0.9030208676018907 1.125303332877016e-06 0.9038195223753869 1.125303464814953e-06 0.9040958310886574 \
1.125303866030017e-06 0.9049509627747726 1.125303964290194e-06 0.9051582028152527 1.125304430164004e-06 0.9060587574877488 1.125304591662727e-06 0.9063060456044927 \
1.12530573567525e-06 0.9055153668657776 1.125305880654596e-06 0.9049059606760256 1.125306059207353e-06 0.9039396653125833 1.125306239402631e-06 0.9027054491383806 \
1.125306382093561e-06 0.9015369228101149 1.125306499253165e-06 0.9004524619440171 1.125306588234525e-06 0.8995505656965809 1.125306679878178e-06 0.8985529714258781 \
1.12530681299011e-06 0.8969831049011855 1.125306906711193e-06 0.8957895978311226 1.125306997850002e-06 0.8945634483845346 1.125307111142313e-06 0.8929516940777753 \
1.125307214251226e-06 0.8913998138690341 1.125307310518406e-06 0.8898830246517148 1.125307429655523e-06 0.8879200664089764 1.125307598240772e-06 0.8849885378698126 \
1.125307760012273e-06 0.8820195265790133 1.125307953231332e-06 0.8782956415026882 1.125308138794443e-06 0.8745571577041361 1.125308349060748e-06 0.8701566079887386 \
1.125308531309789e-06 0.8662213066841463 1.125308716173183e-06 0.8621339172744639 1.12530888885833e-06 0.8582419637438897 1.125309074966403e-06 0.8539816046497358 \
1.125309252782491e-06 0.849858603441091 1.125309433499072e-06 0.8456251963850057 1.125309598637331e-06 0.8417258760277182 1.125309763911433e-06 0.837798995916667 \
1.125309927159096e-06 0.8339004324287677 1.12531008574937e-06 0.8300982805770993 1.125310262673771e-06 0.8258418712800655 1.125310459187584e-06 0.8211009660847696 \
1.125310626744125e-06 0.8170498602679914 1.125310793484544e-06 0.8130123908857781 1.125310967908062e-06 0.8087844286215062 1.125311137277684e-06 0.8046757316210446 \
1.125311305476779e-06 0.8005936994537799 1.125311494325046e-06 0.7960093488074458 1.125311685140882e-06 0.7913773844868103 1.125311893523092e-06 0.7863203192056716 \
1.125312119942597e-06 0.7808277108969495 1.125312309142794e-06 0.7762391340290878 1.125312519289483e-06 0.7711455503222944 1.125312668057988e-06 0.7675418410361046 \
1.125312799050976e-06 0.7643705172588006 1.125312936616212e-06 0.7610417440783073 1.125313042367441e-06 0.7584842184275663 1.125313177141075e-06 0.7552262509102785 \
1.125313288973801e-06 0.7525244432456109 1.125313418408964e-06 0.7493992292091655 1.125313573597688e-06 0.7456545577979357 1.125313685233441e-06 0.7429626190147979 \
1.125313844808055e-06 0.7391166470929011 1.125314020129688e-06 0.7348935218456193 1.125314232505151e-06 0.7297828120356423 1.125314425387679e-06 0.7251458607116523 \
1.125314582088971e-06 0.7213823872711312 1.125314768763662e-06 0.716903961299824 1.125314957650011e-06 0.7123775767926828 1.125315148534203e-06 0.70780884692282 \
1.125315335282138e-06 0.7033444557767304 1.125315518366954e-06 0.698972331957095 1.125315655685935e-06 0.6956951921588121 1.125315808928893e-06 0.6920418367118417 \
1.125316004057543e-06 0.6873949992893974 1.125316161351872e-06 0.6836535194673684 1.125316320746467e-06 0.6798660670227984 1.12531651649026e-06 0.6752219404489795 \
1.125316708689394e-06 0.6706682621108646 1.125316943641022e-06 0.6651105611269369 1.12531713111727e-06 0.6606839627962382 1.125317368354404e-06 0.6550894036851447 \
1.125317557534366e-06 0.6506361170423679 1.125317738150179e-06 0.6463915264929231 1.125317901844741e-06 0.6425504277539856 1.12531804639615e-06 0.6391628119244788 \
1.12531818686792e-06 0.6358764726647652 1.125318313968707e-06 0.6329064225879303 1.125318446276184e-06 0.6298198307262635 1.12531857286323e-06 0.626870110582017 \
1.125318703443498e-06 0.62383130535404 1.125318832712897e-06 0.6208285625908692 1.125318971819793e-06 0.6176004736356133 1.125319120330103e-06 0.6141606483517721 \
1.125319309878658e-06 0.6097777958748198 1.125319455581914e-06 0.6064170107178907 1.125319690632478e-06 0.601007464699683 1.125319873631749e-06 0.5968099615921 \
1.125320097973423e-06 0.5916778694808832 1.125320269146672e-06 0.5877753019413697 1.125320401480491e-06 0.5847634284691802 1.12532053327703e-06 0.5817721407249107 \
1.125320639820933e-06 0.5793579518205488 1.125320735711292e-06 0.5771868999037388 1.125320828211542e-06 0.5750974572268882 1.125320920638905e-06 0.5730134868920421 \
1.125320993067212e-06 0.5713818265150021 1.125321048796317e-06 0.5701269325864891 1.125321109905405e-06 0.5687522410723198 1.12532120667008e-06 0.5665806864277688 \
1.125321268161595e-06 0.5652027770813386 1.125321327214216e-06 0.5638802801505602 1.125321402840882e-06 0.5621878686488651 1.12532146986366e-06 0.5606896577364279 \
1.12532154346077e-06 0.5590483558003441 1.125321611066772e-06 0.5575429304381756 1.125321727135829e-06 0.5549610936632026 1.125321827342234e-06 0.5527359403974305 \
1.125321939349424e-06 0.5502565947066531 1.125322033841475e-06 0.5481686943853854 1.125322154996173e-06 0.5454955387196141 1.125322255183939e-06 0.5432910220514219 \
1.125322371174451e-06 0.5407443765731218 1.125322478878289e-06 0.5383833065966291 1.125322588456977e-06 0.5359861028148916 1.125322700578421e-06 0.5335400310751951 \
1.125322827515605e-06 0.5307765704644959 1.125322949665123e-06 0.5281221248815906 1.125323089426038e-06 0.525095489155881 1.125323226564154e-06 0.522132778766487 \
1.125323376529244e-06 0.5189020692106626 1.125323535302247e-06 0.5154923220538846 1.125323709327904e-06 0.511765695450105 1.125323896158028e-06 0.5077823379664483 \
1.125324101125994e-06 0.5034264211640872 1.125324323834942e-06 0.4987133299464507 1.125324576739139e-06 0.4933874474923696 1.125324811693046e-06 0.4884604410272814 \
1.125325107961308e-06 0.4822828691822955 1.125325397751266e-06 0.4762763831984252 1.125325704087085e-06 0.4699660956099861 1.125326016405612e-06 0.4635767846525711 \
1.125326354971068e-06 0.4566963260653934 1.125326678082485e-06 0.4501741115777416 1.125327016477788e-06 0.4433881855507311 1.125327340309053e-06 0.4369378830387565 \
1.125327664703474e-06 0.4305204627449936 1.12532800763776e-06 0.4237851826852676 1.125328346918578e-06 0.4171698123421442 1.125328686393212e-06 0.4105997181257849 \
1.125329129505058e-06 0.4020958655332711 1.125329491573227e-06 0.3952155038183801 1.125329812124964e-06 0.3891775711374149 1.125330199059535e-06 0.3819561902961204 \
1.125330526929795e-06 0.3758957719299574 1.125330812088852e-06 0.3706704968427373 1.125331130457646e-06 0.3648820026298218 1.125331413288573e-06 0.3597820188690578 \
1.125331641977337e-06 0.3556924369094372 1.125331859870142e-06 0.3518226517641353 1.125332055119486e-06 0.3483769517668343 1.125332262027586e-06 0.344751588202948 \
1.125332476824342e-06 0.3410137651016431 1.125332729050892e-06 0.3366564674340092 1.125332971046205e-06 0.3325077909124976 1.125333201898484e-06 0.3285822460490526 \
1.125333416746675e-06 0.3249550452085373 1.125333637103364e-06 0.3212604562488142 1.125333838674264e-06 0.3179050685021769 1.125334041758211e-06 0.3145531374773136 \
1.125334239655597e-06 0.3113121771742085 1.125334426754836e-06 0.3082694484595072 1.125334620655179e-06 0.3051385396431291 1.125334825703514e-06 0.3018527636900292 \
1.125335005938266e-06 0.2989872106339772 1.125335241836277e-06 0.2952669081535775 1.125335443123828e-06 0.2921198200609627 1.125335644514631e-06 0.2889965001417216 \
1.125335869163794e-06 0.2855437159941698 1.125336034543768e-06 0.2830223598911593 1.125336212348106e-06 0.280330186126118 1.125336396004319e-06 0.277570343839212 \
1.125336581246076e-06 0.2748090658167894 1.125336759391454e-06 0.2721781298892599 1.125336932983517e-06 0.2696316866093095 1.12533709334837e-06 0.267306655456324 \
1.125337214459553e-06 0.2655585721882695 1.125337367654341e-06 0.2633570345323199 1.125337494985789e-06 0.2615475749425888 1.125337598313628e-06 0.2600830587034867 \
1.125337715638424e-06 0.2584225376281647 1.125337833445381e-06 0.2567591557214636 1.125337957409147e-06 0.2550199666844239 1.125338074393314e-06 0.2533821414201824 \
1.125338205189442e-06 0.2515535495016885 1.125338322399552e-06 0.2499173892700276 1.125338475652677e-06 0.2477853623028658 1.125338611183197e-06 0.2459029165157107 \
1.125338742864406e-06 0.244074199323236 1.125338899457317e-06 0.2419017673596028 1.125339024653874e-06 0.2401755227310949 1.125339160371501e-06 0.2383060149301216 \
1.125339292798663e-06 0.2364844144139329 1.125339412772324e-06 0.2348355337769661 1.125339575820161e-06 0.232606585912384 1.125339714627252e-06 0.230713852557009 \
1.125339853100972e-06 0.2288300961780371 1.125339958645721e-06 0.2273962817971701 1.125340087007401e-06 0.2256537837490921 1.125340191135024e-06 0.2242444877898851 \
1.125340291651026e-06 0.222886569499566 1.125340366695402e-06 0.2218745444235658 1.125340444028458e-06 0.2208349692306942 1.125340518791637e-06 0.2198305887827458 \
1.125340596755314e-06 0.218785487158918 1.125340651621824e-06 0.2180503923904892 1.1253407081186e-06 0.2172938400168352 1.125340751572119e-06 0.2167123195211523 \
1.125340791613165e-06 0.2161767335077376 1.125340830852113e-06 0.2156521099473339 1.12534087172635e-06 0.2151058606261434 1.12534092587884e-06 0.2143825797409383 \
1.125340964295972e-06 0.2138698309421548 1.125341003584678e-06 0.2133480458229882 1.125341065121386e-06 0.2125332203444249 1.125341127098916e-06 0.2117131287842428 \
1.125341183575664e-06 0.2109664019951111 1.125341248207255e-06 0.2101124842966758 1.125341343715876e-06 0.2088522205996687 1.125341431031608e-06 0.207701294711168 \
1.125341527641208e-06 0.2064291756790013 1.125341624870762e-06 0.2051510266126755 1.125341725717823e-06 0.2038307158897115 1.125341826317594e-06 0.2025192706911573 \
1.125341922808891e-06 0.2012627769767186 1.125342024991065e-06 0.1999338657614989 1.125342128630721e-06 0.1985898465970496 1.125342238404734e-06 0.1971698847140261 \
1.12534234757976e-06 0.1957617939809042 1.125342467677852e-06 0.1942174441246506 1.125342577697376e-06 0.1928086337505992 1.125342685809285e-06 0.1914295694688549 \
1.125342808837984e-06 0.1898652723262108 1.125342898948554e-06 0.1887234630454603 1.125343006314044e-06 0.1873671680421656 1.125343083125353e-06 0.1864004060894758 \
1.125343166570621e-06 0.1853535952511875 1.125343256102432e-06 0.1842338297700716 1.125343340667899e-06 0.1831790839553313 1.125343420384039e-06 0.1821880912968773 \
1.125343521709242e-06 0.1809331989518758 1.125343630056471e-06 0.1795959386230563 1.125343726532169e-06 0.1784102562612937 1.125343851909986e-06 0.1768766438339704 \
1.125343984693456e-06 0.1752616821119887 1.125344102464279e-06 0.1738362801839788 1.125344248115856e-06 0.1720835746408261 1.125344358713008e-06 0.1707596463148658 \
1.125344500843447e-06 0.1690680578777541 1.12534461655307e-06 0.1676985735146403 1.125344722027083e-06 0.166456424915798 1.125344816543742e-06 0.1653485352650968 \
1.125344912181115e-06 0.1642320043563913 1.125345009252959e-06 0.1631032360400927 1.125345108304212e-06 0.161956192050434 1.125345202227769e-06 0.1608730077890209 \
1.125345287503444e-06 0.1598934595213354 1.125345387883236e-06 0.1587475631033795 1.125345472186073e-06 0.1577906478848196 1.125345574585582e-06 0.1566342854655733 \
1.125345651979844e-06 0.1557646215197878 1.125345744324758e-06 0.154731814591042 1.12534581457623e-06 0.1539498814072817 1.125345910750659e-06 0.1528844393027091 \
1.125345987575322e-06 0.152038051282755 1.125346066345474e-06 0.1511758489440315 1.125346140238395e-06 0.150370438825067 1.125346207936138e-06 0.1496353997608715 \
1.125346304000026e-06 0.1485973848112393 1.125346373572453e-06 0.1478489919002561 1.125346457461625e-06 0.1469503328160803 1.125346518593461e-06 0.146298213254472 \
1.125346590861543e-06 0.1455309799806117 1.125346663300106e-06 0.1447677488542132 1.125346744281147e-06 0.1439178685120187 1.125346810355616e-06 0.1432275520600639 \
1.125346887756114e-06 0.1424219220725307 1.125346977131571e-06 0.1414956876531561 1.125347047992216e-06 0.1407644282175171 1.125347146879283e-06 0.1397487730030469 \
1.125347224198192e-06 0.1389620820751095 1.125347306243419e-06 0.1381330876879582 1.12534739435453e-06 0.1372467208126059 1.125347461981677e-06 0.1365690714953818 \
1.125347542278859e-06 0.1357674830239305 1.125347617062888e-06 0.1350239185327315 1.125347685064065e-06 0.1343502586094245 1.125347731746974e-06 0.1338891847862563 \
1.125347820998567e-06 0.1330118383700247 1.125347859221617e-06 0.1326395291833771 1.125347928213527e-06 0.1319690872918072 1.125347980961596e-06 0.1314578750898332 \
1.125348063954378e-06 0.1306559489775353 1.125348104132829e-06 0.1302688434457458 1.125348196650203e-06 0.1293805059784019 1.12534823536857e-06 0.1290098403727171 \
1.125348309129285e-06 0.1283055160094505 1.125348370757287e-06 0.1277188748199021 1.125348442784976e-06 0.1270353589407805 1.125348510952008e-06 0.1263909833196726 \
1.125348585574169e-06 0.1256908956540175 1.125348667426635e-06 0.1249253613889138 1.125348750880797e-06 0.124147338931438 1.125348823832511e-06 0.1234692772477456 \
1.125348896559441e-06 0.122795332839617 1.125348956549436e-06 0.1222410931008323 1.125349042917447e-06 0.121445549533078 1.125349103886165e-06 0.1208856452315438 \
1.125349162271955e-06 0.1203507897957366 1.12534922790662e-06 0.119751336354628 1.125349287260861e-06 0.1192111367930785 1.125349355292642e-06 0.1185941868697126 \
1.125349452587012e-06 0.11771710490035 1.125349531078992e-06 0.1170124163111649 1.125349621315123e-06 0.1162055395685231 1.125349717161808e-06 0.1153523005684616 \
1.125349792119505e-06 0.1146878351828532 1.125349896478921e-06 0.1137670532163148 1.125349983267518e-06 0.1130053589403202 1.125350092924934e-06 0.1120476726212376 \
1.125350174478997e-06 0.1113387926087848 1.125350270092629e-06 0.1105114393564785 1.125350346804822e-06 0.10985058581598 1.125350441723287e-06 0.1090364400125625 \
1.125350517546392e-06 0.1083889268999046 1.125350595246049e-06 0.1077282965354292 1.1253506775775e-06 0.1070311517075373 1.125350737142764e-06 0.1065286079538068 \
1.125350800900501e-06 0.1059924133642201 1.125350861995109e-06 0.1054803128126646 1.125350957858847e-06 0.1046801683739134 1.125351002721942e-06 0.1043071445723913 \
1.125351085962687e-06 0.1036173314376927 1.125351135082509e-06 0.1032117000904133 1.125351244131271e-06 0.1023149933518279 1.125351288967354e-06 0.1019479364619093 \
1.125351379228585e-06 0.1012117400678687 1.125351420105203e-06 0.1008795969612472 1.125351490563617e-06 0.1003088525914566 1.125351576851038e-06 0.09961307626065434 \
1.125351668628597e-06 0.09887705578174606 1.12535173815669e-06 0.09832225024344161 1.125351816683849e-06 0.09769854072774181 1.125351907412525e-06 0.09698178745350861 \
1.125351983228664e-06 0.09638605854785212 1.125352065241407e-06 0.09574500473888557 1.125352146994443e-06 0.09510943278387665 1.125352237502267e-06 0.09440967388330095 \
1.125352327061564e-06 0.09372126988887708 1.125352412671398e-06 0.09306698857649189 1.125352505450896e-06 0.09236212353634379 1.125352586338857e-06 0.0917510971760913 \
1.125352687467827e-06 0.09099177263830999 1.125352767961352e-06 0.09039108594384238 1.125352852204218e-06 0.08976589684797046 1.125352926049265e-06 0.08922077348043934 \
1.125353002898743e-06 0.08865632925481931 1.125353091039112e-06 0.08801255002475737 1.125353171103482e-06 0.08743108261130086 1.125353264139672e-06 0.08675939571108145 \
1.125353382140385e-06 0.08591369538214398 1.125353524513612e-06 0.08490278100234279 1.125353668761962e-06 0.08388867104764453 1.125353811089671e-06 0.08289807427203813 \
1.125353960667415e-06 0.08186746790234835 1.125354096981161e-06 0.08093761126893445 1.125354239101592e-06 0.0799778356000513 1.12535437365502e-06 0.07907840240745091 \
1.12535451400773e-06 0.07814980287393705 1.125354661689802e-06 0.0771833418413561 1.125354811805299e-06 0.07621180464723754 1.125354976525776e-06 0.07515824360926991 \
1.125355140155128e-06 0.07412455432658185 1.125355314933688e-06 0.07303438636984133 1.125355502186304e-06 0.07188220095900363 1.125355712231308e-06 0.07060976590783831 \
1.125355930441531e-06 0.06930979572898451 1.12535616389862e-06 0.06794333957253913 1.125356418744638e-06 0.06648001693367038 1.125356711839195e-06 0.06483321328442151 \
1.125357014178957e-06 0.06317411115207273 1.125357328765833e-06 0.06148945259513613 1.125357725026527e-06 0.05942677493938087 1.125358058743672e-06 0.05774249301432461 \
1.125358466054501e-06 0.05574994498853819 1.12535879393926e-06 0.05419380357502902 1.125359150629899e-06 0.05254809000207299 1.12535946386806e-06 0.05114243792209583 \
1.125359766835193e-06 0.04981740498512215 1.125360064375718e-06 0.04854875663330436 1.125360343155274e-06 0.04739109061078805 1.125360626155169e-06 0.04624570307560639 \
1.125360887895477e-06 0.04521055793698023 1.12536116713437e-06 0.04413130357485813 1.12536143924029e-06 0.0431040186124033 1.125361746607047e-06 0.04197194005652995 \
1.125361968409948e-06 0.04117329707315532 1.125362274870428e-06 0.04009446155587663 1.125362501059881e-06 0.03931650950691581 1.125362739977207e-06 0.03851359500741255 \
1.125362964401039e-06 0.03777663690506906 1.12536316666332e-06 0.03712468825868943 1.125363367705949e-06 0.03648814235703791 1.125363719479983e-06 0.03540095449820539 \
1.125363969725821e-06 0.03464776841732944 1.125364216044101e-06 0.03392252499723709 1.125364497376965e-06 0.03311308780599518 1.12536474046795e-06 0.03242954897046491 \
1.125364975941701e-06 0.03178112583711486 1.125365217601206e-06 0.03113119522156456 1.125365454483484e-06 0.03050988948014832 1.125365685016041e-06 0.02991733361391674 \
1.125365898984569e-06 0.02937801894285819 1.125366104927116e-06 0.02886851641492237 1.125366497651603e-06 0.02792196059063811 1.125366685729283e-06 0.02747992420741849 \
1.125367061168249e-06 0.02661861215736662 1.125367236042477e-06 0.02622659266649364 1.125367659365491e-06 0.02530049759795254 1.125367780614875e-06 0.02504150687334681 \
1.125368221176528e-06 0.02412433837770948 1.125368363674648e-06 0.02383402682615681 1.125368695728157e-06 0.02316883068419595 1.125368878693682e-06 0.02280879143785283 \
1.125369267997886e-06 0.02205689891561978 1.125369436343594e-06 0.02173705378531499 1.125369908457993e-06 0.02085107653961301 1.125370048202727e-06 0.0205916297664938 \
1.125370543782805e-06 0.01969297428531048 1.125370671008237e-06 0.01946923320191776 1.125371238917342e-06 0.01851512288677271 1.12537140317129e-06 0.0182513999453204 \
1.125372013043029e-06 0.0173209960017622 1.125372172728257e-06 0.01708922829277545 1.125372699639798e-06 0.01635462467776483 1.125372904157091e-06 0.01608193551804103 \
1.125373627634478e-06 0.01515939662837778 1.12537379307661e-06 0.01495683325581705 1.125374539636356e-06 0.01408081084911163 1.125374672939569e-06 0.01393008075245666 \
1.125375533124155e-06 0.01299799962960837 1.12537566920557e-06 0.01285670227674402 1.125376609799459e-06 0.01192267652923807 1.125376773572533e-06 0.01176632439256516 \
1.125377774751465e-06 0.01084959205883911 1.125377912229187e-06 0.01072929995296418 1.125379082926798e-06 0.009787962024485789 1.125379175323166e-06 0.009718668544398181 \
1.125380593399014e-06 0.008725931027897449 1.125380680375162e-06 0.00866912727384293 1.125382221370793e-06 0.00770199130002063 1.125382330686807e-06 0.007633428668288294 \
1.125383973934629e-06 0.006673746291950173 1.125384106791908e-06 0.006603544020797993 1.125386201172206e-06 0.005605323336654431 1.125386409576941e-06 0.00551468736035817 \
1.125388763913366e-06 0.004577307911602986 1.125389237472123e-06 0.004407121484391641 1.125392122908979e-06 0.003492041675788492 1.125392652573326e-06 0.00334538389506189 \
1.125396860800552e-06 0.00237996320858989 1.125397374234803e-06 0.002283557532494709 1.125403133485495e-06 0.001325291758975802 1.125403368066713e-06 0.001279502680325907 \
1.125418035894088e-06 0.0002809017338477542 1.12541814896418e-06 0.0002788534805396912 1.12805516904393e-06 -0.0006849217749926401 1.128055335205606e-06 -0.0009443270389602415 \
1.128055814074993e-06 -0.001850320037528519 1.12805590679462e-06 -0.002050462221988249 1.128056272019697e-06 -0.002913187630468476 1.128056363676814e-06 -0.00314709230904735 \
1.128056729783165e-06 -0.004133001189868674 1.128056839930291e-06 -0.004442309109773816 1.128057150668543e-06 -0.005311341427314526 1.128057252407188e-06 -0.005583925258601597 \
1.128057616111313e-06 -0.00638370916272213 1.128057780957636e-06 -0.006585924750287024 1.128058360754957e-06 -0.005792290386912202 1.128058535589415e-06 -0.004916934050781314 \
1.128058652279015e-06 -0.00413641027497409 1.128058778708708e-06 -0.00310656561120747 1.128058880730911e-06 -0.002137079422087956 1.128059000577393e-06 -0.0008406209844352954 \
1.128059091214629e-06 0.0002489246187367611 1.128059189634679e-06 0.001536790859923857 1.128059289358324e-06 0.002948496343048522 1.128059456842332e-06 0.005545701385567424 \
1.128059675420934e-06 0.009327395936412004 1.128059861491256e-06 0.0128572688386996 1.128060082873864e-06 0.01737012273305725 1.128060243533997e-06 0.02082840415615294 \
1.128060406999647e-06 0.02447866954313523 1.128060557635164e-06 0.02794359528291388 1.128060706690917e-06 0.03145289236167962 1.128060856153671e-06 0.03504014479003619 \
1.128061010184684e-06 0.03879791952579481 1.128061172300943e-06 0.04280891157365373 1.128061338330408e-06 0.04696567134311741 1.128061514283228e-06 0.05141478668696391 \
1.128061694953866e-06 0.05602187592747932 1.128061886774812e-06 0.06094655248807559 1.128062093880316e-06 0.06629309753158302 1.128062315452046e-06 0.07203901748582854 \
1.128062550186215e-06 0.07814662931008168 1.128062801725783e-06 0.08470684589377442 1.128063077167849e-06 0.09190125212984442 1.128063377363668e-06 0.09974607960254324 \
1.128063708295878e-06 0.108390578238945 1.128064083962612e-06 0.1181923833971668 1.12806448154548e-06 0.1285487285136021 1.128064948370082e-06 0.1406786766767902 \
1.128065491362617e-06 0.1547396794802719 1.12806612478764e-06 0.1710742296429572 1.128066820727691e-06 0.1889259607126788 1.1280676362848e-06 0.2097135943149445 \
1.128068546312904e-06 0.2327316641523666 1.128069339569124e-06 0.2526372689279454 1.1280700450442e-06 0.2702038474981599 1.128070663988468e-06 0.2855008995781749 \
1.128071231094408e-06 0.2994177966724069 1.128071754174414e-06 0.3121574438576628 1.128072253153207e-06 0.3242197130846058 1.128072737193214e-06 0.3358335658028451 \
1.128073192420047e-06 0.3466679577370423 1.128073666932009e-06 0.3578644504627745 1.128074106840717e-06 0.368158604789619 1.128074592685345e-06 0.3794271463718566 \
1.128075124288118e-06 0.3916316501999784 1.128075626951417e-06 0.4030538969706937 1.12807605602367e-06 0.4127111343288326 1.128076547040338e-06 0.4236561147984291 \
1.128077048470419e-06 0.434714731975362 1.128077395015009e-06 0.442288187401736 1.128077750424386e-06 0.4500000616404133 1.128078177652114e-06 0.4592019891792938 \
1.128078569851637e-06 0.4675774400278049 1.128078870233395e-06 0.4739448723400065 1.128079212045155e-06 0.4811381049525967 1.128079555484969e-06 0.4883107756756314 \
1.128079816220095e-06 0.4937186470393492 1.128080058250048e-06 0.4987071765458648 1.128080324195292e-06 0.5041573145298286 1.128080581464587e-06 0.509394255416739 \
1.12808077158369e-06 0.5132422368582924 1.128080985109851e-06 0.5175451019736222 1.128081124800157e-06 0.5203466115392713 1.128081271000449e-06 0.5232668091041763 \
1.12808148498835e-06 0.5275186200231483 1.12808169300461e-06 0.5316389396023125 1.128081885465879e-06 0.5354321131715788 1.12808207058211e-06 0.5390651926504321 \
1.128082244955557e-06 0.5424725330931349 1.128082549497633e-06 0.5484058192982523 1.128082810056515e-06 0.5534602958276967 1.128083111487545e-06 0.5592859190791987 \
1.128083365805138e-06 0.5641865993769294 1.128083658661328e-06 0.5698153316805189 1.12808391787448e-06 0.5747800306938655 1.128084188950812e-06 0.579963273174682 \
1.128084430794571e-06 0.5845680738798381 1.128084688299729e-06 0.5894577538325241 1.128084915043605e-06 0.5937419314630586 1.128085152044424e-06 0.5982006324572362 \
1.128085362230986e-06 0.6021379329905048 1.12808557499152e-06 0.6061060319396779 1.128085827870286e-06 0.6107954169450593 1.128086031533554e-06 0.6145509252949414 \
1.128086222250936e-06 0.6180531102377972 1.128086409587374e-06 0.6214768531423983 1.128086598465652e-06 0.6249070011644339 1.128086806665447e-06 0.6286671070650327 \
1.128087050997562e-06 0.6330499453121026 1.128087250564095e-06 0.6366057789565548 1.128087454709836e-06 0.6402215701419991 1.12808763934909e-06 0.643474671963314 \
1.128087908884781e-06 0.6481901084955864 1.128088136591637e-06 0.652149230294136 1.128088324263375e-06 0.6553888277830079 1.12808850516352e-06 0.6584949378977958 \
1.128088664704602e-06 0.661221510907812 1.128088835167002e-06 0.6641177016088209 1.128088986918443e-06 0.6666817235716488 1.128089124561455e-06 0.6689905419339194 \
1.128089273556319e-06 0.6714784915997724 1.128089401298182e-06 0.6736028790357499 1.128089544284695e-06 0.675968899142866 1.128089666067751e-06 0.6779749688503388 \
1.128089802351161e-06 0.6802121872853304 1.128089922180063e-06 0.682172759947357 1.128090068775623e-06 0.6845626218370968 1.128090187248565e-06 0.6864845934661837 \
1.128090283181927e-06 0.6880368302455475 1.128090375701511e-06 0.6895284278106264 1.128090480762022e-06 0.6912169000724893 1.128090578843908e-06 0.6927871490736753 \
1.128090715959225e-06 0.6949707622226827 1.128090835157868e-06 0.6968607547931925 1.128090945097838e-06 0.6985951241089645 1.128091082597081e-06 0.7007503743809057 \
1.128091214026983e-06 0.7027960765825516 1.128091346256499e-06 0.7048392108129343 1.128091459433897e-06 0.7065756917706891 1.128091613866752e-06 0.708927873976708 \
1.128091744646745e-06 0.7109048231498766 1.128091867315455e-06 0.7127465601965561 1.128091973583711e-06 0.7143329262278221 1.128092095963735e-06 0.7161490373358268 \
1.128092197817232e-06 0.7176517022913665 1.128092331955131e-06 0.7196190116794019 1.128092452648172e-06 0.7213783352064487 1.128092571789971e-06 0.7231049829175343 \
1.128092696807985e-06 0.7249059312823601 1.128092826647791e-06 0.7267645120560844 1.128092946459962e-06 0.7284691779696002 1.128093075453213e-06 0.730293808329565 \
1.128093207560277e-06 0.7321507998840678 1.128093325866095e-06 0.7338038328985433 1.128093469126786e-06 0.7357927618453034 1.128093571581473e-06 0.7372070005703254 \
1.128093667788359e-06 0.7385290937783453 1.12809377280598e-06 0.7399656334130889 1.128093883577511e-06 0.7414708009413548 1.128093985256052e-06 0.7428439364018735 \
1.128094088217507e-06 0.7442258341871242 1.12809420514366e-06 0.7457850038572696 1.128094333903937e-06 0.747489965072781 1.128094435062908e-06 0.7488201182152049 \
1.128094583931952e-06 0.7507626302114226 1.128094731611489e-06 0.75267249971878 1.128094850976855e-06 0.7542038164026367 1.1280949974607e-06 0.7560679527984652 \
1.12809512063619e-06 0.7576223900169708 1.128095261439865e-06 0.7593848990234215 1.128095398032531e-06 0.7610800595258669 1.128095520190381e-06 0.7625841275516777 \
1.128095632846779e-06 0.7639610711610054 1.12809577457292e-06 0.7656796138775311 1.12809590073942e-06 0.767196844592689 1.128096016156724e-06 0.768574452686535 \
1.128096146464904e-06 0.7701179991486644 1.128096262177572e-06 0.7714782821591826 1.12809638500186e-06 0.7729116492687436 1.128096502846128e-06 0.7742769236963016 \
1.128096608476119e-06 0.7754922619072108 1.128096723849553e-06 0.7768108638983861 1.128096829112716e-06 0.7780056027231214 1.128096940062529e-06 0.7792565499870431 \
1.128097026467031e-06 0.7802246528436213 1.128097130500851e-06 0.7813823422463088 1.128097244396594e-06 0.7826398494046257 1.128097347430013e-06 0.7837684443710583 \
1.128097455512714e-06 0.7849432998269023 1.12809756376437e-06 0.7861107422109641 1.128097699181616e-06 0.7875582910536544 1.128097811855724e-06 0.7887521292973186 \
1.128097936279784e-06 0.7900592323105087 1.128098054252648e-06 0.7912877959129118 1.128098198720603e-06 0.7927781272271259 1.128098316389742e-06 0.7939806363584788 \
1.128098452269582e-06 0.7953567374150946 1.128098587013954e-06 0.7967081403609936 1.128098698084933e-06 0.7978123285366109 1.128098797974273e-06 0.7987978371087655 \
1.128098899654231e-06 0.7997937268659365 1.128099032867897e-06 0.8010867894381996 1.128099151240716e-06 0.8022243628210853 1.12809927278179e-06 0.8033812848148773 \
1.128099392145442e-06 0.8045065422543012 1.128099513276819e-06 0.80563739819571 1.128099644976236e-06 0.8068544426691319 1.128099767984513e-06 0.8079795872959963 \
1.12809989582812e-06 0.8091371804586788 1.12810002673464e-06 0.8103101881504271 1.128100150327798e-06 0.8114062915203997 1.128100257500303e-06 0.8123479140825919 \
1.128100364929502e-06 0.8132835730547656 1.128100447598621e-06 0.8139979974227743 1.12810056531038e-06 0.8150069815425507 1.128100655915986e-06 0.8157770472204025 \
1.128100786569431e-06 0.8168774959419571 1.128100930959301e-06 0.8180800468042847 1.128101064133715e-06 0.8191766687328477 1.128101174025107e-06 0.8200725423139092 \
1.128101317623992e-06 0.8212302325252553 1.128101471014683e-06 0.8224508494407716 1.128101599092908e-06 0.8234574467428303 1.128101738880276e-06 0.8245431382086058 \
1.128101865129839e-06 0.8255122018650548 1.128102019728392e-06 0.8266841987320058 1.128102151939368e-06 0.8276738265999063 1.128102278166151e-06 0.8286078934539939 \
1.128102395913874e-06 0.8294698388787296 1.128102544986668e-06 0.8305480062617677 1.12810271231822e-06 0.8317406852496945 1.128102845539497e-06 0.8326770812274722 \
1.12810301832082e-06 0.8338744310092966 1.128103186826194e-06 0.8350236380668206 1.128103356205492e-06 0.8361608866600232 1.128103537840761e-06 0.8373606451951652 \
1.128103680174083e-06 0.8382866867625347 1.128103794011069e-06 0.8390185116470331 1.128103925192579e-06 0.8398522525089582 1.128104026724794e-06 0.8404903982372576 \
1.128104143009054e-06 0.8412135669902132 1.128104277643808e-06 0.8420406924792603 1.128104474666644e-06 0.8432316292878405 1.128104664772186e-06 0.8443592803112207 \
1.128104874895499e-06 0.8455816023960827 1.128105055213604e-06 0.8466107566581813 1.128105252676705e-06 0.8477171937062282 1.12810542674582e-06 0.8486750118570332 \
1.12810560906524e-06 0.8496608982186138 1.128105780480376e-06 0.8505716849290491 1.128105954593653e-06 0.8514808063694008 1.128106130324621e-06 0.8523822271368225 \
1.128106306436321e-06 0.8532696099472232 1.128106496054173e-06 0.8542074684498208 1.12810668683567e-06 0.8551330189126392 1.128106888431747e-06 0.8560917259710515 \
1.128107081166005e-06 0.856990088884472 1.128107290037826e-06 0.8579439907476532 1.128107520740263e-06 0.8589743400177088 1.128107785183227e-06 0.8601259267840322 \
1.128108084005915e-06 0.8613896125360476 1.128108363960216e-06 0.8625380186322354 1.128108648086082e-06 0.8636694076724545 1.128108922855057e-06 0.8647317823994775 \
1.128109194712217e-06 0.8657531067718063 1.128109465089334e-06 0.8667403371654003 1.128109722167856e-06 0.8676533221001362 1.128109994792687e-06 0.868594905839151 \
1.128110270759836e-06 0.8695208838709013 1.128110540864093e-06 0.8704012674911344 1.128110840740104e-06 0.8713491368600049 1.128111211801162e-06 0.8724801680184872 \
1.12811150674079e-06 0.8733472453740196 1.128111761036548e-06 0.8740729094291386 1.128112059297474e-06 0.8748989982677786 1.128112332904015e-06 0.8756336613858092 \
1.128112569029958e-06 0.876250392688866 1.128112809374056e-06 0.8768621356511911 1.128113031706182e-06 0.8774140071409635 1.128113225712247e-06 0.8778848105679672 \
1.128113555434997e-06 0.8786625669521169 1.128113710608526e-06 0.8790190643519731 1.128114028387606e-06 0.879730644938159 1.128114207248864e-06 0.8801204696806418 \
1.128114549710761e-06 0.8808457867651537 1.128114733837363e-06 0.8812245477320809 1.128115208711942e-06 0.8821665346129511 1.128115376108352e-06 0.8824869809105039 \
1.128115841951854e-06 0.883348261932613 1.128116022773548e-06 0.8836708855253055 1.128116516812651e-06 0.8845204537290557 1.128116658162059e-06 0.8847551796839913 \
1.128117264500122e-06 0.8857215808967022 1.128117416569336e-06 0.8859539944113424 1.128118063256356e-06 0.8869009218298172 1.128118191551239e-06 0.8870812460539503 \
1.128118839667745e-06 0.8879562712787433 1.128118969467641e-06 0.8881245027440973 1.12811974767834e-06 0.8890830197250962 1.128119862725472e-06 0.8892171882189283 \
1.128120718396314e-06 0.8901564861234483 1.128120863744077e-06 0.8903061494816453 1.128121849499649e-06 0.8912466483555094 1.128122070607711e-06 0.8914402669210102 \
1.128123215727714e-06 0.892367747196105 1.128123346939159e-06 0.8924695935232408 1.128124688211624e-06 0.8934615053489913 1.1281248396029e-06 0.8935661991834861 \
1.12812632105512e-06 0.8944951400107031 1.128126559934816e-06 0.8946288932334222 1.128128329356654e-06 0.895502508848118 1.128128718477945e-06 0.895670668133377 \
1.128131112210654e-06 0.8965556062201232 1.128131587750592e-06 0.8967047758494365 1.128135650819818e-06 0.8977025964496719 1.128136142295654e-06 0.8977953148389237 \
1.128144458892796e-06 0.8987880790885289 1.128145378794248e-06 0.8988514070442593 1.128299242370168e-06 0.8998485708192639 1.128302885496457e-06 0.8998628537402877 \
1.128529614276672e-06 0.8989664306490068 1.128529844616583e-06 0.8988008565867064 1.128531459536881e-06 0.897804750401333 1.128531637269166e-06 0.8977103535805105 \
1.128548403669271e-06 0.8986978311584225 1.128548539768403e-06 0.8987160394686986 1.128563710608672e-06 0.8997133888183054 1.128563987713508e-06 0.899719468756186 \
1.129048028906422e-06 0.9005852143835333 1.129048202241039e-06 0.9007408621809421 1.129048862730638e-06 0.9015135064485434 1.12904902879582e-06 0.9017527716291757 \
1.129049555130528e-06 0.9026184054967997 1.129049746244448e-06 0.9029704910143604 1.1290501104655e-06 0.9036902342402512 1.129050289664921e-06 0.9040628043424317 \
1.129050651551594e-06 0.9048333795345931 1.129050846661164e-06 0.9052442844328937 1.129051379059525e-06 0.9062266394381637 1.129051561413164e-06 0.9064623886473868 \
1.129052553393556e-06 0.905594670761786 1.129052714934123e-06 0.9049318860608667 1.129052882926576e-06 0.9040378649110347 1.129053042758061e-06 0.9029782421366458 \
1.129053180254799e-06 0.9018984154159868 1.129053313162111e-06 0.9007052793196499 1.129053439587579e-06 0.8994328447569792 1.129053546986819e-06 0.8982475863895881 \
1.129053651483477e-06 0.8970047013543965 1.129053765533147e-06 0.8955451342423859 1.129053855502734e-06 0.8943225684615312 1.129053960321373e-06 0.8928208677113324 \
1.129054049769612e-06 0.891473284704788 1.129054132145393e-06 0.8901820884368528 1.129054223238393e-06 0.8887006634027688 1.129054360574471e-06 0.8863657732814155 \
1.129054459067403e-06 0.8846195012157601 1.129054571141153e-06 0.8825649218508906 1.129054702024186e-06 0.880080778639088 1.129054838495216e-06 0.8774018563482072 \
1.129054991949379e-06 0.8742910281085086 1.129055151043747e-06 0.8709679977889497 1.129055315327649e-06 0.867445283300377 1.129055471995751e-06 0.8640104344288071 \
1.129055624086531e-06 0.860615744772629 1.129055777800206e-06 0.857132398554192 1.129055937362381e-06 0.853469801378647 1.129056092451083e-06 0.8498714074018293 \
1.129056266130401e-06 0.8458039138600054 1.129056429161269e-06 0.8419559450883216 1.129056590803684e-06 0.8381170660338335 1.129056753450421e-06 0.8342344554797501 \
1.129056914868927e-06 0.8303657475978833 1.129057083463406e-06 0.8263109424305363 1.129057266356504e-06 0.8219002364007665 1.129057434185218e-06 0.8178440888239877 \
1.129057602471033e-06 0.8137703061148112 1.129057773299085e-06 0.8096302849976138 1.129057945473642e-06 0.8054541271740473 1.129058113235561e-06 0.8013830614994394 \
1.129058296865018e-06 0.7969255463994016 1.129058468271496e-06 0.7927646873948894 1.129058653714802e-06 0.7882638003278283 1.129058820385454e-06 0.7842196820467244 \
1.129058989271585e-06 0.7801233737411432 1.129059173427882e-06 0.7756572567105651 1.129059368037911e-06 0.7709405333854473 1.129059515293241e-06 0.7673736106648734 \
1.129059641923832e-06 0.7643079795643375 1.129059783780644e-06 0.7608754495129878 1.129059888184422e-06 0.7583505812556488 1.129060020577074e-06 0.7551502542766809 \
1.129060130161271e-06 0.7525028097975122 1.129060263325923e-06 0.7492875979647342 1.129060419507685e-06 0.7455190770546114 1.129060532737112e-06 0.7427887939149777 \
1.129060695258476e-06 0.7388718945951063 1.129060867439292e-06 0.7347246296492568 1.129061063444044e-06 0.7300078517193382 1.129061227834023e-06 0.7260553905833119 \
1.129061380230704e-06 0.7223944885043934 1.129061543905858e-06 0.718466402706526 1.129061711831558e-06 0.7144406657912139 1.129061891671936e-06 0.7101336212543717 \
1.129062067965886e-06 0.7059164985576465 1.129062239040521e-06 0.7018286413152719 1.129062407358697e-06 0.6978099102718778 1.129062560624829e-06 0.6941537154717222 \
1.129062722508398e-06 0.6902960245155986 1.129062901459938e-06 0.6860364417190952 1.12906303567149e-06 0.6828448068431195 1.129063139177788e-06 0.6803854168085423 \
1.1290632384622e-06 0.6780286039046017 1.129063339916677e-06 0.6756220912380299 1.129063432373276e-06 0.6734303711245889 1.129063516962075e-06 0.6714267031582685 \
1.129063610539411e-06 0.6692114082407524 1.129063727081631e-06 0.6664546942583044 1.129063836559192e-06 0.6638675763958631 1.129063949672203e-06 0.6611971533414394 \
1.12906407279097e-06 0.6582923426231613 1.129064197017283e-06 0.6553636581362478 1.129064367777427e-06 0.6513432847262797 1.129064526226014e-06 0.6476181700514572 \
1.129064698513837e-06 0.6435738126612673 1.129064844491904e-06 0.6401512360303271 1.12906498628512e-06 0.6368325564797357 1.129065117883574e-06 0.6337564355289309 \
1.129065248046859e-06 0.630718219665797 1.1290653735718e-06 0.6277924818644975 1.129065505354707e-06 0.6247239543970449 1.129065635278203e-06 0.6217046839485236 \
1.129065771586778e-06 0.6185408917806742 1.129065916200345e-06 0.615188962872713 1.129066075692536e-06 0.611499189008522 1.129066249152652e-06 0.6074939486938447 \
1.129066420159954e-06 0.6035554342946753 1.129066651528522e-06 0.5982402936372396 1.129066894990528e-06 0.5926661367297537 1.129067069111016e-06 0.5886942528256315 \
1.129067215383093e-06 0.5853638081576373 1.129067349755312e-06 0.58231230528805 1.129067466850207e-06 0.5796585826255305 1.129067562614553e-06 0.5774900935424465 \
1.129067661461096e-06 0.5752566196463251 1.129067745438414e-06 0.5733628024369305 1.129067823052464e-06 0.571614165956722 1.129067884377937e-06 0.5702331258704825 \
1.129067949058576e-06 0.5687779664863769 1.129068030366711e-06 0.5669528575016536 1.129068080436707e-06 0.5658306078972934 1.129068129757269e-06 0.5647256890740617 \
1.129068191677069e-06 0.5633393552914843 1.129068239508894e-06 0.5622690492396486 1.129068290013679e-06 0.5611395143522533 1.129068350075717e-06 0.559799205480933 \
1.129068409358512e-06 0.5584782058326896 1.129068484415226e-06 0.5568072508052372 1.129068554097883e-06 0.5552574373576753 1.129068639686449e-06 0.5533559356568912 \
1.129068726753821e-06 0.5514265885063823 1.129068810416341e-06 0.5495763264044081 1.129068896561366e-06 0.5476734676082877 1.129068992265987e-06 0.5455621222678217 \
1.129069096550939e-06 0.5432673229847179 1.129069211218113e-06 0.5407497407899529 1.129069319936574e-06 0.5383664115638558 1.129069429508814e-06 0.5359693749054023 \
1.129069541813574e-06 0.5335193270114367 1.129069668589195e-06 0.530759392645703 1.129069790866427e-06 0.5281021910076299 1.129069930952405e-06 0.5250685463469849 \
1.129070067969763e-06 0.5221084647952599 1.129070218271135e-06 0.5188705764247719 1.129070377166376e-06 0.5154582091324615 1.129070551500259e-06 0.5117250894133971 \
1.129070738517481e-06 0.5077378180012799 1.129070943835486e-06 0.5033745272871338 1.129071155677679e-06 0.498891131759938 1.129071408479721e-06 0.4935662239713107 \
1.12907161056737e-06 0.4893264048484654 1.129071845160675e-06 0.4844277613141263 1.129072081275272e-06 0.4795194943790256 1.129072334451769e-06 0.474283574581623 \
1.129072644981732e-06 0.4679020429045382 1.12907286303971e-06 0.4634451779596257 1.129073036485344e-06 0.4599153839204358 1.129073212977781e-06 0.4563351808422506 \
1.129073492459578e-06 0.4506930409909046 1.129073724703484e-06 0.4460279192631412 1.129074011797073e-06 0.44029020239849 1.129074229643181e-06 0.435960758243863 \
1.129074439695769e-06 0.4318042429497612 1.129074640893605e-06 0.4278406951573778 1.129074823313766e-06 0.4242617300271556 1.129074997208751e-06 0.4208637793449936 \
1.129075162072867e-06 0.4176529694331993 1.12907532082684e-06 0.4145718140694327 1.129075487073787e-06 0.4113577680628809 1.129075635718993e-06 0.4084923702366076 \
1.129075788087249e-06 0.4055658186126443 1.129075930150432e-06 0.4028468403491589 1.12907609952631e-06 0.3996150665462138 1.12907621990823e-06 0.3973276483660343 \
1.129076329881494e-06 0.3952449223617059 1.129076444806895e-06 0.3930732253581283 1.129076597048475e-06 0.3902080468194818 1.12907670926954e-06 0.3881039677199808 \
1.129076816462041e-06 0.386098874836553 1.12907696899029e-06 0.383254723448244 1.129077097137419e-06 0.380874963946598 1.129077219985412e-06 0.3786015923730871 \
1.129077399083788e-06 0.375299968600122 1.12907754816842e-06 0.3725653942578417 1.129077715875808e-06 0.3695018296724824 1.129077871273442e-06 0.3666748141177644 \
1.129077995440288e-06 0.3644243980538668 1.129078109332156e-06 0.3623666676050148 1.129078230775526e-06 0.3601804966264144 1.129078410927293e-06 0.3569532670533712 \
1.129078577415114e-06 0.3539878629329621 1.129078767834223e-06 0.3506138544217919 1.129078959590819e-06 0.3472380408565978 1.129079142640212e-06 0.344035729794033 \
1.129079291612277e-06 0.3414435189591631 1.129079411552182e-06 0.3393660536257183 1.129079534213665e-06 0.3372483242714233 1.129079657244151e-06 0.3351324902755385 \
1.129079802148562e-06 0.3326515017845288 1.129079905461337e-06 0.3308907757076019 1.129079999190846e-06 0.3292979229163631 1.129080089851148e-06 0.3277620998585528 \
1.129080200972602e-06 0.3258853746017661 1.129080308145579e-06 0.3240820510456246 1.12908040642023e-06 0.3224338250618513 1.129080518824776e-06 0.3205545940512134 \
1.129080682764676e-06 0.3178277446588927 1.129080844402555e-06 0.3151576097143818 1.129080992189301e-06 0.3127316247504084 1.129081154434516e-06 0.3100832165115083 \
1.129081314465073e-06 0.3074868334344322 1.129081466728372e-06 0.3050304870660137 1.129081620100242e-06 0.3025703731928215 1.129081778808771e-06 0.3000411640344692 \
1.1290819432579e-06 0.297437246442505 1.129082110484976e-06 0.2948063590562646 1.129082263596513e-06 0.292412731930112 1.12908244669444e-06 0.2895700146919417 \
1.129082637002178e-06 0.2866380344427262 1.129082785905236e-06 0.2843603072871506 1.129082959842542e-06 0.2817165165722222 1.12908313671993e-06 0.2790484233348025 \
1.129083284317148e-06 0.2768363681311815 1.129083473948849e-06 0.2740172295061162 1.129083623950767e-06 0.2718052906662373 1.129083761060958e-06 0.2697943906627059 \
1.129083902591401e-06 0.2677397479842996 1.12908401605027e-06 0.2661005451260196 1.129084152340596e-06 0.2641384584581135 1.129084282417217e-06 0.2622807416655737 \
1.12908440067147e-06 0.2606037730704709 1.129084518527066e-06 0.2589348966568543 1.129084649420877e-06 0.2570853888657079 1.129084789659635e-06 0.2551145527343576 \
1.129084905154221e-06 0.2534976852533538 1.129085034005598e-06 0.2516957519945816 1.12908514915158e-06 0.2500885525459272 1.129085302462547e-06 0.2479513765689386 \
1.129085440316308e-06 0.2460367343642474 1.12908557977796e-06 0.2441002375748529 1.129085735245815e-06 0.2419427021952501 1.12908586002843e-06 0.2402176526454788 \
1.129085999893338e-06 0.2382916534360561 1.129086128595514e-06 0.2365220787132559 1.129086249554366e-06 0.234860341242685 1.129086366599666e-06 0.2332541163798121 \
1.12908649260073e-06 0.2315368940272461 1.129086589320323e-06 0.2302195772445239 1.129086681409196e-06 0.2289683907689286 1.129086795826667e-06 0.2274152998827935 \
1.129086894197314e-06 0.2260807986508055 1.129087011344108e-06 0.2244933520241092 1.129087114435226e-06 0.2231010305483718 1.129087219949952e-06 0.2216798666278746 \
1.129087300868012e-06 0.2205933880575098 1.129087374539197e-06 0.2196046443759679 1.129087417268434e-06 0.2190314036349237 1.129087460398579e-06 0.2184540235451489 \
1.129087511196061e-06 0.217774515685755 1.129087548370939e-06 0.217277430841393 1.129087589041954e-06 0.2167338127731004 1.129087631833756e-06 0.2161620985357572 \
1.129087668244897e-06 0.2156758299561118 1.129087710169888e-06 0.2151161507306283 1.129087764712098e-06 0.2143884526296278 1.129087803170857e-06 0.2138756926875936 \
1.129087842797626e-06 0.2133496230586122 1.129087904630128e-06 0.212531488259555 1.129087966356579e-06 0.2117156525305126 1.129088022493854e-06 0.210974237875411 \
1.129088086149084e-06 0.210134110843225 1.129088180240117e-06 0.2088936328424611 1.129088267048376e-06 0.2077505933124353 1.12908836100502e-06 0.2065146061917991 \
1.129088459047254e-06 0.2052266823513323 1.129088560634619e-06 0.2038976009052371 1.129088661543568e-06 0.2025832113009377 1.129088758279377e-06 0.2013244528083448 \
1.129088860404348e-06 0.1999972806373927 1.129088963735905e-06 0.1986583046056677 1.129089073618507e-06 0.1972379690671278 1.129089182560765e-06 0.1958337611883887 \
1.129089302395885e-06 0.1942937175364915 1.129089412679751e-06 0.1928822800638286 1.129089520558496e-06 0.191507108810815 1.129089646621254e-06 0.1899051957406391 \
1.129089736488961e-06 0.1887671190866151 1.1290898469673e-06 0.1873723090993208 1.129089924500249e-06 0.1863971337376019 1.129090008823992e-06 0.1853400660204312 \
1.12909009641205e-06 0.1842452710069853 1.129090184204644e-06 0.18315095174413 1.129090265924515e-06 0.1821357652581398 1.129090363486193e-06 0.1809282658474054 \
1.129090470197344e-06 0.1796118512064394 1.129090570679026e-06 0.178377576484793 1.129090694850238e-06 0.1768595317522179 1.129090828741761e-06 0.1752320886156309 \
1.129090947653953e-06 0.1737937102924047 1.129091098054147e-06 0.1719851742607024 1.12909120888924e-06 0.1706594030660365 1.129091348655982e-06 0.168997130456427 \
1.12909146718129e-06 0.1675953052211382 1.129091572608521e-06 0.1663548750207849 1.12909166731838e-06 0.1652455210322802 1.129091760628154e-06 0.1641568522804657 \
1.12909186153427e-06 0.1629842804551663 1.129091956952102e-06 0.1618800504313296 1.129092054143025e-06 0.1607598891027116 1.129092135704507e-06 0.1598237474547246 \
1.129092241020952e-06 0.1586229753023833 1.129092324500659e-06 0.1576763029943549 1.12909242602995e-06 0.1565306813704828 1.129092503260486e-06 0.1556635090415242 \
1.129092594132523e-06 0.154647919213242 1.129092663483833e-06 0.1538765336840219 1.129092748067884e-06 0.1529397840535594 1.129092822461091e-06 0.1521208717489242 \
1.129092901831293e-06 0.151251902275755 1.129092976418964e-06 0.1504388356812226 1.129093045640521e-06 0.1496871728711989 1.129093140321328e-06 0.1486640077242138 \
1.129093210087093e-06 0.1479134441579097 1.129093294531656e-06 0.147008717574758 1.129093356097002e-06 0.1463518850554192 1.129093430139493e-06 0.1455673550676988 \
1.129093503525017e-06 0.1447940960774066 1.129093584960259e-06 0.1439395015691976 1.129093654409405e-06 0.1432139999234875 1.129093729511102e-06 0.1424323701137583 \
1.129093819423173e-06 0.1415006120834361 1.129093896506793e-06 0.1407052977810757 1.129093995617377e-06 0.1396885207473417 1.12909406515744e-06 0.138983077430453 \
1.129094146475915e-06 0.1381612812129989 1.129094216644325e-06 0.1374549162714094 1.129094295612438e-06 0.1366629455350578 1.12909437459072e-06 0.1358740351737466 \
1.12909444691251e-06 0.1351544405911459 1.129094516277969e-06 0.1344667589602006 1.129094564981977e-06 0.1339854049281765 1.129094655744348e-06 0.1330945614011112 \
1.129094687765876e-06 0.1327823711724506 1.129094775869844e-06 0.131925672678654 1.129094808363886e-06 0.1316105445757083 1.129094907031543e-06 0.1306564447580443 \
1.129094950687519e-06 0.130235859061297 1.129095028669336e-06 0.1294866595045693 1.129095066000294e-06 0.1291289430202982 1.129095168151694e-06 0.128153223240932 \
1.129095235595654e-06 0.1275115375392494 1.129095300748612e-06 0.1268935577290946 1.129095366654626e-06 0.1262729746041904 1.129095437806609e-06 0.1256052797936485 \
1.12909552074397e-06 0.1248293808775363 1.129095606139451e-06 0.1240331657139879 1.129095682226844e-06 0.1233259817834828 1.129095762687521e-06 0.1225806238777534 \
1.129095820771462e-06 0.1220441728027253 1.129095892104936e-06 0.1213870835332726 1.129095976893369e-06 0.1206085709991845 1.129096038048402e-06 0.1200487744399507 \
1.129096108134853e-06 0.1194096117168642 1.129096170640142e-06 0.1188419501154776 1.12909623664509e-06 0.1182453094891599 1.129096305417857e-06 0.1176255789053269 \
1.129096374874481e-06 0.1170017375875525 1.129096458038731e-06 0.1162574953874909 1.129096531156255e-06 0.1156056107435251 1.129096601870241e-06 0.1149774116339468 \
1.129096661221924e-06 0.1144518657417393 1.129096766519136e-06 0.1135239342411639 1.12909681238663e-06 0.1131212254602471 1.129096899340683e-06 0.1123603821649216 \
1.129096942354464e-06 0.1119852310621949 1.129096987221211e-06 0.1115947726395539 1.129097076954706e-06 0.1108164664143028 1.129097147839057e-06 0.110204256460374 \
1.129097226692571e-06 0.109525796983828 1.129097289470346e-06 0.1089876103666232 1.129097349464702e-06 0.1084750215669379 1.129097460462474e-06 0.1075310013968523 \
1.12909754121676e-06 0.1068475792877216 1.129097653680086e-06 0.1059005796323111 1.129097704824629e-06 0.1054717782906781 1.129097787809798e-06 0.1047785948356612 \
1.129097845974503e-06 0.1042945647727652 1.129097960212503e-06 0.1033482075721767 1.12909801011597e-06 0.1029366076865433 1.129098095857569e-06 0.1022320954501846 \
1.129098144889019e-06 0.1018307629303728 1.129098227455441e-06 0.101157455862875 1.129098298387777e-06 0.1005815064560546 1.129098366538127e-06 0.1000302812267231 \
1.129098444148443e-06 0.0994053199805509 1.129098516491814e-06 0.09882546240595018 1.129098594067778e-06 0.09820656846618626 1.129098682738439e-06 0.09750287271560702 \
1.129098756553227e-06 0.09692010793638871 1.129098838144235e-06 0.09627924899616347 1.129098916282703e-06 0.09566870926115327 1.129099002032494e-06 0.09500229249765579 \
1.129099089729402e-06 0.09432453920671229 1.129099183638967e-06 0.09360304191323381 1.129099280098285e-06 0.09286661217778783 1.129099358728946e-06 0.09226977907248698 \
1.129099461452546e-06 0.09149473120661993 1.129099545280196e-06 0.09086620530027881 1.129099666032378e-06 0.08996702094116031 1.129099795302029e-06 0.08901247130467421 \
1.129099951190493e-06 0.08787237469953549 1.129100106290076e-06 0.08675000010972149 1.129100263305882e-06 0.08562614142917294 1.129100443326735e-06 0.08435280068725284 \
1.129100593847602e-06 0.08330035525696428 1.129100742221624e-06 0.08227363395463329 1.129100879838855e-06 0.08133079092382095 1.129101019758505e-06 0.08038162993974078 \
1.129101156365493e-06 0.07946425488810546 1.129101295092791e-06 0.07854214404995859 1.129101440403653e-06 0.07758663187171365 1.129101588151466e-06 0.07662571164688473 \
1.129101746748333e-06 0.07560598447141591 1.129101911000851e-06 0.07456266320243836 1.129102080017927e-06 0.07350246718885647 1.129102261906921e-06 0.07237646636762114 \
1.129102462529019e-06 0.07115268999588262 1.129102676406562e-06 0.0698691158856425 1.129102904040694e-06 0.0685263410462881 1.129103145626235e-06 0.06712722147996912 \
1.129103427215414e-06 0.06552977831071743 1.129103724369535e-06 0.06388229915275011 1.129104047802611e-06 0.06213267023812474 1.129104438962031e-06 0.0600758559534558 \
1.129104840456333e-06 0.05803293250078725 1.129105217397059e-06 0.05617754872181892 1.129105584510791e-06 0.05442503025024555 1.129105934627471e-06 0.05280240270907886 \
1.129106253933125e-06 0.05136309724710254 1.129106558257407e-06 0.05002640192327024 1.129106855163313e-06 0.04875503464657577 1.129107137163639e-06 0.04757867888787161 \
1.129107417596943e-06 0.04643900623749339 1.129107682320567e-06 0.04538777697325767 1.129107958218279e-06 0.04431704973151576 1.129108232683143e-06 0.04327654260273706 \
1.129108531102423e-06 0.04217254828989973 1.12910875761848e-06 0.04135316230013186 1.129109069531318e-06 0.04025053053625379 1.129109289786109e-06 0.03948972371590862 \
1.129109507050863e-06 0.03875470657060948 1.129109716773513e-06 0.03806113111453101 1.1291100269559e-06 0.03705828856757609 1.129110249553778e-06 0.03635538859683734 \
1.129110496919279e-06 0.03559019656168042 1.129110769325655e-06 0.03476651972027592 1.129110989958209e-06 0.03411384091885184 1.12911127423846e-06 0.03329124852897781 \
1.129111512151752e-06 0.0326183788879464 1.129111750241164e-06 0.03195887699386461 1.129111985496492e-06 0.03132132139405813 1.129112214275199e-06 0.03071728735992773 \
1.129112447005948e-06 0.03011490821398154 1.129112666308989e-06 0.02955843195412813 1.129112870252059e-06 0.02905055018162466 1.129113269161796e-06 0.02808303002558106 \
1.129113456316051e-06 0.02764052191221165 1.129113828521772e-06 0.0267814187683372 1.129114015473295e-06 0.02635997027055515 1.129114384827242e-06 0.02554620807076183 \
1.12911453848041e-06 0.02521471147941385 1.129114954694564e-06 0.02434161493068329 1.129115160182381e-06 0.02392065165079968 1.129115499190341e-06 0.02323955384462723 \
1.129115681885069e-06 0.02287916718068597 1.129116138978978e-06 0.02199597290476789 1.129116268719714e-06 0.02174967209293581 1.129116722140138e-06 0.02089828923199067 \
1.12911686451243e-06 0.0206336680476187 1.12911739407919e-06 0.01967289368906444 1.129117520286198e-06 0.01945139161001456 1.129118082520635e-06 0.01850749734048266 \
1.129118245259022e-06 0.01824627541187189 1.129118809439087e-06 0.01738327200207762 1.129118961183154e-06 0.01716165742474803 1.129119662862638e-06 0.01618760396393164 \
1.129119832951728e-06 0.01596324388168 1.129120488009604e-06 0.01513221026437959 1.129120654523916e-06 0.01492874613340729 1.129121387637676e-06 0.01406966818047924 \
1.129121520900854e-06 0.01391906482409888 1.129122372558029e-06 0.01299647369571925 1.129122510500478e-06 0.01285324185793544 1.129123450559967e-06 0.0119198170026788 \
1.129123614321604e-06 0.01176347583728811 1.129124601555038e-06 0.01085909507266535 1.129124736144114e-06 0.0107410715025141 1.129125877583545e-06 0.009819907073012045 \
1.129125985822443e-06 0.009738548299709823 1.129127309069827e-06 0.00880579379490502 1.129127441815525e-06 0.008718202093769473 1.12912896431665e-06 0.007760835273143199 \
1.129129076858719e-06 0.007690148685505111 1.129130769150306e-06 0.00669558715138598 1.129130909416892e-06 0.00662113250846694 1.129132982426194e-06 0.005629132576249021 \
1.12913317498771e-06 0.005545002188831318 1.129135385197559e-06 0.004656096148610405 1.129135791984232e-06 0.004507219767123045 1.129138613724209e-06 0.003590578528330178 \
1.129139135019959e-06 0.00344214578404881 1.129143347121009e-06 0.002447529662748036 1.129143899683877e-06 0.002340875287107731 1.129149782973417e-06 0.001359168649576994 \
1.129150032246415e-06 0.001311490127959886 1.129163182367465e-06 0.0003136950974005476 1.129163299150435e-06 0.0003112730584132499 1.158990000000011e-06 3.042397160644726e-06 \
1.202746667027013e-06 -0.0009024818035526668 1.20274673944263e-06 -0.001022682652537627 1.202747175467347e-06 -0.001858525046639076 1.20274726236173e-06 -0.002046124893065343 \
1.202747617065043e-06 -0.00288168582347465 1.202747716611644e-06 -0.003135075204051477 1.202747976881349e-06 -0.003828199033013717 1.20274811720375e-06 -0.004216406518003108 \
1.202748344689832e-06 -0.004856871791621592 1.202748481897271e-06 -0.005239031028659006 1.20274886679612e-06 -0.006187559915121 1.202748998893307e-06 -0.006423332025500122 \
1.202749687336335e-06 -0.005917035979538006 1.202749844265069e-06 -0.005202654566481615 1.202749971914232e-06 -0.004414133290428114 1.202750099456021e-06 -0.003433350487145549 \
1.202750217130234e-06 -0.002355902309038119 1.20275031626992e-06 -0.001320627313728655 1.20275042165263e-06 -9.507383675133965e-05 1.202750535559933e-06 0.001369964538583592 \
1.202750666615329e-06 0.003229572948258866 1.202750791978548e-06 0.005172303930030842 1.202750983820411e-06 0.008432154569684791 1.202751127490204e-06 0.01107975669588844 \
1.202751285472018e-06 0.01417105828876112 1.202751434071664e-06 0.01723098336859398 1.202751587122593e-06 0.02051714008521248 1.202751746187569e-06 0.02405720796424875 \
1.202751899257778e-06 0.02756764950178633 1.202752047604842e-06 0.03105219347129199 1.202752196711284e-06 0.03462388853332505 1.202752351275713e-06 0.03838854885099419 \
1.202752511961677e-06 0.04235886888523473 1.202752676640863e-06 0.04647718198980624 1.202752853163807e-06 0.05093664320808645 1.202753032175606e-06 0.05549818742091989 \
1.202753222948448e-06 0.0603932190016783 1.2027534277958e-06 0.06567927942044927 1.202753648293053e-06 0.07139554989571946 1.202753881211021e-06 0.07745499876455469 \
1.202754130458799e-06 0.08395499695136356 1.202754403380327e-06 0.09108394918256098 1.202754700173384e-06 0.09884095133633181 1.202755027609896e-06 0.1073964775374675 \
1.202755397423695e-06 0.1170487607486894 1.202755792369976e-06 0.1273407304921971 1.202756250458528e-06 0.1392499850125259 1.202756782558388e-06 0.1530377249371455 \
1.202757408110397e-06 0.169180864038255 1.202758094102463e-06 0.1867931863309214 1.202758896945878e-06 0.2072766958045763 1.20275979625821e-06 0.2300508264895909 \
1.202760696698323e-06 0.2526618731709107 1.202761498589855e-06 0.2726215666318766 1.202762194096996e-06 0.2897857674353052 1.202762826931282e-06 0.3052728323588638 \
1.202763422339774e-06 0.3197161646377594 1.202763969382815e-06 0.3328722959176427 1.202764503143162e-06 0.3455929446372428 1.202765022382586e-06 0.3578476146335662 \
1.202765529774049e-06 0.3697097539883151 1.202766033395218e-06 0.3813674725871593 1.202766545138114e-06 0.3930934709428262 1.202767052299123e-06 0.404595334768291 \
1.202767582595137e-06 0.4164962117964878 1.202768068708626e-06 0.4272847049163567 1.202768546816947e-06 0.437781779057129 1.202768986249071e-06 0.4473362978389137 \
1.202769109408535e-06 0.4500002106608159 1.202769355727463e-06 0.4553046876287923 1.202769698999459e-06 0.4626558934952216 1.202770010436459e-06 0.4692815017887791 \
1.202770261147724e-06 0.4745855323881177 1.202770531976868e-06 0.480281321066213 1.202770868458777e-06 0.4873122872019196 1.202771224467388e-06 0.4946959640027882 \
1.202771541737556e-06 0.5012322602315481 1.202771780618105e-06 0.506122906570856 1.202772021646287e-06 0.5110269393752048 1.202772273577991e-06 0.5161276795544476 \
1.202772513731835e-06 0.5209621749612534 1.202772736483296e-06 0.5254248476203834 1.202772925040944e-06 0.5291850880529715 1.202773139790987e-06 0.5334523706207774 \
1.202773354339378e-06 0.5376948565446859 1.20277361310367e-06 0.5427871977552768 1.202773863931242e-06 0.5477009885064807 1.202774119350104e-06 0.5526782776843104 \
1.20277447039263e-06 0.5594898819265107 1.202774735000954e-06 0.5645984056527484 1.20277500141751e-06 0.569709962982798 1.20277526193182e-06 0.5746801970751495 \
1.202775529021882e-06 0.5797469183389945 1.202775772159963e-06 0.5843213438768613 1.202776027852189e-06 0.5890994944692448 1.202776255671159e-06 0.5933243819692556 \
1.202776493215979e-06 0.5976999800355528 1.202776704606466e-06 0.6015679915939678 1.202776916747225e-06 0.6054277082074113 1.202777105936602e-06 0.6088479815213901 \
1.20277723709492e-06 0.6112112531841202 1.202777369391478e-06 0.6135871094428261 1.202777554614204e-06 0.6169015645304802 1.202777716636591e-06 0.6197943209800671 \
1.202777875055755e-06 0.6226100751126036 1.202778009167622e-06 0.6249846001944386 1.202778181488729e-06 0.6280247049765127 1.202778310427531e-06 0.6302937061188456 \
1.202778430805044e-06 0.6324061607157294 1.202778571333915e-06 0.634864734791624 1.202778764419408e-06 0.6382321981637986 1.202778914230185e-06 0.6408363654380513 \
1.20277908153778e-06 0.6437327988167145 1.202779262592003e-06 0.6468572757970242 1.202779465918433e-06 0.6503523798695617 1.202779648771588e-06 0.6534819287355287 \
1.202779819395834e-06 0.6563879501053153 1.202779996860074e-06 0.6594029650344411 1.202780162839025e-06 0.6622113135173925 1.202780320075814e-06 0.6648594636266301 \
1.202780460561866e-06 0.6672075432495704 1.202780604291995e-06 0.6695987751186935 1.202780737338985e-06 0.6718055529208897 1.202780879311128e-06 0.6741523780906628 \
1.202780999371661e-06 0.6761293215200647 1.202781144309748e-06 0.6785098354674278 1.202781260306798e-06 0.6804095298668216 1.202781379886685e-06 0.6823647593763783 \
1.20278147884666e-06 0.68397755359623 1.202781597355079e-06 0.6859039329668146 1.20278168439936e-06 0.6873150904607619 1.20278180641018e-06 0.6892866586554622 \
1.202781905332791e-06 0.6908817703737582 1.202781997228166e-06 0.6923536807698466 1.202782097196706e-06 0.6939486118486815 1.202782195442366e-06 0.6955126686751646 \
1.202782287156128e-06 0.6969676095571918 1.20278239128907e-06 0.698613189139943 1.202782527015812e-06 0.7007470979739818 1.202782681624274e-06 0.7031613517373301 \
1.202782816731986e-06 0.7052558942641604 1.202782963068532e-06 0.7075085519458914 1.202783091536074e-06 0.7094732734147607 1.202783215720207e-06 0.7113609898537658 \
1.202783325624507e-06 0.7130225953369277 1.202783442207576e-06 0.7147759898693785 1.202783542385407e-06 0.7162749667021007 1.202783679474216e-06 0.7183149847558421 \
1.202783799463242e-06 0.7200901405411056 1.20278391857669e-06 0.7218426783097279 1.202784045072077e-06 0.723693513465353 1.202784170939449e-06 0.7255245570057045 \
1.202784293560468e-06 0.7272980597885179 1.202784421177992e-06 0.7291334326655684 1.202784551426783e-06 0.7309957624152177 1.202784673019733e-06 0.73272442801297 \
1.202784811788425e-06 0.7346853525547948 1.202784912196869e-06 0.7360963845229137 1.202785015584257e-06 0.7375412410987998 1.2027851092447e-06 0.7388443755773992 \
1.202785220866297e-06 0.7403895158541485 1.2027853073349e-06 0.7415798421827293 1.20278540819801e-06 0.7429609798983192 1.202785540294733e-06 0.7447573558536402 \
1.202785649496034e-06 0.7462323422761349 1.202785754027664e-06 0.747635567415085 1.202785877674145e-06 0.7492836897664436 1.20278602637058e-06 0.7512497161812216 \
1.202786148251239e-06 0.7528480713857697 1.202786261855803e-06 0.7543274008692354 1.202786402375488e-06 0.7561429069656862 1.20278654356493e-06 0.7579511824827749 \
1.202786661311106e-06 0.7594470562859095 1.202786790000766e-06 0.7610693809796742 1.202786932555413e-06 0.7628512182523866 1.202787048411964e-06 0.7642872416835913 \
1.20278719417523e-06 0.7660789429779771 1.202787316007677e-06 0.7675637574673733 1.202787434476374e-06 0.7689965471136999 1.202787557264006e-06 0.7704700089613156 \
1.202787683416889e-06 0.7719718272910862 1.202787793785939e-06 0.7732757954107932 1.202787919217035e-06 0.7747465774777432 1.202788024698746e-06 0.775974259539018 \
1.202788157865176e-06 0.7775122819577122 1.202788280546631e-06 0.7789173428708996 1.202788415309674e-06 0.7804473432620218 1.202788525980963e-06 0.7816923373676121 \
1.202788635302591e-06 0.7829118427552927 1.202788770435026e-06 0.7844048889494442 1.20278892121405e-06 0.7860523747618094 1.202789061582958e-06 0.7875692293014268 \
1.202789181294483e-06 0.7888502570533434 1.202789319548824e-06 0.7903153082715967 1.202789442919159e-06 0.7916096503654788 1.202789588017784e-06 0.7931164937536124 \
1.202789727758044e-06 0.7945521172774316 1.202789854939467e-06 0.7958455533278409 1.20278997397922e-06 0.7970449251022731 1.202790086337411e-06 0.7981670522831598 \
1.202790190566191e-06 0.79919939674296 1.202790285905002e-06 0.8001364844871954 1.202790422193112e-06 0.8014634245741865 1.202790539085656e-06 0.8025894467082511 \
1.202790658725145e-06 0.8037305025474466 1.202790780606717e-06 0.8048811831579785 1.202790902985054e-06 0.8060245537852575 1.202791031013733e-06 0.8072081965553952 \
1.202791155658532e-06 0.8083483262222385 1.20279128615728e-06 0.8095291977395493 1.202791412617707e-06 0.8106611567088965 1.202791539743675e-06 0.8117869190804841 \
1.202791644861151e-06 0.8127087429624065 1.20279175011134e-06 0.8136235164943317 1.202791841251591e-06 0.8144090748259969 1.202791964669625e-06 0.8154632009865571 \
1.202792051748274e-06 0.8162003374872545 1.202792151070959e-06 0.8170344894488412 1.202792295992703e-06 0.8182390501293432 1.202792432261206e-06 0.8193582434421302 \
1.202792541723485e-06 0.8202477434185359 1.202792687843586e-06 0.8214214001843773 1.202792839202198e-06 0.8226208465286928 1.20279296500612e-06 0.8236052915965452 \
1.202793109416779e-06 0.824721541823094 1.20279323401773e-06 0.8256729463037898 1.202793384729791e-06 0.8268094083523665 1.20279352010105e-06 0.8278169867326588 \
1.202793645303979e-06 0.8287379047458127 1.202793762973362e-06 0.829593908450195 1.202793908801339e-06 0.8306418458276996 1.20279407529732e-06 0.8318207857986918 \
1.202794206154408e-06 0.8327345044534114 1.202794379603849e-06 0.833928356718921 1.202794547722323e-06 0.8350667646575466 1.202794717596125e-06 0.8361988603660855 \
1.202794898450754e-06 0.8373843006762304 1.202795041633135e-06 0.8383085120571983 1.202795155746479e-06 0.8390361588138326 1.20279528581247e-06 0.8398559950134801 \
1.202795387687706e-06 0.8404909448220066 1.202795504566998e-06 0.8412116130393378 1.202795641678929e-06 0.8420465258793415 1.202795839559572e-06 0.843231707656198 \
1.202796031345765e-06 0.8443585547012582 1.202796240708829e-06 0.8455646258450146 1.202796422822406e-06 0.846593677725298 1.202796619917178e-06 0.8476867969181797 \
1.202796793185875e-06 0.8486305714188691 1.202796976264561e-06 0.8496104335327738 1.202797147401587e-06 0.8505103231661706 1.202797322080438e-06 0.8514128411730317 \
1.202797497318728e-06 0.8523022053693007 1.202797673458368e-06 0.8531802340241421 1.202797863809624e-06 0.8541115036082744 1.20279805438677e-06 0.855025905954957 \
1.202798254818193e-06 0.8559685891497206 1.202798447410669e-06 0.8568563992305701 1.202798658273807e-06 0.8578086227668252 1.202798886187182e-06 0.8588150784816577 \
1.202799152217719e-06 0.8599606428795262 1.202799450738801e-06 0.8612090806949765 1.202799726692482e-06 0.8623286542354505 1.202800010954596e-06 0.8634483918036945 \
1.202800285103046e-06 0.8644969441068078 1.202800557392313e-06 0.8655088801415273 1.202800827558089e-06 0.8664846790737442 1.202801084736186e-06 0.8673881555543895 \
1.202801357299353e-06 0.868319368003445 1.202801633304697e-06 0.8692355072818493 1.202801903418629e-06 0.870106770567397 1.202802203245002e-06 0.8710447971670072 \
1.202802574222291e-06 0.8721640818024149 1.202802869154012e-06 0.8730224021943973 1.202803123432376e-06 0.873740732376842 1.202803421677207e-06 0.8745584461000401 \
1.202803695285219e-06 0.8752856917963749 1.202803931415444e-06 0.8758961959341748 1.202804171760979e-06 0.8765017794770257 1.202804394097168e-06 0.8770481951318053 \
1.202804588102451e-06 0.8775144010549708 1.202804917823794e-06 0.8782846129827527 1.20280507299682e-06 0.8786376896881318 1.202805390752408e-06 0.8793424631377607 \
1.202805569616983e-06 0.8797286397841958 1.202805912078462e-06 0.8804474051285093 1.202806096217817e-06 0.880822800830328 1.202806571118476e-06 0.881756283451624 \
1.202806738513154e-06 0.8820737784441692 1.2028072043462e-06 0.8829272622221894 1.202807385170493e-06 0.8832470363605239 1.202807879204793e-06 0.8840891816604841 \
1.202808020548669e-06 0.8843218944112644 1.202808626940586e-06 0.8852805359894154 1.202808779011766e-06 0.8855111592597558 1.202809425691436e-06 0.8864506941541785 \
1.202809553987642e-06 0.8866295550025313 1.202810202164815e-06 0.8874976172723908 1.202810331923675e-06 0.8876644392549727 1.202811100144497e-06 0.8886037370453904 \
1.202811229881009e-06 0.8887539063021698 1.202812083306654e-06 0.8896836309705964 1.202812226565088e-06 0.8898301468060963 1.202813212785821e-06 0.890764641901611 \
1.202813434267227e-06 0.8909571971396437 1.202814577308628e-06 0.8918770673440963 1.202814707298117e-06 0.8919774876506176 1.202816058923389e-06 0.8929731820841386 \
1.20281620928357e-06 0.89307657739048 1.202817689916169e-06 0.8939986636922405 1.202817928817934e-06 0.8941315911431026 1.202819693311633e-06 0.894999985510941 \
1.202820000994978e-06 0.8951330875684044 1.202822522266181e-06 0.8960612226716312 1.202822959317422e-06 0.8961978289811912 1.202826862729643e-06 0.8971619289239613 \
1.20282710951145e-06 0.8972094058147089 1.202834686001285e-06 0.8981998139535015 1.202834801913032e-06 0.8982099955090975 1.202853900445735e-06 0.8992062631372056 \
1.202854297888509e-06 0.8992194728667773 1.20300471332359e-06 0.9002121614362558 1.203004979381947e-06 0.9002436812458944 1.203010247532015e-06 0.8993470931706574 \
1.203010453902933e-06 0.899191170936528 1.203011932015743e-06 0.8982046351054961 1.203012112466399e-06 0.8981003355419954 1.203014334948061e-06 0.8971299612768925 \
1.203014541040576e-06 0.897079983173831 1.203024949306681e-06 0.8980580240048047 1.203025087164257e-06 0.8980839755683444 1.203031884513298e-06 0.8990685088718567 \
1.203032070084766e-06 0.8990874390200084 1.203528299258968e-06 0.9000706848616691 1.203528359054814e-06 0.9000975977971888 1.203529612605432e-06 0.9010828413531861 \
1.203529718298036e-06 0.9012097231395001 1.203530376428752e-06 0.9021613947651476 1.203530513611021e-06 0.9023918767045529 1.203531036637641e-06 0.9033649777562528 \
1.203531099501233e-06 0.9034908765919824 1.203531572096783e-06 0.904476514442582 1.203531623410595e-06 0.9045863669199017 1.203532089373931e-06 0.9055619780118375 \
1.203532121578392e-06 0.9056252631670594 1.203532838677129e-06 0.9066212416280413 1.203532923113402e-06 0.9066528951765993 1.203533523179781e-06 0.9059679814895146 \
1.203533643037393e-06 0.9055903401525059 1.203533774200172e-06 0.9050640446667092 1.203533909019925e-06 0.9043926011431642 1.203534057154984e-06 0.9034897747335404 \
1.203534194714335e-06 0.902493211317788 1.203534334926095e-06 0.9013135799985507 1.203534433588205e-06 0.9003872218501816 1.203534519272014e-06 0.8995148096066522 \
1.203534601836213e-06 0.8986166894493001 1.203534716618842e-06 0.8972773101170661 1.203534797717086e-06 0.8962642459447687 1.203534877134364e-06 0.8952218112132616 \
1.203534982588892e-06 0.8937633947192651 1.203535105230195e-06 0.8919606744930825 1.203535204954275e-06 0.890414036797163 1.203535375148686e-06 0.8876203405523397 \
1.203535521333777e-06 0.8850727273800474 1.203535689551925e-06 0.8819879035815887 1.203535861713021e-06 0.8786780617039783 1.203536046099114e-06 0.8749807502679057 \
1.203536230665458e-06 0.8711418063496947 1.203536414912944e-06 0.8671917613865908 1.203536600248607e-06 0.8631174608718694 1.203536774636335e-06 0.8592060069639053 \
1.203536957340272e-06 0.8550405244181323 1.203537132687366e-06 0.8509893565349284 1.203537315016877e-06 0.8467313026054767 1.203537505330306e-06 0.8422468264612591 \
1.203537675660435e-06 0.838204894125699 1.203537842184074e-06 0.8342320488410089 1.203538004754937e-06 0.830337741667393 1.20353815461616e-06 0.8267359097041467 \
1.203538305792179e-06 0.8230937075736249 1.203538494937653e-06 0.8185270080344306 1.203538640655707e-06 0.8150026134285653 1.203538815646674e-06 0.8107652770601156 \
1.203538964118218e-06 0.807166938184282 1.203539136005683e-06 0.8029987283123258 1.203539305073922e-06 0.7988973224349885 1.203539469252632e-06 0.7949140139776875 \
1.203539628580169e-06 0.7910485911592836 1.203539789029776e-06 0.7871568543472617 1.203539990849158e-06 0.7822630953020117 1.203540139296892e-06 0.7786646206504594 \
1.203540293464276e-06 0.77492821376164 1.203540430547636e-06 0.7716074476660475 1.203540539933082e-06 0.7689587163513494 1.203540645866538e-06 0.7663946531324515 \
1.203540772880886e-06 0.7633217481666642 1.203540887243854e-06 0.7605561828888391 1.203540990091676e-06 0.7580702160470256 1.203541111681993e-06 0.7551325442760125 \
1.203541222459267e-06 0.7524575925939972 1.203541339308092e-06 0.7496376180588871 1.203541450092818e-06 0.7469652567786068 1.203541568458919e-06 0.7441116745915923 \
1.203541693286014e-06 0.7411038668912771 1.20354184584781e-06 0.7374292753756717 1.203541979744798e-06 0.7342062928952946 1.203542100776238e-06 0.7312947572377408 \
1.203542264973752e-06 0.7273475399259534 1.203542442334699e-06 0.7230877912371642 1.203542624545108e-06 0.7187161681757385 1.203542805542373e-06 0.7143786395952922 \
1.203542986206316e-06 0.7100537072471783 1.203543176357883e-06 0.7055071781827296 1.203543364117777e-06 0.7010230964996226 1.203543564650882e-06 0.696237807975249 \
1.203543773336343e-06 0.6912646166759551 1.203543980979908e-06 0.6863227581165517 1.203544208547776e-06 0.6809140411171237 1.20354440082261e-06 0.6763521085712711 \
1.203544638087858e-06 0.6707310800019505 1.203544831366122e-06 0.6661595641347996 1.203545064098869e-06 0.6606646229758047 1.203545269656336e-06 0.6558174602470968 \
1.203545502009757e-06 0.6503484594495911 1.203545697011728e-06 0.6457674053103037 1.203545900240336e-06 0.6410004262200759 1.203546080092881e-06 0.6367906205544323 \
1.203546259199312e-06 0.6326052789263827 1.203546422576526e-06 0.628795088826817 1.20354659462593e-06 0.6247880828503264 1.203546758118769e-06 0.6209892715878097 \
1.203546933908588e-06 0.6169100951581823 1.203547115847573e-06 0.6126978430086294 1.203547304331306e-06 0.6083422542008314 1.203547510763727e-06 0.6035858951323969 \
1.20354769007839e-06 0.5994633272559844 1.203547887257257e-06 0.5949432360761027 1.203548096345398e-06 0.5901646611556908 1.20354830209466e-06 0.5854760387944159 \
1.203548542605348e-06 0.5800160304866983 1.20354871573345e-06 0.5760958285528379 1.203548880627452e-06 0.5723746772837877 1.203549061488027e-06 0.5683014035092815 \
1.203549218774123e-06 0.5647722902613652 1.203549387756918e-06 0.5609879409349005 1.203549567863379e-06 0.5569709657351898 1.203549720846506e-06 0.5535669615732179 \
1.203549852560951e-06 0.5506462283231492 1.203549999948651e-06 0.5473865746199473 1.203550087374242e-06 0.5454560063082221 1.203550172245482e-06 0.5435860258811447 \
1.203550270874694e-06 0.5414171943998213 1.203550342966855e-06 0.5398340751058975 1.203550440057874e-06 0.5377039800781129 1.203550525648258e-06 0.5358302678688993 \
1.203550590729134e-06 0.5344081412607664 1.203550714329502e-06 0.5317121235594142 1.203550808753772e-06 0.52965475734789 1.203550906276994e-06 0.5275349985745696 \
1.203551079137645e-06 0.5237893654184622 1.203551214133166e-06 0.5208709659121862 1.203551368316628e-06 0.5175498113398643 1.203551542781984e-06 0.5138002600288881 \
1.20355169458797e-06 0.510550000123414 1.203551840818953e-06 0.5074290310664136 1.203551984717826e-06 0.5043644611166801 1.203552127739669e-06 0.5013276181140283 \
1.203552223349518e-06 0.499301733014788 1.203552317793473e-06 0.4973032961550828 1.203552438849414e-06 0.4947494705229025 1.20355253372771e-06 0.4927525559781179 \
1.203552649558553e-06 0.4903172469328811 1.203552736822402e-06 0.4884854516151125 1.203552819252848e-06 0.4867593351188191 1.203552914660802e-06 0.484765406725184 \
1.203553015371081e-06 0.4826639978995959 1.203553112231473e-06 0.4806459052877932 1.203553250961225e-06 0.4777646955734051 1.203553386666086e-06 0.4749532752442271 \
1.203553587150809e-06 0.4708139964547478 1.203553802464962e-06 0.4663911383470885 1.203553984040267e-06 0.462674698484628 1.203554183012236e-06 0.4586189944293299 \
1.203554353577757e-06 0.455154096457448 1.203554527931445e-06 0.4516251957269069 1.203554696864699e-06 0.4482170126441485 1.20355486946186e-06 0.4447467276163349 \
1.20355505206819e-06 0.4410867902598327 1.203555240617056e-06 0.4373240875354826 1.203555434084593e-06 0.4334777823509549 1.203555642405232e-06 0.4293535036700135 \
1.203555856750462e-06 0.4251286740881063 1.203556082455792e-06 0.4207018662297695 1.203556308999161e-06 0.4162771402745992 1.203556571175911e-06 0.4111844468197049 \
1.203556820209735e-06 0.4063709766754009 1.203557121308433e-06 0.4005865607947761 1.20355741072925e-06 0.3950673729298416 1.203557718243529e-06 0.3892455819062323 \
1.203558040439925e-06 0.3831936848847286 1.203558368170407e-06 0.3770882112794804 1.203558700600163e-06 0.3709500980558715 1.203559030329171e-06 0.3649083177186754 \
1.203559351558758e-06 0.3590729273462687 1.203559682375082e-06 0.3531219177045733 1.203560024730645e-06 0.3470224718704957 1.203560324371677e-06 0.3417374346434491 \
1.203560654159242e-06 0.3359723367088904 1.203560981053185e-06 0.3303128110141857 1.203561319032532e-06 0.3245206193888226 1.203561628003696e-06 0.3192755432624759 \
1.203561952801669e-06 0.31382336954194 1.203562268431866e-06 0.3085864885517507 1.203562573419032e-06 0.3035810258414895 1.203562828757678e-06 0.2994330834535801 \
1.203563093620834e-06 0.295170851203172 1.203563380703519e-06 0.2905978071194348 1.203563603673298e-06 0.2870801635277143 1.203563803212567e-06 0.2839591363066187 \
1.20356401286858e-06 0.2807045410859125 1.203564193125121e-06 0.2779290029372279 1.203564355469842e-06 0.2754463208250681 1.203564505904816e-06 0.2731629026725527 \
1.203564656910124e-06 0.2708866524077067 1.203564853800715e-06 0.2679392949564011 1.203564984945479e-06 0.2659970646012914 1.203565109682018e-06 0.2641561221543183 \
1.20356526127406e-06 0.2619266655689588 1.203565357242231e-06 0.2605306204207966 1.2035654537936e-06 0.2591282589302421 1.203565578413389e-06 0.2573209601776467 \
1.203565720989924e-06 0.255257422470362 1.203565879923458e-06 0.25296979123958 1.203566012589525e-06 0.251062957019046 1.203566196158294e-06 0.2484301322588876 \
1.20356637739346e-06 0.2458327969660818 1.203566588907565e-06 0.2428051031600066 1.203566791497399e-06 0.2399069804317323 1.203566958053847e-06 0.2375282895552967 \
1.203567168273059e-06 0.2345337828133105 1.203567341690945e-06 0.2320692345528927 1.203567570533673e-06 0.2288260787734411 1.203567791168424e-06 0.2257162440502939 \
1.203567966830138e-06 0.2232503232699662 1.203568147290643e-06 0.2207258962977968 1.203568318047021e-06 0.2183528725291195 1.203568498243287e-06 0.2158619697278009 \
1.203568664973905e-06 0.2135675266585953 1.203568814095326e-06 0.2115251542210239 1.203568969905344e-06 0.2094125291275523 1.20356910508577e-06 0.2075875692769576 \
1.203569255167197e-06 0.2055694209972212 1.203569387612823e-06 0.2037957203154137 1.203569528157359e-06 0.2019220745191926 1.203569645226124e-06 0.2003748851744883 \
1.20356977493373e-06 0.1986681706274326 1.203569896991199e-06 0.1970700654731777 1.203570019534635e-06 0.1954731161836187 1.203570137553958e-06 0.1939418157697267 \
1.203570272576731e-06 0.1921981789937757 1.203570417201182e-06 0.1903420634523806 1.203570545551681e-06 0.1887049708672087 1.203570669186156e-06 0.1871351133418249 \
1.203570766736279e-06 0.1859021016257166 1.203570881809208e-06 0.1844539912642748 1.203570975507888e-06 0.1832809848801438 1.203571074292012e-06 0.1820493959460708 \
1.203571197226553e-06 0.1805230483556907 1.203571292980556e-06 0.1793400249325384 1.203571422068107e-06 0.177753298391591 1.203571524533477e-06 0.1764993061988986 \
1.203571622786974e-06 0.1753029542432101 1.203571742874187e-06 0.1738483570896001 1.203571845423405e-06 0.1726127298531683 1.203571955881064e-06 0.1712877101305652 \
1.203572084370928e-06 0.1697552709290656 1.203572175855769e-06 0.1686698090598139 1.203572280340358e-06 0.1674358120019214 1.203572355277094e-06 0.1665544493622226 \
1.203572444845591e-06 0.1655049734124585 1.2035724954106e-06 0.164914347906921 1.203572545388976e-06 0.1643318187475747 1.203572610358061e-06 0.163576534137217 \
1.203572645872029e-06 0.1631646263336159 1.203572718071202e-06 0.162329174921529 1.203572785200298e-06 0.1615546732967998 1.203572844430032e-06 0.160873195114598 \
1.20357288817563e-06 0.1603710314414745 1.203572935822459e-06 0.1598254649913795 1.203573006202993e-06 0.1590230739426561 1.203573088541159e-06 0.1580883269013631 \
1.203573166712759e-06 0.1572048664554128 1.203573248765709e-06 0.1562816770844126 1.203573341469331e-06 0.1552436243401225 1.203573464249495e-06 0.153877370231325 \
1.203573563395588e-06 0.1527810927807017 1.203573664895936e-06 0.1516651170047695 1.203573766171127e-06 0.1505582666538253 1.203573862662911e-06 0.1495093242781697 \
1.203573962080946e-06 0.1484346886615803 1.203574046381569e-06 0.1475281828465028 1.203574139320259e-06 0.1465342051547719 1.2035742219212e-06 0.1456551508734999 \
1.203574330687285e-06 0.1445034822456445 1.203574436330265e-06 0.1433917535370727 1.203574517989855e-06 0.1425365900703354 1.203574611735024e-06 0.1415598856352903 \
1.203574705302971e-06 0.1405903867550886 1.203574788187462e-06 0.139735765814107 1.203574876346636e-06 0.1388313836440244 1.203574956132722e-06 0.1380170907865772 \
1.203575049728122e-06 0.1370669869522621 1.203575139660646e-06 0.1361590166429519 1.203575210211042e-06 0.1354501541392388 1.203575279971219e-06 0.1347521119166949 \
1.203575394120126e-06 0.1336164586193709 1.20357547609874e-06 0.1328058651355588 1.203575563704043e-06 0.1319440719770354 1.203575663205239e-06 0.1309710196939938 \
1.203575772385241e-06 0.1299110174488692 1.203575874550573e-06 0.1289256009328031 1.203575982010779e-06 0.1278959836800649 1.203576102045057e-06 0.1267549558890445 \
1.203576196253092e-06 0.1258657925752028 1.203576327232195e-06 0.1246390638240933 1.203576426659897e-06 0.1237164070883829 1.203576535781582e-06 0.1227104370444639 \
1.20357664463475e-06 0.1217138859540913 1.203576736944154e-06 0.120874257454373 1.203576849784484e-06 0.1198547128626846 1.203576946796524e-06 0.118986084968971 \
1.203577051062872e-06 0.1180628196869088 1.203577160029803e-06 0.1171053395831002 1.203577259569368e-06 0.1162371554254778 1.203577376562078e-06 0.1152245300989246 \
1.203577463662869e-06 0.1144761644999183 1.20357757295452e-06 0.1135478691973115 1.203577654479583e-06 0.1128618460838699 1.203577754254576e-06 0.1120273350449922 \
1.203577871679726e-06 0.1110526766231405 1.203577973464844e-06 0.1102143708571793 1.203578061203792e-06 0.1094962336869811 1.2035781420033e-06 0.1088432886892514 \
1.203578228954319e-06 0.1081456845520918 1.203578309740945e-06 0.1075007757815706 1.203578399947511e-06 0.1067842832273628 1.203578490898266e-06 0.1060655611559195 \
1.20357857956879e-06 0.1053685613006139 1.203578678583611e-06 0.1045946508745568 1.203578772289787e-06 0.1038723470842792 1.203578866149063e-06 0.1031520741219857 \
1.203578966976511e-06 0.1023817709659086 1.203579071607409e-06 0.1015861061604995 1.203579195570165e-06 0.1006484085638475 1.203579292969478e-06 0.09991551135558702 \
1.203579413227425e-06 0.09901872452754552 1.203579524095301e-06 0.09819831936474602 1.203579628568336e-06 0.09742874659471555 1.203579745805045e-06 0.09656937225591002 \
1.203579847599366e-06 0.09582695326576983 1.203579945574917e-06 0.09511577589263259 1.203580086079407e-06 0.09410164141823299 1.203580191157203e-06 0.09334832721827611 \
1.203580289770019e-06 0.09264549593674179 1.203580382484827e-06 0.09198739948435641 1.203580468683212e-06 0.09137785861853052 1.203580562596188e-06 0.09071637432184691 \
1.203580659696934e-06 0.09003559055802626 1.203580769117988e-06 0.08927317549644689 1.203580870101537e-06 0.08857281843916648 1.203580963759483e-06 0.08792605868920525 \
1.203581037934155e-06 0.08741581771673042 1.203581175834007e-06 0.08647193599618339 1.203581248191011e-06 0.08597917321277694 1.203581383512214e-06 0.08506274029062395 \
1.20358146942382e-06 0.08448410751389913 1.203581614152054e-06 0.08351486081643937 1.203581710382619e-06 0.0828744112740944 1.203581798218398e-06 0.08229260392026354 \
1.203581914017306e-06 0.08152964121883956 1.203582029145758e-06 0.08077575264951149 1.20358214291219e-06 0.08003553900012179 1.203582283169683e-06 0.0791300282244784 \
1.203582424545716e-06 0.07822490276368012 1.203582574181758e-06 0.07727536491519127 1.203582718670613e-06 0.07636690312463701 1.203582869844724e-06 0.07542565384097814 \
1.203583019215544e-06 0.07450459906593411 1.203583168562251e-06 0.0735926433331697 1.203583328517767e-06 0.07262574717347114 1.203583484664678e-06 0.07169171823582712 \
1.203583659153113e-06 0.07065947636250877 1.203583828862219e-06 0.0696671357044583 1.203584014041303e-06 0.0685979885997255 1.20358421076238e-06 0.06747763456279594 \
1.2035844212802e-06 0.06629631776014881 1.203584643312255e-06 0.06507007089066431 1.203584873524276e-06 0.0638195278444372 1.203585116035382e-06 0.06252626147401 \
1.203585376689467e-06 0.06116236403900636 1.203585656588531e-06 0.05972739422233359 1.203585950172255e-06 0.05825544847408989 1.203586265108239e-06 0.05671370145268265 \
1.203586607914165e-06 0.05507846134953124 1.203586957380758e-06 0.0534565727116736 1.203587366284915e-06 0.05161746230842366 1.203587712949942e-06 0.05010669351290297 \
1.203588100364996e-06 0.04846839895323611 1.203588444582788e-06 0.04705645202362623 1.203588768009047e-06 0.04576625679949029 1.203589073054809e-06 0.04458093278443617 \
1.203589365916806e-06 0.04347099288378908 1.203589650057723e-06 0.04242242262004604 1.203589926078015e-06 0.04142902112907627 1.203590192930566e-06 0.04049015932812138 \
1.203590461822789e-06 0.03956531631184226 1.203590737883211e-06 0.03863769040165695 1.203591025478782e-06 0.03769451689421055 1.203591265044408e-06 0.03692662498323904 \
1.203591554211835e-06 0.03602084344675294 1.203591770003438e-06 0.03535960341037672 1.203591957720476e-06 0.03479599077274986 1.203592155849583e-06 0.03421285035004928 \
1.203592518724446e-06 0.03317032497347058 1.203592776866276e-06 0.03244834222605905 1.20359308657919e-06 0.0316030971185694 1.203593352049329e-06 0.03089664771451467 \
1.203593620168408e-06 0.03019941363307669 1.203593899042439e-06 0.02949128999862272 1.203594145228876e-06 0.02888043298519722 1.203594375860285e-06 0.02832033800396738 \
1.203594614150204e-06 0.02775711540944564 1.203594849157569e-06 0.02721270742060762 1.203595076940031e-06 0.02669509678424227 1.203595485552303e-06 0.02579039168486155 \
1.203595661854632e-06 0.02540904040268441 1.203596016332316e-06 0.02465798827491217 1.203596200203288e-06 0.02427641469830137 1.20359653515201e-06 0.02359448510613503 \
1.203596699060728e-06 0.02326678168937357 1.203597091331304e-06 0.02249905491676728 1.203597247322069e-06 0.02220010404946675 1.203597678925427e-06 0.02138321689778962 \
1.203597816314806e-06 0.0211255367654138 1.203598333123589e-06 0.02017559010600388 1.203598458659483e-06 0.01995091418019728 1.203598915901008e-06 0.01915998482559782 \
1.203599075046989e-06 0.01889493739859509 1.203599682285467e-06 0.01793263500095189 1.203599816822955e-06 0.01772934138481063 1.203600480086948e-06 0.01678091027541291 \
1.203600673410379e-06 0.01651856846389665 1.20360134106704e-06 0.01565087920017967 1.203601502655887e-06 0.01544858341705342 1.20360225789114e-06 0.01454101846553843 \
1.203602407452107e-06 0.01436800730673201 1.203603297789931e-06 0.01338293844200974 1.203603396447817e-06 0.01327873262558703 1.203604353121314e-06 0.01230993787860994 \
1.203604474231022e-06 0.01219243157195396 1.20360546572373e-06 0.01126376273051215 1.20360562925246e-06 0.01111855113153209 1.203606759174536e-06 0.01018247077230436 \
1.203606871621774e-06 0.01009565848301377 1.203608249445262e-06 0.009103273453806031 1.203608388390533e-06 0.009009747578659758 1.203609942788869e-06 0.008018073335410726 \
1.20361005485534e-06 0.00794673960805117 1.20361169983817e-06 0.006958154532207958 1.203611807090665e-06 0.006899512253112593 1.203613751584152e-06 0.005937533026687714 \
1.20361395848211e-06 0.005843834961138424 1.203616297369853e-06 0.00487227039639981 1.203616721356264e-06 0.004712306502041247 1.20361949358946e-06 0.003780857497341114 \
1.203619941898552e-06 0.003647790772321777 1.203623582397237e-06 0.00272553831825111 1.203624079053072e-06 0.002619503085887757 1.203629830173496e-06 0.001650572925599863 \
1.203630116955383e-06 0.001609446887446839 1.203635471944067e-06 0.0006353228983793809 1.203635677300692e-06 0.0005920420449145349 1.206282712074508e-06 -0.0002718533828215428 \
1.206282867950111e-06 -0.0004579010352009555 1.206283416265203e-06 -0.001326296959495401 1.206283529048879e-06 -0.001543805653187533 1.206283963541019e-06 -0.002491429791030493 \
1.206284039366175e-06 -0.002673591589873599 1.206284396016773e-06 -0.003590195133438418 1.206284523065853e-06 -0.003936807634339821 1.206284801566247e-06 -0.004716444651655622 \
1.206284909650731e-06 -0.005020876868076652 1.206285253249855e-06 -0.00592430224391268 1.20628536024372e-06 -0.006162325733041658 1.206286259614116e-06 -0.005653094509861465 \
1.206286438047546e-06 -0.004687598829536962 1.20628654377096e-06 -0.003940993102967527 1.206286668833738e-06 -0.002883597584075996 1.206286762417834e-06 -0.001971418478057775 \
1.206286840257396e-06 -0.001132968824455395 1.206286920329395e-06 -0.0001977429743171 1.206287042702205e-06 0.001370578777960296 1.206287160958077e-06 0.003041212838230153 \
1.206287279607187e-06 0.004860750887681821 1.206287393089626e-06 0.006730904986417607 1.206287496532765e-06 0.008536402178002854 1.206287611192018e-06 0.01064190690353853 \
1.206287801775811e-06 0.0143607330143792 1.206287935565949e-06 0.01711819191720031 1.206288085819515e-06 0.02033933849841947 1.206288240988763e-06 0.02378599874269359 \
1.206288396380811e-06 0.0273434151175349 1.206288544088043e-06 0.03080849965087477 1.206288693077668e-06 0.03437359286003162 1.206288848068751e-06 0.03814545786868043 \
1.206289007439365e-06 0.04208062121327779 1.206289172372776e-06 0.04620305710844342 1.206289347319105e-06 0.0506208066052034 1.206289526449176e-06 0.05518387280380205 \
1.206289716238432e-06 0.06005265756871143 1.2062899199354e-06 0.06530840376289772 1.206290139745932e-06 0.07100650943730057 1.206290371497377e-06 0.07703584544314998 \
1.206290619322674e-06 0.08349927754587044 1.206290890643603e-06 0.09058756662233436 1.206291185356381e-06 0.09829181712822582 1.206291510614029e-06 0.106792896697727 \
1.206291876859735e-06 0.1163551101154179 1.206292270156448e-06 0.1266079356677421 1.206292722809344e-06 0.1383809089651769 1.206293248524511e-06 0.1520098384503803 \
1.206293867738049e-06 0.1679979965193872 1.206294548482366e-06 0.1854865650013753 1.206295342157321e-06 0.2057488551561759 1.206296230922953e-06 0.2282732214494322 \
1.206297044312215e-06 0.2487218262351868 1.206297766061792e-06 0.2667261628598245 1.206298401725801e-06 0.282460740414376 1.206298973442562e-06 0.2965101025186013 \
1.206299508996846e-06 0.3095696210007924 1.206300012355259e-06 0.3217495654069301 1.206300488682702e-06 0.3331878525640654 1.206300962606306e-06 0.3444754071334732 \
1.206301420078025e-06 0.3552759747331513 1.206301886058294e-06 0.3661792384270033 1.206302335046104e-06 0.376592601923634 1.206302831152646e-06 0.3879857357798637 \
1.206303350914508e-06 0.3998002499051578 1.206303730319152e-06 0.4083447473225827 1.206304170327876e-06 0.4181679450526055 1.206304640096814e-06 0.4285466970600206 \
1.206305125617752e-06 0.4391589006481625 1.206305565065858e-06 0.4486701556983262 1.206305626818807e-06 0.4500002248264944 1.206305750324704e-06 0.4526540461147197 \
1.206305997336498e-06 0.4579447795386873 1.206306249931409e-06 0.463325462421476 1.206306447502525e-06 0.467511453725808 1.206306673074272e-06 0.4722681264242033 \
1.206306994642268e-06 0.4790073975813253 1.206307263421497e-06 0.4846013351959894 1.20630748207297e-06 0.4891262574467725 1.206307692176936e-06 0.4934547887280634 \
1.206307918582462e-06 0.4980921872304203 1.206308127687652e-06 0.5023516957637455 1.206308317089911e-06 0.5061927337048852 1.206308441251129e-06 0.5086969563931187 \
1.206308568006226e-06 0.5112441466129884 1.206308728004704e-06 0.5144514110933732 1.206308975647656e-06 0.5193914248715521 1.206309154234115e-06 0.5229351592435862 \
1.206309325187692e-06 0.5263079149198099 1.206309586537288e-06 0.5314455197962068 1.20630981260887e-06 0.5358634945234868 1.206310015740537e-06 0.5398188128751134 \
1.206310180971268e-06 0.5430252218652345 1.206310337758288e-06 0.5460612552756139 1.206310526914905e-06 0.5497137532216215 1.206310728782659e-06 0.5535976061995346 \
1.206310952933981e-06 0.5578986282275192 1.206311191316346e-06 0.5624617013850463 1.206311426077985e-06 0.566941985223824 1.206311656348691e-06 0.5713275351537204 \
1.206311862141324e-06 0.5752375533958141 1.206312067125538e-06 0.5791255875933676 1.20631230994078e-06 0.5837094709690289 1.206312564698362e-06 0.588493349632063 \
1.206312792926793e-06 0.5927514274590796 1.206313030765665e-06 0.5971656109489694 1.206313243043101e-06 0.6010807441713891 1.206313454836505e-06 0.6049674646600495 \
1.206313708720774e-06 0.6095919957414236 1.206313913314301e-06 0.6132953190650409 1.206314165037654e-06 0.6178178328453598 1.206314352827174e-06 0.6211736970442716 \
1.206314605700251e-06 0.6256587164710262 1.206314804109613e-06 0.6291560967673944 1.206314983842284e-06 0.6323071487074056 1.206315254113091e-06 0.6370161336915187 \
1.206315471396857e-06 0.6407803561788556 1.206315651923236e-06 0.6438916924996977 1.206315853084131e-06 0.6473460740030906 1.206316021667513e-06 0.650231451944099 \
1.20631622602572e-06 0.6537144072723954 1.206316371688778e-06 0.6561873372238678 1.206316536247377e-06 0.6589728476742622 1.206316705716594e-06 0.6618316558839334 \
1.206316859256675e-06 0.664412775690417 1.206317000490202e-06 0.6667750288922751 1.206317144066014e-06 0.6691685747430841 1.206317277296139e-06 0.6713840140331436 \
1.20631741919646e-06 0.6737368819239464 1.206317539430086e-06 0.6757233098298149 1.206317684081139e-06 0.6781085120392751 1.206317800299844e-06 0.6800197521569988 \
1.206317919382163e-06 0.6819757159594566 1.206318017960477e-06 0.6835903813535821 1.206318135558183e-06 0.6855122399681081 1.206318222994146e-06 0.6869376986921233 \
1.206318347740232e-06 0.6889650632873403 1.206318447547296e-06 0.6905825000046129 1.206318540037093e-06 0.6920753042469043 1.206318641321177e-06 0.6937043390836264 \
1.206318739114283e-06 0.695273833970533 1.206318830385075e-06 0.6967333967490603 1.206318932842905e-06 0.6983656370917724 1.206319065752136e-06 0.7004728611232253 \
1.206319220767541e-06 0.7029137789397926 1.206319355649227e-06 0.7050222373350452 1.206319501145018e-06 0.7072806469370021 1.206319628999685e-06 0.709252249158637 \
1.206319753457981e-06 0.7111597484283609 1.206319864783685e-06 0.7128563623504806 1.206319978813713e-06 0.7145852226468989 1.20632007932493e-06 0.7161013069709498 \
1.206320216526077e-06 0.7181590832501857 1.206320336471979e-06 0.7199473375636642 1.206320455641778e-06 0.7217141075019444 1.206320582586792e-06 0.7235855504531626 \
1.20632070735421e-06 0.7254141264975077 1.206320830849597e-06 0.7272133847865295 1.20632095763087e-06 0.7290498056238117 1.206321088220355e-06 0.730930225429108 \
1.206321210432258e-06 0.7326797786847141 1.206321347490272e-06 0.7346298644824388 1.206321448705627e-06 0.7360619656663578 1.206321553674562e-06 0.7375401619041119 \
1.206321645165995e-06 0.7388229997694907 1.206321758241356e-06 0.7404001534680551 1.20632184554224e-06 0.7416107338190071 1.206321950005571e-06 0.7430512000342341 \
1.206322080768703e-06 0.7448411286358657 1.2063221906822e-06 0.7463352048609909 1.206322295341959e-06 0.7477488743938407 1.20632241917362e-06 0.7494094725133206 \
1.206322567926971e-06 0.751387874302702 1.206322689842132e-06 0.7529958494242643 1.206322803696393e-06 0.7544867042370438 1.20632294419585e-06 0.7563117925204224 \
1.206323085519365e-06 0.7581313010100689 1.206323203298972e-06 0.7596352654099263 1.206323331697459e-06 0.7612620174900669 1.206323474021161e-06 0.7630496612437514 \
1.206323590410316e-06 0.7644991888858087 1.206323736133978e-06 0.7662987831554334 1.206323857913867e-06 0.7677897310961733 1.206323976478797e-06 0.7692300520321635 \
1.206324099092246e-06 0.7707078417740018 1.206324225543629e-06 0.77221964326554 1.206324335666584e-06 0.7735261258099556 1.206324461188726e-06 0.7750039859681491 \
1.206324566849672e-06 0.7762386743660952 1.206324702026829e-06 0.7778058706872942 1.206324825637346e-06 0.7792267957652825 1.206324955634725e-06 0.7807078764205345 \
1.206325068606223e-06 0.7819831642610904 1.206325176500111e-06 0.7831908181350914 1.206325313030793e-06 0.7847046126527283 1.206325463151702e-06 0.7863508260127218 \
1.206325605416006e-06 0.7878933964149381 1.206325724997519e-06 0.7891771019825847 1.206325861808649e-06 0.7906313890246753 1.206325984312413e-06 0.7919206245676671 \
1.206326128984341e-06 0.7934276941869095 1.206326269769414e-06 0.794878360380241 1.206326396585209e-06 0.796171745508174 1.206326515632602e-06 0.7973744708066829 \
1.206326627895563e-06 0.7984986270115709 1.206326732283333e-06 0.7995352562746869 1.206326827560395e-06 0.8004739840425704 1.206326963902891e-06 0.8018044219089175 \
1.20632708076796e-06 0.8029326473252685 1.206327200364489e-06 0.8040757482679398 1.2063273222503e-06 0.8052288531124292 1.206327444838559e-06 0.8063765489401953 \
1.206327572579618e-06 0.8075599074701925 1.206327697362526e-06 0.8087035441861687 1.206327827862901e-06 0.8098867241643505 1.206327954229597e-06 0.8110199871086299 \
1.206328081578389e-06 0.8121498004723215 1.206328186791179e-06 0.8130740322933268 1.206328291495184e-06 0.8139855427426806 1.20632838302539e-06 0.8147757515715357 \
1.20632850639836e-06 0.8158311616195392 1.206328593352409e-06 0.8165684017534872 1.206328692208245e-06 0.8173999442793862 1.206328836710884e-06 0.8186029267949408 \
1.206328973036573e-06 0.8197243345631372 1.206329082445008e-06 0.8206145128367788 1.206329228461948e-06 0.821788834531623 1.206329380203007e-06 0.8229927727264784 \
1.206329506119585e-06 0.8239792970156907 1.206329650568649e-06 0.8250971468990039 1.206329775264817e-06 0.8260503472050121 1.206329925878834e-06 0.8271873005969326 \
1.206330061249302e-06 0.8281959289694237 1.206330186472937e-06 0.8291179217777711 1.206330304128897e-06 0.8299746468143927 1.20633044991051e-06 0.8310230722388168 \
1.20633061639426e-06 0.8322027532553667 1.206330747215024e-06 0.8331167337813133 1.206330920675046e-06 0.834311196379941 1.206331088787842e-06 0.8354501125721271 \
1.206331258668969e-06 0.8365827385393307 1.206331439512628e-06 0.8377685497174457 1.206331582704692e-06 0.8386931238161603 1.206331696822189e-06 0.8394210074154138 \
1.2063318268738e-06 0.8402408682651782 1.206331928753516e-06 0.8408758513273116 1.206332045641139e-06 0.841596551294542 1.206332182786859e-06 0.8424315815669623 \
1.206332380696072e-06 0.8436167827761205 1.206332572515411e-06 0.8447436440637145 1.206332781866158e-06 0.8459494874145237 1.206332964017768e-06 0.8469786287449077 \
1.206333161103991e-06 0.8480715276019779 1.206333334356719e-06 0.8490148531186206 1.206333517450963e-06 0.8499943787178993 1.20633368858243e-06 0.8508936588199895 \
1.206333863270272e-06 0.8517955326875627 1.206334038504287e-06 0.8526841769874772 1.206334214641154e-06 0.8535614892404448 1.206334405008494e-06 0.8544920815553035 \
1.206334595580845e-06 0.8554057038167108 1.206334795976838e-06 0.8563474066245403 1.206334988566464e-06 0.8572344253714166 1.206335199466375e-06 0.858185963363946 \
1.206335427341862e-06 0.8591913103610016 1.206335693424718e-06 0.8603357477151101 1.206335991926854e-06 0.8615822374427254 1.206336267816324e-06 0.8627000332972231 \
1.206336552083493e-06 0.8638181192989086 1.206336826221443e-06 0.8648650323418529 1.206337098522366e-06 0.8658754039994767 1.206337368678563e-06 0.8668495780678541 \
1.206337625862699e-06 0.8677515347235455 1.206337898421613e-06 0.8686810999091764 1.206338174469332e-06 0.8695957110915412 1.206338444589599e-06 0.8704649939918846 \
1.206338744449489e-06 0.8714007440816277 1.206339115430115e-06 0.8725171209518352 1.206339410352536e-06 0.8733732402027278 1.206339664628271e-06 0.8740897163373675 \
1.206339962841735e-06 0.8749052413925265 1.206340236411347e-06 0.8756305047096297 1.206340472534749e-06 0.8762394088953867 1.206340712859887e-06 0.8768433401198644 \
1.206340935193821e-06 0.8773882060838187 1.206341129200254e-06 0.8778530214284207 1.206341458909681e-06 0.8786208714695904 1.20634161408109e-06 0.87897283049042 \
1.206341931723491e-06 0.8796750328643211 1.206342110604035e-06 0.8800599154915705 1.206342453064798e-06 0.8807759898408113 1.20634263726721e-06 0.8811501695110489 \
1.206343112296513e-06 0.8820806183873429 1.206343279683462e-06 0.8823969901232691 1.206343745459844e-06 0.8832471741583867 1.206343926299187e-06 0.8835657112976044 \
1.206344420308805e-06 0.8844044135654346 1.206344561623711e-06 0.8846360992458032 1.206345167867327e-06 0.8855901496945974 1.206345319942526e-06 0.8858196526512701 \
1.206345966662599e-06 0.8867549368993356 1.206346094949267e-06 0.8869330782847171 1.206346743158686e-06 0.8877977435561634 1.206346872882985e-06 0.8879638504720397 \
1.206347641302053e-06 0.8888993076310558 1.206347771073903e-06 0.8890488273083775 1.206348624736509e-06 0.8899738047157748 1.206348767761561e-06 0.8901192131187072 \
1.206349754067048e-06 0.8910487927319016 1.2063499755536e-06 0.8912403904783051 1.206351118378139e-06 0.8921548233216382 1.206351248258076e-06 0.8922544308366913 \
1.206352600758498e-06 0.8932425879319322 1.206352751041431e-06 0.8933452769452155 1.206354231575698e-06 0.8942627870546499 1.206354470485492e-06 0.8943950258099049 \
1.206356252518433e-06 0.8952625983306248 1.20635663826586e-06 0.895426813549116 1.206359040424079e-06 0.8963023915260389 1.206359515360049e-06 0.8964490046842035 \
1.206363433287165e-06 0.8974035634625627 1.206363903247409e-06 0.8974927205890085 1.206372272035387e-06 0.8984807567386782 1.206372492545714e-06 0.8984960697096243 \
1.206417072074293e-06 0.8994905034760702 1.206418273460192e-06 0.8995076493514624 1.206554083268694e-06 0.9004821828323031 1.206554262245419e-06 0.9005421539807538 \
1.206557707120338e-06 0.8996085030263692 1.206557879904192e-06 0.8994755022453073 1.2065592062239e-06 0.8985168769831137 1.206559392989208e-06 0.8983970610744239 \
1.206561177194233e-06 0.8974304740967198 1.206561389324515e-06 0.8973403978332656 1.206574730020299e-06 0.8983331062395279 1.206574843308145e-06 0.8983517458922662 \
1.206583546661241e-06 0.8993273409280406 1.20658409447182e-06 0.8993637478389299 1.207076621843715e-06 0.9003542216796759 1.207076717582567e-06 0.9004233209197793 \
1.207077660131942e-06 0.9014023545001312 1.207077822585254e-06 0.9016297223302431 1.207078389291501e-06 0.9025464066367429 1.207078496462212e-06 0.9027401250447874 \
1.207078889770564e-06 0.9035002370985188 1.207079022567928e-06 0.9037710185404622 1.207079402169034e-06 0.9045728679206633 1.207079532383781e-06 0.9048512534150681 \
1.207079993790073e-06 0.9057878278182891 1.207080113037131e-06 0.9060008176934132 1.207081542646165e-06 0.9050557440230738 1.207081626316293e-06 0.9046580283931719 \
1.207081751622122e-06 0.9039622140338933 1.207081859436291e-06 0.9032622438705011 1.207081978430637e-06 0.9023800387125585 1.207082093802854e-06 0.9014106868475621 \
1.207082183899751e-06 0.900578017289966 1.207082295347455e-06 0.8994526603282017 1.207082381426603e-06 0.8985125975436928 1.207082487392252e-06 0.8972736935213672 \
1.207082587160618e-06 0.8960214106762436 1.207082668156228e-06 0.8949470092681954 1.207082777804195e-06 0.8934133399212493 1.207082863391606e-06 0.8921520042367302 \
1.207082955514215e-06 0.8907345325087322 1.207083043733598e-06 0.8893220116766375 1.207083152508351e-06 0.8875100775672261 1.207083235401386e-06 0.8860780350921965 \
1.207083343975057e-06 0.8841400608632336 1.207083436201253e-06 0.8824412727986957 1.20708352082175e-06 0.8808423775446282 1.20708360666218e-06 0.8791839877465467 \
1.20708368587706e-06 0.8776224824828824 1.20708376196503e-06 0.8760960492665846 1.207083854301399e-06 0.874210837196514 1.207083914177735e-06 0.8729702140710593 \
1.207083971566019e-06 0.8717685933706794 1.207084033561192e-06 0.8704574090763495 1.207084096840044e-06 0.8691057216070059 1.207084146911381e-06 0.8680269866686803 \
1.207084196353533e-06 0.8669542389500936 1.20708426002324e-06 0.8655623656543436 1.207084335970659e-06 0.8638877358586781 1.207084384801671e-06 0.8628032002737418 \
1.207084433325624e-06 0.8617197496806845 1.207084509037347e-06 0.8600184098866027 1.207084576246125e-06 0.8584975010852487 1.207084618952631e-06 0.8575263577286506 \
1.207084662855204e-06 0.8565244243916033 1.207084750660351e-06 0.8545103166059256 1.20708481351352e-06 0.8530605771626394 1.207084872183177e-06 0.8517018597088126 \
1.207084908361779e-06 0.8508614974547222 1.207084943180258e-06 0.8500510151036469 1.207084978206243e-06 0.8492340038666518 1.207085048258213e-06 0.8475953578585981 \
1.207085096728698e-06 0.8464581214772323 1.207085140673499e-06 0.8454248116355969 1.207085186191255e-06 0.8443523575543517 1.207085250092166e-06 0.8428433081697474 \
1.20708531621854e-06 0.8412777165526386 1.207085421348608e-06 0.8387809254526315 1.207085509283283e-06 0.8366857089760468 1.207085588228565e-06 0.834800137446173 \
1.207085676393602e-06 0.8326899670047023 1.207085763209599e-06 0.8306078985741704 1.207085851101283e-06 0.8284959280419055 1.207085942350373e-06 0.8262996967350639 \
1.207086045112241e-06 0.8238226494465998 1.207086143615717e-06 0.8214450402687625 1.207086255948632e-06 0.8187302447322098 1.207086368922768e-06 0.8159967029774419 \
1.207086490210663e-06 0.8130591602364435 1.207086620717817e-06 0.8098958628758253 1.20708674976372e-06 0.8067658935936169 1.20708690323932e-06 0.8030416153605923 \
1.207087068523541e-06 0.799029304640783 1.207087236264745e-06 0.7949567682299736 1.207087432788334e-06 0.7901857478752816 1.207087637550659e-06 0.7852160332972318 \
1.207087850227716e-06 0.7800563994093253 1.207088050847662e-06 0.7751902022758907 1.20708825170639e-06 0.7703212856706637 1.207088401728407e-06 0.766686939713112 \
1.207088532263574e-06 0.7635264252913375 1.207088666681014e-06 0.7602735436595947 1.207088772876545e-06 0.7577048602246427 1.207088906182877e-06 0.754482067181252 \
1.207089013215803e-06 0.7518959494812111 1.207089156291704e-06 0.7484409822837247 1.207089320797846e-06 0.7444713482725677 1.207089441615093e-06 0.74155777711076 \
1.207089612721757e-06 0.7374334100931738 1.207089773612309e-06 0.733558046396253 1.20708999020493e-06 0.7283457217000903 1.207090183460631e-06 0.7236999380850822 \
1.207090362395765e-06 0.7194029726762079 1.207090529212387e-06 0.7154015770462002 1.207090715418352e-06 0.7109395231330657 1.207090903351594e-06 0.7064416825495208 \
1.207091069273699e-06 0.7024749886985119 1.207091261631787e-06 0.6978803202016938 1.207091402988682e-06 0.6945068232011449 1.207091559996444e-06 0.6907636199298515 \
1.207091755976089e-06 0.6860965106368763 1.207091918410194e-06 0.6822325558671515 1.207092079586376e-06 0.6784034260021697 1.207092271894574e-06 0.6738409413562468 \
1.207092489556454e-06 0.6686845685784016 1.207092737577756e-06 0.6628199086538362 1.207092915635219e-06 0.6586162961343578 1.207093164179028e-06 0.6527567611811057 \
1.207093366786271e-06 0.6479896840619462 1.207093536596938e-06 0.6440011601507294 1.207093695213124e-06 0.6402799599229552 1.207093833743559e-06 0.637035894415233 \
1.207093969951322e-06 0.6338503464729111 1.207094096262698e-06 0.6309003762865483 1.207094225721933e-06 0.6278810604265532 1.207094354053673e-06 0.6248911458464299 \
1.207094485383603e-06 0.6218374290191309 1.207094617410215e-06 0.6187713222160208 1.207094761570095e-06 0.6154276788919771 1.207094905778687e-06 0.6120888358645944 \
1.207095053433791e-06 0.6086753592300279 1.207095200490149e-06 0.6052842859263143 1.207095358304176e-06 0.6016504852589418 1.207095490909828e-06 0.5986039825107707 \
1.207095622374795e-06 0.5955897059985247 1.207095741804594e-06 0.5928552647156846 1.207095877873286e-06 0.5897484304797134 1.207095992801548e-06 0.5871283594046445 \
1.207096143912269e-06 0.5836892419704927 1.207096258561337e-06 0.5810871834776226 1.207096376499006e-06 0.5784138884735546 1.207096466280294e-06 0.576381560286313 \
1.207096556599689e-06 0.5743415774978985 1.207096623290559e-06 0.5728373329037385 1.207096688852373e-06 0.5713590910263378 1.207096739894496e-06 0.5702089751121119 \
1.207096801596215e-06 0.5688198806440578 1.207096864686071e-06 0.5674025889664359 1.207096929044425e-06 0.5659586381304559 1.207096982438224e-06 0.5647616504486359 \
1.207097075080806e-06 0.5626864159088959 1.207097151688079e-06 0.5609719030357503 1.207097207513141e-06 0.5597256439368602 1.207097276567267e-06 0.5581857825097393 \
1.207097383455393e-06 0.5558054549196561 1.207097461199018e-06 0.5540764009223496 1.207097562049117e-06 0.5518382286767042 1.207097687729972e-06 0.5490568313009737 \
1.207097787971657e-06 0.5468419758621708 1.20709789988934e-06 0.5443739014182352 1.207098003155247e-06 0.5421024366463116 1.207098122904589e-06 0.5394737463112931 \
1.207098224637469e-06 0.5372436950013484 1.207098340157213e-06 0.5347185748314579 1.207098455192299e-06 0.5322102907975605 1.207098581673211e-06 0.529456475824718 \
1.207098707047009e-06 0.5267350629320526 1.207098853862932e-06 0.5235577714138258 1.207098989426381e-06 0.5206304261698983 1.207099147124634e-06 0.5172373565578411 \
1.207099309443689e-06 0.5137528589513558 1.207099490267585e-06 0.5098871206809381 1.207099682715905e-06 0.5057874350093188 1.207099895621209e-06 0.5012700264709963 \
1.207100127802608e-06 0.4963634062180514 1.207100385093187e-06 0.4909555076455908 1.20710062471901e-06 0.4859407514401474 1.207100926434446e-06 0.479662588092526 \
1.2071012143538e-06 0.4737079198104491 1.207101527242619e-06 0.4672821326282255 1.207101846980824e-06 0.4607585360408045 1.207102186575985e-06 0.4538766993710576 \
1.207102513478483e-06 0.4472977926730654 1.207102849036864e-06 0.4405887635920606 1.207103166132787e-06 0.4342949501181722 1.207103500370542e-06 0.4277061431972559 \
1.207103851801663e-06 0.4208322784122511 1.207104166327818e-06 0.4147233751108969 1.207104489505308e-06 0.4084912998479469 1.207104930620066e-06 0.400057814108821 \
1.207105272736104e-06 0.3935812134363078 1.207105572680633e-06 0.3879522399691127 1.207105947811639e-06 0.3809760137481454 1.207106277555878e-06 0.3749002425561211 \
1.207106560798804e-06 0.3697269896098562 1.207106860945059e-06 0.3642865787664632 1.207107140547253e-06 0.3592589179584539 1.207107364323365e-06 0.3552676761685443 \
1.207107576103695e-06 0.3515151294490645 1.207107778537159e-06 0.3479514629380864 1.207107979628427e-06 0.3444362246481504 1.207108185342845e-06 0.3408632458568372 \
1.207108452965717e-06 0.3362478643926977 1.207108691897011e-06 0.3321601360780691 1.207108925403074e-06 0.3281974319442653 1.207109138868474e-06 0.3246000376975314 \
1.207109360246046e-06 0.3208952602338652 1.207109560209693e-06 0.3175728982722026 1.207109764482006e-06 0.3142073831356898 1.207109961828878e-06 0.3109812293225088 \
1.207110147201405e-06 0.3079732989686547 1.207110343307796e-06 0.3048147723336881 1.207110545584936e-06 0.3015820927993307 1.207110721243233e-06 0.2988007390096292 \
1.20711090711339e-06 0.295878328903569 1.207111114092783e-06 0.2926488196724605 1.207111299414374e-06 0.2897857719971084 1.207111494641182e-06 0.2867989994419413 \
1.207111650415531e-06 0.28443329608414 1.207111829172313e-06 0.2817356906084737 1.207112010203233e-06 0.2790344478478936 1.207112160100347e-06 0.2768142575519123 \
1.207112361143774e-06 0.273859574769726 1.207112510258904e-06 0.2716833853889438 1.207112648798334e-06 0.2696726034832688 1.207112800673409e-06 0.2674956304896134 \
1.207112915147538e-06 0.2658586287383957 1.207113046677468e-06 0.2639823142040156 1.207113172435956e-06 0.2622048582339201 1.207113276776362e-06 0.2607341604582348 \
1.207113389755722e-06 0.2591418073851619 1.207113506084246e-06 0.2575033437579446 1.207113649011668e-06 0.2554974228347739 1.207113762273173e-06 0.2539102348881249 \
1.207113896429905e-06 0.2520298733123076 1.20711400690271e-06 0.2504818583075984 1.207114162335285e-06 0.2483006006477398 1.207114303220384e-06 0.2463217957442577 \
1.207114454612954e-06 0.2441928603691365 1.207114609775035e-06 0.2420086586735095 1.207114739184284e-06 0.2401849910837116 1.207114873896377e-06 0.2382868210192302 \
1.207115011594202e-06 0.2363478190565156 1.207115129346217e-06 0.2346905900295477 1.20711528867041e-06 0.2324499447852502 1.207115425932636e-06 0.2305210708572645 \
1.207115566678993e-06 0.2285488733964877 1.207115672470167e-06 0.2270688194984586 1.207115802411565e-06 0.2252532503786337 1.207115902948028e-06 0.2238506847401111 \
1.207116005281736e-06 0.2224250970611539 1.207116079010317e-06 0.2214012665004395 1.20711615824426e-06 0.2203047212273054 1.207116229215508e-06 0.2193236206014474 \
1.207116280678535e-06 0.218612902325451 1.207116333626988e-06 0.2178825126218075 1.207116412781991e-06 0.2167921001391954 1.207116455054626e-06 0.2162104926182252 \
1.207116494899171e-06 0.2156628374086678 1.207116538122821e-06 0.2150692779925967 1.207116579029822e-06 0.2145080585354088 1.207116649152284e-06 0.2135474129702876 \
1.207116682837256e-06 0.2130867492099046 1.207116727666638e-06 0.212477723463 1.2071167865238e-06 0.2116792343136102 1.207116851309261e-06 0.2108017053965978 \
1.207116908790025e-06 0.2100241135398916 1.207116969219033e-06 0.209207737948094 1.207117066255463e-06 0.2078991976528634 1.207117150945123e-06 0.2067595417901527 \
1.207117259855885e-06 0.2052972881712416 1.207117356256692e-06 0.2040065614180294 1.207117451273329e-06 0.2027428333585779 1.207117554705128e-06 0.2013717100485363 \
1.207117649634473e-06 0.2001158751783069 1.207117752654899e-06 0.198757993281026 1.207117857737332e-06 0.1973779917312911 1.207117967046146e-06 0.1959482000350934 \
1.207118077489628e-06 0.1945091075764383 1.207118193779904e-06 0.1929996650696684 1.207118303709896e-06 0.1915811184357085 1.20711841337232e-06 0.1901717999899754 \
1.207118515088966e-06 0.1888694322720079 1.207118608043679e-06 0.1876837490531375 1.207118700772569e-06 0.1865049219968967 1.207118774458125e-06 0.1855719169757668 \
1.20711885729934e-06 0.1845269810791141 1.207118931885337e-06 0.1835895008849975 1.207119001608678e-06 0.1827150226754214 1.207119068327086e-06 0.1818808699270075 \
1.207119164170411e-06 0.1806871657728035 1.207119246877184e-06 0.1796611249561687 1.207119340441008e-06 0.1785035608809835 1.207119435337095e-06 0.1773351434884491 \
1.207119546707405e-06 0.1759704596301353 1.207119688349759e-06 0.1742450478777388 1.207119803596612e-06 0.1728486436789435 1.207119948144251e-06 0.1711076225712051 \
1.207120059739928e-06 0.1697708811114609 1.207120200958902e-06 0.1680898955975501 1.207120316696176e-06 0.1667201145354908 1.207120422656861e-06 0.1654722325850081 \
1.207120521416477e-06 0.164314417410061 1.20712061775965e-06 0.1631901152369615 1.207120706417402e-06 0.1621596955203892 1.207120831751673e-06 0.1607099933926625 \
1.207120926277088e-06 0.1596224416957933 1.20712102401604e-06 0.1585042187118262 1.207121132110917e-06 0.1572745454417887 1.207121226778605e-06 0.1562036643369483 \
1.207121334226451e-06 0.1549951394274829 1.207121425315495e-06 0.1539767092330788 1.207121532087207e-06 0.1527896463435911 1.207121635480473e-06 0.1516469620792683 \
1.207121746560958e-06 0.1504267727114754 1.20712183578694e-06 0.1494522115900035 1.207121921266868e-06 0.1485231035185812 1.207122005192055e-06 0.1476157397758405 \
1.207122074898619e-06 0.1468658175993407 1.207122153536697e-06 0.1460232248551682 1.207122231847954e-06 0.1451880611912267 1.207122302483827e-06 0.1444378248611795 \
1.207122387974695e-06 0.1435337156153706 1.207122475363672e-06 0.1426139614481139 1.207122556951186e-06 0.1417594571206545 1.207122654270137e-06 0.1407454482154784 \
1.20712273495966e-06 0.139910090776864 1.207122825744691e-06 0.1389752404035735 1.207122947088963e-06 0.1377336220260025 1.207123036138604e-06 0.13682812281983 \
1.207123134655454e-06 0.1358318692385875 1.207123221741723e-06 0.1349560640726983 1.207123332152611e-06 0.1338550874529322 1.207123420611433e-06 0.1329791517134813 \
1.207123521340027e-06 0.1319874611681985 1.20712362612958e-06 0.1309622419763913 1.207123720519813e-06 0.1300442429014473 1.207123817024605e-06 0.1291112112475518 \
1.207123916511258e-06 0.1281591654439075 1.207124002912429e-06 0.1273384721630967 1.20712409789256e-06 0.1264411177628728 1.207124202081388e-06 0.1254629331099751 \
1.207124311200139e-06 0.124445178694 1.207124405550594e-06 0.1235704029653004 1.207124517846343e-06 0.1225411084520107 1.207124613309697e-06 0.1216733466577494 \
1.207124717520587e-06 0.1207311846737792 1.207124806865944e-06 0.1199276649878674 1.207124877253218e-06 0.1192980345746366 1.207124952639251e-06 0.1186268760051257 \
1.207125028771421e-06 0.1179522201461119 1.207125097748919e-06 0.1173458504859956 1.207125180268091e-06 0.1166263596898966 1.207125252211578e-06 0.1160015972854393 \
1.207125334290304e-06 0.1152916772467617 1.20712541862478e-06 0.1145654108773922 1.207125496418619e-06 0.113898375935255 1.207125589183521e-06 0.1131065723182637 \
1.207125704787342e-06 0.1121254933399327 1.207125810692911e-06 0.1112341778178403 1.207125888349831e-06 0.1105854195321705 1.207125976646302e-06 0.1098504899494786 \
1.207126056703354e-06 0.1091866403929743 1.207126153629479e-06 0.1083861389179563 1.207126248864964e-06 0.1076031391441806 1.207126337436159e-06 0.1068780200140514 \
1.20712643874426e-06 0.1060523297458165 1.207126544289947e-06 0.1051963702337609 1.207126653484312e-06 0.1043160928234657 1.207126761601933e-06 0.1034503663302994 \
1.207126881519694e-06 0.1024949450012773 1.207126982881521e-06 0.1016914181115986 1.207127088891151e-06 0.100855068690839 1.20712721468278e-06 0.09986840123414902 \
1.207127344240086e-06 0.09885896724496235 1.20712747991544e-06 0.09780904711780367 1.207127655987304e-06 0.09645781830037269 1.207127819787824e-06 0.09521257997344186 \
1.207127982612565e-06 0.09398642071914091 1.2071280677512e-06 0.09334985726464029 1.207128137589223e-06 0.09282999162688726 1.207128207084828e-06 0.09231474740697931 \
1.207128281043488e-06 0.09176875214326782 1.207128377198376e-06 0.09106241641841166 1.207128451613741e-06 0.09051841344162129 1.20712852960331e-06 0.08995079828656057 \
1.20712860605214e-06 0.08939693755534793 1.207128693546224e-06 0.08876614459792892 1.207128795722934e-06 0.08803382885421264 1.207128884287322e-06 0.08740269463919083 \
1.20712899395281e-06 0.08662585268124241 1.207129110009218e-06 0.08580942306245626 1.207129251558034e-06 0.0848216759818637 1.207129384427018e-06 0.08390253510334872 \
1.207129525187328e-06 0.08293727564630923 1.207129674896948e-06 0.08192024575105315 1.207129810608835e-06 0.08100683753927941 1.207129952125717e-06 0.08006309454860433 \
1.207130087247591e-06 0.07917070961097784 1.207130228520028e-06 0.07824718349428782 1.20713037561292e-06 0.07729532867436953 1.207130527122786e-06 0.07632524417621221 \
1.2071306924985e-06 0.07527819040792309 1.20713085625969e-06 0.07425356708383206 1.207131032389632e-06 0.07316505371836476 1.20713122152861e-06 0.07201151367936541 \
1.207131432202234e-06 0.07074528708793332 1.207131651768856e-06 0.06944624562626683 1.207131886535262e-06 0.06808094281860989 1.2071321449277e-06 0.06660616301228137 \
1.207132439592361e-06 0.06496103773121734 1.207132743671683e-06 0.06330286177969326 1.207133104582163e-06 0.06138472526627536 1.207133440499035e-06 0.05964719353945821 \
1.207133880676406e-06 0.05743991201668189 1.207134259043809e-06 0.05560437501227136 1.207134701502772e-06 0.05352996728430704 1.207135055522916e-06 0.05192508193542229 \
1.207135442039672e-06 0.05022502935509546 1.207135786643729e-06 0.04875485597254389 1.207136108618665e-06 0.04741934964807833 1.207136412152492e-06 0.04619304551845941 \
1.207136707073488e-06 0.04503122626702559 1.207136989555767e-06 0.04394770877170886 1.207137266636178e-06 0.04291147062934708 1.207137532363669e-06 0.04194013461971725 \
1.207137803594355e-06 0.0409708748276704 1.207138079853372e-06 0.04000619535229137 1.207138369752594e-06 0.03901828782233653 1.207138598128988e-06 0.03825741181922668 \
1.207138903013055e-06 0.03726495139513845 1.207139119684911e-06 0.03657573971894532 1.207139311041637e-06 0.03597943984071691 1.207139509636156e-06 0.03537298232318693 \
1.207139839551497e-06 0.03438820140908775 1.20714008149717e-06 0.03368375433354889 1.207140396809222e-06 0.03278771666975258 1.207140666929207e-06 0.03203957074185158 \
1.207140923300881e-06 0.03134567005659093 1.207141203312881e-06 0.03060515313352298 1.207141448968657e-06 0.02997014710356035 1.207141681704302e-06 0.02938120249260199 \
1.207141924434299e-06 0.02878348292867495 1.207142161161563e-06 0.02821317433052753 1.207142389807975e-06 0.0276732289298247 1.207142807093635e-06 0.02671456010533928 \
1.207143002274329e-06 0.02627749693639509 1.207143383441411e-06 0.02544369227895442 1.207143560694233e-06 0.02506446942885681 1.207143903145688e-06 0.02434654114125227 \
1.20714405641412e-06 0.02403127656358269 1.207144431432584e-06 0.02327616399748992 1.207144569066725e-06 0.02300530455388665 1.207145053333359e-06 0.02207084195640928 \
1.20714517295276e-06 0.02184403312078184 1.207145589991564e-06 0.02106026682208277 1.207145733393791e-06 0.02079332360769017 1.207146254605173e-06 0.01984598817089831 \
1.207146382379043e-06 0.0196205814374062 1.207146966791417e-06 0.01863359713481367 1.207147139226823e-06 0.01835589372257288 1.207147743323573e-06 0.01743644241612937 \
1.207147904755214e-06 0.01720262545858322 1.207148544701434e-06 0.01631831686205014 1.207148723017601e-06 0.016083210242981 1.207149371001649e-06 0.01526127675881721 \
1.20714953625524e-06 0.01505930898173208 1.207150272557175e-06 0.01419381259610907 1.207150406833226e-06 0.01404154276213586 1.207151203932743e-06 0.01317592498067951 \
1.207151344530355e-06 0.01302934089458718 1.207152309873577e-06 0.0120661300044765 1.207152474212383e-06 0.01190857475316222 1.207153474943512e-06 0.01099048917119646 \
1.207153612213369e-06 0.01087009009405628 1.207154750907886e-06 0.009949273443646761 1.207154865085787e-06 0.009863136028526375 1.207156245730622e-06 0.008889755784408603 \
1.207156400087833e-06 0.00878832203975914 1.207157946582061e-06 0.00781340401000951 1.207158030943764e-06 0.007760176032106158 1.207159716371082e-06 0.006770348169342283 \
1.207159839899572e-06 0.00670487246831437 1.207161889714139e-06 0.005720970231232756 1.207162086114296e-06 0.005634691917282852 1.207164404793654e-06 0.004698942116576918 \
1.207164865407989e-06 0.004530544077955615 1.207167605503531e-06 0.003639937533647344 1.207168123648567e-06 0.00349159181499799 1.207172274289875e-06 0.002502201117031859 \
1.207172812139883e-06 0.002396807933581942 1.20717889437533e-06 0.001421603691354927 1.207179153355741e-06 0.001378272220758726 1.20718447611909e-06 0.0003814093765652445 \
1.207184589276134e-06 0.0003711807182531981 1.20983070639237e-06 -0.0004615907568095335 1.209830868831338e-06 -0.0006852153244161934 1.209831369832807e-06 -0.001554404032531494 \
1.20983145401537e-06 -0.001725199767551738 1.209831855538194e-06 -0.002626792336557519 1.209831944873161e-06 -0.002845673237760077 1.20983223146497e-06 -0.0035898660494722 \
1.209832359033499e-06 -0.003937855927128601 1.209832677745161e-06 -0.004830400105952924 1.209832791946314e-06 -0.00515011308870196 1.209833074346638e-06 -0.005887653497963378 \
1.209833204572857e-06 -0.006177415671381139 1.209834182925754e-06 -0.005220113099403402 1.209834370233287e-06 -0.004004368716724641 1.209834501677689e-06 -0.002901539130564616 \
1.209834607105242e-06 -0.001869327786897239 1.209834692822726e-06 -0.0009323217369615201 1.209834774749213e-06 4.151965372454519e-05 1.209834895786036e-06 0.001618129410352471 \
1.209834994714683e-06 0.003024565667809575 1.209835153111357e-06 0.005482561958548801 1.209835370558587e-06 0.00923691162542661 1.20983555178081e-06 0.0126653356758144 \
1.209835763874906e-06 0.01697021734206094 1.209835926898563e-06 0.02046388365739064 1.209836087520979e-06 0.02403759527126768 1.209836241061221e-06 0.02755862871109176 \
1.209836389117902e-06 0.031036270750196 1.209836538198811e-06 0.03460722192241437 1.209836692728723e-06 0.03837091703902212 1.209836853379538e-06 0.04234026030123839 \
1.209837018034219e-06 0.04645786783841532 1.209837194575117e-06 0.05091770581196236 1.209837373537969e-06 0.05547793877747508 1.209837564281134e-06 0.0603721650098247 \
1.209837769062163e-06 0.06565647483694508 1.209837989534449e-06 0.07137203566208646 1.209838222394174e-06 0.0774299331224613 1.20983847158165e-06 0.08392829098722057 \
1.209838744423778e-06 0.09105513637423955 1.209839041127578e-06 0.09880974921055499 1.209839368453968e-06 0.1073623706929605 1.209839738105355e-06 0.11701033799881 \
1.209840132977169e-06 0.1273002725707723 1.20984059081541e-06 0.1392030195235975 1.20984112262225e-06 0.1529832553757746 1.209841747860046e-06 0.1691182447448397 \
1.209842433607518e-06 0.1867241161332086 1.209843236003391e-06 0.2071957342970069 1.209844134802183e-06 0.2299563735557614 1.209844940415633e-06 0.2501946571168963 \
1.209845654166966e-06 0.2679877251922811 1.209846283728848e-06 0.2835633151515627 1.209846854092298e-06 0.2975737963344939 1.20984738504768e-06 0.3105173405876944 \
1.209847886835131e-06 0.3226580892822354 1.209848366129685e-06 0.3341673054699896 1.209848831685103e-06 0.3452566901045974 1.209849295481511e-06 0.3562094254686541 \
1.209849751229541e-06 0.3668794056881832 1.209850211449675e-06 0.3775613305945491 1.209850749733646e-06 0.3899285626759094 1.20985125058418e-06 0.4013172511919189 \
1.209851650806863e-06 0.4103337945930838 1.209852157667644e-06 0.421642452039157 1.209852643633856e-06 0.4323669409017459 1.209853043148568e-06 0.4410997362599856 \
1.209853453760627e-06 0.4500002277813482 1.20985388268706e-06 0.4592207708982954 1.209854284201442e-06 0.4677760623951868 1.209854591591889e-06 0.4742753916877908 \
1.209854941833647e-06 0.4816249679276425 1.209855295073851e-06 0.4889795533930016 1.20985554824443e-06 0.4942125642332652 1.20985578118832e-06 0.4989990073547648 \
1.209856022831611e-06 0.5039392821429431 1.20985624782223e-06 0.5085102868389438 1.209856439858338e-06 0.5123881070394828 1.209856624670034e-06 0.5161059569497825 \
1.20985684696035e-06 0.5205538992744256 1.209857013671758e-06 0.5238726938135662 1.209857230888353e-06 0.5281726418673847 1.209857433967244e-06 0.5321820613122353 \
1.209857611378699e-06 0.5356681922482178 1.209857799451086e-06 0.5393528234657015 1.209858035483266e-06 0.5439555888699217 1.20985830136529e-06 0.5491186112539347 \
1.209858523127178e-06 0.5534070305875756 1.209858803185033e-06 0.5588091140818973 1.209859046184818e-06 0.5634839438879177 1.209859321538161e-06 0.5687575845994758 \
1.209859566533502e-06 0.5734440561015828 1.209859806827721e-06 0.5780305526007354 1.209860047867023e-06 0.5826153106864888 1.209860305457841e-06 0.5874946531182738 \
1.209860540824618e-06 0.5919209497705462 1.209860772126727e-06 0.5962518282209535 1.209860994653448e-06 0.6003950532231523 1.209861203013056e-06 0.6042587207462122 \
1.209861440854871e-06 0.6086392006348278 1.209861651715086e-06 0.612499186772883 1.209861907322267e-06 0.617151767543529 1.209862106050033e-06 0.620751700070918 \
1.209862381682677e-06 0.6257066023742009 1.209862604438798e-06 0.6296824120643636 1.209862897809922e-06 0.6348814180513288 1.209863130579923e-06 0.6389753720667986 \
1.209863350781309e-06 0.6428252659334456 1.209863552051921e-06 0.6463216644290061 1.209863769340794e-06 0.6500784077528632 1.209863944056704e-06 0.6530842133917786 \
1.209864130321334e-06 0.6562672470877895 1.209864309060386e-06 0.6593113758161715 1.209864471764399e-06 0.6620700940033843 1.20986463703341e-06 0.6648583661366954 \
1.209864780301224e-06 0.6672607123132118 1.209864919531648e-06 0.669583864918244 1.209865059332215e-06 0.6719085596965743 1.209865194107422e-06 0.6741424479378803 \
1.209865321601663e-06 0.6762463034350935 1.209865454555775e-06 0.6784344250006583 1.209865576160125e-06 0.680430207161383 1.209865704573366e-06 0.6825336955632141 \
1.209865820340421e-06 0.6844241240890321 1.209865918381594e-06 0.686020684362688 1.2098660190777e-06 0.687656981754083 1.209866128831463e-06 0.689434454762776 \
1.209866245599418e-06 0.6913211166705923 1.209866336826192e-06 0.6927889453402305 1.209866446031605e-06 0.6945396927028351 1.209866547140326e-06 0.6961566646470493 \
1.209866642540618e-06 0.6976767415743361 1.209866752022643e-06 0.6994136821864276 1.209866886474277e-06 0.7015344809028976 1.209867035493214e-06 0.7038694457768003 \
1.209867164423232e-06 0.7058755144243859 1.209867311083691e-06 0.7081418729260142 1.209867437868072e-06 0.7100885084081828 1.209867562465961e-06 0.7119899232102255 \
1.209867674319728e-06 0.7136874821928206 1.209867787275692e-06 0.7153928249203609 1.209867887829089e-06 0.716903336497302 1.209868025110592e-06 0.7189542886859326 \
1.209868144979452e-06 0.7207346491296758 1.209868264162204e-06 0.7224952472954583 1.209868391164314e-06 0.7243608783177121 1.209868515712665e-06 0.726179956024653 \
1.209868639383676e-06 0.7279757435764195 1.209868765971953e-06 0.7298035010246171 1.209868896541188e-06 0.7316777339938921 1.209869019056222e-06 0.7334262671520465 \
1.209869155299713e-06 0.7353588786631546 1.209869256742486e-06 0.7367901064855561 1.209869362765969e-06 0.7382789144707947 1.209869453297152e-06 0.7395446819117977 \
1.209869567123378e-06 0.7411267287627761 1.209869654784961e-06 0.742338113895605 1.209869760680238e-06 0.7437932991468792 1.209869891033533e-06 0.7455718205320391 \
1.20987000160114e-06 0.7470699275523445 1.209870106271612e-06 0.7484790865773925 1.209870230233143e-06 0.7501360792234356 1.209870378790597e-06 0.752105598322839 \
1.209870500473193e-06 0.7537054667443914 1.209870614584883e-06 0.7551949470168074 1.209870755005484e-06 0.7570132059451244 1.209870896533544e-06 0.7588296197226846 \
1.209871014322814e-06 0.7603289862386273 1.209871142522635e-06 0.7619481626911874 1.209871284590468e-06 0.7637269294216019 1.209871401465576e-06 0.7651780119234867 \
1.209871547139362e-06 0.7669714049983392 1.20987166887781e-06 0.7684572223066155 1.209871787518301e-06 0.7698939375992205 1.209871909984595e-06 0.7713653733660819 \
1.209872036701685e-06 0.7728756341192486 1.209872146603679e-06 0.7741754302862822 1.209872272219022e-06 0.7756497674172792 1.209872378029431e-06 0.7768823528242577 \
1.209872514199553e-06 0.7784559787239111 1.209872638546601e-06 0.7798807766277074 1.209872765971877e-06 0.7813271999647126 1.209872880527956e-06 0.7826155184370988 \
1.209872987208226e-06 0.7838050786084815 1.209873125150823e-06 0.785328674235108 1.209873274600319e-06 0.7869612315653352 1.209873419452537e-06 0.7885256944569791 \
1.209873538888287e-06 0.7898026796320731 1.20987367431316e-06 0.7912364721526877 1.209873795807481e-06 0.7925100718437531 1.209873939166556e-06 0.7939977458315933 \
1.209874082600237e-06 0.7954699260458764 1.209874208411247e-06 0.7967479640295563 1.209874327457929e-06 0.7979459892863545 1.209874439471573e-06 0.7990632136113104 \
1.209874544263454e-06 0.8000996927221937 1.209874639456303e-06 0.8010335634530776 1.209874775866829e-06 0.8023587211299719 1.209874892679005e-06 0.8034813603122919 \
1.209875012140248e-06 0.8046180202255495 1.2098751341806e-06 0.8057672874017472 1.209875257080697e-06 0.8069126780167393 1.209875384200053e-06 0.8080849010520604 \
1.209875509341915e-06 0.8092265787736463 1.209875639893142e-06 0.8104047139317369 1.209875765969389e-06 0.811530109085512 1.209875893966049e-06 0.8126603425876329 \
1.209875999427297e-06 0.8135823118114501 1.209876102696598e-06 0.814477091043954 1.209876195349946e-06 0.8152732203909091 1.209876319044181e-06 0.8163262937528154 \
1.209876406664096e-06 0.8170655553659417 1.209876505330151e-06 0.8178914289762149 1.209876648877154e-06 0.819080619224994 1.209876784463307e-06 0.8201904093102529 \
1.209876893653288e-06 0.8210742465492874 1.209877041102747e-06 0.8222539401850584 1.209877191506449e-06 0.8234410273756358 1.209877316975412e-06 0.8244188977545531 \
1.209877461141395e-06 0.8255287290252299 1.20987758542996e-06 0.8264738611628292 1.209877735900256e-06 0.8276038147969816 1.209877871506615e-06 0.8286089145501508 \
1.209877996601616e-06 0.8295251220930787 1.209878114317453e-06 0.8303776282987162 1.209878260203052e-06 0.8314210189912619 1.209878426696148e-06 0.8325942517713072 \
1.209878557562851e-06 0.833503494447128 1.209878731007462e-06 0.8346911703335461 1.209878899140202e-06 0.8358239212093587 1.20987906899395e-06 0.8369500705213252 \
1.209879249886955e-06 0.838129582835239 1.209879393021216e-06 0.8390486258646698 1.209879507119162e-06 0.8397723391454259 1.209879637246322e-06 0.8405879656882547 \
1.209879739102179e-06 0.8412191375388212 1.209879855947599e-06 0.8419354178465567 1.209879992919396e-06 0.84276453896487 1.209880190759142e-06 0.843942473808897 \
1.20988038244463e-06 0.8450620046306492 1.209880591850993e-06 0.8462610422160779 1.209880773861877e-06 0.8472832413425977 1.209880970977334e-06 0.8483697584184032 \
1.209881144290447e-06 0.8493077402131245 1.209881327325656e-06 0.8502809338042043 1.209881498478783e-06 0.8511747489972419 1.209881673131736e-06 0.8520708361396651 \
1.209881848382891e-06 0.8529540285731302 1.209882024530391e-06 0.8538259128238825 1.209882214836779e-06 0.8547503816925358 1.209882405427748e-06 0.8556583881771193 \
1.209882605979791e-06 0.8565949481971697 1.209882798582589e-06 0.8574764650234362 1.209883009331288e-06 0.8584213553684483 1.209883237362186e-06 0.8594210644592908 \
1.209883503241952e-06 0.8605573106989262 1.209883801820094e-06 0.8617960322792503 1.209884077983729e-06 0.8629075153790151 1.209884362230229e-06 0.8640180616030438 \
1.209884636414231e-06 0.8650581816846495 1.20988490866944e-06 0.8660616517296992 1.209885178858915e-06 0.8670295451208139 1.209885436023238e-06 0.8679256252637404 \
1.209885708596972e-06 0.8688492356117473 1.209885984602435e-06 0.8697577927663542 1.209886254710518e-06 0.8706213441784563 1.209886554568938e-06 0.8715508809746347 \
1.209886925582816e-06 0.8726599440782473 1.209887220515529e-06 0.873510245983525 1.209887474800896e-06 0.8742218447789023 1.209887773044171e-06 0.8750318897722944 \
1.209888046640929e-06 0.8757523113099853 1.209888282767907e-06 0.8763571312809064 1.209888523107206e-06 0.876957042728428 1.209888745440861e-06 0.8774982514557473 \
1.209888939446794e-06 0.8779599514934209 1.209889269165229e-06 0.8787226653583874 1.209889424338019e-06 0.8790722725343518 1.20988974207141e-06 0.8797700114458387 \
1.20988992093906e-06 0.880152324917399 1.209890263400534e-06 0.8808637455080008 1.209890447552368e-06 0.8812353200296749 1.209890922478419e-06 0.8821594045029107 \
1.209891089871654e-06 0.8824737723885729 1.209891555692961e-06 0.8833186808430151 1.209891736520447e-06 0.883635209600208 1.209892230549786e-06 0.8844687288968743 \
1.209892371887773e-06 0.8846990198924604 1.209892978249103e-06 0.8856473543416146 1.209893130320955e-06 0.8858754372639542 1.209893777008948e-06 0.8868048391838264 \
1.209893905303109e-06 0.8869818633102416 1.209894553496582e-06 0.8878410756373726 1.209894683245133e-06 0.8880061989117775 1.209895451498601e-06 0.8889361126992519 \
1.209895581240626e-06 0.8890847997417872 1.209896434697558e-06 0.8900046759307325 1.209896577924673e-06 0.8901495209380393 1.209897564158077e-06 0.8910738355210844 \
1.209897785636141e-06 0.8912643084423501 1.209898928653689e-06 0.8921737958641509 1.20989905863199e-06 0.8922730011388891 1.209900410338988e-06 0.8932565980587214 \
1.209900560692342e-06 0.8933589605607284 1.209902041315768e-06 0.8942730372387374 1.20990228021907e-06 0.8944047337041336 1.209904061344228e-06 0.8952702388217941 \
1.209904447325595e-06 0.8954343910560414 1.209906848871635e-06 0.896309305076933 1.20990732380842e-06 0.8964562995603377 1.20991114197014e-06 0.8973944547681553 \
1.209911624459337e-06 0.897487269196476 1.20991951047485e-06 0.898471373493449 1.20992012663754e-06 0.8985180228791175 1.210015282612379e-06 0.899508178894561 \
1.210016773214557e-06 0.8995204306067698 1.210128061288741e-06 0.9005118233983579 1.210128237625744e-06 0.9005706457326812 1.210131860757067e-06 0.8996048713171836 \
1.210132041955094e-06 0.8994654179496379 1.210133353076571e-06 0.8985275682722235 1.210133534953976e-06 0.8984123497545736 1.21013535794417e-06 0.8974436520388238 \
1.210135517857424e-06 0.8973766233009967 1.210148668688723e-06 0.8983720910457982 1.210148779670277e-06 0.8983905835035384 1.210157601254383e-06 0.8993863063850064 \
1.210158148023847e-06 0.8994226481040219 1.210650719976681e-06 0.9003987622903815 1.210650789769166e-06 0.9004496773542636 1.210651622421929e-06 0.9012853800543292 \
1.210651748468094e-06 0.9014513953152168 1.210652328988958e-06 0.9023435091985418 1.210652469953212e-06 0.9025895326188698 1.210652869091291e-06 0.9033428289365844 \
1.210653019240832e-06 0.9036449200440446 1.210653462322154e-06 0.9045762589490434 1.210653619494256e-06 0.9049121924877023 1.210654065120987e-06 0.9058152254958243 \
1.210654163577326e-06 0.9059929146639856 1.21065558025872e-06 0.9052304871087643 1.210655711415865e-06 0.904616184869324 1.210655880423041e-06 0.9036290332250884 \
1.210656045714917e-06 0.9024406226812831 1.210656151980698e-06 0.9015554774641358 1.210656255417528e-06 0.9006052096506509 1.210656341184247e-06 0.8997486040545581 \
1.210656430678233e-06 0.8987887485205278 1.210656554922632e-06 0.8973492764100613 1.210656673003581e-06 0.8958624931586439 1.210656760219672e-06 0.8946938835082598 \
1.210656884526716e-06 0.8929289312882503 1.210656991510644e-06 0.8913158670103165 1.210657091342348e-06 0.8897378501708729 1.210657217633174e-06 0.8876466417139378 \
1.210657385821785e-06 0.884705368138502 1.210657541521538e-06 0.8818365157686672 1.210657738126367e-06 0.8780362649814708 1.210657921747617e-06 0.8743271923380105 \
1.21065813325501e-06 0.8698916163736473 1.210658314064811e-06 0.8659808238081558 1.210658498645858e-06 0.8618945354625286 1.210658671649854e-06 0.8579913311618118 \
1.210658857050504e-06 0.8537436868396935 1.210659036133651e-06 0.8495884889292737 1.210659219722713e-06 0.8452850234109005 1.210659386484418e-06 0.8413449312544377 \
1.210659554574996e-06 0.8373487193315756 1.210659717684167e-06 0.8334514816705533 1.210659872870403e-06 0.829729402178684 1.210660045969282e-06 0.8255639501984255 \
1.210660231959738e-06 0.8210763864673301 1.210660396580222e-06 0.8170961425007568 1.210660561450132e-06 0.8131038678717658 1.210660736782165e-06 0.8088537582860886 \
1.210660901208668e-06 0.8048648186953292 1.210661069844279e-06 0.8007719922541914 1.210661260647645e-06 0.7961398815555145 1.210661446171819e-06 0.7916360074082958 \
1.210661655100628e-06 0.7865651471012967 1.210661879917618e-06 0.7811107659751856 1.210662069732705e-06 0.77650678233121 1.210662271590188e-06 0.7716133355283564 \
1.210662415860827e-06 0.76811790639139 1.210662557504393e-06 0.7646880872338248 1.210662685202102e-06 0.7615975116975136 1.210662796247944e-06 0.7589113686396982 \
1.21066292481058e-06 0.7558028559024855 1.210663057376087e-06 0.7525995467138866 1.210663170697783e-06 0.7498629233610832 1.210663307032409e-06 0.7465723252212872 \
1.210663413431661e-06 0.7440058350410135 1.210663572650447e-06 0.7401674766516904 1.210663745028142e-06 0.7360137588823189 1.210663907275386e-06 0.7321074183421575 \
1.210664079624344e-06 0.7279612819449855 1.210664239010527e-06 0.7241302920521341 1.210664446815714e-06 0.7191408067115369 1.210664607355379e-06 0.7152908836069264 \
1.210664799844715e-06 0.7106793324906435 1.210664985361064e-06 0.7062404417184839 1.210665155237109e-06 0.7021802791355866 1.210665347106947e-06 0.6975984806629684 \
1.210665493330962e-06 0.6941099299715526 1.210665653617309e-06 0.6902897983225644 1.210665856006145e-06 0.6854719661536142 1.210666037294609e-06 0.681161582477689 \
1.210666206116036e-06 0.6771536053116509 1.210666391961911e-06 0.6727470762459599 1.210666597892751e-06 0.6678715161770782 1.210666765819558e-06 0.6639016226084196 \
1.210666926081262e-06 0.6601182542089066 1.210667164933735e-06 0.65448589698252 1.210667332694849e-06 0.6505369020837752 1.210667513768288e-06 0.6462813620835641 \
1.210667674923199e-06 0.642499550819208 1.21066782119046e-06 0.6390715923276049 1.210667959878569e-06 0.6358268652274862 1.210668089235615e-06 0.6328040340451749 \
1.21066821862017e-06 0.6297855584526113 1.21066834694149e-06 0.6267952385336898 1.210668477143629e-06 0.6237652412672913 1.210668606160074e-06 0.6207683673242944 \
1.210668744735633e-06 0.6175525629501428 1.21066889281122e-06 0.6141227553162802 1.210669079138505e-06 0.60981438109949 1.210669226822204e-06 0.6064079319686639 \
1.21066946198641e-06 0.600995965122186 1.210669654434141e-06 0.5965821560879089 1.210669895003955e-06 0.5910808370261941 1.210670064051326e-06 0.587228367631822 \
1.21067020171775e-06 0.5840969866928536 1.210670329822727e-06 0.581191110277254 1.210670443409422e-06 0.5786182870235701 1.210670534774226e-06 0.5765512826027382 \
1.210670624196113e-06 0.5745328691003393 1.210670691457846e-06 0.573016830490748 1.210670757478049e-06 0.5715297341779608 1.210670809531724e-06 0.5703577032508095 \
1.210670873770593e-06 0.5689124506700958 1.210670935307116e-06 0.5675311492520995 1.21067099958866e-06 0.5660899724818867 1.210671052779756e-06 0.5648985048860162 \
1.21067114512554e-06 0.5628316153148989 1.210671221701441e-06 0.5611191615154557 1.210671277545091e-06 0.5598732849310241 1.2106713468882e-06 0.5583285932816697 \
1.210671452739476e-06 0.5559733466166974 1.21067153043128e-06 0.5542469170533902 1.210671631029868e-06 0.5520159549745236 1.210671759063078e-06 0.5491849411292137 \
1.21067185856046e-06 0.5469885705929382 1.210671971125811e-06 0.544508366501287 1.210672074170131e-06 0.5422442603473754 1.210672194219017e-06 0.5396115972585003 \
1.210672295833426e-06 0.5373863339265779 1.210672411457693e-06 0.5348611538529422 1.210672526573874e-06 0.5323536236546169 1.210672653010918e-06 0.529604142030661 \
1.210672778525186e-06 0.5268822104345234 1.210672925204862e-06 0.5237112381511962 1.21067306087557e-06 0.5207845659358002 1.210673218641409e-06 0.5173942078023266 \
1.21067338106335e-06 0.5139116507621072 1.210673561971818e-06 0.5100482739823553 1.210673754563972e-06 0.5059503908118104 1.210673967555743e-06 0.5014368974673542 \
1.21067419998846e-06 0.4965308659362653 1.210674457509373e-06 0.49112491222925 1.210674697473551e-06 0.4861095397820235 1.210674998677906e-06 0.4798501326413723 \
1.210675286975534e-06 0.4738957353990632 1.210675600061861e-06 0.4674739717793394 1.210675919588141e-06 0.4609631488871989 1.210676259085406e-06 0.4540919149088484 \
1.210676585275518e-06 0.4475353831519197 1.21067692175678e-06 0.4408159131180407 1.210677238467587e-06 0.4345373385230166 1.21067757255266e-06 0.4279587671099637 \
1.210677924261529e-06 0.4210864038135054 1.210678238746378e-06 0.4149846225409808 1.210678562192836e-06 0.4087533091618546 1.210679003120949e-06 0.400331870031168 \
1.210679344916025e-06 0.3938679283557566 1.210679644350069e-06 0.3882534014213259 1.210680018872672e-06 0.3812944595528024 1.21068034825039e-06 0.375233915169682 \
1.210680631354694e-06 0.3700684563936956 1.210680931099705e-06 0.3646408765157301 1.210681210595549e-06 0.3596219010422631 1.210681434267487e-06 0.3556377385586224 \
1.210681645979195e-06 0.3518907610576284 1.210681848481927e-06 0.3483292724130969 1.210682049543475e-06 0.3448190020587957 1.210682255221384e-06 0.3412518188287665 \
1.21068247359686e-06 0.3374887625241871 1.210682717359257e-06 0.3333167726275162 1.21068294411583e-06 0.3294678078423895 1.210683164026801e-06 0.3257615367192951 \
1.210683382451408e-06 0.3221060038181086 1.210683586476418e-06 0.318715141566024 1.210683788334208e-06 0.3153870758963987 1.210683988657596e-06 0.3121102802474151 \
1.210684175271502e-06 0.309079115007194 1.210684372573109e-06 0.3058982938882217 1.210684581156335e-06 0.3025606704206737 1.210684786791057e-06 0.2992974534031506 \
1.210685011523137e-06 0.2957609785165763 1.210685228418979e-06 0.2923771984023277 1.210685436098331e-06 0.2891642611511841 1.210685667149178e-06 0.2856239464683982 \
1.210685841949429e-06 0.2829684481899911 1.210686021147604e-06 0.2802647299798244 1.21068619002212e-06 0.2777348429135014 1.210686418345394e-06 0.274348458173166 \
1.210686595082661e-06 0.2717528218126659 1.210686763365392e-06 0.2693020894036587 1.210686935832162e-06 0.2668230333489093 1.210687069934441e-06 0.264903804409765 \
1.210687215894446e-06 0.2628277003548514 1.210687354589947e-06 0.2608803500812688 1.210687476871551e-06 0.2591684246570544 1.210687610990381e-06 0.2572942758553639 \
1.210687740091486e-06 0.2554978336754472 1.21068785952522e-06 0.2538430842138498 1.21068798636042e-06 0.2520939183506197 1.210688106001441e-06 0.2504447954274527 \
1.210688255617635e-06 0.2483797066042054 1.210688390481146e-06 0.2465170278296022 1.21068852003856e-06 0.2447289494531232 1.210688677103379e-06 0.2425624627506451 \
1.210688801099014e-06 0.2408491463446025 1.210688941247149e-06 0.2389135279283614 1.21068907114005e-06 0.2371200701944942 1.210689191757671e-06 0.2354534357320198 \
1.210689354230601e-06 0.2332087289724075 1.2106895002847e-06 0.2311905595759856 1.210689638605484e-06 0.2292825126447264 1.210689746532702e-06 0.2277949627009887 \
1.210689877317609e-06 0.225993474229161 1.210689975823626e-06 0.22463752857886 1.210690079906972e-06 0.2232056532573264 1.210690152783836e-06 0.2222046546567725 \
1.210690234937313e-06 0.2210804129356655 1.210690302346398e-06 0.2201585377209549 1.210690349050661e-06 0.2195201149856669 1.21069039846802e-06 0.2188449488487562 \
1.210690489422163e-06 0.2176035744446363 1.210690555816576e-06 0.2166983392055156 1.210690602779869e-06 0.2160586379972232 1.210690653091075e-06 0.2153737902794619 \
1.210690712240425e-06 0.2145693142997165 1.210690755086328e-06 0.2139870779821451 1.210690798893629e-06 0.2133941263688522 1.210690868423894e-06 0.2124566309962414 \
1.210690955340708e-06 0.2112864027023158 1.210691036529563e-06 0.2101949018929156 1.210691122429027e-06 0.2090416531541652 1.210691216575207e-06 0.2077796428137634 \
1.210691308329081e-06 0.2065517647617813 1.210691403625517e-06 0.2052788208685862 1.210691500104208e-06 0.2039945431316728 1.21069160092949e-06 0.2026602783061639 \
1.210691696885502e-06 0.2013924147365721 1.210691799571213e-06 0.2000377255165624 1.210691902607567e-06 0.1986831378210229 1.210692012697906e-06 0.1972405340748948 \
1.210692121449794e-06 0.1958206085628783 1.210692241171749e-06 0.1942631948714586 1.210692351614651e-06 0.1928328887741874 1.210692459617459e-06 0.1914411844406488 \
1.210692584973803e-06 0.1898318066870429 1.210692677907979e-06 0.1886434908940876 1.210692756278755e-06 0.1876443873000938 1.210692832918829e-06 0.1866698667869858 \
1.210692915430143e-06 0.1856249297118943 1.210692984939759e-06 0.1847473639743596 1.210693050895387e-06 0.1839166514106665 1.210693115162722e-06 0.1831089953192083 \
1.210693227146207e-06 0.1817072258029639 1.210693321200174e-06 0.1805353135896268 1.210693428841935e-06 0.1791985758407087 1.210693535314993e-06 0.1778827552324552 \
1.21069365530692e-06 0.1764073736674057 1.210693793359546e-06 0.174720142305475 1.210693909520101e-06 0.1733081217455876 1.210694071616903e-06 0.1713503924599185 \
1.21069418670542e-06 0.1699688234017716 1.210694326691019e-06 0.1682987764548305 1.210694443897095e-06 0.1669083002780509 1.210694554816447e-06 0.1655990025649634 \
1.210694652444933e-06 0.1644521190704843 1.210694747295481e-06 0.1633427224865242 1.210694863349894e-06 0.161991523106341 1.210694954898444e-06 0.1609305136382055 \
1.21069505100742e-06 0.1598214181625073 1.210695145225553e-06 0.1587403933520305 1.210695238726156e-06 0.1576732160104884 1.210695332323478e-06 0.1566104070550305 \
1.210695428005017e-06 0.1555300824433628 1.210695518592921e-06 0.1545132165873678 1.210695609606078e-06 0.1534969984004868 1.210695705154556e-06 0.1524358767948732 \
1.210695795820268e-06 0.1514342506187442 1.210695898892631e-06 0.1503020548964867 1.21069597134408e-06 0.1495100717445464 1.210696050444873e-06 0.148649146151682 \
1.210696124993092e-06 0.1478424742503694 1.210696196024501e-06 0.1470770917224498 1.210696268788982e-06 0.1462962409077327 1.210696343406157e-06 0.1454990959398698 \
1.210696413389118e-06 0.1447543557055888 1.210696487550038e-06 0.143968261688537 1.210696541295377e-06 0.1434005634796054 1.210696594578932e-06 0.1428396203849428 \
1.21069665977469e-06 0.1421555039833398 1.210696731080731e-06 0.141411576573238 1.210696795450793e-06 0.1407432786314442 1.210696868802754e-06 0.1399847409254479 \
1.210696929420321e-06 0.1393607073002494 1.210697015453805e-06 0.1384787080092832 1.210697091404821e-06 0.1377037134581418 1.210697181372726e-06 0.1367902106004182 \
1.210697263099684e-06 0.1359645165492482 1.210697345789662e-06 0.1351360437760365 1.210697428345969e-06 0.1343145513298757 1.210697533908125e-06 0.1332698421778018 \
1.210697615775408e-06 0.1324642397250402 1.210697713142868e-06 0.1315110876582503 1.210697803143729e-06 0.130634908321232 1.210697891113988e-06 0.1297829978838479 \
1.210697974043843e-06 0.1289892226181523 1.210698048280934e-06 0.1282822873521282 1.210698147931993e-06 0.1273377645104763 1.210698243687052e-06 0.1264350619688987 \
1.210698330534457e-06 0.1256206895242312 1.210698420535994e-06 0.1247808744623497 1.210698500868675e-06 0.1240346855852102 1.210698587562703e-06 0.1232365419604467 \
1.210698686393032e-06 0.1223331159004786 1.21069877647517e-06 0.1215131568528167 1.210698886718427e-06 0.1205141992263624 1.210698973949866e-06 0.1197275966302077 \
1.210699042523e-06 0.1191120727131645 1.210699127185393e-06 0.1183553887582162 1.210699193692874e-06 0.1177634990399222 1.210699265148799e-06 0.1171309945267847 \
1.210699334822604e-06 0.1165184920865242 1.210699412159692e-06 0.1158409171037389 1.210699507902975e-06 0.1150054407698888 1.210699579157887e-06 0.1143861389207103 \
1.21069964652742e-06 0.1138025718558601 1.210699714964191e-06 0.113211685696446 1.210699790554542e-06 0.1125613765304429 1.210699881296389e-06 0.1117840233035959 \
1.210699964000116e-06 0.1110788257213999 1.210700077599187e-06 0.1101151050704521 1.210700187474899e-06 0.1091895325357105 1.210700279674213e-06 0.1084169374841771 \
1.210700403623545e-06 0.1073835127717347 1.210700491987867e-06 0.1066505015902263 1.210700631446837e-06 0.1055001025916527 1.210700730743538e-06 0.1046863788921388 \
1.21070082339359e-06 0.1039306459201802 1.210700933598102e-06 0.1030359883605075 1.210701018892542e-06 0.1023467905686673 1.210701103793345e-06 0.101663637589173 \
1.210701186744309e-06 0.1009989740617136 1.21070130925421e-06 0.1000225794851696 1.210701431196063e-06 0.09905761200121259 1.210701557818349e-06 0.09806258992746317 \
1.210701670630472e-06 0.09718220909187772 1.210701815205957e-06 0.09606278874246346 1.210701952919885e-06 0.09500564015228773 1.210702069610674e-06 0.09411672853020667 \
1.210702197354242e-06 0.0931507147971556 1.210702297018758e-06 0.09240236948627445 1.210702376452638e-06 0.09180921593916676 1.210702475187936e-06 0.09107599640376031 \
1.210702553063239e-06 0.09050081472416407 1.210702634529155e-06 0.08990210528957472 1.210702709246463e-06 0.0893557072655629 1.210702789776201e-06 0.08876971652456604 \
1.210702908608526e-06 0.08791061481419053 1.210702998269062e-06 0.08726673116015753 1.210703103183109e-06 0.08651800316437093 1.210703234657667e-06 0.08558693768262025 \
1.210703395765802e-06 0.08445695903909305 1.210703535947497e-06 0.08348350561263763 1.210703684450103e-06 0.08246223579158835 1.210703821170292e-06 0.08153124812726546 \
1.210703961182002e-06 0.08058696725890066 1.210704098179202e-06 0.07967195061625794 1.210704236789813e-06 0.07875532825288725 1.2107043812627e-06 0.07780967510081127 \
1.210704528808937e-06 0.07685421131041187 1.210704686312648e-06 0.07584560580436887 1.210704850707884e-06 0.07480523464991846 1.210705018799982e-06 0.07375451744755303 \
1.210705199799341e-06 0.07263751640721161 1.210705398512623e-06 0.07142823309373261 1.210705611921415e-06 0.07014922396308329 1.2107058380853e-06 0.06881630383186611 \
1.210706078645623e-06 0.06742468841361035 1.210706356206536e-06 0.06585179211508728 1.210706653410938e-06 0.06420523370201831 1.210706971711662e-06 0.06248365192299224 \
1.210707361695962e-06 0.06043183534616462 1.210707760522748e-06 0.05839861031494715 1.210708202994687e-06 0.05621846258761681 1.21070858797559e-06 0.05438828987170503 \
1.210709000022182e-06 0.05249218901100536 1.210709351759698e-06 0.05092353490091287 1.21070968726435e-06 0.04946969867921969 1.210709997763245e-06 0.04816021644386199 \
1.210710291700064e-06 0.04695194805701195 1.210710584430997e-06 0.04577883625507727 1.210710859274204e-06 0.04470700909733757 1.210711133117927e-06 0.04366353526031765 \
1.210711398807688e-06 0.04267398813878486 1.210711674116703e-06 0.04167180388267511 1.210711958673621e-06 0.04066026046469497 1.210712254971736e-06 0.03963283340811159 \
1.210712513847122e-06 0.03875659098599576 1.210712741803528e-06 0.03800131046948733 1.210712960528722e-06 0.03729095380188759 1.210713180383449e-06 0.03659437723507575 \
1.210713521249514e-06 0.03554043311314246 1.210713797290394e-06 0.03470953269536187 1.210714090721169e-06 0.03384790442147732 1.210714373289092e-06 0.03303898052111545 \
1.210714628198529e-06 0.03232625790162248 1.210714908882988e-06 0.03155947796597136 1.210715154716382e-06 0.03090318379665042 1.21071538687767e-06 0.03029616297556957 \
1.210715627215008e-06 0.02968398395812225 1.210715862851843e-06 0.02909722707395018 1.210716091063021e-06 0.0285403787496557 1.21071650783575e-06 0.02755138287878544 \
1.210716702361127e-06 0.02710176794309662 1.210717088601532e-06 0.02623051698020805 1.210717267770925e-06 0.0258356865503758 1.210717618998109e-06 0.02507792837274256 \
1.210717786904157e-06 0.0247229612172224 1.210718171166812e-06 0.02392944198669211 1.210718286448541e-06 0.02369675911063252 1.210718728496378e-06 0.02282172072611499 \
1.210718950311652e-06 0.02239223679446916 1.210719473931311e-06 0.02139838041889957 1.21071962929382e-06 0.02110714647916685 1.210720146999888e-06 0.02015295207761772 \
1.210720272033152e-06 0.01992792118872039 1.210720796234659e-06 0.01901759738223179 1.210720932454034e-06 0.01879045572456909 1.21072153873049e-06 0.01783210191617334 \
1.210721705739623e-06 0.01758082406519646 1.210722348947267e-06 0.01666064795441237 1.210722528091535e-06 0.0164167113061686 1.210723218250269e-06 0.01551958953683085 \
1.210723381870153e-06 0.01531511209162885 1.21072414235084e-06 0.01440332854054019 1.210724289392963e-06 0.01423371673427115 1.210725107264621e-06 0.01333087949608782 \
1.210725226813134e-06 0.01320411419549955 1.210726142674656e-06 0.01227329163592313 1.210726284027572e-06 0.01213544173166964 1.210727232503148e-06 0.01124488043697059 \
1.210727391142586e-06 0.01110230805801717 1.21072857354363e-06 0.01011356759191894 1.21072867164402e-06 0.01003725601038859 1.21072993325548e-06 0.009120360285939955 \
1.210730067669331e-06 0.009028655389366201 1.210731608240655e-06 0.008043892937307966 1.210731689273999e-06 0.007992925041580451 1.210733277867931e-06 0.007023242357651564 \
1.210733410759078e-06 0.006948518507451114 1.21073538746242e-06 0.005952856104192286 1.210735569200568e-06 0.005869662958407677 1.210737671554228e-06 0.004980929874643355 \
1.210738112345997e-06 0.004810448874467742 1.210740767560855e-06 0.003892108290451164 1.210741244140394e-06 0.003745909362026665 1.210744882222615e-06 0.00279447349697209 \
1.21074540774606e-06 0.002678838783887205 1.210751013810845e-06 0.001700248310874221 1.210751324898547e-06 0.001653333728976835 1.210756459226246e-06 0.0006858192122199529 \
1.210756653206019e-06 0.0006440832883579712 1.213404576914862e-06 -0.0002037173203380238 1.213404741115283e-06 -0.0003889174928863678 1.213405314458091e-06 -0.001270938904608877 \
1.213405389392278e-06 -0.001411855863724778 1.213405849976055e-06 -0.002393592696522268 1.213405961916807e-06 -0.002660411672198376 1.213406215188795e-06 -0.003300974950034667 \
1.2134063815721e-06 -0.003745951779090856 1.21340667656787e-06 -0.004566571567208835 1.213406788055442e-06 -0.00488071790655901 1.213407067428216e-06 -0.005641221413069743 \
1.213407188386555e-06 -0.005938820066262044 1.213408282339389e-06 -0.005180465225493313 1.213408406471631e-06 -0.004410796826645887 1.213408530879049e-06 -0.003456122327429311 \
1.213408650435429e-06 -0.002364170815481491 1.213408748579805e-06 -0.001341064316055312 1.213408855004127e-06 -0.0001052154991983786 1.213408967239972e-06 0.001336046702817826 \
1.213409102195821e-06 0.003249882807978809 1.213409224782331e-06 0.005149402351921401 1.213409413644246e-06 0.008353592055059769 1.213409554826579e-06 0.01094873860302964 \
1.213409708187922e-06 0.01393943619118621 1.213409851561427e-06 0.01687898420971235 1.213410005752867e-06 0.02017576688295359 1.213410161892825e-06 0.02363796584892512 \
1.213410317618878e-06 0.02719811802828209 1.213410465112557e-06 0.03065407560139007 1.213410613784323e-06 0.03420778369279751 1.213410769114408e-06 0.03798436241030867 \
1.213410927740288e-06 0.04189786275883118 1.213411092673448e-06 0.0460171220807938 1.213411267096336e-06 0.05041857973200652 1.213411446085736e-06 0.05497510627343041 \
1.213411635385597e-06 0.05982852266675163 1.213411838393603e-06 0.06506368941101938 1.213412057870669e-06 0.07075025585284363 1.213412288935331e-06 0.07675903373893865 \
1.213412535995649e-06 0.08319974270080552 1.213412806420637e-06 0.0902619122132732 1.213413099984324e-06 0.09793335781011638 1.213413424033306e-06 0.1064001814721126 \
1.213413788254856e-06 0.1159066558703892 1.213414180806326e-06 0.1261372395632307 1.213414630304251e-06 0.1378252442462487 1.213415153096484e-06 0.1513754922073403 \
1.213415766694219e-06 0.1672157090591849 1.213416444455093e-06 0.184625848284817 1.213417232720213e-06 0.2047487967247964 1.213418115553072e-06 0.22712469896725 \
1.213418933839029e-06 0.2476994923478653 1.213419661268608e-06 0.2658503723959502 1.213420301381636e-06 0.2817009601644404 1.21342087568535e-06 0.2958213763442377 \
1.213421413251317e-06 0.3089396094373287 1.213421917248776e-06 0.3211464104224903 1.21342239337143e-06 0.3325930942309646 1.213422871259445e-06 0.3439912352478621 \
1.213423324592551e-06 0.3547121966731367 1.213423795885259e-06 0.3657614311162562 1.213424238561085e-06 0.3760518588326446 1.213424757059872e-06 0.3879885572071845 \
1.213425284221992e-06 0.3999987293386327 1.213425663131624e-06 0.4085537955782026 1.213426193047166e-06 0.4204060347738258 1.213426622963746e-06 0.429919877745455 \
1.213427076664521e-06 0.4398653393542544 1.213427543378037e-06 0.4500002271552926 1.213427981059267e-06 0.4594210430579985 1.213428389021531e-06 0.468120704286539 \
1.213428708454565e-06 0.4748816926501604 1.213429080589837e-06 0.4826992142337162 1.213429315571978e-06 0.4876010339127531 1.213429549178225e-06 0.4924491904621348 \
1.213429797190648e-06 0.4975647713404599 1.213430095592078e-06 0.5036796627825791 1.21343035194848e-06 0.5088948470128004 1.21343056424179e-06 0.5131878547336713 \
1.213430758259862e-06 0.5170959594548015 1.213430905246394e-06 0.5200432695146362 1.213431059224405e-06 0.523118600542271 1.213431277106154e-06 0.5274469616807909 \
1.21343153021048e-06 0.5324525256580425 1.213431740049324e-06 0.5365797337241586 1.213431951502634e-06 0.5407247601751553 1.213432233709534e-06 0.5462280430697679 \
1.213432463254817e-06 0.5506821559930507 1.213432679151024e-06 0.5548604062613707 1.213432961372541e-06 0.560308769190463 1.213433212680268e-06 0.5651538146135803 \
1.21343351034116e-06 0.5708625224168123 1.213433760568061e-06 0.5756519166658941 1.213434016931556e-06 0.5805516059354519 1.21343425734157e-06 0.585116682128892 \
1.213434515521386e-06 0.5900038400537884 1.213434739113592e-06 0.5942175703762435 1.213434977623163e-06 0.5986919452581434 1.213435185207862e-06 0.6025689278491061 \
1.213435401730487e-06 0.6065904171332736 1.213435651033092e-06 0.6111939272561876 1.213435856106535e-06 0.6149609706257601 1.213436107378861e-06 0.6195555361399968 \
1.213436310600886e-06 0.6232455818254186 1.213436507472791e-06 0.6267987644955494 1.213436700764307e-06 0.630267737067843 1.213436955542762e-06 0.6348113783570861 \
1.213437185753374e-06 0.638887973644319 1.213437403107185e-06 0.6427143472883045 1.213437701512908e-06 0.6479268061885751 1.213437916915757e-06 0.6516657345437264 \
1.213438118139476e-06 0.6551344108237934 1.213438293060984e-06 0.6581323437428509 1.213438458126254e-06 0.6609495238976936 1.213438627594775e-06 0.6638251431769452 \
1.213438779731612e-06 0.666392827642013 1.213438917642298e-06 0.6687037209181631 1.213439066478412e-06 0.6711867545200138 1.213439194593014e-06 0.6733159837320549 \
1.213439337815828e-06 0.6756849429836936 1.213439459090078e-06 0.6776819274526149 1.213439596688762e-06 0.6799401191146522 1.213439716069216e-06 0.6818929034138137 \
1.213439863176963e-06 0.6842914131385206 1.213439980378628e-06 0.6861933934268433 1.213440073884205e-06 0.6877071857403232 1.213440164873897e-06 0.6891752279197846 \
1.213440267615961e-06 0.6908280855439021 1.213440369133525e-06 0.6924555900607121 1.213440487516631e-06 0.6943444167618776 1.213440599637217e-06 0.6961264383846065 \
1.213440717192718e-06 0.6979868779962457 1.213440902343005e-06 0.7008959348649784 1.213441033535213e-06 0.7029413755586562 1.213441169703753e-06 0.7050491462541959 \
1.213441291222456e-06 0.7069171228306749 1.213441431145468e-06 0.7090538254196674 1.213441535088117e-06 0.7106315721465845 1.213441646249101e-06 0.712309798010818 \
1.213441750508965e-06 0.7138759052437967 1.213441880147057e-06 0.7158124745844324 1.213441977077769e-06 0.7172526339884565 1.213442116000004e-06 0.7193052800722975 \
1.213442235549293e-06 0.7210612846995991 1.213442355121866e-06 0.7228080613301419 1.213442480897243e-06 0.7246353354365959 1.213442607615586e-06 0.7264656873164689 \
1.213442729655437e-06 0.728218443613998 1.21344285780388e-06 0.7300486655261287 1.213442987872205e-06 0.7318956587421809 1.213443108863227e-06 0.7336041830685722 \
1.213443249633811e-06 0.7355801168346318 1.21344335060338e-06 0.7369898206659778 1.213443452204237e-06 0.7384020079314992 1.213443548224548e-06 0.7397310783624924 \
1.213443659137403e-06 0.7412570822736337 1.21344374678503e-06 0.7424563811251772 1.213443846639401e-06 0.7438154404043728 1.213443981404539e-06 0.7456370856934184 \
1.213444097699018e-06 0.747198032089633 1.213444201190815e-06 0.7485782798032956 1.213444325446263e-06 0.7502239458264747 1.213444470359203e-06 0.7521280942578691 \
1.213444588339771e-06 0.753666143975803 1.213444707270879e-06 0.7552056331692281 1.213444846850418e-06 0.7569980918234445 1.213444991202808e-06 0.7588357421297242 \
1.213445109263616e-06 0.7603265096672839 1.213445234085335e-06 0.7618908200857619 1.213445373916531e-06 0.7636286950759973 1.213445498679428e-06 0.7651662633748356 \
1.213445642192899e-06 0.7669199865864609 1.213445762878377e-06 0.7683824344671055 1.213445883722124e-06 0.7698356273746885 1.213446003367048e-06 0.7712633747646481 \
1.213446133074687e-06 0.7727989859455529 1.21344624181849e-06 0.7740766298596218 1.213446364466227e-06 0.7755070372682662 1.213446474242911e-06 0.7767778749889983 \
1.213446603267025e-06 0.7782599816788072 1.213446735043344e-06 0.7797610257751375 1.21344684835592e-06 0.7810403609326458 1.213446969441862e-06 0.7823954393038701 \
1.213447073314495e-06 0.7835479431998941 1.213447215597518e-06 0.785111775748914 1.213447363800666e-06 0.7867227488076519 1.213447522694201e-06 0.7884297907063792 \
1.213447642887224e-06 0.7897074707829422 1.21344779245393e-06 0.7912811323018302 1.213447916569147e-06 0.7925734175081853 1.213448042273444e-06 0.7938699048627912 \
1.213448145219011e-06 0.7949224966762399 1.213448259590165e-06 0.7960823495211882 1.213448372064409e-06 0.7972131756542409 1.213448462336983e-06 0.7981137961420948 \
1.213448551677879e-06 0.7989989930139054 1.213448676903817e-06 0.800229513878344 1.21344878467518e-06 0.8012785338618679 1.213448914342979e-06 0.8025281307685926 \
1.213449035722257e-06 0.8036855380110038 1.213449152278057e-06 0.8047859282369955 1.213449273083453e-06 0.80591497746663 1.213449405708758e-06 0.8071413435168892 \
1.213449527502378e-06 0.8082555056211007 1.213449654106103e-06 0.8094015704683005 1.213449779719621e-06 0.8105266036187198 1.213449899211046e-06 0.8115857443778658 \
1.213450037409299e-06 0.8127973981963581 1.213450146908548e-06 0.8137473213416323 1.213450231056663e-06 0.8144713378799666 1.21345035186072e-06 0.8155017394983226 \
1.213450447369557e-06 0.8163089346032877 1.21345058366036e-06 0.8174496006492775 1.213450726424414e-06 0.8186303638797883 1.213450860857535e-06 0.8197292014569521 \
1.213450970729519e-06 0.8206175763825388 1.213451114629137e-06 0.8217677661037901 1.21345126795672e-06 0.8229768690765377 1.213451395805574e-06 0.8239722812379519 \
1.213451536202905e-06 0.8250521595273246 1.213451662107844e-06 0.8260088941474263 1.21345181672401e-06 0.8271688948348412 1.21345194907934e-06 0.8281489842609937 \
1.213452075346168e-06 0.8290730392392056 1.213452193006695e-06 0.8299245984162376 1.213452341409092e-06 0.8309852945996649 1.21345250860326e-06 0.8321626230293395 \
1.213452641380572e-06 0.8330844501529713 1.213452814281769e-06 0.8342675727345584 1.213452982699063e-06 0.8354015168591284 1.213453152193536e-06 0.8365246342267009 \
1.213453333630418e-06 0.8377070668209077 1.213453476186559e-06 0.8386219603417975 1.21345359009745e-06 0.8393441765511721 1.213453720973659e-06 0.8401643924869071 \
1.213453822596633e-06 0.8407940582489307 1.213453939036872e-06 0.8415078269750864 1.213454074330058e-06 0.8423269142909066 1.213454271595159e-06 0.8435017451489455 \
1.213454462114483e-06 0.844614933042255 1.213454672039296e-06 0.8458175693076773 1.213454852817827e-06 0.8468334846981137 1.213455050185846e-06 0.8479221976595614 \
1.213455224044341e-06 0.8488638701886076 1.213455406558583e-06 0.8498353939890455 1.213455577902694e-06 0.8507314120859523 1.213455752248258e-06 0.8516272398309612 \
1.213455927651258e-06 0.8525125793730954 1.213456103896448e-06 0.8533864315694911 1.213456293665327e-06 0.8543099749208749 1.213456484423344e-06 0.8552205033559714 \
1.21345668621255e-06 0.8561646193034282 1.213456878916116e-06 0.8570482883232282 1.213457088356793e-06 0.8579892478796384 1.213457318098559e-06 0.8589986827500428 \
1.213457583567511e-06 0.8601360945383778 1.213457882213856e-06 0.8613786760148464 1.213458160601222e-06 0.8625023989005415 1.213458444791177e-06 0.8636161469557806 \
1.213458719285784e-06 0.8646608622318305 1.213458991377281e-06 0.8656672252055042 1.213459261593727e-06 0.8666387059277968 1.213459518761915e-06 0.8675381145236246 \
1.21345979132098e-06 0.8684653318325959 1.21346006734232e-06 0.8693777905953765 1.213460337484171e-06 0.8702455402709716 1.213460637231955e-06 0.8711796653984102 \
1.213461008105813e-06 0.872294745819888 1.213461303028797e-06 0.8731503023941 1.213461557284845e-06 0.8738665406311316 1.213461855515577e-06 0.8746822274488602 \
1.213462129133902e-06 0.8754080260278182 1.213462365269549e-06 0.8760175227551726 1.213462605621406e-06 0.876622281264788 1.213462827963785e-06 0.8771680781109068 \
1.213463021968128e-06 0.8776338860468618 1.213463351691208e-06 0.8784037109613512 1.21346350686397e-06 0.8787567114621292 1.213463824616497e-06 0.879461652496718 \
1.213464003481858e-06 0.8798480920375044 1.213464345943324e-06 0.8805675499479563 1.213464530084847e-06 0.8809434933546246 1.213465004990284e-06 0.8818790560183651 \
1.213465172384703e-06 0.8821975058309585 1.213465638216128e-06 0.8830540251881659 1.213465819040967e-06 0.8833751042472839 1.213466313074347e-06 0.8842212008576973 \
1.213466454417056e-06 0.884455124402366 1.213467060806836e-06 0.8854193259359495 1.213467212878983e-06 0.8856514227360587 1.213467859557471e-06 0.8865980751852495 \
1.213467987853825e-06 0.8867785329419297 1.213468635979926e-06 0.8876550049536978 1.213468765772447e-06 0.8878236738033012 1.213469544034095e-06 0.8887860366092379 \
1.213469659025973e-06 0.8889208282599539 1.213470514758392e-06 0.8898661633196656 1.213470660021537e-06 0.8900169066926564 1.213471645777722e-06 0.8909664261264102 \
1.213471866882863e-06 0.8911622482549515 1.213473011997307e-06 0.8921020388386462 1.213473143207264e-06 0.8922053928944147 1.2134743308658e-06 0.8931033243919096 \
1.213474484486092e-06 0.8932130731307282 1.213475894522803e-06 0.8941348173026452 1.213476117329622e-06 0.8942660193790342 1.213477798020331e-06 0.8951452796684343 \
1.21347812564151e-06 0.8952966652167414 1.213480355582631e-06 0.8961896554712738 1.213480908496592e-06 0.8963788593752812 1.213484476711123e-06 0.8973573335043913 \
1.213484800223538e-06 0.8974284307984646 1.213491156631826e-06 0.8984120886469452 1.213491705534673e-06 0.8984686671268907 1.213544207609024e-06 0.8994658645395698 \
1.213544850637887e-06 0.8994692460188505 1.21373698930852e-06 0.9004073346715066 1.213737190722491e-06 0.9004708280105613 1.213741150500432e-06 0.8995366825576255 \
1.21374133452723e-06 0.8993953949813248 1.213742651124504e-06 0.8984641879157507 1.213742823168359e-06 0.8983566564859006 1.213744719544654e-06 0.8973720929359315 \
1.213744893250842e-06 0.897304621671452 1.213757467177875e-06 0.8982933655523699 1.213757552368112e-06 0.8983081509245614 1.213765819241151e-06 0.8993078551592517 \
1.213766293960572e-06 0.8993433667976791 1.214259794870012e-06 0.9002974142054325 1.214259914349736e-06 0.9003767372269074 1.214260807172786e-06 0.9012336455299185 \
1.214260953429423e-06 0.901423267690772 1.214261548322101e-06 0.9023325668564308 1.214261683292918e-06 0.9025673929107925 1.214262187968707e-06 0.9035294259428087 \
1.214262320579608e-06 0.9038000271808221 1.214262721206973e-06 0.9046475051114249 1.214262865572371e-06 0.9049556543240072 1.21426328869358e-06 0.9058123566484279 \
1.214263384150639e-06 0.9059850892484415 1.214264808709455e-06 0.9052205906349737 1.214264933747309e-06 0.9046352442223391 1.214265060157898e-06 0.9039223775493039 \
1.214265162806642e-06 0.9032486771507763 1.214265290021932e-06 0.9022944222362175 1.214265408867758e-06 0.9012801950564071 1.214265506520237e-06 0.9003603330664713 \
1.214265588522259e-06 0.8995243596151602 1.214265668185821e-06 0.8986589236008835 1.214265778963989e-06 0.8973708307079206 1.214265880140004e-06 0.8961049472956977 \
1.214265963084475e-06 0.8950067229086057 1.214266071529893e-06 0.8934921260891034 1.21426617999385e-06 0.8918872687155874 1.214266275049989e-06 0.8904106867557802 \
1.214266395922642e-06 0.8884444419111864 1.214266516699262e-06 0.8863849482818795 1.214266629744433e-06 0.8843763393508186 1.214266732915182e-06 0.8824794505619851 \
1.214266818515338e-06 0.8808620855018965 1.214266892989399e-06 0.8794251273161163 1.214266987312942e-06 0.8775673968166831 1.214267075773858e-06 0.8757888800524039 \
1.21426715484687e-06 0.8741711975775893 1.214267248834225e-06 0.872216793437976 1.214267330179529e-06 0.8704993514258973 1.214267425093555e-06 0.8684673705816817 \
1.214267518136275e-06 0.8664480751909672 1.214267614922069e-06 0.8643215060814092 1.214267738217441e-06 0.8615778533848952 1.214267851664453e-06 0.859022019682563 \
1.214267977516491e-06 0.8561558571929792 1.214268100844635e-06 0.8533196845306243 1.214268230022927e-06 0.850323637950593 1.214268370619783e-06 0.8470370034914 \
1.214268479399505e-06 0.8444782910716596 1.214268614459257e-06 0.8412850455921466 1.214268724119566e-06 0.8386804253780991 1.214268853299345e-06 0.8356002443501571 \
1.214268979483175e-06 0.8325812421138936 1.21426910657353e-06 0.8295317031556502 1.214269235595804e-06 0.826427745883674 1.214269344676045e-06 0.8237985689995477 \
1.214269484526701e-06 0.8204223029647078 1.214269623954893e-06 0.8170507778356514 1.214269756708524e-06 0.8138366863616762 1.214269886777199e-06 0.8106848159989707 \
1.214270010472646e-06 0.8076853837479523 1.214270147427036e-06 0.8043627031572629 1.214270261138882e-06 0.8016030849198694 1.214270388615923e-06 0.7985086235398901 \
1.214270499416994e-06 0.7958187897651571 1.214270618603452e-06 0.7929254985494992 1.214270731982509e-06 0.7901733724735396 1.214270866292901e-06 0.7869138859547327 \
1.214270973387169e-06 0.7843152933129034 1.214271089404312e-06 0.7815009627552112 1.214271218595275e-06 0.778367508739124 1.214271316207711e-06 0.7760002683782802 \
1.214271421787151e-06 0.773440790716327 1.21427153046932e-06 0.7708069008430674 1.214271632885583e-06 0.7683258101021144 1.214271726279241e-06 0.7660641808432364 \
1.214271845835017e-06 0.7631702213567544 1.214271938307379e-06 0.7609327305817616 1.214272030945494e-06 0.7586922094322426 1.21427212937031e-06 0.7563124992069843 \
1.214272237347962e-06 0.7537030947613649 1.214272333616474e-06 0.7513778334636231 1.214272419872877e-06 0.7492952979736797 1.214272522736666e-06 0.7468128004450286 \
1.214272601580994e-06 0.744910856519283 1.214272702387036e-06 0.7424801602439853 1.214272836915276e-06 0.7392377693660663 1.214272974140136e-06 0.7359316755186537 \
1.214273117619987e-06 0.7324773442723981 1.214273266044177e-06 0.7289066083419234 1.214273409305472e-06 0.7254625447335662 1.214273549382452e-06 0.7220977259655398 \
1.214273705808317e-06 0.7183435968963056 1.214273830210067e-06 0.715360858370426 1.214273951271848e-06 0.7124600029613375 1.21427410478411e-06 0.7087850045121084 \
1.214274239566055e-06 0.7055614325718365 1.214274365665088e-06 0.7025479112911024 1.214274508839371e-06 0.6991289103945657 1.214274628921163e-06 0.6962626602560111 \
1.214274758155491e-06 0.6931807499479741 1.214274864640539e-06 0.6906432840523983 1.214274976916362e-06 0.6879696524977363 1.214275073251648e-06 0.6856773754336868 \
1.21427517606134e-06 0.683232326200841 1.214275270865193e-06 0.6809792012818872 1.214275376187123e-06 0.6784784437814733 1.214275484625777e-06 0.6759058899658261 \
1.214275583635058e-06 0.673558569590366 1.21427570039165e-06 0.6707929011939652 1.214275808476928e-06 0.6682347329991606 1.214275918483137e-06 0.6656332609774134 \
1.214276004570979e-06 0.6635992664604092 1.214276134166118e-06 0.6605400273835189 1.214276226767366e-06 0.6583552307294462 1.214276322555092e-06 0.6560965362104854 \
1.214276407507078e-06 0.6540950852804182 1.214276526801602e-06 0.6512869789851043 1.21427661407154e-06 0.6492343850333612 1.214276704778562e-06 0.6471030993779646 \
1.214276805943536e-06 0.6447280068361273 1.214276885774359e-06 0.6428551652550211 1.214276974560194e-06 0.6407732405330839 1.214277052250421e-06 0.6389536101386547 \
1.214277114019368e-06 0.6375081226244841 1.214277177784013e-06 0.6360167668935747 1.214277241018233e-06 0.634538653569437 1.214277280258806e-06 0.6336218002627473 \
1.214277320897828e-06 0.6326726453797233 1.214277400982362e-06 0.6308039353694699 1.214277470886543e-06 0.6291742390428672 1.214277521523257e-06 0.6279942052995945 \
1.214277560272899e-06 0.6270914175114127 1.214277599267879e-06 0.6261832343283663 1.214277643882627e-06 0.6251445623164014 1.214277686739083e-06 0.6241478292286105 \
1.214277737053687e-06 0.6229782634938205 1.214277788990864e-06 0.6217719122409077 1.214277874058449e-06 0.6197972300178722 1.214277934038866e-06 0.6184052992407258 \
1.214278023826075e-06 0.61632338076978 1.214278100290157e-06 0.6145529519516876 1.214278179854447e-06 0.6127119801362371 1.214278260891059e-06 0.6108383709630588 \
1.214278350105382e-06 0.6087775861620425 1.214278440965394e-06 0.6066826282541496 1.214278528184102e-06 0.6046739453334793 1.214278621957293e-06 0.6025158549334848 \
1.214278723642757e-06 0.6001788642681311 1.214278823240849e-06 0.5978941858483342 1.214278935095889e-06 0.5953317151711254 1.214279051129026e-06 0.5926772450523136 \
1.214279172750132e-06 0.5899020947998995 1.214279277133946e-06 0.5875236635596754 1.214279421924166e-06 0.5842296531729801 1.214279534584127e-06 0.5816734289694181 \
1.214279643596094e-06 0.5792035939892568 1.214279736075537e-06 0.5771100174076607 1.214279829526177e-06 0.5749994714793375 1.21427992185204e-06 0.5729181236728181 \
1.214279994438741e-06 0.571283073141143 1.214280050392967e-06 0.5700232888304386 1.214280111461249e-06 0.5686498830286455 1.214280209950764e-06 0.5664400707212188 \
1.214280273162208e-06 0.5650238531380825 1.214280333588177e-06 0.5636708824310654 1.21428041053656e-06 0.5619492451093103 1.214280473695101e-06 0.5605380106414651 \
1.21428056200871e-06 0.558569506627369 1.214280633210033e-06 0.5569845302974165 1.214280719745787e-06 0.555060151797141 1.21428084109856e-06 0.5523665438352664 \
1.214280969027808e-06 0.5495364947125975 1.214281067158439e-06 0.5473694328713704 1.214281180282435e-06 0.5448752016832871 1.214281282350254e-06 0.5426314425864434 \
1.214281401299125e-06 0.5400217272291628 1.214281504386832e-06 0.5377630705755105 1.214281618593986e-06 0.5352670017334624 1.214281732009658e-06 0.532794946211756 \
1.214281859080713e-06 0.5300302694710822 1.214281982900802e-06 0.5273426867079006 1.214282127689607e-06 0.5242103332418484 1.21428226351311e-06 0.5212782585303676 \
1.214282418567969e-06 0.5179428401013338 1.214282579419853e-06 0.5144913885072363 1.2142827581493e-06 0.5106699876709851 1.21428294832834e-06 0.5066200804011861 \
1.214283158230362e-06 0.5021665212646098 1.214283386936347e-06 0.4973332357952056 1.214283640864285e-06 0.4919960258408594 1.214283881797751e-06 0.4869529241725989 \
1.214284177960236e-06 0.4807889695952298 1.214284467957623e-06 0.4747910561470179 1.214284774200956e-06 0.4684976697011882 1.214285094876888e-06 0.4619520863481486 \
1.214285422744054e-06 0.4553041925245184 1.214285762989109e-06 0.4484521981997251 1.214286088414654e-06 0.4419418052309769 1.214286410321802e-06 0.4355465312739703 \
1.214286740535907e-06 0.4290298934287748 1.2142870965285e-06 0.4220583188787752 1.214287415406929e-06 0.4158579595363656 1.214287752858691e-06 0.4093433989943853 \
1.214288180725408e-06 0.4011531841887147 1.214288529437356e-06 0.3945419525178304 1.214288837073319e-06 0.388759214407489 1.214289216899811e-06 0.3816861832573664 \
1.214289548089372e-06 0.3755780492082042 1.214289831697452e-06 0.370391509977049 1.214290142516397e-06 0.3647512908748707 1.214290421833005e-06 0.3597258263082204 \
1.214290648329153e-06 0.3556836811642302 1.214290864011538e-06 0.3518598964090484 1.214291061295543e-06 0.3483842179544538 1.214291266280002e-06 0.3447988491770444 \
1.214291478501967e-06 0.3411119200457455 1.214291733807154e-06 0.33670771290924 1.214291975329403e-06 0.3325734463267218 1.214292206706731e-06 0.3286464933807047 \
1.214292421559231e-06 0.3250253651850565 1.214292642118388e-06 0.3213332986541765 1.214292843544355e-06 0.3179852906236645 1.214293046612606e-06 0.3146379646143546 \
1.214293244508216e-06 0.3114011111455273 1.214293431469302e-06 0.3083651674074345 1.214293625269522e-06 0.3052406640298299 1.214293829186134e-06 0.3019773030815858 \
1.214294008255468e-06 0.2991336297844484 1.214294243846324e-06 0.2954229173226265 1.214294444650423e-06 0.2922868215109002 1.214294645829315e-06 0.2891696385850206 \
1.214294869639057e-06 0.2857334090862961 1.214295034201803e-06 0.2832271910241367 1.214295211129189e-06 0.2805503385691353 1.214295396922194e-06 0.2777610713150803 \
1.21429557873767e-06 0.2750538970423583 1.214295757762463e-06 0.2724132377985424 1.214295925107616e-06 0.2699606650006489 1.214296085536534e-06 0.2676371805838822 \
1.214296208110286e-06 0.2658719571410424 1.214296357874814e-06 0.2637236906090554 1.21429648557194e-06 0.2619099339733745 1.214296592880312e-06 0.2603957336038235 \
1.214296708880974e-06 0.2587625259947361 1.214296819189571e-06 0.2572125806747212 1.214296945068767e-06 0.2554509781935611 1.214297060550618e-06 0.2538402638894013 \
1.214297195131521e-06 0.2519757335310172 1.214297307194775e-06 0.2504255755821768 1.214297457534135e-06 0.2483447107137444 1.214297597159989e-06 0.2464124269747185 \
1.21429774305181e-06 0.2444035064209518 1.214297876012448e-06 0.2425734862730615 1.214297999574161e-06 0.2408709992523319 1.214298146783853e-06 0.2388417729476062 \
1.214298263370682e-06 0.2372355665500016 1.214298402825832e-06 0.23532008003217 1.214298537000301e-06 0.2334768281602104 1.214298662976758e-06 0.2317465561243653 \
1.214298782376161e-06 0.2301094434087779 1.214298877230585e-06 0.2288105340759602 1.214298990368185e-06 0.2272617792622066 1.214299070684642e-06 0.2261626001158484 \
1.214299158249699e-06 0.2249657246820506 1.214299283786836e-06 0.2232507767215072 1.214299389480543e-06 0.2218101326756785 1.214299479135054e-06 0.2205921574607158 \
1.214299549986253e-06 0.2196300825522397 1.214299593014783e-06 0.2190460135436258 1.214299635305326e-06 0.2184724035808872 1.214299677647042e-06 0.2178984240735344 \
1.214299749842462e-06 0.2169203674089526 1.214299792235817e-06 0.2163464205126744 1.214299827490656e-06 0.2158693585303403 1.21429987168224e-06 0.2152716287340076 \
1.214299941290467e-06 0.2143309212991285 1.214299975633797e-06 0.2138672544767182 1.214300020093325e-06 0.2132698436071631 1.214300087771806e-06 0.2123628126304402 \
1.214300174199065e-06 0.2112058698236149 1.214300248835667e-06 0.2102078598594563 1.214300330137676e-06 0.2091219706754807 1.21430042701506e-06 0.2078300362310651 \
1.214300552998548e-06 0.2061528795789772 1.214300655533384e-06 0.2047906894256944 1.214300757016902e-06 0.2034500128132261 1.214300858082597e-06 0.202119416354989 \
1.214300954696817e-06 0.2008491615811921 1.21430105666124e-06 0.1995112314821507 1.214301163383484e-06 0.1981153840927639 1.214301271788624e-06 0.1967018790395962 \
1.21430138378278e-06 0.1952465002768531 1.214301496249907e-06 0.1937897263683151 1.214301608323246e-06 0.1923454332378671 1.214301716215721e-06 0.1909603537828802 \
1.21430181759865e-06 0.1896629368444172 1.214301909236099e-06 0.1884941330679491 1.214302003211707e-06 0.1872990757663449 1.214302074478072e-06 0.1863957871745983 \
1.21430215115336e-06 0.1854271890400033 1.214302254812475e-06 0.184122202819407 1.214302328479595e-06 0.1831974022686171 1.214302401825496e-06 0.1822796569444652 \
1.214302515215845e-06 0.1808667181969195 1.214302603074485e-06 0.1797760932362061 1.214302686923162e-06 0.1787387947787487 1.21430281588559e-06 0.1771515524267008 \
1.214302917772084e-06 0.1759040172436072 1.214303023472791e-06 0.1746156056808686 1.214303125120866e-06 0.1733818993219825 1.214303255982584e-06 0.1718019019596718 \
1.214303363179222e-06 0.1705140034701537 1.214303492508118e-06 0.168969083715685 1.21430360420461e-06 0.167642098072289 1.214303704535189e-06 0.1664555496840579 \
1.214303800335743e-06 0.1653276075899142 1.214303911148015e-06 0.1640289617085985 1.214303998548296e-06 0.1630090521997956 1.214304109869413e-06 0.1617156184952586 \
1.214304202821272e-06 0.1606409001560029 1.21430429039415e-06 0.1596330843918451 1.214304392025023e-06 0.1584700928658864 1.214304476479078e-06 0.1575086241734052 \
1.214304551583458e-06 0.1566573095634876 1.2143046294057e-06 0.1557789554714152 1.214304709763569e-06 0.1548759612316424 1.214304810818399e-06 0.1537464547857493 \
1.214304893251963e-06 0.1528311848879565 1.214304985556514e-06 0.1518114053368895 1.214305062490987e-06 0.150965812476358 1.214305145413558e-06 0.1500585909391909 \
1.214305216944298e-06 0.1492793026301012 1.214305313327797e-06 0.1482344968214558 1.214305383556283e-06 0.1474766665551334 1.214305466536561e-06 0.1465853655470201 \
1.214305527978825e-06 0.1459298106834085 1.214305599661209e-06 0.1451677491870439 1.214305668289752e-06 0.1444408762699853 1.214305718558262e-06 0.1439102090153988 \
1.214305766138067e-06 0.143409423336876 1.214305820187418e-06 0.1428423132663369 1.214305879529516e-06 0.1422216078256897 1.214305947564923e-06 0.1415124633834424 \
1.214306023828345e-06 0.1407207186008814 1.214306092108145e-06 0.1400161356079559 1.214306186894323e-06 0.1390460813732662 1.214306276448135e-06 0.1381341561933974 \
1.214306348133609e-06 0.1374075731330657 1.214306432085018e-06 0.1365606113096345 1.214306497397473e-06 0.1359045398875483 1.214306558840598e-06 0.1352895588344758 \
1.214306633117097e-06 0.1345490408254265 1.214306695327357e-06 0.1339328028964004 1.214306763298366e-06 0.133265236037424 1.214306822505406e-06 0.1326856657519672 \
1.214306895177878e-06 0.1319767402814105 1.214306970197988e-06 0.1312477270463112 1.214307055651411e-06 0.1304208267333309 1.21430714175175e-06 0.1295914604616623 \
1.214307241877205e-06 0.1286317929389105 1.214307323166875e-06 0.127857435971709 1.214307424934223e-06 0.1268981149578782 1.214307509182182e-06 0.1261072369695883 \
1.214307607998911e-06 0.1251836587365037 1.214307680839456e-06 0.1245055382686853 1.214307760865543e-06 0.1237631876254407 1.214307831351338e-06 0.1231117958237987 \
1.214307903881761e-06 0.1224439308288319 1.214307981350756e-06 0.1217331219782777 1.214308088702104e-06 0.1207554316575004 1.21430818934012e-06 0.1198442997624752 \
1.214308261927674e-06 0.1191899427853172 1.214308330759514e-06 0.1185715582611356 1.214308396546334e-06 0.1179824683205609 1.214308466175132e-06 0.1173610347366148 \
1.214308536558877e-06 0.1167350538439435 1.21430861173725e-06 0.1160688810594495 1.214308715991485e-06 0.1151493019715505 1.214308791126139e-06 0.114489769343061 \
1.214308860041223e-06 0.1138870655592168 1.214308923246095e-06 0.1133369146236164 1.21430899278746e-06 0.1127339156958381 1.214309050088964e-06 0.1122385190692166 \
1.214309121730019e-06 0.1116210355509516 1.214309179565093e-06 0.1111240709857579 1.214309251686527e-06 0.1105063809580559 1.21430931410261e-06 0.1099736279351742 \
1.214309398424132e-06 0.1092565349771765 1.2143094660201e-06 0.1086842173446869 1.214309574816032e-06 0.1077671916889585 1.214309679126564e-06 0.1068924975608609 \
1.214309758614772e-06 0.1062289053282379 1.214309846183183e-06 0.1055008617114655 1.214309909639535e-06 0.1049752776433979 1.214309971350652e-06 0.10446579874651 \
1.214310075190416e-06 0.103612238268202 1.214310157871118e-06 0.1029362225408096 1.214310256339144e-06 0.1021348761715451 1.214310340785582e-06 0.101450818648051 \
1.214310457263062e-06 0.1005121841703865 1.214310591996508e-06 0.09943411943161744 1.214310728066045e-06 0.0983541971400249 1.214310842385452e-06 0.09745369041838402 \
1.214310927852596e-06 0.09678457778867394 1.214311038134269e-06 0.09592640631053104 1.214311118922622e-06 0.09530159220710262 1.214311218473494e-06 0.09453592511176086 \
1.214311308421543e-06 0.09384821103094763 1.214311380924943e-06 0.09329669945188329 1.214311462667009e-06 0.09267796846073476 1.214311590787245e-06 0.09171467366828615 \
1.214311672199308e-06 0.09110674702409056 1.214311746631215e-06 0.09055373306570065 1.214311821605099e-06 0.08999936228352182 1.214311901024075e-06 0.08941505746347288 \
1.214312009684932e-06 0.08862052380504259 1.214312104044904e-06 0.08793517800096999 1.214312193440026e-06 0.08728987318634121 1.214312300205743e-06 0.086524181682867 \
1.214312418708183e-06 0.08568073755029131 1.214312560233253e-06 0.08468224831562859 1.214312693371676e-06 0.08375174214918565 1.214312834217007e-06 0.08277682112810406 \
1.214312983268988e-06 0.08175525972387458 1.214313119066718e-06 0.08083369778093191 1.214313260523232e-06 0.0798830809748103 1.214313395783148e-06 0.07898330517332906 \
1.214313537164988e-06 0.07805242629322809 1.214313684232761e-06 0.07709434677344783 1.214313835960902e-06 0.07611680364043326 1.214314001309203e-06 0.07506403321855706 \
1.214314165176721e-06 0.07403332863189842 1.214314341490649e-06 0.07293832728335037 1.214314530925751e-06 0.07177777688466977 1.214314741692455e-06 0.07050569389938771 \
1.214314961464952e-06 0.06920150027616521 1.214315196433104e-06 0.06783224552442871 1.214315455333654e-06 0.06635227408830123 1.214315750264117e-06 0.06470266364809808 \
1.214316054610178e-06 0.06304001691994518 1.214316416556457e-06 0.06111393619706453 1.214316732684213e-06 0.05947639552636011 1.214317174006677e-06 0.0572596911373907 \
1.21431748757272e-06 0.05573556853365672 1.214317911072189e-06 0.0537382660685313 1.214318255024043e-06 0.05216649213267931 1.21431859526531e-06 0.05065508790922631 \
1.2143189061029e-06 0.04931137323461653 1.214319200574802e-06 0.04807062469528345 1.214319494274299e-06 0.04686392507224969 1.214319769145536e-06 0.04576537019482012 \
1.214320044685701e-06 0.04468949010490332 1.21432030977623e-06 0.04367785045825667 1.214320586533311e-06 0.04264571401740119 1.214320869801436e-06 0.04161414314527601 \
1.214321167794735e-06 0.04055545327485047 1.214321427280131e-06 0.03965542606183669 1.214321657303569e-06 0.03887446236327848 1.214321876995156e-06 0.03814321686473518 \
1.214322101935296e-06 0.0374128399305801 1.21432242218897e-06 0.0363978329183388 1.21432270998682e-06 0.03550963653148703 1.214322986382154e-06 0.03467738358988744 \
1.214323270201283e-06 0.03384352473043348 1.214323508310587e-06 0.03315996078327022 1.214323792621371e-06 0.03236211345273886 1.214324034533221e-06 0.03169864947531036 \
1.214324269673395e-06 0.03106710921041438 1.214324511380923e-06 0.03043352335444016 1.214324748333857e-06 0.02982731501219571 1.214324978676274e-06 0.02925002048968134 \
1.214325192426852e-06 0.02872465224286764 1.214325398273815e-06 0.02822791768061097 1.214325790610838e-06 0.02730524204782691 1.214325979002849e-06 0.02687312495148303 \
1.214326354614307e-06 0.02603163971789 1.214326529081082e-06 0.02564950258131362 1.214326953015541e-06 0.02474274850847508 1.214327073769958e-06 0.02449086781212801 \
1.214327544020722e-06 0.02353384026002922 1.214327693235787e-06 0.02323677291035493 1.214328086867998e-06 0.02246740853134286 1.214328257894343e-06 0.02213909006726131 \
1.214328745173275e-06 0.02121869533024997 1.214328887220983e-06 0.02095326544309953 1.214329420237252e-06 0.01997576278857772 1.214329542401289e-06 0.01975737097014436 \
1.214330064559033e-06 0.01885981776906158 1.214330235137336e-06 0.01857989792133653 1.214330722450399e-06 0.01781360777737795 1.214330893973323e-06 0.01755501440977742 \
1.21433151376008e-06 0.01666567753024489 1.214331684684406e-06 0.0164316648397145 1.214332390235397e-06 0.01551160061118263 1.214332552852409e-06 0.01530799450170666 \
1.2143333097459e-06 0.01439879525764199 1.214333450662544e-06 0.01423641007536438 1.214334350661384e-06 0.01324361033368418 1.214334438010635e-06 0.01315122959105692 \
1.214335342363989e-06 0.01223321097894121 1.214335479555938e-06 0.01209984223734439 1.214336450212214e-06 0.01118944790767422 1.214336578130092e-06 0.01107451071402888 \
1.214337728540039e-06 0.01011008206277823 1.214337822342075e-06 0.01003687265682024 1.214339078387888e-06 0.009120584045805383 1.214339215929201e-06 0.009026502753623255 \
1.214340774683602e-06 0.008029670037698805 1.214340858486287e-06 0.007977066150721189 1.214342463865106e-06 0.00699828665725172 1.21434257476345e-06 0.006935886594503895 \
1.214344507009824e-06 0.005959177461785255 1.21434468671476e-06 0.005876661013304485 1.214346798505876e-06 0.004981749118765498 1.214347141291012e-06 0.004848482978762325 \
1.214349654457045e-06 0.003966891390423618 1.214350124178715e-06 0.003819799497680527 1.21435376449499e-06 0.002847564273158896 1.214354280232175e-06 0.002731633924241866 \
1.214359622062014e-06 0.001773027297371861 1.214359907382299e-06 0.001729522787584184 1.214365136030129e-06 0.0007540451492352357 1.214365310176696e-06 0.0007162692714263865 \
1.217013698769002e-06 -0.0001123232525192561 1.21701387179429e-06 -0.0002901710972538241 1.217014491546045e-06 -0.001202022686018724 1.217014580115222e-06 -0.001365806793032466 \
1.217014941086355e-06 -0.002110727959526865 1.21701506578065e-06 -0.002395793696299351 1.217015429622531e-06 -0.003299857180474864 1.2170156008982e-06 -0.003758114451912169 \
1.217015894896038e-06 -0.004576312838821549 1.217016005104443e-06 -0.004886880824040592 1.217016283358441e-06 -0.005643955697619643 1.21701640463225e-06 -0.00594200199557267 \
1.217017498254348e-06 -0.00517389603226481 1.217017621358228e-06 -0.004409713243767066 1.217017744826303e-06 -0.003462788751204457 1.2170178649921e-06 -0.002366010162083454 \
1.217017962853768e-06 -0.001346276287748183 1.217018069556104e-06 -0.0001076498664581183 1.217018181397488e-06 0.001328007358939307 1.217018317371855e-06 0.003256083960376262 \
1.217018439401011e-06 0.00514709866632534 1.217018627817289e-06 0.008343062029134115 1.217018768805819e-06 0.01093380316938193 1.217018921577523e-06 0.01391176330477175 \
1.217019064280151e-06 0.01683596409946878 1.217019218632388e-06 0.02013443377634912 1.217019374426043e-06 0.02358734537610087 1.21701953048334e-06 0.02715365164079262 \
1.21701967788774e-06 0.03060642997674319 1.217019826504485e-06 0.03415780069914553 1.217019981925702e-06 0.03793559522944389 1.217020140311532e-06 0.04184227512730877 \
1.217020305251154e-06 0.04596085539464361 1.217020479500423e-06 0.05035714787605008 1.217020658443539e-06 0.05491177248689325 1.217020847583032e-06 0.0597604232635115 \
1.21702105036361e-06 0.06498910043066243 1.217021269735637e-06 0.07067233091134768 1.217021500572134e-06 0.07667464705993039 1.217021747383969e-06 0.0831083675499642 \
1.21702201751608e-06 0.09016243555275107 1.217022310704188e-06 0.0978236474935409 1.217022634359626e-06 0.1062798466079799 1.217022997926912e-06 0.1157689210849182 \
1.21702339022043e-06 0.1259925151671456 1.217023838699915e-06 0.1376538644086695 1.2170243603994e-06 0.1511757390224034 1.217024972772044e-06 0.1669844191341421 \
1.217025649417359e-06 0.1843663871188266 1.21702643632765e-06 0.2044554566749352 1.217027317548744e-06 0.2267919980918504 1.217028137292384e-06 0.2474048556006221 \
1.217028865745329e-06 0.2655829647002126 1.217029507221317e-06 0.2814688958417333 1.217030083144486e-06 0.2956305456066151 1.217030620401302e-06 0.3087428400511723 \
1.217031124292597e-06 0.3209487846516751 1.217031601896145e-06 0.3324328152479784 1.217032080019379e-06 0.343838772307344 1.217032532118229e-06 0.3545331600964184 \
1.217033003884519e-06 0.365596737404158 1.21703344758136e-06 0.3759140547845509 1.217033969549898e-06 0.3879344734281669 1.217034497087831e-06 0.399956933836353 \
1.217034876602574e-06 0.4085271910771138 1.217035405564175e-06 0.4203606102508351 1.217035874883256e-06 0.4307444005277802 1.217036310038791e-06 0.4402814026247405 \
1.217036757516117e-06 0.4500002273945978 1.217037197539592e-06 0.4594737646471725 1.217037600841335e-06 0.4680814138276727 1.217037919241101e-06 0.4748254127722248 \
1.217038289219015e-06 0.4826007100982719 1.217038525472097e-06 0.4875314737878706 1.217038760543493e-06 0.4924129045770672 1.217039011882831e-06 0.4975994385012801 \
1.217039318269866e-06 0.5038799449729535 1.217039575228319e-06 0.5091120301871851 1.217039783702615e-06 0.5133309170973237 1.217039984084905e-06 0.5173683849445317 \
1.217040126478606e-06 0.5202244049244739 1.217040275403072e-06 0.5231993726577677 1.217040486949329e-06 0.5274019882470222 1.217040713006952e-06 0.5318780389403845 \
1.217040907549333e-06 0.5357103559602913 1.217041096681229e-06 0.539423417888626 1.217041326128277e-06 0.5439012399750046 1.217041508634083e-06 0.5474563135343053 \
1.217041745996952e-06 0.5520623276458133 1.21704201499126e-06 0.5572695987004129 1.21704226390171e-06 0.5620706638085723 1.217042507918532e-06 0.5667633705755619 \
1.217042780273744e-06 0.5719926523718327 1.217043041669874e-06 0.5769928369418796 1.217043299301279e-06 0.5819084237686675 1.217043546144628e-06 0.586601202059797 \
1.217043791890354e-06 0.5912552023551558 1.217044018467874e-06 0.5955288021520931 1.217044249620064e-06 0.5998646534936181 1.217044455900444e-06 0.6037202012184053 \
1.217044684021204e-06 0.6079592993751251 1.217044906401185e-06 0.6120725203834017 1.217045133377667e-06 0.6162454422471376 1.217045348430617e-06 0.6201823359462864 \
1.21704557780019e-06 0.6243500782103125 1.217045846823065e-06 0.6292041961704016 1.217046069836712e-06 0.6331993632081415 1.217046282091289e-06 0.6369772451758789 \
1.217046493488879e-06 0.6407176358819484 1.217046693558109e-06 0.644236566349866 1.217046923151959e-06 0.6482486956559365 1.217047163988886e-06 0.6524328529570182 \
1.217047345738273e-06 0.6555667906748446 1.2170475342865e-06 0.6588018260593631 1.21704768736614e-06 0.6614154033769962 1.217047859374421e-06 0.6643352515471471 \
1.21704800954724e-06 0.6668697017322168 1.217048146064529e-06 0.6691578850264722 1.217048295693716e-06 0.6716547631652277 1.217048423434085e-06 0.673777752640997 \
1.217048563020223e-06 0.6760856948620949 1.21704868725891e-06 0.6781310478824312 1.21704881840875e-06 0.6802827752320969 1.217048942850093e-06 0.6823179209931315 \
1.217049080080916e-06 0.6845542421253382 1.217049200329086e-06 0.6865048414796368 1.21704934166053e-06 0.6887891282595083 1.217049441991641e-06 0.6904033553735033 \
1.217049563109343e-06 0.6923460943304175 1.217049653886878e-06 0.6937948943079848 1.217049751145344e-06 0.6953408241330762 1.217049847353224e-06 0.6968660703265798 \
1.217049935967068e-06 0.6982647859968389 1.217050033255091e-06 0.6997938110311075 1.217050165723729e-06 0.7018622871835729 1.217050320913928e-06 0.7042674555997347 \
1.217050458791879e-06 0.7063866855441746 1.217050603646153e-06 0.7085960165693863 1.21705073070791e-06 0.7105202221428537 1.21705085539347e-06 0.7123960184768648 \
1.217050968098846e-06 0.7140814553427599 1.217051079889191e-06 0.7157437310299281 1.21705118066784e-06 0.7172341607972841 1.217051317946296e-06 0.7192525454101454 \
1.217051437630367e-06 0.7210013704967912 1.217051557059838e-06 0.7227365757678518 1.21705168394306e-06 0.7245692610776365 1.217051808360712e-06 0.7263556789600311 \
1.217051932093537e-06 0.728121726658988 1.217052058689064e-06 0.7299181396522603 1.217052189074464e-06 0.7317573312219798 1.217052311884284e-06 0.7334798522758219 \
1.21705244732006e-06 0.7353678990088863 1.217052548609838e-06 0.7367723836293941 1.217052656232334e-06 0.7382576460517265 1.217052745760416e-06 0.7394878879617913 \
1.217052860308785e-06 0.7410528648863303 1.217052948337041e-06 0.7422487366778059 1.217053055415107e-06 0.7436953530868765 1.2170531854801e-06 0.7454403311053276 \
1.217053296759795e-06 0.7469230742113165 1.217053401378355e-06 0.7483084058091373 1.21705352546134e-06 0.7499400420429273 1.217053673762168e-06 0.7518749696944975 \
1.217053795162033e-06 0.7534462209622173 1.21705390960278e-06 0.7549170836379747 1.217054049940098e-06 0.7567069362027918 1.217054191702981e-06 0.7584995177563068 \
1.217054309503919e-06 0.759977341175643 1.217054437480785e-06 0.761570846386187 1.217054579183209e-06 0.7633205808366864 1.217054696694523e-06 0.7647599110190483 \
1.217054842299792e-06 0.7665289162262866 1.217054963994099e-06 0.7679951561698679 1.217055082724709e-06 0.7694149786178283 1.217055205011304e-06 0.7708662727382939 \
1.21705533205582e-06 0.77236234268503 1.217055441699792e-06 0.7736439866494906 1.217055567386705e-06 0.7751025186690397 1.217055673401805e-06 0.776323977486031 \
1.217055808987772e-06 0.7778743028704433 1.217055933950769e-06 0.7792913979962601 1.217056059856921e-06 0.7807070123991936 1.217056175124167e-06 0.7819915514687489 \
1.21705628142864e-06 0.7831664991275713 1.217056419833432e-06 0.7846822315516878 1.217056569129882e-06 0.7862997378875561 1.217056714637328e-06 0.7878588534534761 \
1.217056834041839e-06 0.7891257303126159 1.217056969134663e-06 0.7905455128963393 1.217057090387826e-06 0.7918076974797237 1.217057233381105e-06 0.7932816011184505 \
1.217057377585411e-06 0.7947523458802197 1.217057503122239e-06 0.7960199014141693 1.217057622168612e-06 0.7972110037065316 1.217057734104495e-06 0.7983213107123885 \
1.217057838976047e-06 0.7993531099923881 1.217057934226459e-06 0.8002831901653534 1.217058070569705e-06 0.8016020813281191 1.217058187393835e-06 0.8027203407102198 \
1.217058306798445e-06 0.803852171037294 1.217058428905249e-06 0.8049980820693966 1.217058551860251e-06 0.8061401395390313 1.217058678828951e-06 0.8073073595000361 \
1.21705880406856e-06 0.8084467645495962 1.217058934640955e-06 0.8096220968518901 1.217059060631473e-06 0.8107441738369082 1.217059188817386e-06 0.8118738099374113 \
1.217059294347114e-06 0.8127947795787664 1.217059397218887e-06 0.8136847278655364 1.217059490214057e-06 0.8144826950388273 1.21705961401066e-06 0.8155354283166244 \
1.217059701978917e-06 0.8162769513478326 1.217059800709989e-06 0.8171027376706747 1.217059943975142e-06 0.8182889948057973 1.217060079253827e-06 0.8193962136425846 \
1.21706018836845e-06 0.8202800249700468 1.217060336451758e-06 0.8214657808291811 1.217060486222685e-06 0.8226492530953341 1.217060611457285e-06 0.8236267526687548 \
1.217060755448703e-06 0.8247372275730155 1.217060879504774e-06 0.8256825756473101 1.217061029968032e-06 0.8268152483647575 1.217061165678884e-06 0.8278240064655301 \
1.217061290697392e-06 0.828742521381556 1.217061408452322e-06 0.8295983347934622 1.217061554429135e-06 0.8306466023667578 1.217061720938452e-06 0.8318251482734692 \
1.217061851861028e-06 0.8327390940956469 1.217062025288466e-06 0.8339327615268647 1.217062193435348e-06 0.8350717495747054 1.217062363270277e-06 0.8362042975620877 \
1.217062544195048e-06 0.8373912937861997 1.217062687293307e-06 0.8383160748488641 1.217062801379198e-06 0.8390446117604563 1.217062931553184e-06 0.8398665237782376 \
1.217063033394267e-06 0.8405024977857931 1.217063150213615e-06 0.8412243379523001 1.217063287078045e-06 0.8420597162999857 1.217063484876669e-06 0.8432475311273343 \
1.21706367648074e-06 0.8443767279905872 1.217063885921222e-06 0.8455874169714939 1.217064067846852e-06 0.8466193100105236 1.217064264979958e-06 0.8477171434207121 \
1.217064438329848e-06 0.8486653666163242 1.217064621329232e-06 0.8496493024239481 1.217064792495495e-06 0.8505537352954988 1.217064967127282e-06 0.8514606693963016 \
1.217065142389669e-06 0.8523550102558151 1.217065318541785e-06 0.8532381479010797 1.217065508812824e-06 0.8541746551565574 1.217065699414775e-06 0.85509499218684 \
1.217065900062401e-06 0.8560449689899254 1.217066092672966e-06 0.8569390259424264 1.217066303330652e-06 0.8578972157030333 1.217066531456051e-06 0.8589122247267402 \
1.217066797213369e-06 0.8600655879592763 1.217067095837813e-06 0.8613244245924475 1.217067372169332e-06 0.862454900702886 1.217067656402391e-06 0.8635842083919951 \
1.217067930614306e-06 0.8646423892283146 1.217068202842372e-06 0.8656634505877856 1.217068473051191e-06 0.8666487272755322 1.217068730204067e-06 0.8675609437488442 \
1.217069002786335e-06 0.868501515423508 1.217069278771335e-06 0.8694269133137555 1.217069548872912e-06 0.8703069289141475 1.217069848734863e-06 0.8712546000783432 \
1.217070219768993e-06 0.8723856543073821 1.217070514706754e-06 0.8732530157608677 1.217070768997536e-06 0.8739790309043101 1.217071067254951e-06 0.8748056771600844 \
1.217071340863485e-06 0.8755409825400007 1.21707157699155e-06 0.8761583495732972 1.21707181733693e-06 0.876770807053994 1.217072039670212e-06 0.8773233906735478 \
1.21707223367596e-06 0.8777948466981503 1.217072563398506e-06 0.8785737911727464 1.217072718571944e-06 0.8789308835864816 1.217073036347473e-06 0.8796437246174529 \
1.21707321520917e-06 0.8800342982281311 1.217073557671047e-06 0.8807611334253193 1.217073741799519e-06 0.8811407335605206 1.217074216677857e-06 0.8820849466541889 \
1.217074384074053e-06 0.8824061830950772 1.217074849915456e-06 0.8832696475595492 1.217075030737665e-06 0.8835931319180218 1.217075524775914e-06 0.8844450822729043 \
1.217075666124327e-06 0.8846804878101884 1.217076272457385e-06 0.8856498028150036 1.217076424526725e-06 0.8858829444029697 1.2170770712152e-06 0.8868329272509302 \
1.217077199509723e-06 0.8870138524519416 1.217077847626928e-06 0.8878919388991984 1.217077977425792e-06 0.8880607713689423 1.217078755627481e-06 0.8890227771434612 \
1.217078870684414e-06 0.8891574578072456 1.217079726342848e-06 0.8901003239091128 1.217079871707616e-06 0.8902505899439886 1.21708085746403e-06 0.8911948786459364 \
1.21708107856904e-06 0.8913892999646706 1.217082223696019e-06 0.8923206810037944 1.217082354912619e-06 0.892422953350996 1.217083696124267e-06 0.8934189515818408 \
1.217083847523211e-06 0.8935240845833778 1.217085328961459e-06 0.8944568913393511 1.217085567840892e-06 0.8945912088657246 1.217087337161074e-06 0.8954685138428928 \
1.217087726310841e-06 0.895637400736999 1.217090119976628e-06 0.896526474291006 1.21709059568945e-06 0.8966764365754722 1.217094011699057e-06 0.8975478548673914 \
1.217094658849072e-06 0.8976786076740833 1.217102137013678e-06 0.8986646932675814 1.217102809590796e-06 0.8987192862546014 1.217195253995367e-06 0.8997188196574962 \
1.217195917228051e-06 0.8997241906476866 1.217385126389945e-06 0.900686595210158 1.217385288462789e-06 0.9007292695325627 1.217387933983676e-06 0.8998161167154269 \
1.217388102533154e-06 0.8996881690130656 1.217389379285545e-06 0.8987393243250013 1.217389581451881e-06 0.8986030018074492 1.217391189561267e-06 0.8976721249252815 \
1.217391381667193e-06 0.8975774045828077 1.217406495049839e-06 0.8985726115129884 1.217406683108756e-06 0.8986004060702872 1.217417988037768e-06 0.8995874924221801 \
1.217418361423516e-06 0.8996034751727418 1.217907373786698e-06 0.9005892719715856 1.217907484554898e-06 0.9006868984798269 1.217908237227259e-06 0.9015617873136611 \
1.217908339021945e-06 0.9017086238768567 1.21790887442049e-06 0.9025814930725723 1.217908976929663e-06 0.9027670217776843 1.217909369148482e-06 0.9035254014384071 \
1.217909509991429e-06 0.9038129158713877 1.217909951028881e-06 0.9047472953155866 1.217910136514484e-06 0.9051402477015744 1.217910652827601e-06 0.9061269394579334 \
1.217910737502694e-06 0.9062564181617988 1.217911972174744e-06 0.9053011091537977 1.217912129388156e-06 0.9045688862145235 1.217912321204818e-06 0.9034162411061901 \
1.217912488045348e-06 0.9021712267446264 1.217912635003746e-06 0.9008824031243315 1.217912749119943e-06 0.8997575350477262 1.217912878992032e-06 0.8983446880789033 \
1.21791299010955e-06 0.8970273815442567 1.217913082914029e-06 0.8958483937359277 1.217913171236719e-06 0.8946639786015808 1.217913274417478e-06 0.8932058048613533 \
1.217913366625414e-06 0.8918333298588224 1.21791345419561e-06 0.8904732289418564 1.217913568189077e-06 0.8886245408236838 1.217913729993501e-06 0.8858564722885236 \
1.217913914992118e-06 0.8825005184224666 1.217914107151785e-06 0.8788219124347386 1.217914308599139e-06 0.874780227084481 1.217914515009728e-06 0.8704697801294994 \
1.217914700181681e-06 0.8664790122147591 1.217914884689405e-06 0.862405115500708 1.217915057841297e-06 0.8585071391690239 1.217915242887321e-06 0.8542751393552932 \
1.217915420261525e-06 0.8501657390392787 1.217915597007955e-06 0.8460284987362284 1.217915763166606e-06 0.8421077870518131 1.217915925211044e-06 0.8382599993991456 \
1.217916091783925e-06 0.8342839555277276 1.217916250437662e-06 0.8304816347052207 1.217916441313687e-06 0.8258903812682129 1.217916616297259e-06 0.8216694867670907 \
1.217916786243393e-06 0.8175615830390965 1.217916951419568e-06 0.8135626411663678 1.217917124611674e-06 0.8093650119631921 1.217917295673877e-06 0.8052155696745213 \
1.217917463774914e-06 0.801136095357175 1.217917654109863e-06 0.7965156511928794 1.217917837691807e-06 0.7920591698039 1.217918045682732e-06 0.7870113041480956 \
1.217918268259242e-06 0.7816114142545842 1.217918457674258e-06 0.7770174196885687 1.217918650984654e-06 0.7723312127316435 1.217918794430241e-06 0.7688556734481145 \
1.217918943853591e-06 0.7652374066097742 1.217919063006063e-06 0.7623536300085233 1.217919175722545e-06 0.7596269484184472 1.217919284997451e-06 0.7569846861296079 \
1.21791942102721e-06 0.753697254849378 1.217919533823024e-06 0.750972995067179 1.21791965602098e-06 0.7480232093637929 1.217919767605753e-06 0.7453311011793381 \
1.217919892312216e-06 0.7423241425761796 1.217920046694167e-06 0.7386034578119585 1.217920213478233e-06 0.7345862494782525 1.217920430642921e-06 0.7293605768817599 \
1.21792062520351e-06 0.7246835946359503 1.217920785534396e-06 0.7208333202545074 1.217920960959999e-06 0.7166251500492028 1.217921150723573e-06 0.7120779400724765 \
1.217921339451897e-06 0.7075610435995559 1.217921521273265e-06 0.7032145396962334 1.217921705870676e-06 0.6988062725207448 1.217921842953811e-06 0.6955348514212173 \
1.21792199624205e-06 0.6918805091472418 1.217922191613795e-06 0.6872279990818534 1.217922347770547e-06 0.6835136309588888 1.217922505722766e-06 0.6797605476340507 \
1.21792270397403e-06 0.6750570282453686 1.217922897319928e-06 0.6704763548785364 1.217923133825274e-06 0.6648822204491218 1.217923320030378e-06 0.6604858901039825 \
1.217923557652698e-06 0.6548824851665868 1.217923744451452e-06 0.6504854738275335 1.217923925009212e-06 0.6462424706993735 1.217924088085156e-06 0.6424159959781919 \
1.217924232696721e-06 0.6390271817202816 1.217924373299071e-06 0.6357379642635244 1.217924500108657e-06 0.632774906490579 1.217924632245193e-06 0.6296924762754078 \
1.217924758489145e-06 0.6267508340255646 1.217924889752774e-06 0.6236963630311418 1.217925018850514e-06 0.6206978048938425 1.217925158276179e-06 0.6174624210713571 \
1.217925306646171e-06 0.6140261568477932 1.21792550120306e-06 0.6095278574984737 1.217925644648937e-06 0.6062198040692683 1.217925879109183e-06 0.6008245134060309 \
1.217926051007495e-06 0.5968818013610552 1.217926263928034e-06 0.5920102583789468 1.217926436394651e-06 0.5880775912131976 1.217926566719198e-06 0.5851108450968721 \
1.217926698275517e-06 0.5821241897920357 1.217926808505599e-06 0.5796262478458715 1.217926904159847e-06 0.5774603558442819 1.217927003393806e-06 0.5752182923213994 \
1.217927086311908e-06 0.5733484809858778 1.217927165227534e-06 0.5715706040143225 1.217927228156309e-06 0.5701535626562365 1.217927293664786e-06 0.5686800671140783 \
1.217927374150839e-06 0.5668736364148982 1.217927424016847e-06 0.5657560592102344 1.217927473205615e-06 0.5646541775062763 1.217927534675401e-06 0.5632780399140616 \
1.217927582596929e-06 0.5622058085646952 1.217927633441648e-06 0.5610687758404553 1.217927692541903e-06 0.5597501790023616 1.21792775115623e-06 0.5584442118409422 \
1.217927826782323e-06 0.5567607189607793 1.217927897341035e-06 0.5551915720267918 1.217927986471042e-06 0.5532116467156011 1.21792807569462e-06 0.5512351177508077 \
1.217928160998231e-06 0.5493490637975145 1.217928248625197e-06 0.5474138635528197 1.21792834562712e-06 0.545274424894262 1.217928449972891e-06 0.5429792414815097 \
1.217928566264316e-06 0.5404269323775457 1.217928672601932e-06 0.5380963700835184 1.217928784310815e-06 0.5356536306660374 1.217928896605295e-06 0.5332047801427824 \
1.217929023802854e-06 0.5304364255197962 1.217929146572528e-06 0.5277698476303582 1.217929288796925e-06 0.5246912237717902 1.217929425160057e-06 0.5217463069543907 \
1.217929577381123e-06 0.5184691491721333 1.217929737017329e-06 0.5150420887864461 1.217929912992522e-06 0.5112761258030903 1.217930101501109e-06 0.5072591542828934 \
1.21793030856769e-06 0.5028616940969075 1.217930533509662e-06 0.4981043078903621 1.217930784905619e-06 0.4928144328841237 1.217931021331185e-06 0.4878598554762091 \
1.217931318494919e-06 0.4816683149127979 1.217931609172211e-06 0.4756487143466775 1.217931917027196e-06 0.469313240945046 1.217932230852954e-06 0.4628991126846517 \
1.217932559994313e-06 0.4562163541974347 1.21793289337242e-06 0.4494927613461197 1.217933224999028e-06 0.4428490490857003 1.217933546548425e-06 0.4364504708187015 \
1.217933874224238e-06 0.4299742838549845 1.217934221843861e-06 0.4231546934710667 1.217934555065174e-06 0.4166645133789623 1.217934900974402e-06 0.4099771621835854 \
1.217935346388222e-06 0.4014400148089548 1.217935704178092e-06 0.3946500490499754 1.217936018334912e-06 0.3887397205534429 1.217936402745392e-06 0.3815756289527631 \
1.217936732720037e-06 0.3754830843203271 1.217937017930125e-06 0.3702633801070484 1.217937326220382e-06 0.3646649204592909 1.217937606017443e-06 0.3596257204303125 \
1.217937832011793e-06 0.3555880084110294 1.217938046849748e-06 0.3517755993421203 1.21793824528482e-06 0.3482769933469286 1.217938449224337e-06 0.3447071465415313 \
1.217938659760396e-06 0.3410461989361561 1.217938916734522e-06 0.3366091000429626 1.217939157995129e-06 0.3324763702393667 1.217939389568845e-06 0.3285420159269506 \
1.217939604222291e-06 0.3249208057821749 1.217939825046275e-06 0.3212218866489027 1.217940026292867e-06 0.3178749657716667 1.21794022938212e-06 0.3145250552959265 \
1.217940427226992e-06 0.3112865758726304 1.217940614079937e-06 0.3082497660855442 1.217940808016663e-06 0.3051208532403978 1.217941011761317e-06 0.30185834615803 \
1.217941190488583e-06 0.2990186060348319 1.217941428134378e-06 0.2952727068736475 1.217941627896611e-06 0.2921508861588616 1.217941829525427e-06 0.2890253490052915 \
1.217942054991886e-06 0.285561995332 1.217942221086285e-06 0.2830312764183137 1.217942399705387e-06 0.2803277612349699 1.217942581409589e-06 0.2775983111934518 \
1.217942770043305e-06 0.2747882307029562 1.217942947466508e-06 0.2721695222189568 1.217943124659646e-06 0.2695724116247911 1.217943284731561e-06 0.2672552081803913 \
1.217943405132239e-06 0.2655193337608355 1.217943552958303e-06 0.2633957862580221 1.217943681588075e-06 0.2615692882062232 1.217943783793659e-06 0.2601227034409412 \
1.217943902028939e-06 0.2584516051170885 1.2179440224823e-06 0.2567534139348401 1.217944146190618e-06 0.2550183706610066 1.217944264442643e-06 0.2533694204037282 \
1.217944392295773e-06 0.2515887492000971 1.217944512581604e-06 0.249915736161692 1.21794466526121e-06 0.2477917697339537 1.217944800173989e-06 0.2459264316518071 \
1.21794492881341e-06 0.2441493177932957 1.217945086528788e-06 0.2419705448111171 1.217945213210091e-06 0.2402201997919771 1.217945348536158e-06 0.2383592392624043 \
1.217945487448727e-06 0.2364550510890953 1.217945605221031e-06 0.2348405558720491 1.21794576449185e-06 0.2326580599570062 1.217945901013704e-06 0.2307878375452989 \
1.217946042245651e-06 0.2288626996658652 1.217946148058693e-06 0.2274220928889542 1.21794627840164e-06 0.2256484734765637 1.217946378112453e-06 0.2242944442559471 \
1.217946480933888e-06 0.2228991027388591 1.217946554349542e-06 0.2219046249368765 1.217946634181104e-06 0.2208265149641777 1.217946704228335e-06 0.2198809561195558 \
1.217946754631426e-06 0.2192009305305119 1.217946806883225e-06 0.2184966408607167 1.217946886120743e-06 0.2174292050927151 1.217946927964696e-06 0.2168658036437602 \
1.217946967304648e-06 0.216336351877609 1.217947010340058e-06 0.2157575332679269 1.217947054507484e-06 0.2151638767852215 1.217947128273224e-06 0.2141731338947761 \
1.217947163785221e-06 0.2136967174286463 1.217947211500021e-06 0.2130606706933813 1.217947272229561e-06 0.2122518321687151 1.217947340486787e-06 0.2113438957752176 \
1.217947413008566e-06 0.2103801801047663 1.217947485683193e-06 0.2094152724966429 1.217947593999181e-06 0.2079788886429202 1.217947691670323e-06 0.20668564243436 \
1.217947803221819e-06 0.2052110974836689 1.217947901757253e-06 0.2039136008387587 1.217948005250393e-06 0.2025572972554956 1.217948101152128e-06 0.2013021587886929 \
1.217948203780057e-06 0.1999606878451601 1.21794830660317e-06 0.1986207062101238 1.217948416722797e-06 0.1971897063011611 1.217948525418353e-06 0.1957815523781236 \
1.217948645095582e-06 0.1942360962608612 1.217948755373261e-06 0.192818053470401 1.217948863436481e-06 0.1914343471929882 1.217948988535148e-06 0.1898375077741012 \
1.217949078504982e-06 0.1886931806549971 1.217949157191935e-06 0.1876950225942949 1.217949234476806e-06 0.1867173468865102 1.217949320985383e-06 0.1856271834369256 \
1.217949419934593e-06 0.1843848109964498 1.217949490443458e-06 0.1835017733581451 1.217949561894511e-06 0.1826096997732476 1.217949667039846e-06 0.1813018727451555 \
1.217949746279476e-06 0.1803200401832796 1.21794982736337e-06 0.1793174195483187 1.21794992085531e-06 0.1781663090788374 1.217950021631285e-06 0.1769308188703378 \
1.217950171343388e-06 0.175105380089017 1.217950287132704e-06 0.1737009932372819 1.217950438138081e-06 0.1718807311127691 1.2179505492465e-06 0.1705485445502526 \
1.217950691372959e-06 0.168854666407182 1.217950809031379e-06 0.167460358327668 1.217950913935975e-06 0.1662230887079887 1.217951008998573e-06 0.1651069099307241 \
1.217951102429828e-06 0.1640147999883682 1.21795120347649e-06 0.1628388413495604 1.217951299823398e-06 0.1617223204899406 1.217951396975644e-06 0.1606011553546776 \
1.217951480024216e-06 0.1596469772300165 1.21795159006187e-06 0.1583897228513109 1.217951672364432e-06 0.1574542248873526 1.217951777364141e-06 0.156267858580057 \
1.21795185506021e-06 0.1553950893374849 1.217951937879689e-06 0.1544690878994293 1.217952019541594e-06 0.1535604570452941 1.217952108890884e-06 0.152571060794856 \
1.21795218460332e-06 0.1517364980793458 1.217952267165934e-06 0.1508307726525361 1.217952343747367e-06 0.1499942554682341 1.217952412035253e-06 0.1492531084507001 \
1.217952505402265e-06 0.1482449401818621 1.217952574555677e-06 0.1475015570698688 1.217952650180008e-06 0.1466917482325688 1.217952711729129e-06 0.1460354497178591 \
1.217952778977892e-06 0.1453208357145237 1.217952850039892e-06 0.1445684785944268 1.21795292553732e-06 0.143772322008306 1.21795298444886e-06 0.1431546944759192 \
1.21795306112247e-06 0.1423563022825049 1.217953141443211e-06 0.1415233898163201 1.21795321459452e-06 0.1407682091691316 1.217953308750941e-06 0.139800669784813 \
1.217953380355125e-06 0.1390684367429364 1.217953453815901e-06 0.1383201464810226 1.217953537327652e-06 0.1374732033664194 1.217953626806795e-06 0.1365744208092838 \
1.2179536918717e-06 0.1359252211013016 1.217953803997723e-06 0.1348115665849295 1.217953869183864e-06 0.1341670699454539 1.217953939222108e-06 0.1334770515823289 \
1.217953999527163e-06 0.1328849371768329 1.217954054537987e-06 0.1323464455745446 1.217954142654965e-06 0.1314871014507438 1.21795418344126e-06 0.131090685705856 \
1.217954287144011e-06 0.1300923774523848 1.21795433045658e-06 0.1296773144713907 1.217954391675178e-06 0.1290920262082728 1.217954436511898e-06 0.1286643765206081 \
1.217954524107923e-06 0.127831527987147 1.217954565661879e-06 0.1274377589706847 1.21795462552339e-06 0.1268718307679372 1.217954697367115e-06 0.1261946708524367 \
1.217954753579841e-06 0.1256664967939027 1.21795481606734e-06 0.125081039250218 1.217954890295323e-06 0.1243877959456236 1.217954964976328e-06 0.1236954937854857 \
1.217955052159541e-06 0.1228905551604285 1.217955120558092e-06 0.1222610287411191 1.217955201128775e-06 0.1215216597888775 1.217955282424256e-06 0.120778012781285 \
1.217955349340781e-06 0.1201677797529914 1.217955432157726e-06 0.1194156054679852 1.217955491346448e-06 0.1188799972037829 1.217955557267448e-06 0.1182853617472536 \
1.217955637141492e-06 0.1175675408705869 1.21795571363729e-06 0.1168828806096336 1.2179557950994e-06 0.1161574242846086 1.217955893570281e-06 0.1152852106851665 \
1.21795596868063e-06 0.114622623867465 1.21795607166842e-06 0.1137180076826871 1.217956145852371e-06 0.1130691786503039 1.217956243471825e-06 0.1122190343868764 \
1.21795633928278e-06 0.1113890351962442 1.217956435131205e-06 0.110562946039519 1.217956516069412e-06 0.1098685209805978 1.217956604452683e-06 0.1091134439098378 \
1.217956703052662e-06 0.108274944429282 1.217956775836866e-06 0.1076586405352824 1.217956865109775e-06 0.1069058608836731 1.217956927091788e-06 0.1063852406583179 \
1.217956989684956e-06 0.1058613310701875 1.217957074907104e-06 0.105150777260444 1.217957180369478e-06 0.1042758147594986 1.217957260199961e-06 0.1036167065755082 \
1.217957340914214e-06 0.1029530974056021 1.21795742352795e-06 0.1022768941101355 1.217957493972562e-06 0.1017026162492672 1.217957597231928e-06 0.1008648142128753 \
1.217957670072053e-06 0.1002767039768694 1.217957755712335e-06 0.09958839426015198 1.217957874514073e-06 0.09863954321822334 1.217957942151898e-06 0.09810250133474645 \
1.21795801190202e-06 0.09755100310752296 1.217958089237e-06 0.09694230106952094 1.217958181657254e-06 0.09621870517595056 1.217958253354782e-06 0.09566033062548993 \
1.217958339171942e-06 0.09499542738017568 1.217958441597192e-06 0.09420660575030523 1.217958534892083e-06 0.09349264652734962 1.217958631208556e-06 0.09276005482712441 \
1.217958708110818e-06 0.09217843893134048 1.217958801590805e-06 0.09147541043939374 1.217958880833232e-06 0.09088281005358793 1.217958995455426e-06 0.0900310686188453 \
1.217959125063686e-06 0.08907580221142102 1.217959258320877e-06 0.08810234090122065 1.217959402350766e-06 0.08705990691030199 1.21795955951891e-06 0.08593388720602639 \
1.217959709295387e-06 0.08487214151476249 1.217959871762979e-06 0.08373303262435308 1.217960014942984e-06 0.08273971668837025 1.217960167622107e-06 0.0816913199659166 \
1.217960301891878e-06 0.08077856892457436 1.217960443644156e-06 0.07982444400446118 1.217960578643816e-06 0.07892500874648442 1.217960720601214e-06 0.07798882638923543 \
1.217960867448644e-06 0.07703088995320664 1.217961019894053e-06 0.07604750978240994 1.217961185112776e-06 0.07499422991502351 1.217961349250621e-06 0.07396067809208305 \
1.217961526112024e-06 0.07286119333145537 1.21796171645358e-06 0.07169407515132428 1.217961927410093e-06 0.07042030845332216 1.217962147819232e-06 0.0691121699798517 \
1.217962383344393e-06 0.06773900533435212 1.217962643793767e-06 0.0662496528900723 1.217962939459177e-06 0.06459579389282195 1.217963244581463e-06 0.06292902455725519 \
1.217963609576024e-06 0.06098725515092194 1.217964004456839e-06 0.05894944116461652 1.217964410847493e-06 0.05692211719668253 1.217964826573035e-06 0.05491854459141238 \
1.217965189379358e-06 0.0532251207245777 1.217965533980648e-06 0.05166301626031383 1.21796584916051e-06 0.05027284652491828 1.217966144689875e-06 0.04900240867073854 \
1.217966442670383e-06 0.04775344010203557 1.217966718469173e-06 0.04662857640242725 1.217966997243769e-06 0.04551884372531381 1.217967261178638e-06 0.04449205559535935 \
1.217967537201377e-06 0.04344260531795661 1.21796781615763e-06 0.04240676967887352 1.217968129850963e-06 0.04127097799875453 1.21796836585125e-06 0.04043636567030678 \
1.217968621645988e-06 0.03955075129286261 1.217968881769487e-06 0.03867033103466553 1.21796915190476e-06 0.03778142289416799 1.217969431124747e-06 0.03688501536902895 \
1.217969712963396e-06 0.03600226561751176 1.217969989839066e-06 0.03515600409566183 1.217970268932665e-06 0.03432349610146775 1.217970501810273e-06 0.03364444121149882 \
1.217970785646989e-06 0.03283527291840588 1.217971025751924e-06 0.03216626441466421 1.217971265550746e-06 0.0315119836023277 1.21797150482792e-06 0.03087436846876356 \
1.217971740084942e-06 0.03026290129608995 1.217971971011964e-06 0.02967475842909434 1.217972186001007e-06 0.02913788335257221 1.21797258815546e-06 0.02816043724496065 \
1.217972786878278e-06 0.02768988489927659 1.217973160561295e-06 0.0268265706552881 1.217973347359617e-06 0.02640514011949098 1.217973694919304e-06 0.02563810810034544 \
1.217973816848767e-06 0.0253740445387235 1.217974199320208e-06 0.02456430406701914 1.217974370028237e-06 0.02421180751242828 1.217974827125621e-06 0.02328894863848502 \
1.217975012758007e-06 0.0229225623309489 1.21797537621526e-06 0.02221803970155307 1.217975596582613e-06 0.02179832126591805 1.21797605430897e-06 0.02093867417890744 \
1.217976189728599e-06 0.02068687731869814 1.217976719624047e-06 0.01972418011126781 1.217976838945017e-06 0.01951377505543128 1.217977404730696e-06 0.01856069823426573 \
1.217977569110437e-06 0.0182962226476828 1.217978187655734e-06 0.01735107502432094 1.217978357709933e-06 0.01710418363667701 1.217978889842166e-06 0.01636278834442301 \
1.217979086926142e-06 0.01610013864443424 1.217979810045215e-06 0.01517806887136661 1.217979974675381e-06 0.01497647803580381 1.217980723800768e-06 0.01409711804523418 \
1.21798085710012e-06 0.01394643716836554 1.217981717353759e-06 0.01301449210748497 1.217981852457379e-06 0.01287422877142914 1.21798279503482e-06 0.01193816285908547 \
1.217982958630574e-06 0.01178202925388569 1.217983959987201e-06 0.0108653384673985 1.217984097529988e-06 0.01074500730514941 1.217985319636371e-06 0.009765086624518643 \
1.217985426589084e-06 0.00968516078425012 1.217986830780577e-06 0.008707372520026449 1.217986935611284e-06 0.008639312158696611 1.217988470448246e-06 0.00767719340797631 \
1.217988565731548e-06 0.007617466071856052 1.217990174528868e-06 0.006680264535635283 1.217990308605608e-06 0.006609506832171614 1.217992405618559e-06 0.005610918814474722 \
1.217992636163191e-06 0.005510783990371394 1.217994959158435e-06 0.004586584533412417 1.217995440488638e-06 0.004413562233393853 1.217998278050269e-06 0.003511943147855551 \
1.217998822969955e-06 0.003360532104877318 1.218002947178352e-06 0.002408309874554541 1.218003490902011e-06 0.002305347543005144 1.218009362191237e-06 0.001333291345955189 \
1.218009605056421e-06 0.001286469439319215 1.218023932948772e-06 0.0002880570268237783 1.218024077507414e-06 0.0002853642807229123 1.220661356428513e-06 -0.0006859155495331031 \
1.22066149598365e-06 -0.000901903561740745 1.220662005077583e-06 -0.001859438188174024 1.220662094565085e-06 -0.002052812934985279 1.220662457959945e-06 -0.00291126965001638 \
1.220662548982016e-06 -0.003143482006111167 1.220662914420052e-06 -0.004127275145644371 1.220663024680619e-06 -0.004436819103926468 1.220663336727774e-06 -0.005309594399865315 \
1.220663439442621e-06 -0.005584800160857357 1.220663803290477e-06 -0.006384516484886619 1.220663968081209e-06 -0.006586298968823262 1.220664547677408e-06 -0.005791490933239759 \
1.220664722787551e-06 -0.004914057272375438 1.220664839479485e-06 -0.004132845175365214 1.220664966064091e-06 -0.003100877896798674 1.220665067873013e-06 -0.002132773363901063 \
1.220665188361723e-06 -0.0008283127610571584 1.220665278808799e-06 0.0002599396317828252 1.22066537669893e-06 0.001541559978017447 1.22066547576324e-06 0.002943971508909197 \
1.220665646570516e-06 0.005594911825788154 1.220665868338539e-06 0.00944046646559993 1.220666064242385e-06 0.01317281463966807 1.220666223123767e-06 0.01639870563256729 \
1.220666387552263e-06 0.01989779506365397 1.220666541918294e-06 0.02331070396473752 1.220666700690818e-06 0.02693200463312963 1.220666847428777e-06 0.03036422445567413 \
1.220666996052748e-06 0.0339113704936035 1.220667151667245e-06 0.03768995713197771 1.220667308909259e-06 0.04156499463828727 1.220667473802058e-06 0.04567927910670353 \
1.220667647221578e-06 0.05005184210758699 1.220667825915293e-06 0.05459761989277153 1.220668014531131e-06 0.05943075613080645 1.220668215431274e-06 0.06460909294799391 \
1.220668434888065e-06 0.0702927970720964 1.220668664434352e-06 0.07626037976612585 1.220668910133291e-06 0.08266408948881369 1.22066917869823e-06 0.08967663153997742 \
1.220669470040145e-06 0.09728936802005522 1.220669791708172e-06 0.1056939239977524 1.220670152022263e-06 0.1150987971742611 1.220670543001701e-06 0.1252892839303718 \
1.220670986416517e-06 0.1368209045172546 1.220671502729605e-06 0.1502062239570841 1.220672108934821e-06 0.16586000516691 1.220672780191848e-06 0.1831102247110778 \
1.220673559691505e-06 0.20301830483439 1.220674432001389e-06 0.2251413938832897 1.220675262336714e-06 0.2460320778586349 1.220675993667064e-06 0.264292249712138 \
1.220676641612843e-06 0.280346965484095 1.220677224923317e-06 0.29469740877147 1.220677760655584e-06 0.3077798509628869 1.220678263914169e-06 0.3199778888071559 \
1.22067874911767e-06 0.3316516836183861 1.220679228040376e-06 0.3430829066939081 1.220679674471008e-06 0.3536501814456421 1.220680148800718e-06 0.3647819492304352 \
1.220680597991712e-06 0.3752331958288908 1.22068108846397e-06 0.3865396207984229 1.220681617036723e-06 0.3985997842463301 1.220681988181063e-06 0.4069920784971888 \
1.220682515935418e-06 0.4188173133762567 1.220682978292178e-06 0.4290642331729484 1.220683450624318e-06 0.4394285229343968 1.220683932409041e-06 0.4498981261869666 \
1.220683965448159e-06 0.4506126593745911 1.220684003207152e-06 0.45142837879914 1.220684078725137e-06 0.4530572051633331 1.220684229761107e-06 0.4563088938659436 \
1.220684437280373e-06 0.460764549126051 1.220684625319184e-06 0.4647825567212808 1.220684844328398e-06 0.469441659996985 1.22068508715941e-06 0.4745824626509371 \
1.220685386935037e-06 0.4808894567257585 1.220685624728187e-06 0.4858624696070272 1.220685887949588e-06 0.4913374535260851 1.220686148847133e-06 0.4967277906005185 \
1.22068637840122e-06 0.5014431429135263 1.220686601461414e-06 0.506003872007333 1.220686803037404e-06 0.5100983586086808 1.220686951867463e-06 0.51310967141356 \
1.220687196178516e-06 0.5180317772556589 1.220687328783749e-06 0.5206893064287169 1.220687468140331e-06 0.5234717264876519 1.220687679105724e-06 0.5276623644271943 \
1.220687853979606e-06 0.5311266030493931 1.220688122027852e-06 0.5364094032095129 1.22068831705351e-06 0.5402319029111832 1.220688496615017e-06 0.5437361368949839 \
1.220688747571146e-06 0.5486228351952749 1.220689024979257e-06 0.5540035987981641 1.220689308928559e-06 0.5594901708581531 1.22068956456585e-06 0.5644152233389156 \
1.22068985554807e-06 0.570006772487656 1.220690115853754e-06 0.5749917787111524 1.220690384297874e-06 0.5801232573974072 1.220690627063004e-06 0.5847450403362237 \
1.220690883594205e-06 0.5896146675871002 1.220691109757648e-06 0.59388771440121 1.220691347099143e-06 0.5983512154742827 1.22069155648786e-06 0.6022720321566808 \
1.220691770260628e-06 0.6062574570422776 1.220692023713469e-06 0.6109557890491497 1.220692226567817e-06 0.6146943332140289 1.220692419372338e-06 0.6182333111593361 \
1.220692609677365e-06 0.6217090173923294 1.220692800335854e-06 0.6251694921350958 1.22069300291378e-06 0.6288260100903066 1.220693265662542e-06 0.6335359534764116 \
1.220693494630232e-06 0.6376100987349322 1.220693714577867e-06 0.6414991146358265 1.22069394026254e-06 0.6454625140719233 1.220694149149966e-06 0.6491091855837361 \
1.220694370803585e-06 0.652957810138281 1.220694555693011e-06 0.6561429680377227 1.220694745707565e-06 0.6594017273991298 1.220694895862686e-06 0.6619630641908443 \
1.220695070740593e-06 0.6649292185271485 1.22069521646131e-06 0.6673855496832628 1.220695352493842e-06 0.6696641287411549 1.220695500856121e-06 0.672138295335571 \
1.220695630303834e-06 0.6742883907026684 1.220695764169531e-06 0.6764996355878535 1.22069589251393e-06 0.6786115243545502 1.220696017902059e-06 0.6806677490053815 \
1.220696147367755e-06 0.6827843190971332 1.22069627834897e-06 0.6849171426143115 1.220696426722072e-06 0.6873221141612875 1.220696534784827e-06 0.6890667486235877 \
1.2206966633165e-06 0.6911333958680312 1.220696798756284e-06 0.6933004139195943 1.220696923690607e-06 0.6952876996714908 1.220697049447875e-06 0.6972799977491608 \
1.220697155963766e-06 0.6989584331773744 1.220697273081655e-06 0.7007929859467624 1.220697391621401e-06 0.7026383448210159 1.220697514924797e-06 0.704545102273978 \
1.220697618097696e-06 0.7061304255463237 1.220697769068859e-06 0.7084341141567283 1.220697885323065e-06 0.7101955266062138 1.220698015883454e-06 0.7121605601685687 \
1.220698134445982e-06 0.7139335830373704 1.220698240519852e-06 0.7155108922888329 1.220698340544792e-06 0.716990346352101 1.220698477870007e-06 0.719009255813789 \
1.220698596531362e-06 0.7207429633399333 1.220698718230586e-06 0.7225107522614664 1.220698843413151e-06 0.7243181860083944 1.220698965432965e-06 0.7260693242762759 \
1.220699093464719e-06 0.7278954552757622 1.220699217946458e-06 0.7296603419865877 1.220699346245781e-06 0.7314685590147565 1.220699473339584e-06 0.7332489547570846 \
1.220699599364423e-06 0.7350034830462163 1.22069970210311e-06 0.7364262918236342 1.220699816775856e-06 0.7380063527755659 1.220699898181918e-06 0.7391232259175492 \
1.220700017381438e-06 0.7407496908814458 1.220700110023778e-06 0.7420059782745783 1.220700248182835e-06 0.7438668850244906 1.220700379238335e-06 0.7456179978167152 \
1.220700509370502e-06 0.7473439783685625 1.220700614344577e-06 0.7487266533969134 1.220700753484419e-06 0.7505456565005918 1.220700907428719e-06 0.7525407731682957 \
1.220701029372999e-06 0.7541080835708853 1.220701176919359e-06 0.7559892974429111 1.220701298924537e-06 0.7575320275232224 1.220701447624467e-06 0.7593968175435225 \
1.220701581671092e-06 0.7610632318338031 1.220701703924347e-06 0.7625711443351471 1.220701816790257e-06 0.763953046884334 1.220701959641225e-06 0.7656882893306027 \
1.22070208636412e-06 0.7672149413549471 1.220702202168994e-06 0.7685995877768005 1.220702331910823e-06 0.7701390587657672 1.220702447649211e-06 0.7715019052061673 \
1.220702570601637e-06 0.7729391548276606 1.220702688317297e-06 0.7743051053122872 1.220702794287273e-06 0.7755262985206828 1.220702910698468e-06 0.7768586864857919 \
1.220703017316401e-06 0.7780703956921795 1.220703129515121e-06 0.7793369495935717 1.22070321618369e-06 0.7803089322889447 1.220703319569181e-06 0.7814603789665585 \
1.220703432733433e-06 0.7827108149434853 1.220703538380716e-06 0.783868819044773 1.220703647720273e-06 0.7850578567336689 1.220703754897288e-06 0.786214126597127 \
1.220703884303365e-06 0.7875981444497275 1.220703996720751e-06 0.7887899291890393 1.22070412010849e-06 0.7900869036018625 1.220704237558826e-06 0.7913106402786101 \
1.220704381085744e-06 0.7927918312347375 1.220704496005322e-06 0.7939667362870242 1.220704634727735e-06 0.7953719780830618 1.220704772759876e-06 0.7967562205547866 \
1.22070488225303e-06 0.7978444364842524 1.22070498327146e-06 0.7988406866985471 1.22070508435942e-06 0.7998302780396641 1.220705216746616e-06 0.8011146558616069 \
1.220705335472037e-06 0.8022550163876687 1.220705457256542e-06 0.8034134048507504 1.220705576346336e-06 0.8045351524060473 1.220705697550853e-06 0.8056657048884367 \
1.220705829194665e-06 0.8068811249615274 1.220705952212703e-06 0.8080052413861453 1.220706079823024e-06 0.8091594649786741 1.220706210891683e-06 0.8103325925767672 \
1.220706334212046e-06 0.8114249716726942 1.220706442136311e-06 0.8123719892944993 1.220706549931703e-06 0.8133095350680949 1.220706631652631e-06 0.8140147772069938 \
1.220706748520248e-06 0.815015186305849 1.220706839581256e-06 0.8157880755829442 1.220706973749888e-06 0.8169164295805346 1.22070711832076e-06 0.8181184617099191 \
1.220707251823127e-06 0.8192158725965917 1.220707361789038e-06 0.8201107352847025 1.220707505654698e-06 0.8212684563313245 1.220707658960262e-06 0.8224861772268215 \
1.220707786698555e-06 0.8234883060891934 1.220707927340891e-06 0.8245786478120171 1.220708053124456e-06 0.8255423809867173 1.220708207742427e-06 0.8267124309768116 \
1.220708340154194e-06 0.8277017767197102 1.220708466433798e-06 0.8286345641820314 1.220708584064113e-06 0.8294941055817234 1.220708732230976e-06 0.8305638349826423 \
1.220708899375221e-06 0.8317531470681401 1.220709031993881e-06 0.832683775428688 1.220709204938569e-06 0.8338803479528284 1.220709373325224e-06 0.8350269493631071 \
1.220709542859754e-06 0.8361634673386688 1.220709724228909e-06 0.8373596561587384 1.220709866861491e-06 0.8382862741713709 1.22070998079734e-06 0.8390176620397163 \
1.220710111571134e-06 0.8398476357987267 1.220710213225074e-06 0.8404856735008092 1.220710329718803e-06 0.8412091703399448 1.220710465236349e-06 0.8420405885319162 \
1.220710662580143e-06 0.8432318270427018 1.220710853245141e-06 0.8443612543037786 1.22071106310198e-06 0.8455804035625291 1.220711244039104e-06 0.8466117334714958 \
1.220711441374591e-06 0.8477160230260256 1.220711615161427e-06 0.8486711109012058 1.220711797742881e-06 0.8496572451898022 1.220711969062461e-06 0.850566499179887 \
1.220712143447508e-06 0.8514760798656241 1.220712318831052e-06 0.8523748177975867 1.22071249506321e-06 0.8532619682996843 1.220712684901452e-06 0.8542000584728613 \
1.220712875637665e-06 0.8551245802328369 1.220713077434399e-06 0.856083442102113 1.220713270127775e-06 0.8569809170305027 1.220713479756077e-06 0.857937542729613 \
1.22071370919384e-06 0.8589615588718806 1.22071397499048e-06 0.8601183337444025 1.220714273565708e-06 0.8613802063570262 1.220714551467221e-06 0.8625196921548358 \
1.220714835677695e-06 0.8636511027355716 1.220715110089482e-06 0.8647118800460076 1.220715382252364e-06 0.8657341977214618 1.220715652421456e-06 0.8667205537246333 \
1.220715909616139e-06 0.8676338760342862 1.220716182155811e-06 0.868575115807136 1.220716458190291e-06 0.8695013130444248 1.220716728342986e-06 0.8703818891200001 \
1.220717028049788e-06 0.8713292845176382 1.220717398867258e-06 0.8724597217497643 1.220717693785921e-06 0.8733269024855727 1.220717948030199e-06 0.8740525764960509 \
1.220718246254199e-06 0.8748787854419284 1.220718519878969e-06 0.8756137195941651 1.220718756017959e-06 0.8762307200963571 1.220718996373686e-06 0.8768427579093606 \
1.220719218719338e-06 0.8773949085683344 1.220719412723072e-06 0.877865919014753 1.220719742447196e-06 0.878644045115768 1.220719897619855e-06 0.8790007149587372 \
1.220720215373248e-06 0.879712598742095 1.220720394238605e-06 0.8801026384247937 1.220720736700094e-06 0.8808283583858193 1.220720920841293e-06 0.8812073588304842 \
1.220721395746114e-06 0.8821499412898334 1.220721563140601e-06 0.8824705695712217 1.220722028971889e-06 0.8833323038036038 1.220722209796772e-06 0.8836551183393088 \
1.220722703830028e-06 0.8845051821644966 1.220722845172603e-06 0.8847400410050358 1.220723451563118e-06 0.8857071861637142 1.220723603635685e-06 0.8859397703602404 \
1.220724250313758e-06 0.8868873789663725 1.220724378610247e-06 0.8870678433440622 1.220725026723245e-06 0.8879435266410994 1.220725156528524e-06 0.8881118897635528 \
1.220725934785608e-06 0.8890711781604964 1.220726049780423e-06 0.8892053868933587 1.220726905511062e-06 0.8901454611437621 1.220727050777629e-06 0.8902951528450479 \
1.220728036533732e-06 0.8912364417375994 1.220728257640946e-06 0.8914302300078862 1.220729402752027e-06 0.892358484239638 1.220729533960174e-06 0.8924604119362172 \
1.22073087526337e-06 0.8934531785430913 1.22073102665103e-06 0.8935579568409697 1.220732508109867e-06 0.8944876667405802 1.220732746990229e-06 0.894621531696939 \
1.220734516461986e-06 0.8954958910368339 1.220734905568824e-06 0.8956641700186337 1.220737299334232e-06 0.8965498195158238 1.220737774894223e-06 0.8966991754584082 \
1.220741837950387e-06 0.8976977719002629 1.220742329424408e-06 0.8977905759376156 1.220750645951487e-06 0.8987839664765119 1.220751565805377e-06 0.8988472044554419 \
1.220877770945903e-06 0.8998441026240215 1.220878784754255e-06 0.8998514601858095 1.221070497347411e-06 0.8990059056521554 1.221070727348974e-06 0.8988405173838494 \
1.221072342221535e-06 0.8978439928078279 1.221072519935389e-06 0.8977495532019018 1.221089285710429e-06 0.8987316330193963 1.221089421698825e-06 0.8987497732072308 \
1.221104884427939e-06 0.8997471920221268 1.221105152292531e-06 0.8997526389354535 1.221588977619799e-06 0.9006560548284696 1.221589098408999e-06 0.9007687033315858 \
1.221589886180038e-06 0.9017381658104292 1.221590020318757e-06 0.901943163319478 1.221590513933531e-06 0.9027850367016239 1.221590658833145e-06 0.9030569221572713 \
1.22159105464053e-06 0.9038490360455199 1.221591174436184e-06 0.9041001886668685 1.221591558609718e-06 0.9049189780371781 1.221591670731365e-06 0.9051556495331843 \
1.221592178052336e-06 0.9061253139956988 1.221592272051192e-06 0.90626859229291 1.221593430700898e-06 0.9055667778886739 1.221593533663832e-06 0.9051589876696525 \
1.221593617506701e-06 0.9047707260375384 1.221593751246752e-06 0.9040404158978201 1.221593851964133e-06 0.9033957423200318 1.221593959579919e-06 0.9026166239542108 \
1.221594077153173e-06 0.9016533104038295 1.221594165418223e-06 0.90085556431878 1.221594285051691e-06 0.8996698288011099 1.221594382373389e-06 0.8986166602050341 \
1.221594493390828e-06 0.8973222354192386 1.221594595500415e-06 0.8960407982554908 1.221594678931815e-06 0.8949326975987755 1.221594783112883e-06 0.8934749428758865 \
1.221594874199646e-06 0.8921321265381427 1.221594966740432e-06 0.8907058396397178 1.22159506189443e-06 0.8891776325191247 1.221595176449407e-06 0.88725933118288 \
1.221595265292509e-06 0.8857137884271823 1.221595363531691e-06 0.8839502506198179 1.221595448901865e-06 0.8823735982707064 1.221595529802107e-06 0.8808434949738935 \
1.2215956027634e-06 0.8794355441897157 1.221595669782045e-06 0.8781198554636557 1.221595738393124e-06 0.8767515715160701 1.221595821888036e-06 0.8750591081124355 \
1.221595884015366e-06 0.8737811510706814 1.221595946997964e-06 0.8724704924326797 1.221596042153715e-06 0.8704632161180945 1.221596142764353e-06 0.8683077530860182 \
1.221596222643545e-06 0.8665738309361769 1.221596306905814e-06 0.8647250601592834 1.221596386016074e-06 0.8629723295901451 1.221596448831519e-06 0.8615696597604833 \
1.221596536288554e-06 0.8596016864744445 1.221596602182084e-06 0.8581079708060287 1.221596670243626e-06 0.856556281928966 1.221596719556134e-06 0.8554267461646872 \
1.221596774792924e-06 0.85415654045335 1.221596815532529e-06 0.8532164928603474 1.221596861834283e-06 0.8521450198670055 1.221596892048343e-06 0.8514441160591502 \
1.221596921089625e-06 0.8507691938976955 1.22159695172822e-06 0.8500558939662993 1.22159701300541e-06 0.8486254874746039 1.221597066077972e-06 0.8473828229799116 \
1.221597119733165e-06 0.8461232012188223 1.221597182390447e-06 0.8446482873934593 1.221597245673395e-06 0.8431545995644786 1.221597336171269e-06 0.8410121009440262 \
1.22159743316905e-06 0.8387078554355326 1.22159751614655e-06 0.8367307351423475 1.221597598150906e-06 0.8347721678896715 1.221597687219307e-06 0.8326403548070889 \
1.221597771732643e-06 0.8306135893189693 1.221597862591524e-06 0.8284303722590877 1.221597954526378e-06 0.8262176456275642 1.221598056957309e-06 0.8237486178045141 \
1.22159815707534e-06 0.8213320995840899 1.221598271896223e-06 0.8185572053828121 1.22159838410276e-06 0.8158423448209959 1.221598509096305e-06 0.8128151787794674 \
1.221598640356713e-06 0.8096337870015397 1.221598785627755e-06 0.8061104108175116 1.221598940135368e-06 0.8023613213197434 1.221599111575989e-06 0.7981999722344618 \
1.221599275625781e-06 0.794217661721315 1.221599460041203e-06 0.7897413884478564 1.221599666533577e-06 0.7847307375046715 1.22159985602742e-06 0.7801344622909899 \
1.221600049421183e-06 0.775444374634302 1.221600249988037e-06 0.7705834242206392 1.221600397552439e-06 0.7670092004965298 1.22160052756389e-06 0.7638619034739171 \
1.221600662428303e-06 0.7605987503374771 1.221600768918754e-06 0.7580234999254772 1.221600900608547e-06 0.7548403390839162 1.221601007032976e-06 0.7522693550468039 \
1.221601150211605e-06 0.7488125398635642 1.221601311338716e-06 0.7449250928176189 1.221601429565533e-06 0.7420746008290786 1.221601599798354e-06 0.7379721584775248 \
1.221601765724624e-06 0.7339761998059781 1.221601985266954e-06 0.7286940862104242 1.221602178454078e-06 0.724050920820232 1.221602353368041e-06 0.719851304223293 \
1.221602520315139e-06 0.7158476177432674 1.2216027078061e-06 0.711355754450834 1.221602895234537e-06 0.7068709122373377 1.221603063571096e-06 0.7028473835914892 \
1.22160325640163e-06 0.6982428782038785 1.221603396451378e-06 0.694901318858167 1.221603552708666e-06 0.6911769338170629 1.221603746878113e-06 0.6865540563080536 \
1.221603905984602e-06 0.6827702245679255 1.221604064344632e-06 0.679008548037742 1.22160425966174e-06 0.6743756772263459 1.221604470090519e-06 0.6693917663527935 \
1.221604722792665e-06 0.6634173774538097 1.221604902460616e-06 0.6591769455535931 1.221605154037489e-06 0.6532475027332399 1.221605354410306e-06 0.6485340174553987 \
1.221605526064158e-06 0.6445032789616798 1.221605684756275e-06 0.6407814961122935 1.221605823964202e-06 0.637522316374186 1.221605960288252e-06 0.6343349641335875 \
1.221606087501276e-06 0.6313646237382058 1.221606216993834e-06 0.6283457899522861 1.221606344985121e-06 0.6253646753452949 1.22160647605963e-06 0.6223174651643489 \
1.221606606771705e-06 0.6192830747181834 1.221606749379758e-06 0.6159760732208495 1.221606892103236e-06 0.612672916206165 1.221607044651037e-06 0.6091471600588 \
1.221607189155025e-06 0.6058158037532523 1.221607353173272e-06 0.6020406322262999 1.221607490637933e-06 0.5988837056407329 1.221607625454949e-06 0.5957940466067043 \
1.221607746953592e-06 0.5930134750293682 1.221607885803897e-06 0.5898448108574432 1.221607999450713e-06 0.5872554148224447 1.221608150860886e-06 0.5838116422847746 \
1.22160826457956e-06 0.5812320812748947 1.221608383992651e-06 0.5785269636915771 1.221608472673178e-06 0.5765205397309219 1.22160856381827e-06 0.5744630259469776 \
1.221608629157145e-06 0.5729901393713442 1.221608693626847e-06 0.5715377831648228 1.221608744447459e-06 0.5703933076453638 1.221608803422399e-06 0.569066051987989 \
1.221608870867106e-06 0.5675516747474645 1.221608937959298e-06 0.5660472084764079 1.221608990879742e-06 0.5648615894615425 1.221609086527226e-06 0.5627204246953637 \
1.221609143708362e-06 0.5614413394337 1.221609197510978e-06 0.5602399192081799 1.221609259253083e-06 0.5588634520375642 1.221609345086214e-06 0.5569525037715509 \
1.221609427781862e-06 0.5551133137453282 1.221609553910589e-06 0.552313430559463 1.221609689009665e-06 0.5493247407981657 1.221609787329828e-06 0.5471534914294828 \
1.22160989990789e-06 0.5446716589975775 1.221610002452305e-06 0.5424173856211837 1.221610122561131e-06 0.5397821662853191 1.221610224248782e-06 0.5375541863492928 \
1.221610339752746e-06 0.5350300289250629 1.221610454643861e-06 0.5325260225312031 1.221610581121134e-06 0.5297740207092871 1.22161070633833e-06 0.5270565158317848 \
1.221610853184312e-06 0.5238798967507053 1.221610988642446e-06 0.5209557060405445 1.221611146203055e-06 0.5175672114705414 1.221611308357229e-06 0.5140875588169389 \
1.221611489068307e-06 0.5102248342695275 1.22161168131606e-06 0.5061308236654174 1.221611894038323e-06 0.5016182665703952 1.221612125943484e-06 0.4967183500883584 \
1.221612383137188e-06 0.4913135654247419 1.221612622690498e-06 0.4863004534671564 1.221612924620373e-06 0.4800178499336004 1.221613212386814e-06 0.4740665530855001 \
1.221613525189057e-06 0.4676409412178996 1.221613845020806e-06 0.4611139840073785 1.221614184657409e-06 0.4542292677834274 1.221614511873228e-06 0.4476411633207955 \
1.221614847034797e-06 0.4409363684817221 1.221615164291458e-06 0.4346351592989786 1.221615498111436e-06 0.4280489847791872 1.22161584979678e-06 0.4211625252737479 \
1.221616163864498e-06 0.4150547397555842 1.221616486893702e-06 0.4088175946446666 1.221616927873099e-06 0.4003732788922496 1.221617270275942e-06 0.3938810608698495 \
1.221617570723831e-06 0.3882325136127223 1.221617946053402e-06 0.3812375944419973 1.22161827612863e-06 0.3751439175705365 1.221618559406411e-06 0.3699597784791666 \
1.221618859913773e-06 0.3645020109013299 1.221619139561233e-06 0.3594637112692664 1.221619363423524e-06 0.3554634414471464 1.221619575274513e-06 0.35170280677964 \
1.221619777623114e-06 0.3481338771034005 1.221619978758139e-06 0.3446120049995081 1.221620184535657e-06 0.3410324794262659 1.221620445514371e-06 0.3365252478245505 \
1.221620685004553e-06 0.3324209773202946 1.221620917679624e-06 0.3284665339262754 1.221621131761216e-06 0.3248537323113044 1.221621352906983e-06 0.3211475567840967 \
1.221621553789873e-06 0.3178053707831449 1.221621757181075e-06 0.3144500223650613 1.221621954849488e-06 0.3112139453100684 1.221622141093175e-06 0.3081862077816076 \
1.221622336074257e-06 0.3050391973134606 1.221622539536502e-06 0.3017803754370622 1.221622717477408e-06 0.2989521325826759 1.221622953201112e-06 0.2952356640875101 \
1.221623151333966e-06 0.2921385263640672 1.221623352678033e-06 0.2890160050544278 1.22162357696723e-06 0.2855690750291008 1.221623741897129e-06 0.2830551950838826 \
1.221623919525814e-06 0.2803657404651576 1.221624103924961e-06 0.2775946687427531 1.221624287746307e-06 0.2748547260732712 1.221624466202979e-06 0.2722194282383935 \
1.221624638103246e-06 0.2696976713509589 1.221624798643653e-06 0.2673699088296289 1.221624920125712e-06 0.265617282026588 1.221625073047239e-06 0.2634201198254058 \
1.221625200480934e-06 0.2616085083773952 1.221625304654605e-06 0.2601317890528609 1.221625421559082e-06 0.2584775571399547 1.221625536570573e-06 0.2568557450124987 \
1.221625660932803e-06 0.2551103168403305 1.221625776507087e-06 0.2534925198640895 1.221625910614608e-06 0.2516172680784447 1.221626025601849e-06 0.2500177396912131 \
1.221626179351445e-06 0.2478798443778067 1.221626316154646e-06 0.2459790966208961 1.221626450740453e-06 0.2441094379339017 1.221626606604589e-06 0.2419575875351012 \
1.221626731253411e-06 0.2402378086535915 1.221626870468935e-06 0.2383186229544463 1.22162700069296e-06 0.236525770455347 1.221627121045801e-06 0.2348769158236033 \
1.221627256439085e-06 0.233027137746051 1.221627407644063e-06 0.2309620730808924 1.221627542400533e-06 0.2291249940296414 1.22162764708672e-06 0.2277003186426776 \
1.221627769622861e-06 0.2260366668203369 1.22162790456742e-06 0.2242086518061946 1.221627999683168e-06 0.2229209267876512 1.221628114943222e-06 0.2213657311907907 \
1.221628197476202e-06 0.2202562617028589 1.221628268681533e-06 0.2192992955643472 1.221628317389017e-06 0.2186449771734718 1.221628364583973e-06 0.2180112263680214 \
1.221628411132792e-06 0.2173864029843717 1.221628464521355e-06 0.2166701476649976 1.221628501898025e-06 0.2161690444847812 1.221628539283138e-06 0.2156680710113931 \
1.221628579604508e-06 0.2151283464800275 1.221628650854648e-06 0.2141753141901174 1.221628685068904e-06 0.2137180869447317 1.221628731463535e-06 0.2131018213873352 \
1.221628791907201e-06 0.2122998083652294 1.22162886091012e-06 0.2113853596849882 1.221628926205072e-06 0.210520730631805 1.221628994183195e-06 0.2096212333552783 \
1.221629110629525e-06 0.2080823984153433 1.221629200551714e-06 0.2068957989735914 1.22162930821762e-06 0.2054771097790837 1.221629404278935e-06 0.2042146625011118 \
1.221629507657509e-06 0.2028641889872041 1.221629604342544e-06 0.2016026287683381 1.221629707152397e-06 0.2002625524503448 1.221629807912368e-06 0.1989526210414513 \
1.221629919058035e-06 0.1975116692735505 1.221630026097529e-06 0.1961279675313261 1.221630144004064e-06 0.1946083430154048 1.221630252114387e-06 0.1932197128021231 \
1.221630361412988e-06 0.1918224631760269 1.221630482044739e-06 0.1902849927564414 1.221630576945331e-06 0.1890796997295432 1.22163070550625e-06 0.18745262875399 \
1.221630798541038e-06 0.1862801166370808 1.221630900937595e-06 0.1849947785893032 1.221630988904886e-06 0.1838942174288659 1.221631087175557e-06 0.182668828510528 \
1.221631183776179e-06 0.1814691026470878 1.221631270414693e-06 0.1803971466393716 1.221631356823705e-06 0.1793305247657973 1.221631452660814e-06 0.1781527189679156 \
1.221631557387689e-06 0.1768710765218302 1.221631703199975e-06 0.1750963017969037 1.221631819167907e-06 0.1736923427161618 1.221631975631711e-06 0.1718092975148396 \
1.22163208681163e-06 0.1704786474822015 1.221632227061631e-06 0.1688098560703619 1.221632350073035e-06 0.1673544160765056 1.221632456564034e-06 0.1661007559767333 \
1.221632552889492e-06 0.1649724583647661 1.221632650322959e-06 0.1638357962207703 1.221632754176237e-06 0.1626293386330815 1.22163284597681e-06 0.1615673458739011 \
1.221632944364525e-06 0.1604337426303964 1.22163302728317e-06 0.1594828374885931 1.221633122651503e-06 0.1583950132920943 1.221633205213852e-06 0.1574587876231885 \
1.221633307798537e-06 0.1563016192679324 1.221633384076854e-06 0.1554454316211293 1.221633472662479e-06 0.1544557264474612 1.221633544831984e-06 0.1536532700165102 \
1.221633626541473e-06 0.1527486200895024 1.221633700220281e-06 0.1519363404455653 1.22163378044041e-06 0.1510573496788611 1.221633852168484e-06 0.1502755532525617 \
1.221633920425463e-06 0.149534520573691 1.221634018141423e-06 0.1484788062294206 1.221634087591606e-06 0.147731872792437 1.221634170343085e-06 0.1468455801890639 \
1.221634230379995e-06 0.1462052652532956 1.221634300618659e-06 0.1454587420502366 1.221634372046193e-06 0.1447037411390827 1.221634452559695e-06 0.1438588888651768 \
1.221634515822599e-06 0.1431977449412327 1.221634593496578e-06 0.1423892845091393 1.221634682806343e-06 0.141463758692191 1.221634752169929e-06 0.1407479403162204 \
1.221634850118149e-06 0.1397418416088305 1.221634940462669e-06 0.1388188591118084 1.221635026242994e-06 0.1379520826379384 1.221635093896779e-06 0.1372719511642241 \
1.22163516020463e-06 0.1366075914250998 1.221635238824321e-06 0.1358227655030745 1.22163531951923e-06 0.135020537018139 1.221635377921894e-06 0.1344419857224206 \
1.221635438674417e-06 0.1338420332148588 1.221635532580729e-06 0.1329184183639811 1.221635574978232e-06 0.1325029080242558 1.221635654222426e-06 0.1317336600863391 \
1.221635694592585e-06 0.1313430593815061 1.221635784293464e-06 0.130477658168832 1.22163582324155e-06 0.1301029732927899 1.221635918857236e-06 0.1291862249441596 \
1.221635957741065e-06 0.1288146335111444 1.221636050975841e-06 0.1279263274670414 1.22163611931843e-06 0.1272775968534341 1.221636171639285e-06 0.1267823325594629 \
1.221636253739999e-06 0.1260075984242486 1.221636324903378e-06 0.1253406747583812 1.221636402856366e-06 0.1246136378429537 1.221636481976102e-06 0.1238779526756392 \
1.221636560619333e-06 0.1231489004754178 1.221636640654242e-06 0.122409328367501 1.221636702388658e-06 0.1218405706457005 1.22163677598364e-06 0.1211645344030958 \
1.221636859363458e-06 0.120401093559758 1.221636923460189e-06 0.1198161795466899 1.221636992898777e-06 0.119184869057559 1.221637065921716e-06 0.1185234239195788 \
1.221637150796627e-06 0.1177582144838446 1.221637230159479e-06 0.117046673033812 1.221637314893136e-06 0.1162898833629492 1.221637405604425e-06 0.1154830714735263 \
1.221637481187504e-06 0.1148135241260771 1.221637546915428e-06 0.1142333070693714 1.221637606975201e-06 0.1137047561823949 1.221637676580917e-06 0.1130943456353956 \
1.221637742999969e-06 0.1125141752866663 1.221637822411232e-06 0.1118230150855203 1.221637912674161e-06 0.1110406875128299 1.221637981718461e-06 0.1104447270551955 \
1.22163805627358e-06 0.1098035355921305 1.221638144757501e-06 0.1090456469739195 1.221638223865648e-06 0.1083709350695736 1.221638293734029e-06 0.1077773127978274 \
1.221638374743399e-06 0.1070920034756896 1.221638430948213e-06 0.106618206733547 1.221638493607492e-06 0.1060916009495399 1.221638558754098e-06 0.105545887371837 \
1.221638630089726e-06 0.1049504956797945 1.221638750386101e-06 0.1039516085561449 1.221638801939674e-06 0.103525508500865 1.221638857088742e-06 0.1030709598036589 \
1.221638947785926e-06 0.1023262935955709 1.221639030175778e-06 0.1016530765296615 1.221639125755586e-06 0.1008759670630478 1.221639232965152e-06 0.1000092507657299 \
1.221639336624559e-06 0.09917656019160864 1.221639422832161e-06 0.09848810438956324 1.221639509074386e-06 0.09780303991321163 1.221639588615461e-06 0.09717448010577609 \
1.221639668628333e-06 0.09654538840876434 1.221639759916661e-06 0.09583163072761708 1.22163984166208e-06 0.09519620281310773 1.221639930588917e-06 0.09450872319168514 \
1.221640020366224e-06 0.09381864801001834 1.221640097328872e-06 0.09323024625953365 1.221640187653689e-06 0.0925435244861572 1.221640251462415e-06 0.09206084550525626 \
1.221640323925983e-06 0.09151514907748673 1.221640388054635e-06 0.09103438864950099 1.221640466302011e-06 0.09045054736970405 1.221640566003292e-06 0.08971110930136832 \
1.221640640056444e-06 0.08916512281998501 1.221640726664979e-06 0.08852997392441805 1.221640872964685e-06 0.08746544055362569 1.221640983676948e-06 0.08666684197409438 \
1.221641093986626e-06 0.08587717033461532 1.221641236182269e-06 0.08486839672072237 1.22164137623472e-06 0.08388450488753585 1.221641518880534e-06 0.08289222299161547 \
1.221641667651249e-06 0.08186778387581196 1.221641804363935e-06 0.08093569403044946 1.221641946484565e-06 0.07997640434545976 1.221642081061545e-06 0.07907728405019222 \
1.221642221281423e-06 0.07814997945867638 1.221642369028229e-06 0.07718353387841098 1.221642518982415e-06 0.07621348085094087 1.221642683698247e-06 0.07516037195605636 \
1.221642847284364e-06 0.07412732798506308 1.221643021932716e-06 0.07303837372665309 1.221643208986408e-06 0.07188781219077654 1.221643418972926e-06 0.0706159374129187 \
1.221643637046174e-06 0.06931715807027321 1.221643870366328e-06 0.06795188046253516 1.221644124845882e-06 0.0664909822812602 1.22164441780254e-06 0.06484528303377844 \
1.221644719953089e-06 0.06318745987130532 1.221645057674792e-06 0.06138078634948794 1.221645452783393e-06 0.05932807220464856 1.221645820234636e-06 0.05747953410674719 \
1.221646237842402e-06 0.05544691527644593 1.221646582838376e-06 0.0538196438399016 1.221646933380665e-06 0.05221302159193914 1.221647248341029e-06 0.0508087490907442 \
1.221647547582396e-06 0.049508488261462 1.221647846948248e-06 0.04824029756235761 1.221648122190958e-06 0.04710512226277328 1.221648405654525e-06 0.04596497870754415 \
1.221648667254947e-06 0.04493681260994405 1.221648944707071e-06 0.04387103439794762 1.221649220766506e-06 0.04283531238677037 1.221649529036243e-06 0.04170718945545093 \
1.221649751468863e-06 0.0409114719535993 1.221650039009947e-06 0.03990505631995635 1.22165027524288e-06 0.0390969788355163 1.221650593704555e-06 0.03803800466874574 \
1.221650844115589e-06 0.03722710566490722 1.221651167100391e-06 0.03620720400565681 1.221651425436406e-06 0.03541203096995557 1.221651715410285e-06 0.03454066075983582 \
1.221651945205103e-06 0.0338658635512188 1.221652230100444e-06 0.03304787219836024 1.221652469846563e-06 0.03237513696606491 1.221652710481132e-06 0.03171392889024889 \
1.221652949599619e-06 0.03107212555077287 1.22165318553853e-06 0.03045460689686571 1.221653416367391e-06 0.02986254663395104 1.221653631393919e-06 0.02932175456294728 \
1.22165403355976e-06 0.0283374222946415 1.22165423211788e-06 0.02786401170979088 1.221654605819066e-06 0.02699470773596776 1.221654792632261e-06 0.02657042318767052 \
1.221655138633508e-06 0.02580176906824739 1.221655260576947e-06 0.02553595448027303 1.221655643429963e-06 0.02472011952872977 1.221655803864149e-06 0.02438657631284594 \
1.221656246865303e-06 0.02348572425118655 1.221656417479345e-06 0.02314627247835563 1.221656738055941e-06 0.02251902970747987 1.221656938340868e-06 0.0221336684630111 \
1.221657385278801e-06 0.02128811173678137 1.221657513222917e-06 0.02104854104185888 1.221658001100276e-06 0.02014826272243131 1.221658136077553e-06 0.01990454278080647 \
1.221658618329071e-06 0.0190640092473091 1.221658780655186e-06 0.01879235028057063 1.221659267049527e-06 0.01801148170254873 1.221659430077186e-06 0.01776103207540622 \
1.221660110298877e-06 0.01676849304257711 1.221660249382615e-06 0.01657541006259178 1.221660981877148e-06 0.01560782569993242 1.22166114077078e-06 0.01540693214221847 \
1.221661923851867e-06 0.01445869962397344 1.221662069644422e-06 0.01428952172302696 1.221662920425781e-06 0.01334248985256295 1.221663031529053e-06 0.01322388191882306 \
1.221663964823417e-06 0.0122699293983148 1.221664098661466e-06 0.01213902814618388 1.221665057199482e-06 0.01123495036716388 1.221665178316551e-06 0.01112486091825863 \
1.221666300400349e-06 0.01017270671243764 1.221666405901602e-06 0.01008921053061839 1.221667734976014e-06 0.009112307258623473 1.221667855180288e-06 0.009029744095492466 \
1.221669403542048e-06 0.008036808760534916 1.221669484329818e-06 0.007986285493236449 1.221671055209352e-06 0.007024564730313319 1.221671122625551e-06 0.006986095570813155 \
1.221673043392229e-06 0.006001386377072119 1.221673230194113e-06 0.005914747648762168 1.221675545608061e-06 0.0049318160947762 1.221675945134908e-06 0.004777795182599986 \
1.221678508944408e-06 0.003889929704329555 1.221679007815328e-06 0.003736330440833864 1.221682637539317e-06 0.002784984367379526 1.221683188233292e-06 0.002663729254427667 \
1.221688586673672e-06 0.001711392372544448 1.221688899941244e-06 0.001662511220227468 1.221693892233791e-06 0.0006970413096974805 1.221694076252826e-06 0.0006571176749162138 \
1.22434255539561e-06 -0.0002691198397987355 1.224342711454572e-06 -0.0004551674219448388 1.224343259438427e-06 -0.001322174727784445 1.22434337237642e-06 -0.001539785040943742 \
1.22434380163135e-06 -0.002474302920374066 1.224343907888515e-06 -0.002730173903076456 1.224344190690667e-06 -0.003454402452283872 1.22434430428521e-06 -0.003760966378165151 \
1.224344642839789e-06 -0.004705104513819927 1.22434475526375e-06 -0.005021586953003071 1.224345083541651e-06 -0.005887841248467669 1.224345191080172e-06 -0.006130875888161453 \
1.224346071006203e-06 -0.005789627805322099 1.22434624621225e-06 -0.004910736584223327 1.224346363043013e-06 -0.004127745010746014 1.224346489910138e-06 -0.00309221842859156 \
1.224346591442863e-06 -0.002125750314016509 1.224346712864133e-06 -0.0008095618968406578 1.224346803029046e-06 0.0002767910803854594 1.224346900212696e-06 0.001550247908954045 \
1.22434699828696e-06 0.002938803805678211 1.224347165508045e-06 0.005530627736217106 1.224347387813323e-06 0.009378371294171852 1.224347573551714e-06 0.01290572951649239 \
1.224347797633049e-06 0.01747895571448658 1.224347957277782e-06 0.02091945933227325 1.224348121767111e-06 0.02459614091902196 1.224348271591569e-06 0.0280452875125503 \
1.224348420991461e-06 0.03156498790849799 1.224348570522767e-06 0.03515592969144176 1.224348724602661e-06 0.03891669635189081 1.224348886786809e-06 0.0429309674228065 \
1.224349053210035e-06 0.0470989728378523 1.224349229143508e-06 0.05154884981278444 1.224349410271779e-06 0.05616867911875007 1.224349602402705e-06 0.06110225049351239 \
1.224349810098117e-06 0.0664648391313285 1.224350032018198e-06 0.07222051812179281 1.224350267219681e-06 0.07834079218654426 1.224350519405989e-06 0.08491829088081257 \
1.224350795545224e-06 0.09213111703448683 1.224351096666701e-06 0.1000001933597138 1.224351428586562e-06 0.1086702418150647 1.22435180590533e-06 0.1185147411083515 \
1.224352204195387e-06 0.1288888856248832 1.224352673503707e-06 0.1410822143415975 1.224353219529231e-06 0.1552200475789812 1.224353854489538e-06 0.1715918832733369 \
1.224354553890129e-06 0.1895291194622146 1.224355372129055e-06 0.2103807608661494 1.224356277823022e-06 0.2332840710921665 1.224357067334088e-06 0.253091928008631 \
1.224357771092906e-06 0.2706124241987875 1.22435838894372e-06 0.2858796548825839 1.224358954567131e-06 0.2997575097153312 1.224359476302405e-06 0.3124620269501652 \
1.224359974086121e-06 0.3244932238414255 1.224360457724081e-06 0.3360954048923613 1.224360914598216e-06 0.3469667650518959 1.22436138743911e-06 0.3581213589834248 \
1.224361827052466e-06 0.3684065070151987 1.224362314929562e-06 0.379719432411247 1.224362845729985e-06 0.3919028193132517 1.22436334362536e-06 0.4032143644097119 \
1.224363775002613e-06 0.41292177789323 1.224364261889801e-06 0.4237731225600331 1.224364761989243e-06 0.4348012155672935 1.224365106609934e-06 0.4423321287141763 \
1.224365460003778e-06 0.4500000647748709 1.224365887773617e-06 0.4592134948422093 1.224366279634688e-06 0.4675816212925634 1.224366579929044e-06 0.4739471552041949 \
1.224366921860125e-06 0.4811428413521782 1.22436726519457e-06 0.4883132334011818 1.224367525955058e-06 0.4937215836208605 1.224367768011588e-06 0.4987106167174703 \
1.224368034010056e-06 0.5041617362307154 1.22436829349824e-06 0.5094435946950286 1.22436848341454e-06 0.5132872703533161 1.224368698649141e-06 0.5176241792560061 \
1.2243688371999e-06 0.5204025546691405 1.224368982080679e-06 0.5232962183003332 1.224369195494746e-06 0.5275364624051522 1.224369397519361e-06 0.5315382148201082 \
1.224369590248024e-06 0.5353370730264509 1.224369775503404e-06 0.5389735557287745 1.224369952500928e-06 0.5424323215059959 1.224370261764263e-06 0.5484573594957171 \
1.224370522912311e-06 0.5535233414883098 1.224370824731481e-06 0.5593562770234363 1.224371080160122e-06 0.5642781701956761 1.224371372515619e-06 0.5698968483756405 \
1.224371631969813e-06 0.5748654731717864 1.22437190208979e-06 0.5800301911327002 1.224372144100348e-06 0.5846380733684551 1.224372401610146e-06 0.5895273573494454 \
1.224372628054483e-06 0.5938057549890672 1.224372864942966e-06 0.5982619499065401 1.224373074987873e-06 0.6021962733001386 1.224373287918585e-06 0.6061670177072124 \
1.224373541397282e-06 0.6108668889270118 1.224373744692931e-06 0.6146150465592417 1.224373936381114e-06 0.6181346807088086 1.224374125007479e-06 0.6215812235468744 \
1.224374312325417e-06 0.6249823889551316 1.224374517937406e-06 0.6286953279350977 1.224374767760625e-06 0.6331759959753138 1.224374971572404e-06 0.6368063379741715 \
1.224375179211121e-06 0.6404826298163093 1.224375371862737e-06 0.6438748386876914 1.224375616474811e-06 0.6481531432733096 1.224375864373314e-06 0.6524620620600715 \
1.224376044208219e-06 0.6555644139995785 1.224376234982255e-06 0.6588391718544121 1.224376388158437e-06 0.6614554104590837 1.224376559827147e-06 0.6643705886591137 \
1.224376710293968e-06 0.6669108747194671 1.224376846897972e-06 0.6692010654183506 1.224376996338373e-06 0.6716954191563786 1.224377124072523e-06 0.6738189269502312 \
1.22437726394477e-06 0.6761323074508511 1.224377388021905e-06 0.6781756764962316 1.22437751938327e-06 0.6803315871556701 1.224377643554731e-06 0.6823627547057004 \
1.224377781331592e-06 0.6846081866267727 1.224377901575812e-06 0.6865586181592046 1.224378043628418e-06 0.6888545186016138 1.224378143856123e-06 0.6904668682779994 \
1.224378265160113e-06 0.6924123325129877 1.224378356135388e-06 0.6938641504265992 1.224378453518671e-06 0.695411869780077 1.224378550601538e-06 0.6969507228893711 \
1.224378639884158e-06 0.6983595753378042 1.224378737855943e-06 0.699898781449533 1.22437886813103e-06 0.7019319515314388 1.224379021543255e-06 0.7043083163565919 \
1.224379157109067e-06 0.7063909659299702 1.224379301449562e-06 0.708591461371511 1.224379427320445e-06 0.710496752775434 1.224379552347831e-06 0.712376488910674 \
1.224379666630191e-06 0.7140841686551523 1.224379777613336e-06 0.7157331888171029 1.224379877308405e-06 0.7172065512867005 1.224380014352623e-06 0.7192196995505324 \
1.224380133379835e-06 0.7209572005600779 1.224380253677943e-06 0.7227029412191364 1.224380380176864e-06 0.7245276185835638 1.224380504108467e-06 0.7263044524160376 \
1.2243806283948e-06 0.7280754330070212 1.224380754759953e-06 0.7298652243312684 1.224380884571695e-06 0.7316925631262517 1.224381008410214e-06 0.7334254795816325 \
1.224381141191101e-06 0.735272086289578 1.224381242042306e-06 0.7366670415914529 1.224381355233976e-06 0.738224777043618 1.224381442019956e-06 0.7394137384482823 \
1.224381558645253e-06 0.7410021813026957 1.224381647934511e-06 0.7422110784210975 1.224381759111394e-06 0.7437075443329063 1.224381888370158e-06 0.7454347509364776 \
1.224382002229194e-06 0.7469455276109591 1.224382106633406e-06 0.74832188588007 1.224382231000437e-06 0.7499498655229884 1.224382378240616e-06 0.7518616907275563 \
1.224382498520907e-06 0.753411006437983 1.224382614425446e-06 0.7548933175676444 1.22438275450129e-06 0.7566706674475765 1.22438289711296e-06 0.7584645678799224 \
1.224383015067203e-06 0.7599365027959469 1.224383141883712e-06 0.7615071445339606 1.224383282766856e-06 0.7632375905494565 1.224383402560354e-06 0.7646969139886852 \
1.224383547519211e-06 0.7664484133613445 1.224383669077996e-06 0.7679052725436226 1.22438378811749e-06 0.7693214142140735 1.224383909748853e-06 0.7707575700077021 \
1.224384037717832e-06 0.772256936813787 1.224384146933014e-06 0.7735272422640712 1.224384271823892e-06 0.774969549136603 1.224384378939953e-06 0.7761978171588899 \
1.224384512193147e-06 0.7777146071439789 1.224384639296593e-06 0.7791497354387434 1.224384761047568e-06 0.7805132846941326 1.224384877632151e-06 0.7818078758210534 \
1.224384983459753e-06 0.7829735233300771 1.224385122825895e-06 0.7844949153190801 1.224385271897695e-06 0.786105286864636 1.224385419626362e-06 0.7876841235632186 \
1.22438553893224e-06 0.7889471147195867 1.224385672939052e-06 0.7903527806482344 1.224385793365227e-06 0.791604423795974 1.224385934910404e-06 0.7930616786923709 \
1.224386082336417e-06 0.7945638089648995 1.224386206810925e-06 0.7958198087139573 1.224386325854918e-06 0.7970105506108808 1.224386437445202e-06 0.7981174590942314 \
1.224386542674491e-06 0.7991530841216606 1.224386638185594e-06 0.8000862307887144 1.224386774247548e-06 0.8014036057482816 1.224386891123682e-06 0.8025237700417888 \
1.224387010277354e-06 0.8036549841722296 1.224387132589548e-06 0.8048050501807249 1.224387255861622e-06 0.8059526272620129 1.224387382358399e-06 0.8071184350969989 \
1.224387507861062e-06 0.8082633544790385 1.224387638586967e-06 0.8094437311890262 1.224387764154939e-06 0.8105658358439867 1.224387893209804e-06 0.8117072367686948 \
1.224387999065961e-06 0.8126345588578442 1.224388100234837e-06 0.8135133322873783 1.224388194854657e-06 0.8143286754242188 1.22438831913574e-06 0.8153900871385379 \
1.224388408847426e-06 0.816149614585347 1.22438850788495e-06 0.8169816577628611 1.224388645662827e-06 0.8181280288377792 1.224388780198677e-06 0.81923501721715 \
1.224388888604944e-06 0.8201180631035904 1.224389038518447e-06 0.8213254631869725 1.224389189097026e-06 0.8225223201378843 1.22438931459218e-06 0.8235077122548546 \
1.224389458438707e-06 0.8246238332260477 1.224389583021971e-06 0.8255790649890803 1.224389731875191e-06 0.8267066458678887 1.224389868023775e-06 0.827725029289517 \
1.224389993047603e-06 0.8286494160599757 1.224390110754582e-06 0.8295103773055483 1.224390256393581e-06 0.8305630309532103 1.224390422774875e-06 0.8317484146982921 \
1.224390553358565e-06 0.8326660250626342 1.224390726880675e-06 0.8338683097812621 1.224390895002578e-06 0.8350147136930499 1.22439106486518e-06 0.8361549927788252 \
1.224391245766883e-06 0.8373497079260466 1.224391388876165e-06 0.8382806519784776 1.224391502965127e-06 0.839013953006387 1.224391633127604e-06 0.8398410866028793 \
1.224391734972734e-06 0.8404811280669765 1.22439185179894e-06 0.8412075886390841 1.22439198869038e-06 0.8420483852080155 1.224392186497604e-06 0.843243620449199 \
1.224392378122751e-06 0.8443797466267589 1.224392587554618e-06 0.8455974227529048 1.2243927695013e-06 0.8466352798309468 1.224392966630154e-06 0.8477391449715804 \
1.224393139971015e-06 0.8486924050423899 1.224393322979321e-06 0.8496814535024207 1.224393494142356e-06 0.8505903669473519 1.224393668779451e-06 0.851501688465695 \
1.224393844039281e-06 0.8524001683007644 1.22439402018973e-06 0.8532872510191711 1.22439421047003e-06 0.8542278331088334 1.22439440106916e-06 0.8551519386507073 \
1.224394601692395e-06 0.8561055033533737 1.22439479430095e-06 0.8570028516027762 1.224395004981641e-06 0.8579644845832216 1.224395233083109e-06 0.8589827023971403 \
1.224395498871092e-06 0.860139640227508 1.224395797483852e-06 0.8614018215255795 1.224396073772491e-06 0.8625348754565382 1.22439635800901e-06 0.8636666213345715 \
1.22439663221378e-06 0.8647267940813509 1.224396904448638e-06 0.8657495569722869 1.22439717465278e-06 0.8667361702337206 1.224397431808391e-06 0.867649441901348 \
1.224397704388604e-06 0.8685908808535525 1.22439798037489e-06 0.8695169452638583 1.224398250477721e-06 0.870397355937691 1.224398550334798e-06 0.8713451925332844 \
1.224398921362456e-06 0.8724761722512941 1.224399216299767e-06 0.8733433185969293 1.224399470589207e-06 0.8740690226522811 1.224399768845991e-06 0.874895168896023 \
1.224400042455427e-06 0.8756299040683481 1.224400278583914e-06 0.8762466977562872 1.224400518929828e-06 0.8768585021646264 1.224400741263492e-06 0.8774104263690854 \
1.224400935269169e-06 0.8778812671168952 1.224401264991886e-06 0.8786590883967833 1.224401420165319e-06 0.8790156160651978 1.224401737941389e-06 0.8797272612331356 \
1.224401916803032e-06 0.8801171459162566 1.224402259264861e-06 0.8808425821290963 1.224402443393021e-06 0.881221400612852 1.224402918270754e-06 0.8821634994206867 \
1.224403085666965e-06 0.8824839765989225 1.224403551508906e-06 0.8833452998114757 1.224403732330958e-06 0.8836679564577563 1.224404226369383e-06 0.8845176198113115 \
1.224404367718007e-06 0.8847523712107549 1.224404974052073e-06 0.8857188576377059 1.224405126121396e-06 0.8859512996759633 1.224405772809559e-06 0.8868983431897121 \
1.22440590110417e-06 0.8870786909355212 1.224406549221232e-06 0.8879538337624689 1.224406679020295e-06 0.8881220828502663 1.224407457223772e-06 0.8890807033877333 \
1.224407572278734e-06 0.8892148977954012 1.224408427940207e-06 0.8901543051721961 1.224408573301076e-06 0.8903040038307473 1.224409559057127e-06 0.8912446482480114 \
1.224409780162496e-06 0.8914382978987679 1.224410925289424e-06 0.8923659558950503 1.224411056506439e-06 0.8924678262926897 1.224412397715013e-06 0.8934599079028542 \
1.224412549114272e-06 0.8935646301988298 1.224414030551995e-06 0.8944937559627255 1.224414269431373e-06 0.8946275407274444 1.224416038746979e-06 0.8955013787854181 \
1.224416427898191e-06 0.8956696032899972 1.224418821561142e-06 0.8965547188539188 1.22441929727014e-06 0.8967039926079825 1.22442336043021e-06 0.8977020505850396 \
1.224423851854269e-06 0.8977948037134476 1.224432168453822e-06 0.898787348739254 1.22443308835295e-06 0.8988506593152591 1.22457657358348e-06 0.8998476076348748 \
1.224577692016456e-06 0.8998537475785264 1.224782783635956e-06 0.898985773748599 1.224783010725457e-06 0.8988224379910277 1.224784620332255e-06 0.8978282360369357 \
1.224784797740799e-06 0.8977338482811539 1.2248017048891e-06 0.8987315468430059 1.224801814328198e-06 0.8987460089186867 1.224817595049444e-06 0.8997418097871094 \
1.224817891375339e-06 0.8997476966799167 1.225301325027745e-06 0.9007060148833608 1.225301454078085e-06 0.9008313386292994 1.225302104227931e-06 0.9016292186224167 \
1.225302293723661e-06 0.9019133038041363 1.22530279694564e-06 0.9027675859898705 1.2253029324183e-06 0.9030208676018907 1.225303332877016e-06 0.9038195223753869 \
1.225303464814953e-06 0.9040958310886574 1.225303866030017e-06 0.9049509627747726 1.225303964290194e-06 0.9051582028152527 1.225304430164004e-06 0.9060587574877488 \
1.225304591662727e-06 0.9063060456044927 1.225305735675251e-06 0.9055153668657776 1.225305880654596e-06 0.9049059606760256 1.225306059207354e-06 0.9039396653125833 \
1.225306239402631e-06 0.9027054491383806 1.225306382093561e-06 0.9015369228101149 1.225306499253165e-06 0.9004524619440171 1.225306588234526e-06 0.8995505656965809 \
1.225306679878178e-06 0.8985529714258781 1.22530681299011e-06 0.8969831049011855 1.225306906711193e-06 0.8957895978311226 1.225306997850002e-06 0.8945634483845346 \
1.225307111142313e-06 0.8929516940777753 1.225307214251226e-06 0.8913998138690341 1.225307310518406e-06 0.8898830246517148 1.225307429655523e-06 0.8879200664089764 \
1.225307598240772e-06 0.8849885378698126 1.225307760012273e-06 0.8820195265790133 1.225307953231332e-06 0.8782956415026882 1.225308138794443e-06 0.8745571577041361 \
1.225308349060748e-06 0.8701566079887386 1.225308531309789e-06 0.8662213066841463 1.225308716173184e-06 0.8621339172744639 1.22530888885833e-06 0.8582419637438897 \
1.225309074966403e-06 0.8539816046497358 1.225309252782491e-06 0.849858603441091 1.225309433499072e-06 0.8456251963850057 1.225309598637331e-06 0.8417258760277182 \
1.225309763911433e-06 0.837798995916667 1.225309927159096e-06 0.8339004324287677 1.22531008574937e-06 0.8300982805770993 1.225310262673771e-06 0.8258418712800655 \
1.225310459187584e-06 0.8211009660847696 1.225310626744125e-06 0.8170498602679914 1.225310793484544e-06 0.8130123908857781 1.225310967908062e-06 0.8087844286215062 \
1.225311137277684e-06 0.8046757316210446 1.225311305476779e-06 0.8005936994537799 1.225311494325046e-06 0.7960093488074458 1.225311685140882e-06 0.7913773844868103 \
1.225311893523092e-06 0.7863203192056716 1.225312119942597e-06 0.7808277108969495 1.225312309142794e-06 0.7762391340290878 1.225312519289483e-06 0.7711455503222944 \
1.225312668057988e-06 0.7675418410361046 1.225312799050976e-06 0.7643705172588006 1.225312936616212e-06 0.7610417440783073 1.225313042367441e-06 0.7584842184275663 \
1.225313177141075e-06 0.7552262509102785 1.225313288973801e-06 0.7525244432456109 1.225313418408965e-06 0.7493992292091655 1.225313573597688e-06 0.7456545577979357 \
1.225313685233441e-06 0.7429626190147979 1.225313844808055e-06 0.7391166470929011 1.225314020129688e-06 0.7348935218456193 1.225314232505151e-06 0.7297828120356423 \
1.225314425387679e-06 0.7251458607116523 1.225314582088971e-06 0.7213823872711312 1.225314768763662e-06 0.716903961299824 1.225314957650011e-06 0.7123775767926828 \
1.225315148534203e-06 0.70780884692282 1.225315335282138e-06 0.7033444557767304 1.225315518366954e-06 0.698972331957095 1.225315655685935e-06 0.6956951921588121 \
1.225315808928892e-06 0.6920418367118417 1.225316004057543e-06 0.6873949992893974 1.225316161351872e-06 0.6836535194673684 1.225316320746467e-06 0.6798660670227984 \
1.22531651649026e-06 0.6752219404489795 1.225316708689394e-06 0.6706682621108646 1.225316943641022e-06 0.6651105611269369 1.22531713111727e-06 0.6606839627962382 \
1.225317368354404e-06 0.6550894036851447 1.225317557534366e-06 0.6506361170423679 1.225317738150179e-06 0.6463915264929231 1.225317901844741e-06 0.6425504277539856 \
1.225318046396151e-06 0.6391628119244788 1.22531818686792e-06 0.6358764726647652 1.225318313968708e-06 0.6329064225879303 1.225318446276184e-06 0.6298198307262635 \
1.22531857286323e-06 0.626870110582017 1.225318703443498e-06 0.62383130535404 1.225318832712897e-06 0.6208285625908692 1.225318971819793e-06 0.6176004736356133 \
1.225319120330103e-06 0.6141606483517721 1.225319309878658e-06 0.6097777958748198 1.225319455581914e-06 0.6064170107178907 1.225319690632478e-06 0.601007464699683 \
1.225319873631749e-06 0.5968099615921 1.225320097973423e-06 0.5916778694808832 1.225320269146672e-06 0.5877753019413697 1.225320401480491e-06 0.5847634284691802 \
1.22532053327703e-06 0.5817721407249107 1.225320639820933e-06 0.5793579518205488 1.225320735711292e-06 0.5771868999037388 1.225320828211542e-06 0.5750974572268882 \
1.225320920638905e-06 0.5730134868920421 1.225320993067212e-06 0.5713818265150021 1.225321048796317e-06 0.5701269325864891 1.225321109905405e-06 0.5687522410723198 \
1.22532120667008e-06 0.5665806864277688 1.225321268161595e-06 0.5652027770813386 1.225321327214216e-06 0.5638802801505602 1.225321402840882e-06 0.5621878686488651 \
1.22532146986366e-06 0.5606896577364279 1.22532154346077e-06 0.5590483558003441 1.225321611066773e-06 0.5575429304381756 1.225321727135829e-06 0.5549610936632026 \
1.225321827342235e-06 0.5527359403974305 1.225321939349424e-06 0.5502565947066531 1.225322033841475e-06 0.5481686943853854 1.225322154996173e-06 0.5454955387196141 \
1.225322255183939e-06 0.5432910220514219 1.225322371174451e-06 0.5407443765731218 1.225322478878289e-06 0.5383833065966291 1.225322588456977e-06 0.5359861028148916 \
1.225322700578421e-06 0.5335400310751951 1.225322827515605e-06 0.5307765704644959 1.225322949665123e-06 0.5281221248815906 1.225323089426038e-06 0.525095489155881 \
1.225323226564154e-06 0.522132778766487 1.225323376529244e-06 0.5189020692106626 1.225323535302247e-06 0.5154923220538846 1.225323709327905e-06 0.511765695450105 \
1.225323896158028e-06 0.5077823379664483 1.225324101125994e-06 0.5034264211640872 1.225324323834942e-06 0.4987133299464507 1.225324576739139e-06 0.4933874474923696 \
1.225324811693046e-06 0.4884604410272814 1.225325107961308e-06 0.4822828691822955 1.225325397751266e-06 0.4762763831984252 1.225325704087085e-06 0.4699660956099861 \
1.225326016405612e-06 0.4635767846525711 1.225326354971068e-06 0.4566963260653934 1.225326678082485e-06 0.4501741115777416 1.225327016477788e-06 0.4433881855507311 \
1.225327340309054e-06 0.4369378830387565 1.225327664703474e-06 0.4305204627449936 1.22532800763776e-06 0.4237851826852676 1.225328346918578e-06 0.4171698123421442 \
1.225328686393212e-06 0.4105997181257849 1.225329129505058e-06 0.4020958655332711 1.225329491573227e-06 0.3952155038183801 1.225329812124965e-06 0.3891775711374149 \
1.225330199059534e-06 0.3819561902961204 1.225330526929795e-06 0.3758957719299574 1.225330812088852e-06 0.3706704968427373 1.225331130457646e-06 0.3648820026298218 \
1.225331413288573e-06 0.3597820188690578 1.225331641977337e-06 0.3556924369094372 1.225331859870142e-06 0.3518226517641353 1.225332055119486e-06 0.3483769517668343 \
1.225332262027586e-06 0.344751588202948 1.225332476824342e-06 0.3410137651016431 1.225332729050892e-06 0.3366564674340092 1.225332971046205e-06 0.3325077909124976 \
1.225333201898484e-06 0.3285822460490526 1.225333416746675e-06 0.3249550452085373 1.225333637103364e-06 0.3212604562488142 1.225333838674264e-06 0.3179050685021769 \
1.225334041758211e-06 0.3145531374773136 1.225334239655597e-06 0.3113121771742085 1.225334426754836e-06 0.3082694484595072 1.22533462065518e-06 0.3051385396431291 \
1.225334825703514e-06 0.3018527636900292 1.225335005938266e-06 0.2989872106339772 1.225335241836278e-06 0.2952669081535775 1.225335443123828e-06 0.2921198200609627 \
1.225335644514631e-06 0.2889965001417216 1.225335869163794e-06 0.2855437159941698 1.225336034543768e-06 0.2830223598911593 1.225336212348106e-06 0.280330186126118 \
1.225336396004319e-06 0.277570343839212 1.225336581246076e-06 0.2748090658167894 1.225336759391454e-06 0.2721781298892599 1.225336932983517e-06 0.2696316866093095 \
1.22533709334837e-06 0.267306655456324 1.225337214459553e-06 0.2655585721882695 1.225337367654341e-06 0.2633570345323199 1.225337494985789e-06 0.2615475749425888 \
1.225337598313629e-06 0.2600830587034867 1.225337715638424e-06 0.2584225376281647 1.225337833445381e-06 0.2567591557214636 1.225337957409147e-06 0.2550199666844239 \
1.225338074393314e-06 0.2533821414201824 1.225338205189442e-06 0.2515535495016885 1.225338322399552e-06 0.2499173892700276 1.225338475652677e-06 0.2477853623028658 \
1.225338611183197e-06 0.2459029165157107 1.225338742864406e-06 0.244074199323236 1.225338899457317e-06 0.2419017673596028 1.225339024653875e-06 0.2401755227310949 \
1.225339160371502e-06 0.2383060149301216 1.225339292798663e-06 0.2364844144139329 1.225339412772324e-06 0.2348355337769661 1.225339575820161e-06 0.232606585912384 \
1.225339714627252e-06 0.230713852557009 1.225339853100972e-06 0.2288300961780371 1.225339958645721e-06 0.2273962817971701 1.225340087007401e-06 0.2256537837490921 \
1.225340191135024e-06 0.2242444877898851 1.225340291651026e-06 0.222886569499566 1.225340366695402e-06 0.2218745444235658 1.225340444028458e-06 0.2208349692306942 \
1.225340518791637e-06 0.2198305887827458 1.225340596755314e-06 0.218785487158918 1.225340651621824e-06 0.2180503923904892 1.2253407081186e-06 0.2172938400168352 \
1.225340751572119e-06 0.2167123195211523 1.225340791613165e-06 0.2161767335077376 1.225340830852113e-06 0.2156521099473339 1.22534087172635e-06 0.2151058606261434 \
1.22534092587884e-06 0.2143825797409383 1.225340964295972e-06 0.2138698309421548 1.225341003584678e-06 0.2133480458229882 1.225341065121387e-06 0.2125332203444249 \
1.225341127098916e-06 0.2117131287842428 1.225341183575664e-06 0.2109664019951111 1.225341248207255e-06 0.2101124842966758 1.225341343715876e-06 0.2088522205996687 \
1.225341431031607e-06 0.207701294711168 1.225341527641208e-06 0.2064291756790013 1.225341624870762e-06 0.2051510266126755 1.225341725717823e-06 0.2038307158897115 \
1.225341826317594e-06 0.2025192706911573 1.225341922808891e-06 0.2012627769767186 1.225342024991065e-06 0.1999338657614989 1.225342128630722e-06 0.1985898465970496 \
1.225342238404734e-06 0.1971698847140261 1.22534234757976e-06 0.1957617939809042 1.225342467677852e-06 0.1942174441246506 1.225342577697376e-06 0.1928086337505992 \
1.225342685809285e-06 0.1914295694688549 1.225342808837984e-06 0.1898652723262108 1.225342898948554e-06 0.1887234630454603 1.225343006314045e-06 0.1873671680421656 \
1.225343083125353e-06 0.1864004060894758 1.225343166570621e-06 0.1853535952511875 1.225343256102432e-06 0.1842338297700716 1.225343340667899e-06 0.1831790839553313 \
1.225343420384039e-06 0.1821880912968773 1.225343521709242e-06 0.1809331989518758 1.225343630056471e-06 0.1795959386230563 1.22534372653217e-06 0.1784102562612937 \
1.225343851909986e-06 0.1768766438339704 1.225343984693456e-06 0.1752616821119887 1.22534410246428e-06 0.1738362801839788 1.225344248115856e-06 0.1720835746408261 \
1.225344358713008e-06 0.1707596463148658 1.225344500843447e-06 0.1690680578777541 1.22534461655307e-06 0.1676985735146403 1.225344722027083e-06 0.166456424915798 \
1.225344816543743e-06 0.1653485352650968 1.225344912181115e-06 0.1642320043563913 1.225345009252959e-06 0.1631032360400927 1.225345108304212e-06 0.161956192050434 \
1.225345202227769e-06 0.1608730077890209 1.225345287503444e-06 0.1598934595213354 1.225345387883236e-06 0.1587475631033795 1.225345472186073e-06 0.1577906478848196 \
1.225345574585582e-06 0.1566342854655733 1.225345651979844e-06 0.1557646215197878 1.225345744324758e-06 0.154731814591042 1.22534581457623e-06 0.1539498814072817 \
1.225345910750659e-06 0.1528844393027091 1.225345987575323e-06 0.152038051282755 1.225346066345474e-06 0.1511758489440315 1.225346140238395e-06 0.150370438825067 \
1.225346207936138e-06 0.1496353997608715 1.225346304000026e-06 0.1485973848112393 1.225346373572453e-06 0.1478489919002561 1.225346457461626e-06 0.1469503328160803 \
1.225346518593461e-06 0.146298213254472 1.225346590861543e-06 0.1455309799806117 1.225346663300106e-06 0.1447677488542132 1.225346744281147e-06 0.1439178685120187 \
1.225346810355616e-06 0.1432275520600639 1.225346887756114e-06 0.1424219220725307 1.225346977131571e-06 0.1414956876531561 1.225347047992216e-06 0.1407644282175171 \
1.225347146879283e-06 0.1397487730030469 1.225347224198192e-06 0.1389620820751095 1.225347306243418e-06 0.1381330876879582 1.22534739435453e-06 0.1372467208126059 \
1.225347461981677e-06 0.1365690714953818 1.225347542278859e-06 0.1357674830239305 1.225347617062888e-06 0.1350239185327315 1.225347685064065e-06 0.1343502586094245 \
1.225347731746974e-06 0.1338891847862563 1.225347820998568e-06 0.1330118383700247 1.225347859221617e-06 0.1326395291833771 1.225347928213527e-06 0.1319690872918072 \
1.225347980961596e-06 0.1314578750898332 1.225348063954378e-06 0.1306559489775353 1.225348104132829e-06 0.1302688434457458 1.225348196650203e-06 0.1293805059784019 \
1.22534823536857e-06 0.1290098403727171 1.225348309129285e-06 0.1283055160094505 1.225348370757287e-06 0.1277188748199021 1.225348442784976e-06 0.1270353589407805 \
1.225348510952008e-06 0.1263909833196726 1.225348585574169e-06 0.1256908956540175 1.225348667426635e-06 0.1249253613889138 1.225348750880797e-06 0.124147338931438 \
1.225348823832511e-06 0.1234692772477456 1.225348896559441e-06 0.122795332839617 1.225348956549436e-06 0.1222410931008323 1.225349042917447e-06 0.121445549533078 \
1.225349103886165e-06 0.1208856452315438 1.225349162271956e-06 0.1203507897957366 1.22534922790662e-06 0.119751336354628 1.225349287260861e-06 0.1192111367930785 \
1.225349355292642e-06 0.1185941868697126 1.225349452587012e-06 0.11771710490035 1.225349531078992e-06 0.1170124163111649 1.225349621315123e-06 0.1162055395685231 \
1.225349717161808e-06 0.1153523005684616 1.225349792119505e-06 0.1146878351828532 1.225349896478921e-06 0.1137670532163148 1.225349983267518e-06 0.1130053589403202 \
1.225350092924934e-06 0.1120476726212376 1.225350174478997e-06 0.1113387926087848 1.225350270092629e-06 0.1105114393564785 1.225350346804823e-06 0.10985058581598 \
1.225350441723287e-06 0.1090364400125625 1.225350517546392e-06 0.1083889268999046 1.225350595246049e-06 0.1077282965354292 1.2253506775775e-06 0.1070311517075373 \
1.225350737142764e-06 0.1065286079538068 1.225350800900501e-06 0.1059924133642201 1.225350861995109e-06 0.1054803128126646 1.225350957858847e-06 0.1046801683739134 \
1.225351002721942e-06 0.1043071445723913 1.225351085962687e-06 0.1036173314376927 1.225351135082509e-06 0.1032117000904133 1.225351244131271e-06 0.1023149933518279 \
1.225351288967354e-06 0.1019479364619093 1.225351379228585e-06 0.1012117400678687 1.225351420105203e-06 0.1008795969612472 1.225351490563617e-06 0.1003088525914566 \
1.225351576851038e-06 0.09961307626065434 1.225351668628598e-06 0.09887705578174606 1.22535173815669e-06 0.09832225024344161 1.225351816683849e-06 0.09769854072774181 \
1.225351907412525e-06 0.09698178745350861 1.225351983228664e-06 0.09638605854785212 1.225352065241407e-06 0.09574500473888557 1.225352146994444e-06 0.09510943278387665 \
1.225352237502267e-06 0.09440967388330095 1.225352327061565e-06 0.09372126988887708 1.225352412671398e-06 0.09306698857649189 1.225352505450897e-06 0.09236212353634379 \
1.225352586338857e-06 0.0917510971760913 1.225352687467827e-06 0.09099177263830999 1.225352767961353e-06 0.09039108594384238 1.225352852204218e-06 0.08976589684797046 \
1.225352926049265e-06 0.08922077348043934 1.225353002898743e-06 0.08865632925481931 1.225353091039113e-06 0.08801255002475737 1.225353171103482e-06 0.08743108261130086 \
1.225353264139672e-06 0.08675939571108145 1.225353382140385e-06 0.08591369538214398 1.225353524513613e-06 0.08490278100234279 1.225353668761962e-06 0.08388867104764453 \
1.225353811089671e-06 0.08289807427203813 1.225353960667415e-06 0.08186746790234835 1.225354096981161e-06 0.08093761126893445 1.225354239101592e-06 0.0799778356000513 \
1.22535437365502e-06 0.07907840240745091 1.22535451400773e-06 0.07814980287393705 1.225354661689802e-06 0.0771833418413561 1.225354811805299e-06 0.07621180464723754 \
1.225354976525777e-06 0.07515824360926991 1.225355140155128e-06 0.07412455432658185 1.225355314933688e-06 0.07303438636984133 1.225355502186304e-06 0.07188220095900363 \
1.225355712231308e-06 0.07060976590783831 1.225355930441531e-06 0.06930979572898451 1.22535616389862e-06 0.06794333957253913 1.225356418744638e-06 0.06648001693367038 \
1.225356711839195e-06 0.06483321328442151 1.225357014178957e-06 0.06317411115207273 1.225357328765833e-06 0.06148945259513613 1.225357725026527e-06 0.05942677493938087 \
1.225358058743672e-06 0.05774249301432461 1.225358466054501e-06 0.05574994498853819 1.22535879393926e-06 0.05419380357502902 1.225359150629899e-06 0.05254809000207299 \
1.22535946386806e-06 0.05114243792209583 1.225359766835193e-06 0.04981740498512215 1.225360064375719e-06 0.04854875663330436 1.225360343155274e-06 0.04739109061078805 \
1.225360626155169e-06 0.04624570307560639 1.225360887895477e-06 0.04521055793698023 1.22536116713437e-06 0.04413130357485813 1.22536143924029e-06 0.0431040186124033 \
1.225361746607047e-06 0.04197194005652995 1.225361968409948e-06 0.04117329707315532 1.225362274870428e-06 0.04009446155587663 1.225362501059881e-06 0.03931650950691581 \
1.225362739977206e-06 0.03851359500741255 1.225362964401039e-06 0.03777663690506906 1.225363166663321e-06 0.03712468825868943 1.225363367705949e-06 0.03648814235703791 \
1.225363719479983e-06 0.03540095449820539 1.225363969725821e-06 0.03464776841732944 1.225364216044101e-06 0.03392252499723709 1.225364497376965e-06 0.03311308780599518 \
1.22536474046795e-06 0.03242954897046491 1.225364975941701e-06 0.03178112583711486 1.225365217601206e-06 0.03113119522156456 1.225365454483484e-06 0.03050988948014832 \
1.225365685016041e-06 0.02991733361391674 1.225365898984569e-06 0.02937801894285819 1.225366104927116e-06 0.02886851641492237 1.225366497651603e-06 0.02792196059063811 \
1.225366685729283e-06 0.02747992420741849 1.225367061168249e-06 0.02661861215736662 1.225367236042478e-06 0.02622659266649364 1.225367659365492e-06 0.02530049759795254 \
1.225367780614876e-06 0.02504150687334681 1.225368221176528e-06 0.02412433837770948 1.225368363674648e-06 0.02383402682615681 1.225368695728158e-06 0.02316883068419595 \
1.225368878693682e-06 0.02280879143785283 1.225369267997886e-06 0.02205689891561978 1.225369436343594e-06 0.02173705378531499 1.225369908457993e-06 0.02085107653961301 \
1.225370048202727e-06 0.0205916297664938 1.225370543782805e-06 0.01969297428531048 1.225370671008238e-06 0.01946923320191776 1.225371238917342e-06 0.01851512288677271 \
1.22537140317129e-06 0.0182513999453204 1.225372013043029e-06 0.0173209960017622 1.225372172728257e-06 0.01708922829277545 1.225372699639798e-06 0.01635462467776483 \
1.225372904157091e-06 0.01608193551804103 1.225373627634478e-06 0.01515939662837778 1.22537379307661e-06 0.01495683325581705 1.225374539636356e-06 0.01408081084911163 \
1.225374672939569e-06 0.01393008075245666 1.225375533124155e-06 0.01299799962960837 1.22537566920557e-06 0.01285670227674402 1.225376609799459e-06 0.01192267652923807 \
1.225376773572533e-06 0.01176632439256516 1.225377774751465e-06 0.01084959205883911 1.225377912229187e-06 0.01072929995296418 1.225379082926799e-06 0.009787962024485789 \
1.225379175323166e-06 0.009718668544398181 1.225380593399014e-06 0.008725931027897449 1.225380680375162e-06 0.00866912727384293 1.225382221370793e-06 0.00770199130002063 \
1.225382330686807e-06 0.007633428668288294 1.225383973934629e-06 0.006673746291950173 1.225384106791908e-06 0.006603544020797993 1.225386201172206e-06 0.005605323336654431 \
1.225386409576941e-06 0.00551468736035817 1.225388763913366e-06 0.004577307911602986 1.225389237472123e-06 0.004407121484391641 1.22539212290898e-06 0.003492041675788492 \
1.225392652573327e-06 0.00334538389506189 1.225396860800552e-06 0.00237996320858989 1.225397374234803e-06 0.002283557532494709 1.225403133485496e-06 0.001325291758975802 \
1.225403368066713e-06 0.001279502680325907 1.225418035894088e-06 0.0002809017338477542 1.22541814896418e-06 0.0002788534805396912 1.22805516904393e-06 -0.0006849217749926401 \
1.228055335205606e-06 -0.0009443270389602415 1.228055814074993e-06 -0.001850320037528519 1.22805590679462e-06 -0.002050462221988249 1.228056272019697e-06 -0.002913187630468476 \
1.228056363676814e-06 -0.00314709230904735 1.228056729783165e-06 -0.004133001189868674 1.228056839930291e-06 -0.004442309109773816 1.228057150668543e-06 -0.005311341427314526 \
1.228057252407188e-06 -0.005583925258601597 1.228057616111313e-06 -0.00638370916272213 1.228057780957636e-06 -0.006585924750287024 1.228058360754957e-06 -0.005792290386912202 \
1.228058535589415e-06 -0.004916934050781314 1.228058652279015e-06 -0.00413641027497409 1.228058778708708e-06 -0.00310656561120747 1.228058880730911e-06 -0.002137079422087956 \
1.228059000577393e-06 -0.0008406209844352954 1.228059091214629e-06 0.0002489246187367611 1.228059189634679e-06 0.001536790859923857 1.228059289358324e-06 0.002948496343048522 \
1.228059456842333e-06 0.005545701385567424 1.228059675420934e-06 0.009327395936412004 1.228059861491256e-06 0.0128572688386996 1.228060082873864e-06 0.01737012273305725 \
1.228060243533998e-06 0.02082840415615294 1.228060406999647e-06 0.02447866954313523 1.228060557635164e-06 0.02794359528291388 1.228060706690917e-06 0.03145289236167962 \
1.228060856153671e-06 0.03504014479003619 1.228061010184684e-06 0.03879791952579481 1.228061172300943e-06 0.04280891157365373 1.228061338330408e-06 0.04696567134311741 \
1.228061514283228e-06 0.05141478668696391 1.228061694953866e-06 0.05602187592747932 1.228061886774812e-06 0.06094655248807559 1.228062093880316e-06 0.06629309753158302 \
1.228062315452046e-06 0.07203901748582854 1.228062550186216e-06 0.07814662931008168 1.228062801725783e-06 0.08470684589377442 1.228063077167849e-06 0.09190125212984442 \
1.228063377363668e-06 0.09974607960254324 1.228063708295878e-06 0.108390578238945 1.228064083962612e-06 0.1181923833971668 1.22806448154548e-06 0.1285487285136021 \
1.228064948370083e-06 0.1406786766767902 1.228065491362617e-06 0.1547396794802719 1.22806612478764e-06 0.1710742296429572 1.228066820727691e-06 0.1889259607126788 \
1.2280676362848e-06 0.2097135943149445 1.228068546312904e-06 0.2327316641523666 1.228069339569124e-06 0.2526372689279454 1.2280700450442e-06 0.2702038474981599 \
1.228070663988468e-06 0.2855008995781749 1.228071231094408e-06 0.2994177966724069 1.228071754174414e-06 0.3121574438576628 1.228072253153207e-06 0.3242197130846058 \
1.228072737193214e-06 0.3358335658028451 1.228073192420047e-06 0.3466679577370423 1.228073666932009e-06 0.3578644504627745 1.228074106840717e-06 0.368158604789619 \
1.228074592685345e-06 0.3794271463718566 1.228075124288119e-06 0.3916316501999784 1.228075626951417e-06 0.4030538969706937 1.22807605602367e-06 0.4127111343288326 \
1.228076547040338e-06 0.4236561147984291 1.228077048470419e-06 0.434714731975362 1.228077395015009e-06 0.442288187401736 1.228077750424386e-06 0.4500000616404133 \
1.228078177652114e-06 0.4592019891792938 1.228078569851637e-06 0.4675774400278049 1.228078870233395e-06 0.4739448723400065 1.228079212045155e-06 0.4811381049525967 \
1.228079555484969e-06 0.4883107756756314 1.228079816220096e-06 0.4937186470393492 1.228080058250049e-06 0.4987071765458648 1.228080324195292e-06 0.5041573145298286 \
1.228080581464587e-06 0.509394255416739 1.228080771583691e-06 0.5132422368582924 1.228080985109851e-06 0.5175451019736222 1.228081124800157e-06 0.5203466115392713 \
1.228081271000449e-06 0.5232668091041763 1.22808148498835e-06 0.5275186200231483 1.22808169300461e-06 0.5316389396023125 1.228081885465879e-06 0.5354321131715788 \
1.228082070582111e-06 0.5390651926504321 1.228082244955557e-06 0.5424725330931349 1.228082549497633e-06 0.5484058192982523 1.228082810056515e-06 0.5534602958276967 \
1.228083111487545e-06 0.5592859190791987 1.228083365805138e-06 0.5641865993769294 1.228083658661328e-06 0.5698153316805189 1.22808391787448e-06 0.5747800306938655 \
1.228084188950812e-06 0.579963273174682 1.228084430794572e-06 0.5845680738798381 1.228084688299729e-06 0.5894577538325241 1.228084915043605e-06 0.5937419314630586 \
1.228085152044424e-06 0.5982006324572362 1.228085362230986e-06 0.6021379329905048 1.22808557499152e-06 0.6061060319396779 1.228085827870286e-06 0.6107954169450593 \
1.228086031533555e-06 0.6145509252949414 1.228086222250936e-06 0.6180531102377972 1.228086409587374e-06 0.6214768531423983 1.228086598465652e-06 0.6249070011644339 \
1.228086806665447e-06 0.6286671070650327 1.228087050997562e-06 0.6330499453121026 1.228087250564095e-06 0.6366057789565548 1.228087454709836e-06 0.6402215701419991 \
1.22808763934909e-06 0.643474671963314 1.228087908884781e-06 0.6481901084955864 1.228088136591637e-06 0.652149230294136 1.228088324263375e-06 0.6553888277830079 \
1.22808850516352e-06 0.6584949378977958 1.228088664704602e-06 0.661221510907812 1.228088835167002e-06 0.6641177016088209 1.228088986918443e-06 0.6666817235716488 \
1.228089124561455e-06 0.6689905419339194 1.228089273556319e-06 0.6714784915997724 1.228089401298182e-06 0.6736028790357499 1.228089544284695e-06 0.675968899142866 \
1.228089666067751e-06 0.6779749688503388 1.228089802351161e-06 0.6802121872853304 1.228089922180063e-06 0.682172759947357 1.228090068775624e-06 0.6845626218370968 \
1.228090187248565e-06 0.6864845934661837 1.228090283181927e-06 0.6880368302455475 1.228090375701511e-06 0.6895284278106264 1.228090480762023e-06 0.6912169000724893 \
1.228090578843908e-06 0.6927871490736753 1.228090715959225e-06 0.6949707622226827 1.228090835157868e-06 0.6968607547931925 1.228090945097838e-06 0.6985951241089645 \
1.228091082597082e-06 0.7007503743809057 1.228091214026983e-06 0.7027960765825516 1.228091346256499e-06 0.7048392108129343 1.228091459433897e-06 0.7065756917706891 \
1.228091613866752e-06 0.708927873976708 1.228091744646745e-06 0.7109048231498766 1.228091867315455e-06 0.7127465601965561 1.228091973583711e-06 0.7143329262278221 \
1.228092095963735e-06 0.7161490373358268 1.228092197817232e-06 0.7176517022913665 1.228092331955131e-06 0.7196190116794019 1.228092452648172e-06 0.7213783352064487 \
1.22809257178997e-06 0.7231049829175343 1.228092696807985e-06 0.7249059312823601 1.228092826647791e-06 0.7267645120560844 1.228092946459962e-06 0.7284691779696002 \
1.228093075453213e-06 0.730293808329565 1.228093207560278e-06 0.7321507998840678 1.228093325866095e-06 0.7338038328985433 1.228093469126786e-06 0.7357927618453034 \
1.228093571581473e-06 0.7372070005703254 1.228093667788359e-06 0.7385290937783453 1.22809377280598e-06 0.7399656334130889 1.228093883577511e-06 0.7414708009413548 \
1.228093985256052e-06 0.7428439364018735 1.228094088217507e-06 0.7442258341871242 1.228094205143661e-06 0.7457850038572696 1.228094333903936e-06 0.747489965072781 \
1.228094435062908e-06 0.7488201182152049 1.228094583931952e-06 0.7507626302114226 1.228094731611489e-06 0.75267249971878 1.228094850976855e-06 0.7542038164026367 \
1.2280949974607e-06 0.7560679527984652 1.22809512063619e-06 0.7576223900169708 1.228095261439865e-06 0.7593848990234215 1.228095398032531e-06 0.7610800595258669 \
1.228095520190381e-06 0.7625841275516777 1.228095632846779e-06 0.7639610711610054 1.22809577457292e-06 0.7656796138775311 1.22809590073942e-06 0.767196844592689 \
1.228096016156724e-06 0.768574452686535 1.228096146464904e-06 0.7701179991486644 1.228096262177572e-06 0.7714782821591826 1.22809638500186e-06 0.7729116492687436 \
1.228096502846128e-06 0.7742769236963016 1.228096608476119e-06 0.7754922619072108 1.228096723849554e-06 0.7768108638983861 1.228096829112716e-06 0.7780056027231214 \
1.228096940062529e-06 0.7792565499870431 1.228097026467031e-06 0.7802246528436213 1.228097130500851e-06 0.7813823422463088 1.228097244396594e-06 0.7826398494046257 \
1.228097347430014e-06 0.7837684443710583 1.228097455512714e-06 0.7849432998269023 1.22809756376437e-06 0.7861107422109641 1.228097699181617e-06 0.7875582910536544 \
1.228097811855724e-06 0.7887521292973186 1.228097936279784e-06 0.7900592323105087 1.228098054252648e-06 0.7912877959129118 1.228098198720603e-06 0.7927781272271259 \
1.228098316389742e-06 0.7939806363584788 1.228098452269582e-06 0.7953567374150946 1.228098587013954e-06 0.7967081403609936 1.228098698084933e-06 0.7978123285366109 \
1.228098797974273e-06 0.7987978371087655 1.228098899654231e-06 0.7997937268659365 1.228099032867897e-06 0.8010867894381996 1.228099151240716e-06 0.8022243628210853 \
1.22809927278179e-06 0.8033812848148773 1.228099392145442e-06 0.8045065422543012 1.228099513276819e-06 0.80563739819571 1.228099644976236e-06 0.8068544426691319 \
1.228099767984513e-06 0.8079795872959963 1.22809989582812e-06 0.8091371804586788 1.22810002673464e-06 0.8103101881504271 1.228100150327798e-06 0.8114062915203997 \
1.228100257500303e-06 0.8123479140825919 1.228100364929502e-06 0.8132835730547656 1.228100447598621e-06 0.8139979974227743 1.228100565310381e-06 0.8150069815425507 \
1.228100655915986e-06 0.8157770472204025 1.228100786569431e-06 0.8168774959419571 1.228100930959301e-06 0.8180800468042847 1.228101064133715e-06 0.8191766687328477 \
1.228101174025106e-06 0.8200725423139092 1.228101317623992e-06 0.8212302325252553 1.228101471014683e-06 0.8224508494407716 1.228101599092908e-06 0.8234574467428303 \
1.228101738880276e-06 0.8245431382086058 1.228101865129839e-06 0.8255122018650548 1.228102019728392e-06 0.8266841987320058 1.228102151939368e-06 0.8276738265999063 \
1.228102278166151e-06 0.8286078934539939 1.228102395913874e-06 0.8294698388787296 1.228102544986668e-06 0.8305480062617677 1.228102712318221e-06 0.8317406852496945 \
1.228102845539497e-06 0.8326770812274722 1.22810301832082e-06 0.8338744310092966 1.228103186826193e-06 0.8350236380668206 1.228103356205492e-06 0.8361608866600232 \
1.228103537840761e-06 0.8373606451951652 1.228103680174083e-06 0.8382866867625347 1.228103794011069e-06 0.8390185116470331 1.228103925192579e-06 0.8398522525089582 \
1.228104026724794e-06 0.8404903982372576 1.228104143009054e-06 0.8412135669902132 1.228104277643808e-06 0.8420406924792603 1.228104474666644e-06 0.8432316292878405 \
1.228104664772186e-06 0.8443592803112207 1.228104874895499e-06 0.8455816023960827 1.228105055213604e-06 0.8466107566581813 1.228105252676705e-06 0.8477171937062282 \
1.22810542674582e-06 0.8486750118570332 1.22810560906524e-06 0.8496608982186138 1.228105780480376e-06 0.8505716849290491 1.228105954593653e-06 0.8514808063694008 \
1.228106130324621e-06 0.8523822271368225 1.228106306436321e-06 0.8532696099472232 1.228106496054173e-06 0.8542074684498208 1.22810668683567e-06 0.8551330189126392 \
1.228106888431747e-06 0.8560917259710515 1.228107081166005e-06 0.856990088884472 1.228107290037826e-06 0.8579439907476532 1.228107520740263e-06 0.8589743400177088 \
1.228107785183227e-06 0.8601259267840322 1.228108084005915e-06 0.8613896125360476 1.228108363960216e-06 0.8625380186322354 1.228108648086082e-06 0.8636694076724545 \
1.228108922855057e-06 0.8647317823994775 1.228109194712217e-06 0.8657531067718063 1.228109465089334e-06 0.8667403371654003 1.228109722167856e-06 0.8676533221001362 \
1.228109994792687e-06 0.868594905839151 1.228110270759836e-06 0.8695208838709013 1.228110540864093e-06 0.8704012674911344 1.228110840740104e-06 0.8713491368600049 \
1.228111211801163e-06 0.8724801680184872 1.22811150674079e-06 0.8733472453740196 1.228111761036548e-06 0.8740729094291386 1.228112059297474e-06 0.8748989982677786 \
1.228112332904015e-06 0.8756336613858092 1.228112569029958e-06 0.876250392688866 1.228112809374056e-06 0.8768621356511911 1.228113031706182e-06 0.8774140071409635 \
1.228113225712247e-06 0.8778848105679672 1.228113555434997e-06 0.8786625669521169 1.228113710608526e-06 0.8790190643519731 1.228114028387606e-06 0.879730644938159 \
1.228114207248865e-06 0.8801204696806418 1.228114549710761e-06 0.8808457867651537 1.228114733837363e-06 0.8812245477320809 1.228115208711942e-06 0.8821665346129511 \
1.228115376108352e-06 0.8824869809105039 1.228115841951854e-06 0.883348261932613 1.228116022773548e-06 0.8836708855253055 1.228116516812651e-06 0.8845204537290557 \
1.228116658162059e-06 0.8847551796839913 1.228117264500122e-06 0.8857215808967022 1.228117416569336e-06 0.8859539944113424 1.228118063256356e-06 0.8869009218298172 \
1.228118191551239e-06 0.8870812460539503 1.228118839667745e-06 0.8879562712787433 1.228118969467641e-06 0.8881245027440973 1.228119747678341e-06 0.8890830197250962 \
1.228119862725472e-06 0.8892171882189283 1.228120718396314e-06 0.8901564861234483 1.228120863744077e-06 0.8903061494816453 1.228121849499649e-06 0.8912466483555094 \
1.228122070607711e-06 0.8914402669210102 1.228123215727715e-06 0.892367747196105 1.228123346939159e-06 0.8924695935232408 1.228124688211624e-06 0.8934615053489913 \
1.2281248396029e-06 0.8935661991834861 1.22812632105512e-06 0.8944951400107031 1.228126559934816e-06 0.8946288932334222 1.228128329356654e-06 0.895502508848118 \
1.228128718477945e-06 0.895670668133377 1.228131112210654e-06 0.8965556062201232 1.228131587750593e-06 0.8967047758494365 1.228135650819818e-06 0.8977025964496719 \
1.228136142295654e-06 0.8977953148389237 1.228144458892796e-06 0.8987880790885289 1.228145378794248e-06 0.8988514070442593 1.228299242370168e-06 0.8998485708192639 \
1.228302885496458e-06 0.8998628537402877 1.228529614276672e-06 0.8989664306490068 1.228529844616583e-06 0.8988008565867064 1.22853145953688e-06 0.897804750401333 \
1.228531637269167e-06 0.8977103535805105 1.228548403669272e-06 0.8986978311584225 1.228548539768403e-06 0.8987160394686986 1.228563710608672e-06 0.8997133888183054 \
1.228563987713508e-06 0.899719468756186 1.229048028906422e-06 0.9005852143835333 1.229048202241039e-06 0.9007408621809421 1.229048862730638e-06 0.9015135064485434 \
1.22904902879582e-06 0.9017527716291757 1.229049555130528e-06 0.9026184054967997 1.229049746244448e-06 0.9029704910143604 1.2290501104655e-06 0.9036902342402512 \
1.229050289664921e-06 0.9040628043424317 1.229050651551594e-06 0.9048333795345931 1.229050846661164e-06 0.9052442844328937 1.229051379059525e-06 0.9062266394381637 \
1.229051561413164e-06 0.9064623886473868 1.229052553393556e-06 0.905594670761786 1.229052714934123e-06 0.9049318860608667 1.229052882926576e-06 0.9040378649110347 \
1.229053042758061e-06 0.9029782421366458 1.229053180254799e-06 0.9018984154159868 1.229053313162111e-06 0.9007052793196499 1.229053439587579e-06 0.8994328447569792 \
1.229053546986819e-06 0.8982475863895881 1.229053651483477e-06 0.8970047013543965 1.229053765533147e-06 0.8955451342423859 1.229053855502734e-06 0.8943225684615312 \
1.229053960321373e-06 0.8928208677113324 1.229054049769612e-06 0.891473284704788 1.229054132145393e-06 0.8901820884368528 1.229054223238393e-06 0.8887006634027688 \
1.229054360574471e-06 0.8863657732814155 1.229054459067403e-06 0.8846195012157601 1.229054571141153e-06 0.8825649218508906 1.229054702024186e-06 0.880080778639088 \
1.229054838495216e-06 0.8774018563482072 1.229054991949379e-06 0.8742910281085086 1.229055151043747e-06 0.8709679977889497 1.22905531532765e-06 0.867445283300377 \
1.229055471995751e-06 0.8640104344288071 1.229055624086531e-06 0.860615744772629 1.229055777800206e-06 0.857132398554192 1.229055937362381e-06 0.853469801378647 \
1.229056092451083e-06 0.8498714074018293 1.229056266130402e-06 0.8458039138600054 1.229056429161269e-06 0.8419559450883216 1.229056590803684e-06 0.8381170660338335 \
1.229056753450421e-06 0.8342344554797501 1.229056914868927e-06 0.8303657475978833 1.229057083463406e-06 0.8263109424305363 1.229057266356504e-06 0.8219002364007665 \
1.229057434185218e-06 0.8178440888239877 1.229057602471033e-06 0.8137703061148112 1.229057773299085e-06 0.8096302849976138 1.229057945473642e-06 0.8054541271740473 \
1.229058113235561e-06 0.8013830614994394 1.229058296865019e-06 0.7969255463994016 1.229058468271496e-06 0.7927646873948894 1.229058653714802e-06 0.7882638003278283 \
1.229058820385454e-06 0.7842196820467244 1.229058989271585e-06 0.7801233737411432 1.229059173427882e-06 0.7756572567105651 1.22905936803791e-06 0.7709405333854473 \
1.229059515293242e-06 0.7673736106648734 1.229059641923832e-06 0.7643079795643375 1.229059783780644e-06 0.7608754495129878 1.229059888184422e-06 0.7583505812556488 \
1.229060020577074e-06 0.7551502542766809 1.229060130161271e-06 0.7525028097975122 1.229060263325923e-06 0.7492875979647342 1.229060419507685e-06 0.7455190770546114 \
1.229060532737112e-06 0.7427887939149777 1.229060695258476e-06 0.7388718945951063 1.229060867439291e-06 0.7347246296492568 1.229061063444044e-06 0.7300078517193382 \
1.229061227834023e-06 0.7260553905833119 1.229061380230704e-06 0.7223944885043934 1.229061543905858e-06 0.718466402706526 1.229061711831558e-06 0.7144406657912139 \
1.229061891671936e-06 0.7101336212543717 1.229062067965886e-06 0.7059164985576465 1.229062239040521e-06 0.7018286413152719 1.229062407358697e-06 0.6978099102718778 \
1.229062560624829e-06 0.6941537154717222 1.229062722508398e-06 0.6902960245155986 1.229062901459938e-06 0.6860364417190952 1.22906303567149e-06 0.6828448068431195 \
1.229063139177788e-06 0.6803854168085423 1.229063238462201e-06 0.6780286039046017 1.229063339916677e-06 0.6756220912380299 1.229063432373276e-06 0.6734303711245889 \
1.229063516962075e-06 0.6714267031582685 1.229063610539411e-06 0.6692114082407524 1.229063727081631e-06 0.6664546942583044 1.229063836559192e-06 0.6638675763958631 \
1.229063949672203e-06 0.6611971533414394 1.22906407279097e-06 0.6582923426231613 1.229064197017283e-06 0.6553636581362478 1.229064367777427e-06 0.6513432847262797 \
1.229064526226015e-06 0.6476181700514572 1.229064698513837e-06 0.6435738126612673 1.229064844491904e-06 0.6401512360303271 1.22906498628512e-06 0.6368325564797357 \
1.229065117883574e-06 0.6337564355289309 1.229065248046859e-06 0.630718219665797 1.2290653735718e-06 0.6277924818644975 1.229065505354707e-06 0.6247239543970449 \
1.229065635278203e-06 0.6217046839485236 1.229065771586778e-06 0.6185408917806742 1.229065916200345e-06 0.615188962872713 1.229066075692536e-06 0.611499189008522 \
1.229066249152652e-06 0.6074939486938447 1.229066420159955e-06 0.6035554342946753 1.229066651528523e-06 0.5982402936372396 1.229066894990528e-06 0.5926661367297537 \
1.229067069111016e-06 0.5886942528256315 1.229067215383094e-06 0.5853638081576373 1.229067349755312e-06 0.58231230528805 1.229067466850207e-06 0.5796585826255305 \
1.229067562614553e-06 0.5774900935424465 1.229067661461096e-06 0.5752566196463251 1.229067745438414e-06 0.5733628024369305 1.229067823052464e-06 0.571614165956722 \
1.229067884377937e-06 0.5702331258704825 1.229067949058576e-06 0.5687779664863769 1.229068030366712e-06 0.5669528575016536 1.229068080436707e-06 0.5658306078972934 \
1.229068129757269e-06 0.5647256890740617 1.229068191677069e-06 0.5633393552914843 1.229068239508894e-06 0.5622690492396486 1.22906829001368e-06 0.5611395143522533 \
1.229068350075717e-06 0.559799205480933 1.229068409358512e-06 0.5584782058326896 1.229068484415226e-06 0.5568072508052372 1.229068554097883e-06 0.5552574373576753 \
1.229068639686449e-06 0.5533559356568912 1.229068726753821e-06 0.5514265885063823 1.229068810416341e-06 0.5495763264044081 1.229068896561366e-06 0.5476734676082877 \
1.229068992265987e-06 0.5455621222678217 1.229069096550939e-06 0.5432673229847179 1.229069211218113e-06 0.5407497407899529 1.229069319936574e-06 0.5383664115638558 \
1.229069429508814e-06 0.5359693749054023 1.229069541813574e-06 0.5335193270114367 1.229069668589196e-06 0.530759392645703 1.229069790866427e-06 0.5281021910076299 \
1.229069930952405e-06 0.5250685463469849 1.229070067969763e-06 0.5221084647952599 1.229070218271135e-06 0.5188705764247719 1.229070377166376e-06 0.5154582091324615 \
1.229070551500259e-06 0.5117250894133971 1.229070738517481e-06 0.5077378180012799 1.229070943835486e-06 0.5033745272871338 1.229071155677679e-06 0.498891131759938 \
1.229071408479721e-06 0.4935662239713107 1.22907161056737e-06 0.4893264048484654 1.229071845160675e-06 0.4844277613141263 1.229072081275272e-06 0.4795194943790256 \
1.229072334451769e-06 0.474283574581623 1.229072644981732e-06 0.4679020429045382 1.22907286303971e-06 0.4634451779596257 1.229073036485344e-06 0.4599153839204358 \
1.229073212977781e-06 0.4563351808422506 1.229073492459578e-06 0.4506930409909046 1.229073724703484e-06 0.4460279192631412 1.229074011797073e-06 0.44029020239849 \
1.229074229643181e-06 0.435960758243863 1.229074439695769e-06 0.4318042429497612 1.229074640893605e-06 0.4278406951573778 1.229074823313766e-06 0.4242617300271556 \
1.229074997208751e-06 0.4208637793449936 1.229075162072867e-06 0.4176529694331993 1.22907532082684e-06 0.4145718140694327 1.229075487073787e-06 0.4113577680628809 \
1.229075635718993e-06 0.4084923702366076 1.229075788087249e-06 0.4055658186126443 1.229075930150432e-06 0.4028468403491589 1.22907609952631e-06 0.3996150665462138 \
1.22907621990823e-06 0.3973276483660343 1.229076329881494e-06 0.3952449223617059 1.229076444806895e-06 0.3930732253581283 1.229076597048475e-06 0.3902080468194818 \
1.22907670926954e-06 0.3881039677199808 1.229076816462041e-06 0.386098874836553 1.22907696899029e-06 0.383254723448244 1.229077097137419e-06 0.380874963946598 \
1.229077219985412e-06 0.3786015923730871 1.229077399083788e-06 0.375299968600122 1.22907754816842e-06 0.3725653942578417 1.229077715875808e-06 0.3695018296724824 \
1.229077871273443e-06 0.3666748141177644 1.229077995440288e-06 0.3644243980538668 1.229078109332156e-06 0.3623666676050148 1.229078230775526e-06 0.3601804966264144 \
