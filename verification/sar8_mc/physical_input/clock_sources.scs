8.17067930614306e-07 0.8646423892283146 8.170682028423722e-07 0.8656634505877856 8.170684730511912e-07 0.8666487272755322 8.17068730204067e-07 0.8675609437488442 \
8.170690027863351e-07 0.868501515423508 8.170692787713349e-07 0.8694269133137555 8.170695488729114e-07 0.8703069289141475 8.170698487348628e-07 0.8712546000783432 \
8.170702197689933e-07 0.8723856543073821 8.170705147067536e-07 0.8732530157608677 8.170707689975357e-07 0.8739790309043101 8.170710672549513e-07 0.8748056771600844 \
8.170713408634846e-07 0.8755409825400007 8.170715769915496e-07 0.8761583495732972 8.170718173369302e-07 0.876770807053994 8.17072039670212e-07 0.8773233906735478 \
8.170722336759598e-07 0.8777948466981503 8.17072563398506e-07 0.8785737911727464 8.170727185719444e-07 0.8789308835864816 8.170730363474729e-07 0.8796437246174529 \
8.1707321520917e-07 0.8800342982281311 8.170735576710471e-07 0.8807611334253193 8.170737417995192e-07 0.8811407335605206 8.170742166778565e-07 0.8820849466541889 \
8.170743840740527e-07 0.8824061830950772 8.170748499154564e-07 0.8832696475595492 8.17075030737665e-07 0.8835931319180218 8.170755247759143e-07 0.8844450822729043 \
8.170756661243274e-07 0.8846804878101884 8.170762724573853e-07 0.8856498028150036 8.170764245267248e-07 0.8858829444029697 8.170770712152002e-07 0.8868329272509302 \
8.170771995097231e-07 0.8870138524519416 8.170778476269278e-07 0.8878919388991984 8.170779774257915e-07 0.8880607713689423 8.170787556274809e-07 0.8890227771434612 \
8.170788706844141e-07 0.8891574578072456 8.170797263428481e-07 0.8901003239091128 8.170798717076157e-07 0.8902505899439886 8.170808574640299e-07 0.8911948786459364 \
8.170810785690402e-07 0.8913892999646706 8.170822236960192e-07 0.8923206810037944 8.170823549126186e-07 0.892422953350996 8.170836961242674e-07 0.8934189515818408 \
8.170838475232108e-07 0.8935240845833778 8.170853289614591e-07 0.8944568913393511 8.170855678408922e-07 0.8945912088657246 8.170873371610739e-07 0.8954685138428928 \
8.170877263108405e-07 0.895637400736999 8.170901199766275e-07 0.896526474291006 8.170905956894498e-07 0.8966764365754722 8.17094011699057e-07 0.8975478548673914 \
8.170946588490716e-07 0.8976786076740833 8.171021370136781e-07 0.8986646932675814 8.171028095907965e-07 0.8987192862546014 8.171952539953667e-07 0.8997188196574962 \
8.171959172280509e-07 0.8997241906476866 8.17385126389945e-07 0.900686595210158 8.173852884627892e-07 0.9007292695325627 8.173879339836764e-07 0.8998161167154269 \
8.173881025331539e-07 0.8996881690130656 8.173893792855451e-07 0.8987393243250013 8.173895814518808e-07 0.8986030018074492 8.173911895612673e-07 0.8976721249252815 \
8.173913816671926e-07 0.8975774045828077 8.174064950498387e-07 0.8985726115129884 8.174066831087563e-07 0.8986004060702872 8.174179880377676e-07 0.8995874924221801 \
8.174183614235164e-07 0.8996034751727418 8.179073737866979e-07 0.9005892719715856 8.179074845548976e-07 0.9006868984798269 8.179082372272589e-07 0.9015617873136611 \
8.179083390219455e-07 0.9017086238768567 8.179088744204902e-07 0.9025814930725723 8.179089769296628e-07 0.9027670217776843 8.179093691484816e-07 0.9035254014384071 \
8.17909509991429e-07 0.9038129158713877 8.179099510288813e-07 0.9047472953155866 8.179101365144842e-07 0.9051402477015744 8.179106528276013e-07 0.9061269394579334 \
8.17910737502694e-07 0.9062564181617988 8.179119721747438e-07 0.9053011091537977 8.179121293881559e-07 0.9045688862145235 8.179123212048176e-07 0.9034162411061901 \
8.179124880453484e-07 0.9021712267446264 8.179126350037462e-07 0.9008824031243315 8.179127491199424e-07 0.8997575350477262 8.179128789920322e-07 0.8983446880789033 \
8.179129901095502e-07 0.8970273815442567 8.179130829140294e-07 0.8958483937359277 8.17913171236719e-07 0.8946639786015808 8.179132744174779e-07 0.8932058048613533 \
8.179133666254135e-07 0.8918333298588224 8.179134541956103e-07 0.8904732289418564 8.179135681890765e-07 0.8886245408236838 8.179137299935004e-07 0.8858564722885236 \
8.179139149921175e-07 0.8825005184224666 8.179141071517853e-07 0.8788219124347386 8.179143085991385e-07 0.874780227084481 8.17914515009728e-07 0.8704697801294994 \
8.179147001816806e-07 0.8664790122147591 8.17914884689405e-07 0.862405115500708 8.179150578412963e-07 0.8585071391690239 8.179152428873213e-07 0.8542751393552932 \
8.179154202615245e-07 0.8501657390392787 8.179155970079552e-07 0.8460284987362284 8.179157631666058e-07 0.8421077870518131 8.179159252110445e-07 0.8382599993991456 \
8.17916091783925e-07 0.8342839555277276 8.179162504376617e-07 0.8304816347052207 8.179164413136869e-07 0.8258903812682129 8.179166162972586e-07 0.8216694867670907 \
8.179167862433925e-07 0.8175615830390965 8.179169514195676e-07 0.8135626411663678 8.179171246116744e-07 0.8093650119631921 8.179172956738768e-07 0.8052155696745213 \
8.179174637749139e-07 0.801136095357175 8.179176541098627e-07 0.7965156511928794 8.179178376918066e-07 0.7920591698039 8.179180456827317e-07 0.7870113041480956 \
8.179182682592422e-07 0.7816114142545842 8.17918457674258e-07 0.7770174196885687 8.179186509846539e-07 0.7723312127316435 8.179187944302406e-07 0.7688556734481145 \
8.179189438535907e-07 0.7652374066097742 8.179190630060629e-07 0.7623536300085233 8.179191757225444e-07 0.7596269484184472 8.179192849974512e-07 0.7569846861296079 \
8.179194210272093e-07 0.753697254849378 8.179195338230239e-07 0.750972995067179 8.1791965602098e-07 0.7480232093637929 8.179197676057526e-07 0.7453311011793381 \
8.179198923122156e-07 0.7423241425761796 8.179200466941669e-07 0.7386034578119585 8.179202134782327e-07 0.7345862494782525 8.179204306429212e-07 0.7293605768817599 \
8.1792062520351e-07 0.7246835946359503 8.179207855343955e-07 0.7208333202545074 8.179209609599985e-07 0.7166251500492028 8.179211507235729e-07 0.7120779400724765 \
8.179213394518974e-07 0.7075610435995559 8.179215212732643e-07 0.7032145396962334 8.179217058706759e-07 0.6988062725207448 8.179218429538112e-07 0.6955348514212173 \
8.179219962420495e-07 0.6918805091472418 8.179221916137951e-07 0.6872279990818534 8.179223477705466e-07 0.6835136309588888 8.179225057227664e-07 0.6797605476340507 \
8.179227039740297e-07 0.6750570282453686 8.179228973199279e-07 0.6704763548785364 8.179231338252739e-07 0.6648822204491218 8.179233200303777e-07 0.6604858901039825 \
8.179235576526979e-07 0.6548824851665868 8.179237444514521e-07 0.6504854738275335 8.179239250092116e-07 0.6462424706993735 8.179240880851561e-07 0.6424159959781919 \
8.179242326967206e-07 0.6390271817202816 8.179243732990705e-07 0.6357379642635244 8.179245001086568e-07 0.632774906490579 8.179246322451931e-07 0.6296924762754078 \
8.179247584891445e-07 0.6267508340255646 8.179248897527744e-07 0.6236963630311418 8.179250188505141e-07 0.6206978048938425 8.179251582761787e-07 0.6174624210713571 \
8.179253066461711e-07 0.6140261568477932 8.179255012030603e-07 0.6095278574984737 8.179256446489368e-07 0.6062198040692683 8.179258791091827e-07 0.6008245134060309 \
8.179260510074947e-07 0.5968818013610552 8.179262639280333e-07 0.5920102583789468 8.179264363946513e-07 0.5880775912131976 8.179265667191975e-07 0.5851108450968721 \
8.179266982755174e-07 0.5821241897920357 8.179268085055991e-07 0.5796262478458715 8.179269041598466e-07 0.5774603558442819 8.179270033938061e-07 0.5752182923213994 \
8.179270863119074e-07 0.5733484809858778 8.179271652275342e-07 0.5715706040143225 8.179272281563093e-07 0.5701535626562365 8.179272936647861e-07 0.5686800671140783 \
8.179273741508387e-07 0.5668736364148982 8.179274240168464e-07 0.5657560592102344 8.179274732056154e-07 0.5646541775062763 8.179275346754007e-07 0.5632780399140616 \
8.179275825969294e-07 0.5622058085646952 8.179276334416479e-07 0.5610687758404553 8.179276925419032e-07 0.5597501790023616 8.179277511562299e-07 0.5584442118409422 \
8.179278267823233e-07 0.5567607189607793 8.17927897341035e-07 0.5551915720267918 8.179279864710419e-07 0.5532116467156011 8.1792807569462e-07 0.5512351177508077 \
8.179281609982305e-07 0.5493490637975145 8.179282486251969e-07 0.5474138635528197 8.179283456271202e-07 0.545274424894262 8.179284499728912e-07 0.5429792414815097 \
8.179285662643155e-07 0.5404269323775457 8.17928672601932e-07 0.5380963700835184 8.179287843108152e-07 0.5356536306660374 8.179288966052949e-07 0.5332047801427824 \
8.179290238028542e-07 0.5304364255197962 8.17929146572528e-07 0.5277698476303582 8.179292887969246e-07 0.5246912237717902 8.179294251600566e-07 0.5217463069543907 \
8.179295773811234e-07 0.5184691491721333 8.179297370173294e-07 0.5150420887864461 8.179299129925215e-07 0.5112761258030903 8.179301015011087e-07 0.5072591542828934 \
8.179303085676898e-07 0.5028616940969075 8.179305335096624e-07 0.4981043078903621 8.179307849056188e-07 0.4928144328841237 8.17931021331185e-07 0.4878598554762091 \
8.179313184949192e-07 0.4816683149127979 8.179316091722113e-07 0.4756487143466775 8.17931917027196e-07 0.469313240945046 8.179322308529533e-07 0.4628991126846517 \
8.17932559994313e-07 0.4562163541974347 8.179328933724197e-07 0.4494927613461197 8.179332249990283e-07 0.4428490490857003 8.179335465484252e-07 0.4364504708187015 \
8.179338742242378e-07 0.4299742838549845 8.179342218438604e-07 0.4231546934710667 8.179345550651742e-07 0.4166645133789623 8.179349009744021e-07 0.4099771621835854 \
8.179353463882216e-07 0.4014400148089548 8.179357041780922e-07 0.3946500490499754 8.179360183349117e-07 0.3887397205534429 8.179364027453916e-07 0.3815756289527631 \
8.179367327200364e-07 0.3754830843203271 8.179370179301252e-07 0.3702633801070484 8.179373262203822e-07 0.3646649204592909 8.179376060174433e-07 0.3596257204303125 \
8.179378320117929e-07 0.3555880084110294 8.179380468497475e-07 0.3517755993421203 8.179382452848198e-07 0.3482769933469286 8.179384492243371e-07 0.3447071465415313 \
8.179386597603963e-07 0.3410461989361561 8.179389167345215e-07 0.3366091000429626 8.179391579951288e-07 0.3324763702393667 8.179393895688451e-07 0.3285420159269506 \
8.179396042222912e-07 0.3249208057821749 8.17939825046275e-07 0.3212218866489027 8.179400262928671e-07 0.3178749657716667 8.179402293821203e-07 0.3145250552959265 \
8.179404272269914e-07 0.3112865758726304 8.179406140799367e-07 0.3082497660855442 8.179408080166626e-07 0.3051208532403978 8.179410117613171e-07 0.30185834615803 \
8.179411904885829e-07 0.2990186060348319 8.179414281343783e-07 0.2952727068736475 8.179416278966111e-07 0.2921508861588616 8.179418295254275e-07 0.2890253490052915 \
8.179420549918856e-07 0.285561995332 8.17942221086285e-07 0.2830312764183137 8.17942399705387e-07 0.2803277612349699 8.179425814095885e-07 0.2775983111934518 \
8.179427700433048e-07 0.2747882307029562 8.179429474665079e-07 0.2721695222189568 8.179431246596455e-07 0.2695724116247911 8.179432847315606e-07 0.2672552081803913 \
8.179434051322386e-07 0.2655193337608355 8.179435529583031e-07 0.2633957862580221 8.179436815880755e-07 0.2615692882062232 8.179437837936585e-07 0.2601227034409412 \
8.179439020289392e-07 0.2584516051170885 8.179440224822997e-07 0.2567534139348401 8.179441461906177e-07 0.2550183706610066 8.179442644426428e-07 0.2533694204037282 \
8.179443922957732e-07 0.2515887492000971 8.179445125816039e-07 0.249915736161692 8.179446652612099e-07 0.2477917697339537 8.179448001739883e-07 0.2459264316518071 \
8.179449288134099e-07 0.2441493177932957 8.17945086528788e-07 0.2419705448111171 8.179452132100908e-07 0.2402201997919771 8.179453485361585e-07 0.2383592392624043 \
8.179454874487268e-07 0.2364550510890953 8.179456052210313e-07 0.2348405558720491 8.179457644918496e-07 0.2326580599570062 8.179459010137042e-07 0.2307878375452989 \
8.179460422456503e-07 0.2288626996658652 8.179461480586929e-07 0.2274220928889542 8.179462784016401e-07 0.2256484734765637 8.17946378112453e-07 0.2242944442559471 \
8.179464809338881e-07 0.2228991027388591 8.179465543495424e-07 0.2219046249368765 8.179466341811041e-07 0.2208265149641777 8.179467042283351e-07 0.2198809561195558 \
8.179467546314263e-07 0.2192009305305119 8.179468068832254e-07 0.2184966408607167 8.179468861207429e-07 0.2174292050927151 8.179469279646958e-07 0.2168658036437602 \
8.179469673046481e-07 0.216336351877609 8.179470103400575e-07 0.2157575332679269 8.179470545074837e-07 0.2151638767852215 8.179471282732236e-07 0.2141731338947761 \
8.179471637852206e-07 0.2136967174286463 8.179472115000211e-07 0.2130606706933813 8.17947272229561e-07 0.2122518321687151 8.179473404867867e-07 0.2113438957752176 \
8.179474130085659e-07 0.2103801801047663 8.179474856831929e-07 0.2094152724966429 8.179475939991808e-07 0.2079788886429202 8.179476916703231e-07 0.20668564243436 \
8.179478032218192e-07 0.2052110974836689 8.179479017572532e-07 0.2039136008387587 8.179480052503929e-07 0.2025572972554956 8.179481011521277e-07 0.2013021587886929 \
8.17948203780057e-07 0.1999606878451601 8.179483066031699e-07 0.1986207062101238 8.179484167227972e-07 0.1971897063011611 8.179485254183531e-07 0.1957815523781236 \
8.179486450955817e-07 0.1942360962608612 8.179487553732606e-07 0.192818053470401 8.179488634364806e-07 0.1914343471929882 8.179489885351485e-07 0.1898375077741012 \
8.179490785049816e-07 0.1886931806549971 8.179491571919346e-07 0.1876950225942949 8.17949234476806e-07 0.1867173468865102 8.179493209853824e-07 0.1856271834369256 \
8.179494199345929e-07 0.1843848109964498 8.179494904434582e-07 0.1835017733581451 8.179495618945114e-07 0.1826096997732476 8.179496670398458e-07 0.1813018727451555 \
8.179497462794754e-07 0.1803200401832796 8.179498273633695e-07 0.1793174195483187 8.1794992085531e-07 0.1781663090788374 8.179500216312847e-07 0.1769308188703378 \
8.179501713433883e-07 0.175105380089017 8.179502871327036e-07 0.1737009932372819 8.179504381380806e-07 0.1718807311127691 8.179505492465001e-07 0.1705485445502526 \
8.179506913729584e-07 0.168854666407182 8.179508090313791e-07 0.167460358327668 8.179509139359749e-07 0.1662230887079887 8.179510089985733e-07 0.1651069099307241 \
8.179511024298278e-07 0.1640147999883682 8.179512034764903e-07 0.1628388413495604 8.179512998233979e-07 0.1617223204899406 8.179513969756437e-07 0.1606011553546776 \
8.179514800242163e-07 0.1596469772300165 8.179515900618698e-07 0.1583897228513109 8.179516723644316e-07 0.1574542248873526 8.179517773641412e-07 0.156267858580057 \
8.179518550602102e-07 0.1553950893374849 8.179519378796887e-07 0.1544690878994293 8.179520195415937e-07 0.1535604570452941 8.179521088908843e-07 0.152571060794856 \
8.1795218460332e-07 0.1517364980793458 8.179522671659343e-07 0.1508307726525361 8.179523437473671e-07 0.1499942554682341 8.179524120352535e-07 0.1492531084507001 \
8.179525054022655e-07 0.1482449401818621 8.179525745556768e-07 0.1475015570698688 8.179526501800083e-07 0.1466917482325688 8.179527117291285e-07 0.1460354497178591 \
8.179527789778923e-07 0.1453208357145237 8.179528500398917e-07 0.1445684785944268 8.179529255373203e-07 0.143772322008306 8.179529844488598e-07 0.1431546944759192 \
8.179530611224699e-07 0.1423563022825049 8.179531414432115e-07 0.1415233898163201 8.179532145945195e-07 0.1407682091691316 8.179533087509407e-07 0.139800669784813 \
8.179533803551247e-07 0.1390684367429364 8.179534538159004e-07 0.1383201464810226 8.179535373276515e-07 0.1374732033664194 8.179536268067953e-07 0.1365744208092838 \
8.179536918717002e-07 0.1359252211013016 8.179538039977228e-07 0.1348115665849295 8.179538691838634e-07 0.1341670699454539 8.179539392221084e-07 0.1334770515823289 \
8.179539995271633e-07 0.1328849371768329 8.179540545379868e-07 0.1323464455745446 8.17954142654965e-07 0.1314871014507438 8.179541834412595e-07 0.131090685705856 \
8.179542871440105e-07 0.1300923774523848 8.179543304565801e-07 0.1296773144713907 8.17954391675178e-07 0.1290920262082728 8.179544365118974e-07 0.1286643765206081 \
8.179545241079233e-07 0.127831527987147 8.179545656618794e-07 0.1274377589706847 8.179546255233895e-07 0.1268718307679372 8.179546973671149e-07 0.1261946708524367 \
8.179547535798413e-07 0.1256664967939027 8.179548160673402e-07 0.125081039250218 8.179548902953232e-07 0.1243877959456236 8.179549649763283e-07 0.1236954937854857 \
8.179550521595408e-07 0.1228905551604285 8.179551205580918e-07 0.1222610287411191 8.17955201128775e-07 0.1215216597888775 8.179552824242559e-07 0.120778012781285 \
8.179553493407808e-07 0.1201677797529914 8.179554321577255e-07 0.1194156054679852 8.179554913464481e-07 0.1188799972037829 8.179555572674477e-07 0.1182853617472536 \
8.179556371414917e-07 0.1175675408705869 8.179557136372898e-07 0.1168828806096336 8.179557950994005e-07 0.1161574242846086 8.179558935702815e-07 0.1152852106851665 \
8.179559686806302e-07 0.114622623867465 8.179560716684202e-07 0.1137180076826871 8.179561458523715e-07 0.1130691786503039 8.179562434718251e-07 0.1122190343868764 \
8.179563392827804e-07 0.1113890351962442 8.179564351312053e-07 0.110562946039519 8.179565160694118e-07 0.1098685209805978 8.179566044526832e-07 0.1091134439098378 \
8.179567030526615e-07 0.108274944429282 8.179567758368655e-07 0.1076586405352824 8.17956865109775e-07 0.1069058608836731 8.179569270917884e-07 0.1063852406583179 \
8.179569896849557e-07 0.1058613310701875 8.179570749071042e-07 0.105150777260444 8.179571803694781e-07 0.1042758147594986 8.179572601999606e-07 0.1036167065755082 \
8.179573409142144e-07 0.1029530974056021 8.179574235279495e-07 0.1022768941101355 8.179574939725617e-07 0.1017026162492672 8.179575972319282e-07 0.1008648142128753 \
8.179576700720535e-07 0.1002767039768694 8.17957755712335e-07 0.09958839426015198 8.179578745140727e-07 0.09863954321822334 8.179579421518978e-07 0.09810250133474645 \
8.179580119020204e-07 0.09755100310752296 8.17958089237e-07 0.09694230106952094 8.179581816572539e-07 0.09621870517595056 8.17958253354782e-07 0.09566033062548993 \
8.179583391719417e-07 0.09499542738017568 8.17958441597192e-07 0.09420660575030523 8.17958534892083e-07 0.09349264652734962 8.179586312085565e-07 0.09276005482712441 \
8.179587081108176e-07 0.09217843893134048 8.179588015908053e-07 0.09147541043939374 8.179588808332317e-07 0.09088281005358793 8.17958995455426e-07 0.0900310686188453 \
8.179591250636858e-07 0.08907580221142102 8.179592583208766e-07 0.08810234090122065 8.179594023507656e-07 0.08705990691030199 8.179595595189095e-07 0.08593388720602639 \
8.179597092953871e-07 0.08487214151476249 8.179598717629785e-07 0.08373303262435308 8.179600149429843e-07 0.08273971668837025 8.17960167622107e-07 0.0816913199659166 \
8.179603018918778e-07 0.08077856892457436 8.179604436441554e-07 0.07982444400446118 8.179605786438163e-07 0.07892500874648442 8.179607206012136e-07 0.07798882638923543 \
8.179608674486441e-07 0.07703088995320664 8.17961019894053e-07 0.07604750978240994 8.179611851127757e-07 0.07499422991502351 8.179613492506213e-07 0.07396067809208305 \
8.179615261120239e-07 0.07286119333145537 8.179617164535802e-07 0.07169407515132428 8.17961927410093e-07 0.07042030845332216 8.179621478192316e-07 0.0691121699798517 \
8.17962383344393e-07 0.06773900533435212 8.179626437937673e-07 0.0662496528900723 8.179629394591772e-07 0.06459579389282195 8.179632445814627e-07 0.06292902455725519 \
8.179636095760241e-07 0.06098725515092194 8.179640044568393e-07 0.05894944116461652 8.179644108474932e-07 0.05692211719668253 8.179648265730353e-07 0.05491854459141238 \
8.179651893793582e-07 0.0532251207245777 8.179655339806477e-07 0.05166301626031383 8.179658491605097e-07 0.05027284652491828 8.179661446898747e-07 0.04900240867073854 \
8.179664426703825e-07 0.04775344010203557 8.179667184691724e-07 0.04662857640242725 8.179669972437683e-07 0.04551884372531381 8.179672611786382e-07 0.04449205559535935 \
8.179675372013766e-07 0.04344260531795661 8.179678161576297e-07 0.04240676967887352 8.179681298509632e-07 0.04127097799875453 8.179683658512502e-07 0.04043636567030678 \
8.179686216459875e-07 0.03955075129286261 8.17968881769487e-07 0.03867033103466553 8.179691519047594e-07 0.03778142289416799 8.179694311247467e-07 0.03688501536902895 \
8.179697129633963e-07 0.03600226561751176 8.17969989839066e-07 0.03515600409566183 8.179702689326649e-07 0.03432349610146775 8.179705018102724e-07 0.03364444121149882 \
8.179707856469893e-07 0.03283527291840588 8.179710257519236e-07 0.03216626441466421 8.179712655507463e-07 0.0315119836023277 8.179715048279204e-07 0.03087436846876356 \
8.179717400849421e-07 0.03026290129608995 8.179719710119639e-07 0.02967475842909434 8.17972186001007e-07 0.02913788335257221 8.179725881554596e-07 0.02816043724496065 \
8.179727868782784e-07 0.02768988489927659 8.179731605612945e-07 0.0268265706552881 8.179733473596173e-07 0.02640514011949098 8.179736949193038e-07 0.02563810810034544 \
8.179738168487671e-07 0.0253740445387235 8.179741993202074e-07 0.02456430406701914 8.179743700282367e-07 0.02421180751242828 8.17974827125621e-07 0.02328894863848502 \
8.179750127580069e-07 0.0229225623309489 8.179753762152597e-07 0.02221803970155307 8.179755965826125e-07 0.02179832126591805 8.179760543089696e-07 0.02093867417890744 \
8.179761897285988e-07 0.02068687731869814 8.179767196240474e-07 0.01972418011126781 8.17976838945017e-07 0.01951377505543128 8.179774047306961e-07 0.01856069823426573 \
8.17977569110437e-07 0.0182962226476828 8.179781876557338e-07 0.01735107502432094 8.179783577099332e-07 0.01710418363667701 8.179788898421661e-07 0.01636278834442301 \
8.179790869261418e-07 0.01610013864443424 8.179798100452149e-07 0.01517806887136661 8.179799746753809e-07 0.01497647803580381 8.179807238007678e-07 0.01409711804523418 \
8.179808571001203e-07 0.01394643716836554 8.179817173537587e-07 0.01301449210748497 8.179818524573793e-07 0.01287422877142914 8.179827950348196e-07 0.01193816285908547 \
8.179829586305737e-07 0.01178202925388569 8.179839599872008e-07 0.0108653384673985 8.179840975299883e-07 0.01074500730514941 8.179853196363712e-07 0.009765086624518643 \
8.179854265890839e-07 0.00968516078425012 8.179868307805774e-07 0.008707372520026449 8.179869356112841e-07 0.008639312158696611 8.179884704482461e-07 0.00767719340797631 \
8.179885657315476e-07 0.007617466071856052 8.179901745288685e-07 0.006680264535635283 8.179903086056076e-07 0.006609506832171614 8.179924056185594e-07 0.005610918814474722 \
8.179926361631908e-07 0.005510783990371394 8.179949591584346e-07 0.004586584533412417 8.179954404886379e-07 0.004413562233393853 8.179982780502688e-07 0.003511943147855551 \
8.179988229699549e-07 0.003360532104877318 8.180029471783515e-07 0.002408309874554541 8.180034909020111e-07 0.002305347543005144 8.180093621912368e-07 0.001333291345955189 \
8.180096050564211e-07 0.001286469439319215 8.180239329487719e-07 0.0002880570268237783 8.180240775074142e-07 0.0002853642807229123 8.206613564285127e-07 -0.0006859155495331031 \
8.206614959836498e-07 -0.000901903561740745 8.206620050775826e-07 -0.001859438188174024 8.206620945650851e-07 -0.002052812934985279 8.206624579599451e-07 -0.00291126965001638 \
8.206625489820155e-07 -0.003143482006111167 8.206629144200523e-07 -0.004127275145644371 8.206630246806195e-07 -0.004436819103926468 8.206633367277739e-07 -0.005309594399865315 \
8.206634394426211e-07 -0.005584800160857357 8.206638032904767e-07 -0.006384516484886619 8.206639680812086e-07 -0.006586298968823262 8.206645476774081e-07 -0.005791490933239759 \
8.206647227875511e-07 -0.004914057272375438 8.206648394794853e-07 -0.004132845175365214 8.206649660640905e-07 -0.003100877896798674 8.206650678730126e-07 -0.002132773363901063 \
8.206651883617227e-07 -0.0008283127610571584 8.206652788087988e-07 0.0002599396317828252 8.206653766989305e-07 0.001541559978017447 8.206654757632394e-07 0.002943971508909197 \
8.206656465705158e-07 0.005594911825788154 8.206658683385387e-07 0.00944046646559993 8.206660642423845e-07 0.01317281463966807 8.206662231237663e-07 0.01639870563256729 \
8.206663875522632e-07 0.01989779506365397 8.206665419182935e-07 0.02331070396473752 8.20666700690818e-07 0.02693200463312963 8.206668474287769e-07 0.03036422445567413 \
8.206669960527481e-07 0.0339113704936035 8.20667151667245e-07 0.03768995713197771 8.206673089092589e-07 0.04156499463828727 8.206674738020577e-07 0.04567927910670353 \
8.206676472215784e-07 0.05005184210758699 8.20667825915293e-07 0.05459761989277153 8.206680145311307e-07 0.05943075613080645 8.206682154312735e-07 0.06460909294799391 \
8.206684348880646e-07 0.0702927970720964 8.206686644343515e-07 0.07626037976612585 8.206689101332909e-07 0.08266408948881369 8.206691786982296e-07 0.08967663153997742 \
8.206694700401445e-07 0.09728936802005522 8.206697917081718e-07 0.1056939239977524 8.20670152022263e-07 0.1150987971742611 8.206705430017012e-07 0.1252892839303718 \
8.206709864165172e-07 0.1368209045172546 8.206715027296045e-07 0.1502062239570841 8.206721089348208e-07 0.16586000516691 8.206727801918478e-07 0.1831102247110778 \
8.206735596915047e-07 0.20301830483439 8.206744320013885e-07 0.2251413938832897 8.206752623367137e-07 0.2460320778586349 8.206759936670633e-07 0.264292249712138 \
8.206766416128433e-07 0.280346965484095 8.206772249233171e-07 0.29469740877147 8.20677760655584e-07 0.3077798509628869 8.20678263914169e-07 0.3199778888071559 \
8.2067874911767e-07 0.3316516836183861 8.206792280403756e-07 0.3430829066939081 8.206796744710079e-07 0.3536501814456421 8.206801488007181e-07 0.3647819492304352 \
8.206805979917124e-07 0.3752331958288908 8.206810884639695e-07 0.3865396207984229 8.206816170367225e-07 0.3985997842463301 8.206819881810625e-07 0.4069920784971888 \
8.206825159354181e-07 0.4188173133762567 8.206829782921778e-07 0.4290642331729484 8.206834506243178e-07 0.4394285229343968 8.206839324090407e-07 0.4498981261869666 \
8.206839654481592e-07 0.4506126593745911 8.206840032071518e-07 0.45142837879914 8.206840787251369e-07 0.4530572051633331 8.206842297611073e-07 0.4563088938659436 \
8.206844372803726e-07 0.460764549126051 8.206846253191843e-07 0.4647825567212808 8.206848443283984e-07 0.469441659996985 8.206850871594093e-07 0.4745824626509371 \
8.206853869350375e-07 0.4808894567257585 8.206856247281872e-07 0.4858624696070272 8.206858879495879e-07 0.4913374535260851 8.206861488471327e-07 0.4967277906005185 \
8.206863784012197e-07 0.5014431429135263 8.206866014614136e-07 0.506003872007333 8.206868030374043e-07 0.5100983586086808 8.206869518674631e-07 0.51310967141356 \
8.206871961785157e-07 0.5180317772556589 8.20687328783749e-07 0.5206893064287169 8.206874681403308e-07 0.5234717264876519 8.206876791057241e-07 0.5276623644271943 \
8.206878539796058e-07 0.5311266030493931 8.206881220278524e-07 0.5364094032095129 8.206883170535097e-07 0.5402319029111832 8.206884966150173e-07 0.5437361368949839 \
8.206887475711458e-07 0.5486228351952749 8.206890249792569e-07 0.5540035987981641 8.20689308928559e-07 0.5594901708581531 8.206895645658505e-07 0.5644152233389156 \
8.206898555480696e-07 0.570006772487656 8.20690115853754e-07 0.5749917787111524 8.206903842978736e-07 0.5801232573974072 8.206906270630042e-07 0.5847450403362237 \
8.20690883594205e-07 0.5896146675871002 8.206911097576483e-07 0.59388771440121 8.206913470991427e-07 0.5983512154742827 8.206915564878602e-07 0.6022720321566808 \
8.206917702606284e-07 0.6062574570422776 8.206920237134688e-07 0.6109557890491497 8.206922265678164e-07 0.6146943332140289 8.206924193723377e-07 0.6182333111593361 \
8.206926096773651e-07 0.6217090173923294 8.20692800335854e-07 0.6251694921350958 8.206930029137796e-07 0.6288260100903066 8.206932656625421e-07 0.6335359534764116 \
8.206934946302321e-07 0.6376100987349322 8.206937145778672e-07 0.6414991146358265 8.206939402625401e-07 0.6454625140719233 8.206941491499662e-07 0.6491091855837361 \
8.206943708035853e-07 0.652957810138281 8.206945556930106e-07 0.6561429680377227 8.206947457075645e-07 0.6594017273991298 8.206948958626861e-07 0.6619630641908443 \
8.206950707405928e-07 0.6649292185271485 8.206952164613094e-07 0.6673855496832628 8.206953524938417e-07 0.6696641287411549 8.206955008561211e-07 0.672138295335571 \
8.206956303038335e-07 0.6742883907026684 8.206957641695307e-07 0.6764996355878535 8.206958925139302e-07 0.6786115243545502 8.206960179020584e-07 0.6806677490053815 \
8.20696147367755e-07 0.6827843190971332 8.206962783489701e-07 0.6849171426143115 8.206964267220724e-07 0.6873221141612875 8.206965347848267e-07 0.6890667486235877 \
8.206966633164996e-07 0.6911333958680312 8.206967987562836e-07 0.6933004139195943 8.206969236906071e-07 0.6952876996714908 8.20697049447875e-07 0.6972799977491608 \
8.206971559637663e-07 0.6989584331773744 8.20697273081655e-07 0.7007929859467624 8.206973916214007e-07 0.7026383448210159 8.206975149247975e-07 0.704545102273978 \
8.206976180976957e-07 0.7061304255463237 8.20697769068859e-07 0.7084341141567283 8.206978853230652e-07 0.7101955266062138 8.206980158834538e-07 0.7121605601685687 \
8.206981344459821e-07 0.7139335830373704 8.206982405198518e-07 0.7155108922888329 8.206983405447916e-07 0.716990346352101 8.206984778700065e-07 0.719009255813789 \
8.206985965313622e-07 0.7207429633399333 8.206987182305859e-07 0.7225107522614664 8.206988434131515e-07 0.7243181860083944 8.206989654329653e-07 0.7260693242762759 \
8.206990934647187e-07 0.7278954552757622 8.206992179464579e-07 0.7296603419865877 8.206993462457807e-07 0.7314685590147565 8.206994733395841e-07 0.7332489547570846 \
8.206995993644231e-07 0.7350034830462163 8.2069970210311e-07 0.7364262918236342 8.206998167758557e-07 0.7380063527755659 8.206998981819179e-07 0.7391232259175492 \
8.207000173814378e-07 0.7407496908814458 8.207001100237781e-07 0.7420059782745783 8.207002481828348e-07 0.7438668850244906 8.207003792383344e-07 0.7456179978167152 \
8.207005093705018e-07 0.7473439783685625 8.207006143445769e-07 0.7487266533969134 8.207007534844189e-07 0.7505456565005918 8.207009074287187e-07 0.7525407731682957 \
8.207010293729986e-07 0.7541080835708853 8.207011769193594e-07 0.7559892974429111 8.20701298924537e-07 0.7575320275232224 8.207014476244666e-07 0.7593968175435225 \
8.207015816710922e-07 0.7610632318338031 8.207017039243471e-07 0.7625711443351471 8.207018167902567e-07 0.763953046884334 8.207019596412246e-07 0.7656882893306027 \
8.207020863641193e-07 0.7672149413549471 8.207022021689945e-07 0.7685995877768005 8.207023319108227e-07 0.7701390587657672 8.207024476492105e-07 0.7715019052061673 \
8.207025706016372e-07 0.7729391548276606 8.20702688317297e-07 0.7743051053122872 8.207027942872732e-07 0.7755262985206828 8.207029106984675e-07 0.7768586864857919 \
8.207030173164003e-07 0.7780703956921795 8.207031295151206e-07 0.7793369495935717 8.207032161836896e-07 0.7803089322889447 8.207033195691813e-07 0.7814603789665585 \
8.207034327334326e-07 0.7827108149434853 8.207035383807155e-07 0.783868819044773 8.207036477202728e-07 0.7850578567336689 8.207037548972877e-07 0.786214126597127 \
8.20703884303365e-07 0.7875981444497275 8.207039967207506e-07 0.7887899291890393 8.207041201084898e-07 0.7900869036018625 8.207042375588255e-07 0.7913106402786101 \
8.207043810857436e-07 0.7927918312347375 8.207044960053219e-07 0.7939667362870242 8.207046347277351e-07 0.7953719780830618 8.207047727598755e-07 0.7967562205547866 \
8.207048822530295e-07 0.7978444364842524 8.207049832714595e-07 0.7988406866985471 8.207050843594197e-07 0.7998302780396641 8.207052167466158e-07 0.8011146558616069 \
8.207053354720369e-07 0.8022550163876687 8.207054572565424e-07 0.8034134048507504 8.207055763463359e-07 0.8045351524060473 8.207056975508533e-07 0.8056657048884367 \
8.207058291946645e-07 0.8068811249615274 8.207059522127029e-07 0.8080052413861453 8.207060798230233e-07 0.8091594649786741 8.207062108916829e-07 0.8103325925767672 \
8.207063342120463e-07 0.8114249716726942 8.207064421363105e-07 0.8123719892944993 8.207065499317031e-07 0.8133095350680949 8.20706631652631e-07 0.8140147772069938 \
8.207067485202474e-07 0.815015186305849 8.207068395812562e-07 0.8157880755829442 8.207069737498876e-07 0.8169164295805346 8.2070711832076e-07 0.8181184617099191 \
8.207072518231266e-07 0.8192158725965917 8.207073617890376e-07 0.8201107352847025 8.207075056546974e-07 0.8212684563313245 8.207076589602621e-07 0.8224861772268215 \
8.207077866985553e-07 0.8234883060891934 8.207079273408908e-07 0.8245786478120171 8.207080531244555e-07 0.8255423809867173 8.207082077424273e-07 0.8267124309768116 \
8.207083401541937e-07 0.8277017767197102 8.207084664337982e-07 0.8286345641820314 8.20708584064113e-07 0.8294941055817234 8.207087322309758e-07 0.8305638349826423 \
8.207088993752207e-07 0.8317531470681401 8.207090319938809e-07 0.832683775428688 8.20709204938569e-07 0.8338803479528284 8.207093733252244e-07 0.8350269493631071 \
8.207095428597541e-07 0.8361634673386688 8.207097242289089e-07 0.8373596561587384 8.207098668614912e-07 0.8382862741713709 8.207099807973396e-07 0.8390176620397163 \
8.207101115711344e-07 0.8398476357987267 8.207102132250742e-07 0.8404856735008092 8.207103297188026e-07 0.8412091703399448 8.207104652363492e-07 0.8420405885319162 \
8.20710662580143e-07 0.8432318270427018 8.20710853245141e-07 0.8443612543037786 8.207110631019802e-07 0.8455804035625291 8.207112440391043e-07 0.8466117334714958 \
8.207114413745909e-07 0.8477160230260256 8.207116151614274e-07 0.8486711109012058 8.207117977428814e-07 0.8496572451898022 8.207119690624607e-07 0.850566499179887 \
8.207121434475075e-07 0.8514760798656241 8.207123188310518e-07 0.8523748177975867 8.207124950632094e-07 0.8532619682996843 8.207126849014517e-07 0.8542000584728613 \
8.207128756376655e-07 0.8551245802328369 8.20713077434399e-07 0.856083442102113 8.207132701277752e-07 0.8569809170305027 8.207134797560764e-07 0.857937542729613 \
8.207137091938401e-07 0.8589615588718806 8.207139749904802e-07 0.8601183337444025 8.207142735657075e-07 0.8613802063570262 8.207145514672208e-07 0.8625196921548358 \
8.207148356776949e-07 0.8636511027355716 8.207151100894824e-07 0.8647118800460076 8.207153822523641e-07 0.8657341977214618 8.207156524214556e-07 0.8667205537246333 \
8.207159096161394e-07 0.8676338760342862 8.207161821558105e-07 0.868575115807136 8.207164581902908e-07 0.8695013130444248 8.207167283429861e-07 0.8703818891200001 \
8.207170280497877e-07 0.8713292845176382 8.207173988672582e-07 0.8724597217497643 8.207176937859212e-07 0.8733269024855727 8.207179480301993e-07 0.8740525764960509 \
8.207182462541984e-07 0.8748787854419284 8.20718519878969e-07 0.8756137195941651 8.207187560179586e-07 0.8762307200963571 8.207189963736862e-07 0.8768427579093606 \
8.20719218719338e-07 0.8773949085683344 8.207194127230722e-07 0.877865919014753 8.207197424471962e-07 0.878644045115768 8.207198976198552e-07 0.8790007149587372 \
8.207202153732478e-07 0.879712598742095 8.207203942386052e-07 0.8801026384247937 8.207207367000935e-07 0.8808283583858193 8.207209208412927e-07 0.8812073588304842 \
8.207213957461143e-07 0.8821499412898334 8.207215631406011e-07 0.8824705695712217 8.207220289718891e-07 0.8833323038036038 8.207222097967713e-07 0.8836551183393088 \
8.207227038300281e-07 0.8845051821644966 8.207228451726029e-07 0.8847400410050358 8.207234515631179e-07 0.8857071861637142 8.207236036356849e-07 0.8859397703602404 \
8.207242503137576e-07 0.8868873789663725 8.207243786102466e-07 0.8870678433440622 8.207250267232453e-07 0.8879435266410994 8.207251565285235e-07 0.8881118897635528 \
8.207259347856079e-07 0.8890711781604964 8.207260497804227e-07 0.8892053868933587 8.207269055110619e-07 0.8901454611437621 8.207270507776287e-07 0.8902951528450479 \
8.207280365337324e-07 0.8912364417375994 8.207282576409459e-07 0.8914302300078862 8.207294027520271e-07 0.892358484239638 8.207295339601743e-07 0.8924604119362172 \
8.207308752633695e-07 0.8934531785430913 8.207310266510305e-07 0.8935579568409697 8.207325081098674e-07 0.8944876667405802 8.207327469902294e-07 0.894621531696939 \
8.207345164619858e-07 0.8954958910368339 8.207349055688234e-07 0.8956641700186337 8.207372993342322e-07 0.8965498195158238 8.207377748942228e-07 0.8966991754584082 \
8.20741837950387e-07 0.8976977719002629 8.207423294244079e-07 0.8977905759376156 8.207506459514872e-07 0.8987839664765119 8.207515658053769e-07 0.8988472044554419 \
8.208777709459031e-07 0.8998441026240215 8.20878784754255e-07 0.8998514601858095 8.210704973474114e-07 0.8990059056521554 8.210707273489741e-07 0.8988405173838494 \
8.210723422215349e-07 0.8978439928078279 8.210725199353886e-07 0.8977495532019018 8.210892857104286e-07 0.8987316330193963 8.210894216988253e-07 0.8987497732072308 \
8.211048844279384e-07 0.8997471920221268 8.211051522925305e-07 0.8997526389354535 8.215889776197985e-07 0.9006560548284696 8.215890984089986e-07 0.9007687033315858 \
8.215898861800373e-07 0.9017381658104292 8.215900203187565e-07 0.901943163319478 8.215905139335305e-07 0.9027850367016239 8.21590658833145e-07 0.9030569221572713 \
8.215910546405301e-07 0.9038490360455199 8.215911744361841e-07 0.9041001886668685 8.215915586097176e-07 0.9049189780371781 8.215916707313646e-07 0.9051556495331843 \
8.215921780523355e-07 0.9061253139956988 8.215922720511915e-07 0.90626859229291 8.215934307008982e-07 0.9055667778886739 8.215935336638316e-07 0.9051589876696525 \
8.215936175067006e-07 0.9047707260375384 8.215937512467521e-07 0.9040404158978201 8.215938519641334e-07 0.9033957423200318 8.215939595799193e-07 0.9026166239542108 \
8.215940771531731e-07 0.9016533104038295 8.215941654182229e-07 0.90085556431878 8.215942850516912e-07 0.8996698288011099 8.215943823733893e-07 0.8986166602050341 \
8.215944933908277e-07 0.8973222354192386 8.215945955004155e-07 0.8960407982554908 8.21594678931815e-07 0.8949326975987755 8.215947831128827e-07 0.8934749428758865 \
8.215948741996462e-07 0.8921321265381427 8.215949667404319e-07 0.8907058396397178 8.2159506189443e-07 0.8891776325191247 8.215951764494069e-07 0.88725933118288 \
8.215952652925088e-07 0.8857137884271823 8.215953635316906e-07 0.8839502506198179 8.215954489018647e-07 0.8823735982707064 8.215955298021066e-07 0.8808434949738935 \
8.215956027633997e-07 0.8794355441897157 8.215956697820454e-07 0.8781198554636557 8.215957383931237e-07 0.8767515715160701 8.215958218880357e-07 0.8750591081124355 \
8.215958840153663e-07 0.8737811510706814 8.215959469979637e-07 0.8724704924326797 8.215960421537152e-07 0.8704632161180945 8.215961427643535e-07 0.8683077530860182 \
8.215962226435446e-07 0.8665738309361769 8.215963069058141e-07 0.8647250601592834 8.215963860160736e-07 0.8629723295901451 8.215964488315188e-07 0.8615696597604833 \
8.215965362885537e-07 0.8596016864744445 8.215966021820844e-07 0.8581079708060287 8.215966702436265e-07 0.856556281928966 8.215967195561343e-07 0.8554267461646872 \
8.215967747929236e-07 0.85415654045335 8.215968155325295e-07 0.8532164928603474 8.215968618342831e-07 0.8521450198670055 8.21596892048343e-07 0.8514441160591502 \
8.215969210896252e-07 0.8507691938976955 8.2159695172822e-07 0.8500558939662993 8.215970130054096e-07 0.8486254874746039 8.215970660779718e-07 0.8473828229799116 \
8.215971197331653e-07 0.8461232012188223 8.215971823904472e-07 0.8446482873934593 8.215972456733951e-07 0.8431545995644786 8.21597336171269e-07 0.8410121009440262 \
8.215974331690495e-07 0.8387078554355326 8.215975161465498e-07 0.8367307351423475 8.215975981509053e-07 0.8347721678896715 8.215976872193065e-07 0.8326403548070889 \
8.215977717326432e-07 0.8306135893189693 8.215978625915233e-07 0.8284303722590877 8.215979545263781e-07 0.8262176456275642 8.215980569573084e-07 0.8237486178045141 \
8.215981570753404e-07 0.8213320995840899 8.215982718962233e-07 0.8185572053828121 8.215983841027603e-07 0.8158423448209959 8.215985090963053e-07 0.8128151787794674 \
8.215986403567132e-07 0.8096337870015397 8.215987856277547e-07 0.8061104108175116 8.21598940135368e-07 0.8023613213197434 8.215991115759889e-07 0.7981999722344618 \
8.215992756257814e-07 0.794217661721315 8.215994600412031e-07 0.7897413884478564 8.215996665335767e-07 0.7847307375046715 8.215998560274197e-07 0.7801344622909899 \
8.216000494211825e-07 0.775444374634302 8.216002499880375e-07 0.7705834242206392 8.21600397552439e-07 0.7670092004965298 8.216005275638895e-07 0.7638619034739171 \
8.216006624283032e-07 0.7605987503374771 8.216007689187539e-07 0.7580234999254772 8.216009006085467e-07 0.7548403390839162 8.216010070329759e-07 0.7522693550468039 \
8.21601150211605e-07 0.7488125398635642 8.216013113387162e-07 0.7449250928176189 8.216014295655331e-07 0.7420746008290786 8.21601599798354e-07 0.7379721584775248 \
8.216017657246235e-07 0.7339761998059781 8.216019852669538e-07 0.7286940862104242 8.216021784540778e-07 0.724050920820232 8.216023533680413e-07 0.719851304223293 \
8.216025203151389e-07 0.7158476177432674 8.216027078061003e-07 0.711355754450834 8.216028952345367e-07 0.7068709122373377 8.216030635710959e-07 0.7028473835914892 \
8.216032564016302e-07 0.6982428782038785 8.216033964513774e-07 0.694901318858167 8.216035527086664e-07 0.6911769338170629 8.216037468781132e-07 0.6865540563080536 \
8.216039059846016e-07 0.6827702245679255 8.216040643446318e-07 0.679008548037742 8.216042596617401e-07 0.6743756772263459 8.216044700905194e-07 0.6693917663527935 \
8.216047227926645e-07 0.6634173774538097 8.216049024606155e-07 0.6591769455535931 8.216051540374889e-07 0.6532475027332399 8.21605354410306e-07 0.6485340174553987 \
8.216055260641581e-07 0.6445032789616798 8.216056847562746e-07 0.6407814961122935 8.216058239642021e-07 0.637522316374186 8.216059602882518e-07 0.6343349641335875 \
8.216060875012758e-07 0.6313646237382058 8.216062169938336e-07 0.6283457899522861 8.216063449851212e-07 0.6253646753452949 8.2160647605963e-07 0.6223174651643489 \
8.216066067717051e-07 0.6192830747181834 8.216067493797576e-07 0.6159760732208495 8.216068921032355e-07 0.612672916206165 8.216070446510367e-07 0.6091471600588 \
8.216071891550244e-07 0.6058158037532523 8.21607353173272e-07 0.6020406322262999 8.216074906379333e-07 0.5988837056407329 8.216076254549489e-07 0.5957940466067043 \
8.216077469535923e-07 0.5930134750293682 8.216078858038965e-07 0.5898448108574432 8.216079994507128e-07 0.5872554148224447 8.216081508608853e-07 0.5838116422847746 \
8.216082645795603e-07 0.5812320812748947 8.216083839926513e-07 0.5785269636915771 8.216084726731778e-07 0.5765205397309219 8.216085638182693e-07 0.5744630259469776 \
8.216086291571447e-07 0.5729901393713442 8.216086936268467e-07 0.5715377831648228 8.21608744447459e-07 0.5703933076453638 8.216088034223983e-07 0.569066051987989 \
8.216088708671063e-07 0.5675516747474645 8.216089379592979e-07 0.5660472084764079 8.216089908797418e-07 0.5648615894615425 8.216090865272253e-07 0.5627204246953637 \
8.216091437083616e-07 0.5614413394337 8.216091975109775e-07 0.5602399192081799 8.216092592530825e-07 0.5588634520375642 8.216093450862141e-07 0.5569525037715509 \
8.216094277818617e-07 0.5551133137453282 8.216095539105889e-07 0.552313430559463 8.216096890096645e-07 0.5493247407981657 8.21609787329828e-07 0.5471534914294828 \
8.216098999078897e-07 0.5446716589975775 8.216100024523052e-07 0.5424173856211837 8.216101225611309e-07 0.5397821662853191 8.216102242487819e-07 0.5375541863492928 \
8.216103397527456e-07 0.5350300289250629 8.216104546438614e-07 0.5325260225312031 8.21610581121134e-07 0.5297740207092871 8.216107063383297e-07 0.5270565158317848 \
8.216108531843122e-07 0.5238798967507053 8.216109886424457e-07 0.5209557060405445 8.216111462030545e-07 0.5175672114705414 8.216113083572294e-07 0.5140875588169389 \
8.21611489068307e-07 0.5102248342695275 8.216116813160604e-07 0.5061308236654174 8.216118940383231e-07 0.5016182665703952 8.216121259434839e-07 0.4967183500883584 \
8.216123831371877e-07 0.4913135654247419 8.216126226904983e-07 0.4863004534671564 8.216129246203734e-07 0.4800178499336004 8.216132123868145e-07 0.4740665530855001 \
8.216135251890574e-07 0.4676409412178996 8.216138450208061e-07 0.4611139840073785 8.216141846574089e-07 0.4542292677834274 8.216145118732278e-07 0.4476411633207955 \
8.216148470347968e-07 0.4409363684817221 8.216151642914575e-07 0.4346351592989786 8.216154981114363e-07 0.4280489847791872 8.2161584979678e-07 0.4211625252737479 \
8.21616163864498e-07 0.4150547397555842 8.216164868937019e-07 0.4088175946446666 8.216169278730989e-07 0.4003732788922496 8.21617270275942e-07 0.3938810608698495 \
8.216175707238304e-07 0.3882325136127223 8.216179460534016e-07 0.3812375944419973 8.216182761286299e-07 0.3751439175705365 8.216185594064112e-07 0.3699597784791666 \
8.216188599137726e-07 0.3645020109013299 8.216191395612329e-07 0.3594637112692664 8.216193634235236e-07 0.3554634414471464 8.216195752745134e-07 0.35170280677964 \
8.216197776231135e-07 0.3481338771034005 8.216199787581391e-07 0.3446120049995081 8.216201845356566e-07 0.3410324794262659 8.216204455143708e-07 0.3365252478245505 \
8.216206850045531e-07 0.3324209773202946 8.216209176796239e-07 0.3284665339262754 8.216211317612159e-07 0.3248537323113044 8.21621352906983e-07 0.3211475567840967 \
8.21621553789873e-07 0.3178053707831449 8.216217571810748e-07 0.3144500223650613 8.216219548494876e-07 0.3112139453100684 8.216221410931751e-07 0.3081862077816076 \
8.216223360742573e-07 0.3050391973134606 8.216225395365022e-07 0.3017803754370622 8.216227174774077e-07 0.2989521325826759 8.216229532011122e-07 0.2952356640875101 \
8.216231513339655e-07 0.2921385263640672 8.216233526780326e-07 0.2890160050544278 8.216235769672296e-07 0.2855690750291008 8.216237418971287e-07 0.2830551950838826 \
8.216239195258139e-07 0.2803657404651576 8.216241039249612e-07 0.2775946687427531 8.216242877463063e-07 0.2748547260732712 8.216244662029787e-07 0.2722194282383935 \
8.216246381032458e-07 0.2696976713509589 8.216247986436534e-07 0.2673699088296289 8.216249201257116e-07 0.265617282026588 8.216250730472387e-07 0.2634201198254058 \
8.216252004809339e-07 0.2616085083773952 8.216253046546046e-07 0.2601317890528609 8.216254215590815e-07 0.2584775571399547 8.21625536570573e-07 0.2568557450124987 \
8.216256609328033e-07 0.2551103168403305 8.216257765070866e-07 0.2534925198640895 8.216259106146075e-07 0.2516172680784447 8.216260256018484e-07 0.2500177396912131 \
8.216261793514453e-07 0.2478798443778067 8.216263161546458e-07 0.2459790966208961 8.21626450740453e-07 0.2441094379339017 8.216266066045887e-07 0.2419575875351012 \
8.216267312534115e-07 0.2402378086535915 8.216268704689347e-07 0.2383186229544463 8.2162700069296e-07 0.236525770455347 8.216271210458007e-07 0.2348769158236033 \
8.216272564390845e-07 0.233027137746051 8.216274076440629e-07 0.2309620730808924 8.21627542400533e-07 0.2291249940296414 8.216276470867202e-07 0.2277003186426776 \
8.216277696228612e-07 0.2260366668203369 8.2162790456742e-07 0.2242086518061946 8.216279996831675e-07 0.2229209267876512 8.216281149432223e-07 0.2213657311907907 \
8.216281974762017e-07 0.2202562617028589 8.216282686815328e-07 0.2192992955643472 8.216283173890172e-07 0.2186449771734718 8.216283645839733e-07 0.2180112263680214 \
8.216284111327914e-07 0.2173864029843717 8.216284645213553e-07 0.2166701476649976 8.216285018980252e-07 0.2161690444847812 8.216285392831377e-07 0.2156680710113931 \
8.216285796045079e-07 0.2151283464800275 8.216286508546474e-07 0.2141753141901174 8.216286850689041e-07 0.2137180869447317 8.216287314635346e-07 0.2131018213873352 \
8.216287919072007e-07 0.2122998083652294 8.216288609101201e-07 0.2113853596849882 8.216289262050715e-07 0.210520730631805 8.216289941831954e-07 0.2096212333552783 \
8.21629110629525e-07 0.2080823984153433 8.216292005517136e-07 0.2068957989735914 8.216293082176196e-07 0.2054771097790837 8.216294042789353e-07 0.2042146625011118 \
8.216295076575089e-07 0.2028641889872041 8.216296043425436e-07 0.2016026287683381 8.216297071523967e-07 0.2002625524503448 8.216298079123679e-07 0.1989526210414513 \
8.216299190580346e-07 0.1975116692735505 8.216300260975286e-07 0.1961279675313261 8.216301440040638e-07 0.1946083430154048 8.216302521143875e-07 0.1932197128021231 \
8.216303614129877e-07 0.1918224631760269 8.216304820447391e-07 0.1902849927564414 8.216305769453309e-07 0.1890796997295432 8.216307055062502e-07 0.18745262875399 \
8.216307985410385e-07 0.1862801166370808 8.216309009375946e-07 0.1849947785893032 8.216309889048857e-07 0.1838942174288659 8.216310871755572e-07 0.182668828510528 \
8.216311837761789e-07 0.1814691026470878 8.216312704146923e-07 0.1803971466393716 8.216313568237045e-07 0.1793305247657973 8.216314526608142e-07 0.1781527189679156 \
8.216315573876885e-07 0.1768710765218302 8.216317031999754e-07 0.1750963017969037 8.216318191679069e-07 0.1736923427161618 8.216319756317111e-07 0.1718092975148396 \
8.2163208681163e-07 0.1704786474822015 8.216322270616306e-07 0.1688098560703619 8.216323500730352e-07 0.1673544160765056 8.216324565640334e-07 0.1661007559767333 \
8.216325528894916e-07 0.1649724583647661 8.216326503229586e-07 0.1638357962207703 8.216327541762373e-07 0.1626293386330815 8.216328459768101e-07 0.1615673458739011 \
8.216329443645254e-07 0.1604337426303964 8.216330272831698e-07 0.1594828374885931 8.216331226515033e-07 0.1583950132920943 8.216332052138515e-07 0.1574587876231885 \
8.216333077985371e-07 0.1563016192679324 8.216333840768539e-07 0.1554454316211293 8.216334726624787e-07 0.1544557264474612 8.216335448319838e-07 0.1536532700165102 \
8.216336265414731e-07 0.1527486200895024 8.216337002202808e-07 0.1519363404455653 8.216337804404095e-07 0.1510573496788611 8.216338521684844e-07 0.1502755532525617 \
8.216339204254628e-07 0.149534520573691 8.216340181414224e-07 0.1484788062294206 8.216340875916063e-07 0.147731872792437 8.216341703430852e-07 0.1468455801890639 \
8.216342303799948e-07 0.1462052652532956 8.216343006186586e-07 0.1454587420502366 8.216343720461929e-07 0.1447037411390827 8.216344525596947e-07 0.1438588888651768 \
8.216345158225991e-07 0.1431977449412327 8.216345934965784e-07 0.1423892845091393 8.216346828063428e-07 0.141463758692191 8.216347521699289e-07 0.1407479403162204 \
8.216348501181492e-07 0.1397418416088305 8.216349404626691e-07 0.1388188591118084 8.216350262429942e-07 0.1379520826379384 8.21635093896779e-07 0.1372719511642241 \
8.216351602046294e-07 0.1366075914250998 8.21635238824321e-07 0.1358227655030745 8.216353195192301e-07 0.135020537018139 8.216353779218939e-07 0.1344419857224206 \
8.216354386744168e-07 0.1338420332148588 8.21635532580729e-07 0.1329184183639811 8.216355749782324e-07 0.1325029080242558 8.21635654222426e-07 0.1317336600863391 \
8.216356945925846e-07 0.1313430593815061 8.216357842934633e-07 0.130477658168832 8.216358232415502e-07 0.1301029732927899 8.216359188572358e-07 0.1291862249441596 \
8.216359577410651e-07 0.1288146335111444 8.216360509758409e-07 0.1279263274670414 8.216361193184299e-07 0.1272775968534341 8.216361716392851e-07 0.1267823325594629 \
8.216362537399991e-07 0.1260075984242486 8.216363249033783e-07 0.1253406747583812 8.216364028563662e-07 0.1246136378429537 8.216364819761021e-07 0.1238779526756392 \
8.21636560619333e-07 0.1231489004754178 8.216366406542415e-07 0.122409328367501 8.216367023886577e-07 0.1218405706457005 8.216367759836405e-07 0.1211645344030958 \
8.216368593634578e-07 0.120401093559758 8.216369234601888e-07 0.1198161795466899 8.216369928987769e-07 0.119184869057559 8.216370659217156e-07 0.1185234239195788 \
8.216371507966272e-07 0.1177582144838446 8.216372301594785e-07 0.117046673033812 8.21637314893136e-07 0.1162898833629492 8.216374056044255e-07 0.1154830714735263 \
8.216374811875037e-07 0.1148135241260771 8.216375469154284e-07 0.1142333070693714 8.21637606975201e-07 0.1137047561823949 8.216376765809174e-07 0.1130943456353956 \
8.216377429999685e-07 0.1125141752866663 8.216378224112316e-07 0.1118230150855203 8.216379126741611e-07 0.1110406875128299 8.216379817184613e-07 0.1104447270551955 \
8.216380562735805e-07 0.1098035355921305 8.216381447575013e-07 0.1090456469739195 8.216382238656482e-07 0.1083709350695736 8.216382937340289e-07 0.1077773127978274 \
8.216383747433988e-07 0.1070920034756896 8.216384309482126e-07 0.106618206733547 8.216384936074921e-07 0.1060916009495399 8.216385587540976e-07 0.105545887371837 \
8.216386300897258e-07 0.1049504956797945 8.216387503861013e-07 0.1039516085561449 8.216388019396737e-07 0.103525508500865 8.216388570887417e-07 0.1030709598036589 \
8.216389477859257e-07 0.1023262935955709 8.216390301757782e-07 0.1016530765296615 8.216391257555856e-07 0.1008759670630478 8.216392329651518e-07 0.1000092507657299 \
8.216393366245584e-07 0.09917656019160864 8.216394228321611e-07 0.09848810438956324 8.216395090743862e-07 0.09780303991321163 8.216395886154604e-07 0.09717448010577609 \
8.216396686283335e-07 0.09654538840876434 8.216397599166613e-07 0.09583163072761708 8.216398416620796e-07 0.09519620281310773 8.216399305889171e-07 0.09450872319168514 \
8.216400203662242e-07 0.09381864801001834 8.216400973288722e-07 0.09323024625953365 8.216401876536891e-07 0.0925435244861572 8.216402514624153e-07 0.09206084550525626 \
8.216403239259827e-07 0.09151514907748673 8.216403880546354e-07 0.09103438864950099 8.216404663020107e-07 0.09045054736970405 8.216405660032922e-07 0.08971110930136832 \
8.216406400564437e-07 0.08916512281998501 8.216407266649787e-07 0.08852997392441805 8.216408729646849e-07 0.08746544055362569 8.216409836769483e-07 0.08666684197409438 \
8.216410939866262e-07 0.08587717033461532 8.216412361822689e-07 0.08486839672072237 8.216413762347203e-07 0.08388450488753585 8.216415188805343e-07 0.08289222299161547 \
8.21641667651249e-07 0.08186778387581196 8.216418043639348e-07 0.08093569403044946 8.21641946484565e-07 0.07997640434545976 8.21642081061545e-07 0.07907728405019222 \
8.216422212814229e-07 0.07814997945867638 8.216423690282293e-07 0.07718353387841098 8.216425189824148e-07 0.07621348085094087 8.216426836982467e-07 0.07516037195605636 \
8.216428472843634e-07 0.07412732798506308 8.216430219327156e-07 0.07303837372665309 8.216432089864081e-07 0.07188781219077654 8.216434189729256e-07 0.0706159374129187 \
8.216436370461739e-07 0.06931715807027321 8.216438703663275e-07 0.06795188046253516 8.216441248458817e-07 0.0664909822812602 8.2164441780254e-07 0.06484528303377844 \
8.21644719953089e-07 0.06318745987130532 8.216450576747915e-07 0.06138078634948794 8.216454527833931e-07 0.05932807220464856 8.21645820234636e-07 0.05747953410674719 \
8.216462378424018e-07 0.05544691527644593 8.216465828383762e-07 0.0538196438399016 8.216469333806655e-07 0.05221302159193914 8.21647248341029e-07 0.0508087490907442 \
8.216475475823956e-07 0.049508488261462 8.216478469482477e-07 0.04824029756235761 8.216481221909582e-07 0.04710512226277328 8.216484056545246e-07 0.04596497870754415 \
8.216486672549465e-07 0.04493681260994405 8.216489447070711e-07 0.04387103439794762 8.216492207665063e-07 0.04283531238677037 8.216495290362429e-07 0.04170718945545093 \
8.216497514688635e-07 0.0409114719535993 8.21650039009947e-07 0.03990505631995635 8.216502752428795e-07 0.0390969788355163 8.216505937045547e-07 0.03803800466874574 \
8.21650844115589e-07 0.03722710566490722 8.216511671003914e-07 0.03620720400565681 8.216514254364062e-07 0.03541203096995557 8.216517154102846e-07 0.03454066075983582 \
8.216519452051024e-07 0.0338658635512188 8.216522301004436e-07 0.03304787219836024 8.21652469846563e-07 0.03237513696606491 8.216527104811323e-07 0.03171392889024889 \
8.216529495996188e-07 0.03107212555077287 8.216531855385298e-07 0.03045460689686571 8.216534163673909e-07 0.02986254663395104 8.216536313939185e-07 0.02932175456294728 \
8.216540335597597e-07 0.0283374222946415 8.2165423211788e-07 0.02786401170979088 8.216546058190659e-07 0.02699470773596776 8.216547926322608e-07 0.02657042318767052 \
8.216551386335082e-07 0.02580176906824739 8.216552605769465e-07 0.02553595448027303 8.216556434299635e-07 0.02472011952872977 8.216558038641491e-07 0.02438657631284594 \
8.21656246865303e-07 0.02348572425118655 8.216564174793445e-07 0.02314627247835563 8.216567380559406e-07 0.02251902970747987 8.216569383408681e-07 0.0221336684630111 \
8.216573852788009e-07 0.02128811173678137 8.216575132229166e-07 0.02104854104185888 8.216580011002759e-07 0.02014826272243131 8.216581360775529e-07 0.01990454278080647 \
8.216586183290713e-07 0.0190640092473091 8.216587806551862e-07 0.01879235028057063 8.216592670495271e-07 0.01801148170254873 8.216594300771862e-07 0.01776103207540622 \
8.216601102988766e-07 0.01676849304257711 8.216602493826144e-07 0.01657541006259178 8.216609818771476e-07 0.01560782569993242 8.216611407707804e-07 0.01540693214221847 \
8.216619238518671e-07 0.01445869962397344 8.216620696444218e-07 0.01428952172302696 8.216629204257814e-07 0.01334248985256295 8.216630315290529e-07 0.01322388191882306 \
8.216639648234166e-07 0.0122699293983148 8.216640986614657e-07 0.01213902814618388 8.21665057199482e-07 0.01123495036716388 8.216651783165508e-07 0.01112486091825863 \
8.216663004003486e-07 0.01017270671243764 8.216664059016017e-07 0.01008921053061839 8.216677349760139e-07 0.009112307258623473 8.216678551802884e-07 0.009029744095492466 \
8.216694035420479e-07 0.008036808760534916 8.216694843298185e-07 0.007986285493236449 8.216710552093519e-07 0.007024564730313319 8.216711226255508e-07 0.006986095570813155 \
8.216730433922295e-07 0.006001386377072119 8.21673230194113e-07 0.005914747648762168 8.216755456080606e-07 0.0049318160947762 8.216759451349076e-07 0.004777795182599986 \
8.216785089444082e-07 0.003889929704329555 8.216790078153284e-07 0.003736330440833864 8.21682637539317e-07 0.002784984367379526 8.216831882332918e-07 0.002663729254427667 \
8.216885866736713e-07 0.001711392372544448 8.216888999412433e-07 0.001662511220227468 8.216938922337913e-07 0.0006970413096974805 8.216940762528259e-07 0.0006571176749162138 \
8.243425553956096e-07 -0.0002691198397987355 8.24342711454572e-07 -0.0004551674219448388 8.243432594384272e-07 -0.001322174727784445 8.243433723764198e-07 -0.001539785040943742 \
8.243438016313498e-07 -0.002474302920374066 8.243439078885149e-07 -0.002730173903076456 8.243441906906665e-07 -0.003454402452283872 8.243443042852103e-07 -0.003760966378165151 \
8.243446428397891e-07 -0.004705104513819927 8.243447552637498e-07 -0.005021586953003071 8.243450835416507e-07 -0.005887841248467669 8.243451910801718e-07 -0.006130875888161453 \
8.243460710062032e-07 -0.005789627805322099 8.243462462122502e-07 -0.004910736584223327 8.243463630430134e-07 -0.004127745010746014 8.243464899101376e-07 -0.00309221842859156 \
8.243465914428629e-07 -0.002125750314016509 8.243467128641333e-07 -0.0008095618968406578 8.243468030290462e-07 0.0002767910803854594 8.243469002126957e-07 0.001550247908954045 \
8.243469982869597e-07 0.002938803805678211 8.243471655080454e-07 0.005530627736217106 8.243473878133233e-07 0.009378371294171852 8.24347573551714e-07 0.01290572951649239 \
8.243477976330495e-07 0.01747895571448658 8.243479572777817e-07 0.02091945933227325 8.243481217671112e-07 0.02459614091902196 8.243482715915693e-07 0.0280452875125503 \
8.243484209914613e-07 0.03156498790849799 8.243485705227667e-07 0.03515592969144176 8.243487246026614e-07 0.03891669635189081 8.243488867868089e-07 0.0429309674228065 \
8.24349053210035e-07 0.0470989728378523 8.243492291435082e-07 0.05154884981278444 8.24349410271779e-07 0.05616867911875007 8.243496024027047e-07 0.06110225049351239 \
8.24349810098117e-07 0.0664648391313285 8.243500320181979e-07 0.07222051812179281 8.243502672196803e-07 0.07834079218654426 8.243505194059893e-07 0.08491829088081257 \
8.243507955452241e-07 0.09213111703448683 8.243510966667007e-07 0.1000001933597138 8.243514285865621e-07 0.1086702418150647 8.243518059053303e-07 0.1185147411083515 \
8.243522041953865e-07 0.1288888856248832 8.243526735037064e-07 0.1410822143415975 8.243532195292308e-07 0.1552200475789812 8.243538544895378e-07 0.1715918832733369 \
8.243545538901292e-07 0.1895291194622146 8.243553721290552e-07 0.2103807608661494 8.243562778230217e-07 0.2332840710921665 8.243570673340878e-07 0.253091928008631 \
8.243577710929056e-07 0.2706124241987875 8.243583889437195e-07 0.2858796548825839 8.243589545671311e-07 0.2997575097153312 8.243594763024047e-07 0.3124620269501652 \
8.243599740861211e-07 0.3244932238414255 8.243604577240811e-07 0.3360954048923613 8.243609145982153e-07 0.3469667650518959 8.243613874391094e-07 0.3581213589834248 \
8.243618270524661e-07 0.3684065070151987 8.24362314929562e-07 0.379719432411247 8.243628457299845e-07 0.3919028193132517 8.243633436253595e-07 0.4032143644097119 \
8.24363775002613e-07 0.41292177789323 8.243642618898012e-07 0.4237731225600331 8.243647619892433e-07 0.4348012155672935 8.243651066099338e-07 0.4423321287141763 \
8.243654600037777e-07 0.4500000647748709 8.243658877736169e-07 0.4592134948422093 8.243662796346881e-07 0.4675816212925634 8.243665799290445e-07 0.4739471552041949 \
8.243669218601248e-07 0.4811428413521782 8.243672651945704e-07 0.4883132334011818 8.24367525955058e-07 0.4937215836208605 8.243677680115876e-07 0.4987106167174703 \
8.243680340100556e-07 0.5041617362307154 8.243682934982395e-07 0.5094435946950286 8.243684834145396e-07 0.5132872703533161 8.243686986491409e-07 0.5176241792560061 \
8.243688371999e-07 0.5204025546691405 8.243689820806791e-07 0.5232962183003332 8.243691954947458e-07 0.5275364624051522 8.243693975193605e-07 0.5315382148201082 \
8.243695902480239e-07 0.5353370730264509 8.243697755034039e-07 0.5389735557287745 8.243699525009276e-07 0.5424323215059959 8.243702617642633e-07 0.5484573594957171 \
8.243705229123106e-07 0.5535233414883098 8.243708247314805e-07 0.5593562770234363 8.243710801601219e-07 0.5642781701956761 8.243713725156194e-07 0.5698968483756405 \
8.243716319698132e-07 0.5748654731717864 8.243719020897901e-07 0.5800301911327002 8.243721441003478e-07 0.5846380733684551 8.243724016101459e-07 0.5895273573494454 \
8.243726280544834e-07 0.5938057549890672 8.243728649429657e-07 0.5982619499065401 8.24373074987873e-07 0.6021962733001386 8.243732879185847e-07 0.6061670177072124 \
8.243735413972821e-07 0.6108668889270118 8.243737446929309e-07 0.6146150465592417 8.243739363811142e-07 0.6181346807088086 8.243741250074786e-07 0.6215812235468744 \
8.243743123254166e-07 0.6249823889551316 8.243745179374062e-07 0.6286953279350977 8.243747677606248e-07 0.6331759959753138 8.243749715724035e-07 0.6368063379741715 \
8.243751792111212e-07 0.6404826298163093 8.24375371862737e-07 0.6438748386876914 8.243756164748104e-07 0.6481531432733096 8.243758643733136e-07 0.6524620620600715 \
8.243760442082187e-07 0.6555644139995785 8.243762349822552e-07 0.6588391718544121 8.24376388158437e-07 0.6614554104590837 8.243765598271468e-07 0.6643705886591137 \
8.243767102939677e-07 0.6669108747194671 8.243768468979714e-07 0.6692010654183506 8.243769963383726e-07 0.6716954191563786 8.243771240725235e-07 0.6738189269502312 \
8.2437726394477e-07 0.6761323074508511 8.243773880219049e-07 0.6781756764962316 8.243775193832699e-07 0.6803315871556701 8.243776435547311e-07 0.6823627547057004 \
8.243777813315919e-07 0.6846081866267727 8.243779015758122e-07 0.6865586181592046 8.243780436284175e-07 0.6888545186016138 8.243781438561225e-07 0.6904668682779994 \
8.243782651601134e-07 0.6924123325129877 8.243783561353879e-07 0.6938641504265992 8.243784535186708e-07 0.695411869780077 8.24378550601538e-07 0.6969507228893711 \
8.243786398841584e-07 0.6983595753378042 8.243787378559428e-07 0.699898781449533 8.243788681310304e-07 0.7019319515314388 8.243790215432551e-07 0.7043083163565919 \
8.243791571090671e-07 0.7063909659299702 8.24379301449562e-07 0.708591461371511 8.243794273204452e-07 0.710496752775434 8.243795523478311e-07 0.712376488910674 \
8.243796666301914e-07 0.7140841686551523 8.243797776133356e-07 0.7157331888171029 8.243798773084045e-07 0.7172065512867005 8.243800143526226e-07 0.7192196995505324 \
8.243801333798347e-07 0.7209572005600779 8.24380253677943e-07 0.7227029412191364 8.243803801768633e-07 0.7245276185835638 8.243805041084668e-07 0.7263044524160376 \
8.243806283948001e-07 0.7280754330070212 8.243807547599529e-07 0.7298652243312684 8.243808845716945e-07 0.7316925631262517 8.243810084102137e-07 0.7334254795816325 \
8.243811411911006e-07 0.735272086289578 8.243812420423057e-07 0.7366670415914529 8.243813552339755e-07 0.738224777043618 8.243814420199562e-07 0.7394137384482823 \
8.243815586452529e-07 0.7410021813026957 8.243816479345105e-07 0.7422110784210975 8.243817591113937e-07 0.7437075443329063 8.243818883701577e-07 0.7454347509364776 \
8.243820022291937e-07 0.7469455276109591 8.243821066334057e-07 0.74832188588007 8.243822310004373e-07 0.7499498655229884 8.243823782406159e-07 0.7518616907275563 \
8.243824985209068e-07 0.753411006437983 8.243826144254458e-07 0.7548933175676444 8.243827545012897e-07 0.7566706674475765 8.243828971129601e-07 0.7584645678799224 \
8.243830150672032e-07 0.7599365027959469 8.243831418837122e-07 0.7615071445339606 8.243832827668562e-07 0.7632375905494565 8.243834025603536e-07 0.7646969139886852 \
8.243835475192107e-07 0.7664484133613445 8.243836690779963e-07 0.7679052725436226 8.243837881174897e-07 0.7693214142140735 8.243839097488532e-07 0.7707575700077021 \
8.243840377178316e-07 0.772256936813787 8.243841469330139e-07 0.7735272422640712 8.243842718238923e-07 0.774969549136603 8.24384378939953e-07 0.7761978171588899 \
8.243845121931473e-07 0.7777146071439789 8.243846392965932e-07 0.7791497354387434 8.243847610475684e-07 0.7805132846941326 8.243848776321507e-07 0.7818078758210534 \
8.243849834597529e-07 0.7829735233300771 8.243851228258954e-07 0.7844949153190801 8.243852718976943e-07 0.786105286864636 8.24385419626362e-07 0.7876841235632186 \
8.243855389322396e-07 0.7889471147195867 8.243856729390521e-07 0.7903527806482344 8.243857933652268e-07 0.791604423795974 8.243859349104043e-07 0.7930616786923709 \
8.243860823364167e-07 0.7945638089648995 8.243862068109251e-07 0.7958198087139573 8.243863258549181e-07 0.7970105506108808 8.243864374452017e-07 0.7981174590942314 \
8.243865426744904e-07 0.7991530841216606 8.24386638185594e-07 0.8000862307887144 8.243867742475476e-07 0.8014036057482816 8.243868911236815e-07 0.8025237700417888 \
8.243870102773537e-07 0.8036549841722296 8.24387132589548e-07 0.8048050501807249 8.243872558616217e-07 0.8059526272620129 8.243873823583983e-07 0.8071184350969989 \
8.243875078610622e-07 0.8082633544790385 8.243876385869669e-07 0.8094437311890262 8.243877641549386e-07 0.8105658358439867 8.243878932098036e-07 0.8117072367686948 \
8.243879990659606e-07 0.8126345588578442 8.243881002348366e-07 0.8135133322873783 8.243881948546565e-07 0.8143286754242188 8.243883191357402e-07 0.8153900871385379 \
8.243884088474262e-07 0.816149614585347 8.243885078849502e-07 0.8169816577628611 8.243886456628271e-07 0.8181280288377792 8.243887801986772e-07 0.81923501721715 \
8.243888886049435e-07 0.8201180631035904 8.243890385184474e-07 0.8213254631869725 8.243891890970255e-07 0.8225223201378843 8.243893145921802e-07 0.8235077122548546 \
8.243894584387069e-07 0.8246238332260477 8.243895830219706e-07 0.8255790649890803 8.243897318751913e-07 0.8267066458678887 8.24389868023775e-07 0.827725029289517 \
8.243899930476023e-07 0.8286494160599757 8.243901107545823e-07 0.8295103773055483 8.243902563935804e-07 0.8305630309532103 8.243904227748753e-07 0.8317484146982921 \
8.243905533585645e-07 0.8326660250626342 8.243907268806749e-07 0.8338683097812621 8.243908950025775e-07 0.8350147136930499 8.243910648651803e-07 0.8361549927788252 \
8.243912457668832e-07 0.8373497079260466 8.24391388876165e-07 0.8382806519784776 8.24391502965127e-07 0.839013953006387 8.243916331276035e-07 0.8398410866028793 \
8.243917349727342e-07 0.8404811280669765 8.243918517989402e-07 0.8412075886390841 8.243919886903802e-07 0.8420483852080155 8.243921864976039e-07 0.843243620449199 \
8.243923781227505e-07 0.8443797466267589 8.243925875546179e-07 0.8455974227529048 8.243927695012999e-07 0.8466352798309468 8.243929666301539e-07 0.8477391449715804 \
8.243931399710143e-07 0.8486924050423899 8.243933229793209e-07 0.8496814535024207 8.243934941423556e-07 0.8505903669473519 8.243936687794505e-07 0.851501688465695 \
8.243938440392814e-07 0.8524001683007644 8.243940201897297e-07 0.8532872510191711 8.243942104700294e-07 0.8542278331088334 8.243944010691599e-07 0.8551519386507073 \
8.243946016923949e-07 0.8561055033533737 8.2439479430095e-07 0.8570028516027762 8.243950049816413e-07 0.8579644845832216 8.243952330831088e-07 0.8589827023971403 \
8.243954988710915e-07 0.860139640227508 8.243957974838521e-07 0.8614018215255795 8.243960737724907e-07 0.8625348754565382 8.243963580090103e-07 0.8636666213345715 \
8.243966322137804e-07 0.8647267940813509 8.243969044486385e-07 0.8657495569722869 8.243971746527799e-07 0.8667361702337206 8.243974318083905e-07 0.867649441901348 \
8.24397704388604e-07 0.8685908808535525 8.2439798037489e-07 0.8695169452638583 8.24398250477721e-07 0.870397355937691 8.243985503347982e-07 0.8713451925332844 \
8.243989213624563e-07 0.8724761722512941 8.243992162997666e-07 0.8733433185969293 8.243994705892065e-07 0.8740690226522811 8.243997688459906e-07 0.874895168896023 \
8.244000424554269e-07 0.8756299040683481 8.244002785839136e-07 0.8762466977562872 8.244005189298273e-07 0.8768585021646264 8.244007412634921e-07 0.8774104263690854 \
8.244009352691695e-07 0.8778812671168952 8.244012649918855e-07 0.8786590883967833 8.244014201653189e-07 0.8790156160651978 8.244017379413894e-07 0.8797272612331356 \
8.244019168030317e-07 0.8801171459162566 8.244022592648612e-07 0.8808425821290963 8.244024433930207e-07 0.881221400612852 8.244029182707539e-07 0.8821634994206867 \
8.24403085666965e-07 0.8824839765989225 8.244035515089056e-07 0.8833452998114757 8.244037323309576e-07 0.8836679564577563 8.244042263693832e-07 0.8845176198113115 \
8.244043677180069e-07 0.8847523712107549 8.244049740520726e-07 0.8857188576377059 8.244051261213959e-07 0.8859512996759633 8.244057728095585e-07 0.8868983431897121 \
8.2440590110417e-07 0.8870786909355212 8.244065492212318e-07 0.8879538337624689 8.244066790202949e-07 0.8881220828502663 8.244074572237723e-07 0.8890807033877333 \
8.24407572278734e-07 0.8892148977954012 8.244084279402064e-07 0.8901543051721961 8.244085733010757e-07 0.8903040038307473 8.244095590571272e-07 0.8912446482480114 \
8.244097801624957e-07 0.8914382978987679 8.244109252894234e-07 0.8923659558950503 8.244110565064392e-07 0.8924678262926897 8.244123977150129e-07 0.8934599079028542 \
8.244125491142719e-07 0.8935646301988298 8.244140305519948e-07 0.8944937559627255 8.24414269431373e-07 0.8946275407274444 8.244160387469791e-07 0.8955013787854181 \
8.244164278981914e-07 0.8956696032899972 8.244188215611417e-07 0.8965547188539188 8.244192972701398e-07 0.8967039926079825 8.244233604302104e-07 0.8977020505850396 \
8.24423851854269e-07 0.8977948037134476 8.244321684538219e-07 0.898787348739254 8.244330883529499e-07 0.8988506593152591 8.245765735834803e-07 0.8998476076348748 \
8.245776920164556e-07 0.8998537475785264 8.247827836359558e-07 0.898985773748599 8.247830107254573e-07 0.8988224379910277 8.247846203322555e-07 0.8978282360369357 \
8.247847977407988e-07 0.8977338482811539 8.248017048890995e-07 0.8987315468430059 8.248018143281978e-07 0.8987460089186867 8.248175950494439e-07 0.8997418097871094 \
8.248178913753395e-07 0.8997476966799167 8.25301325027745e-07 0.9007060148833608 8.253014540780854e-07 0.9008313386292994 8.253021042279306e-07 0.9016292186224167 \
8.253022937236613e-07 0.9019133038041363 8.253027969456399e-07 0.9027675859898705 8.253029324182996e-07 0.9030208676018907 8.253033328770163e-07 0.9038195223753869 \
8.253034648149532e-07 0.9040958310886574 8.253038660300166e-07 0.9049509627747726 8.253039642901936e-07 0.9051582028152527 8.253044301640043e-07 0.9060587574877488 \
8.253045916627274e-07 0.9063060456044927 8.253057356752504e-07 0.9055153668657776 8.253058806545959e-07 0.9049059606760256 8.253060592073535e-07 0.9039396653125833 \
8.253062394026312e-07 0.9027054491383806 8.253063820935605e-07 0.9015369228101149 8.253064992531645e-07 0.9004524619440171 8.253065882345255e-07 0.8995505656965809 \
8.253066798781777e-07 0.8985529714258781 8.253068129901104e-07 0.8969831049011855 8.253069067111928e-07 0.8957895978311226 8.253069978500018e-07 0.8945634483845346 \
8.253071111423132e-07 0.8929516940777753 8.253072142512258e-07 0.8913998138690341 8.253073105184064e-07 0.8898830246517148 8.253074296555228e-07 0.8879200664089764 \
8.253075982407715e-07 0.8849885378698126 8.253077600122728e-07 0.8820195265790133 8.253079532313317e-07 0.8782956415026882 8.253081387944432e-07 0.8745571577041361 \
8.253083490607478e-07 0.8701566079887386 8.253085313097886e-07 0.8662213066841463 8.253087161731833e-07 0.8621339172744639 8.253088888583302e-07 0.8582419637438897 \
8.253090749664033e-07 0.8539816046497358 8.253092527824914e-07 0.849858603441091 8.253094334990722e-07 0.8456251963850057 8.253095986373312e-07 0.8417258760277182 \
8.253097639114333e-07 0.837798995916667 8.253099271590958e-07 0.8339004324287677 8.253100857493695e-07 0.8300982805770993 8.253102626737714e-07 0.8258418712800655 \
8.253104591875838e-07 0.8211009660847696 8.253106267441254e-07 0.8170498602679914 8.253107934845439e-07 0.8130123908857781 8.253109679080616e-07 0.8087844286215062 \
8.253111372776842e-07 0.8046757316210446 8.253113054767785e-07 0.8005936994537799 8.25311494325046e-07 0.7960093488074458 8.253116851408819e-07 0.7913773844868103 \
8.253118935230917e-07 0.7863203192056716 8.25312119942597e-07 0.7808277108969495 8.253123091427939e-07 0.7762391340290878 8.253125192894832e-07 0.7711455503222944 \
8.253126680579874e-07 0.7675418410361046 8.25312799050976e-07 0.7643705172588006 8.25312936616212e-07 0.7610417440783073 8.253130423674414e-07 0.7584842184275663 \
8.253131771410751e-07 0.7552262509102785 8.253132889738004e-07 0.7525244432456109 8.253134184089644e-07 0.7493992292091655 8.253135735976882e-07 0.7456545577979357 \
8.253136852334406e-07 0.7429626190147979 8.253138448080548e-07 0.7391166470929011 8.253140201296881e-07 0.7348935218456193 8.253142325051509e-07 0.7297828120356423 \
8.253144253876788e-07 0.7251458607116523 8.253145820889711e-07 0.7213823872711312 8.253147687636618e-07 0.716903961299824 8.253149576500111e-07 0.7123775767926828 \
8.253151485342027e-07 0.70780884692282 8.253153352821382e-07 0.7033444557767304 8.253155183669542e-07 0.698972331957095 8.253156556859354e-07 0.6956951921588121 \
8.253158089288925e-07 0.6920418367118417 8.253160040575431e-07 0.6873949992893974 8.253161613518717e-07 0.6836535194673684 8.253163207464669e-07 0.6798660670227984 \
8.253165164902601e-07 0.6752219404489795 8.253167086893939e-07 0.6706682621108646 8.253169436410222e-07 0.6651105611269369 8.2531713111727e-07 0.6606839627962382 \
8.253173683544038e-07 0.6550894036851447 8.253175575343661e-07 0.6506361170423679 8.253177381501784e-07 0.6463915264929231 8.253179018447415e-07 0.6425504277539856 \
8.253180463961503e-07 0.6391628119244788 8.2531818686792e-07 0.6358764726647652 8.253183139687074e-07 0.6329064225879303 8.253184462761835e-07 0.6298198307262635 \
8.253185728632297e-07 0.626870110582017 8.253187034434976e-07 0.62383130535404 8.253188327128966e-07 0.6208285625908692 8.253189718197929e-07 0.6176004736356133 \
8.253191203301029e-07 0.6141606483517721 8.253193098786582e-07 0.6097777958748198 8.253194555819145e-07 0.6064170107178907 8.253196906324778e-07 0.601007464699683 \
8.253198736317493e-07 0.5968099615921 8.253200979734226e-07 0.5916778694808832 8.253202691466717e-07 0.5877753019413697 8.253204014804908e-07 0.5847634284691802 \
8.253205332770303e-07 0.5817721407249107 8.253206398209335e-07 0.5793579518205488 8.25320735711292e-07 0.5771868999037388 8.253208282115419e-07 0.5750974572268882 \
8.253209206389049e-07 0.5730134868920421 8.253209930672116e-07 0.5713818265150021 8.253210487963169e-07 0.5701269325864891 8.253211099054045e-07 0.5687522410723198 \
8.253212066700799e-07 0.5665806864277688 8.253212681615945e-07 0.5652027770813386 8.253213272142164e-07 0.5638802801505602 8.253214028408818e-07 0.5621878686488651 \
8.253214698636602e-07 0.5606896577364279 8.253215434607697e-07 0.5590483558003441 8.253216110667724e-07 0.5575429304381756 8.253217271358288e-07 0.5549610936632026 \
8.253218273422345e-07 0.5527359403974305 8.253219393494244e-07 0.5502565947066531 8.253220338414751e-07 0.5481686943853854 8.253221549961725e-07 0.5454955387196141 \
8.253222551839388e-07 0.5432910220514219 8.253223711744508e-07 0.5407443765731218 8.253224788782884e-07 0.5383833065966291 8.253225884569768e-07 0.5359861028148916 \
8.253227005784207e-07 0.5335400310751951 8.253228275156047e-07 0.5307765704644959 8.253229496651232e-07 0.5281221248815906 8.253230894260376e-07 0.525095489155881 \
8.253232265641538e-07 0.522132778766487 8.253233765292441e-07 0.5189020692106626 8.253235353022474e-07 0.5154923220538846 8.253237093279043e-07 0.511765695450105 \
8.25323896158028e-07 0.5077823379664483 8.253241011259935e-07 0.5034264211640872 8.253243238349422e-07 0.4987133299464507 8.253245767391391e-07 0.4933874474923696 \
8.25324811693046e-07 0.4884604410272814 8.253251079613078e-07 0.4822828691822955 8.253253977512662e-07 0.4762763831984252 8.253257040870848e-07 0.4699660956099861 \
8.253260164056119e-07 0.4635767846525711 8.253263549710683e-07 0.4566963260653934 8.25326678082485e-07 0.4501741115777416 8.253270164777878e-07 0.4433881855507311 \
8.253273403090533e-07 0.4369378830387565 8.25327664703474e-07 0.4305204627449936 8.253280076377602e-07 0.4237851826852676 8.253283469185779e-07 0.4171698123421442 \
8.253286863932124e-07 0.4105997181257849 8.253291295050583e-07 0.4020958655332711 8.253294915732268e-07 0.3952155038183801 8.253298121249644e-07 0.3891775711374149 \
8.253301990595345e-07 0.3819561902961204 8.253305269297949e-07 0.3758957719299574 8.253308120888516e-07 0.3706704968427373 8.253311304576464e-07 0.3648820026298218 \
8.253314132885732e-07 0.3597820188690578 8.253316419773369e-07 0.3556924369094372 8.253318598701416e-07 0.3518226517641353 8.253320551194862e-07 0.3483769517668343 \
8.253322620275856e-07 0.344751588202948 8.253324768243417e-07 0.3410137651016431 8.253327290508921e-07 0.3366564674340092 8.253329710462048e-07 0.3325077909124976 \
8.253332018984844e-07 0.3285822460490526 8.253334167466747e-07 0.3249550452085373 8.253336371033643e-07 0.3212604562488142 8.253338386742641e-07 0.3179050685021769 \
8.253340417582106e-07 0.3145531374773136 8.253342396555968e-07 0.3113121771742085 8.253344267548364e-07 0.3082694484595072 8.253346206551795e-07 0.3051385396431291 \
8.253348257035143e-07 0.3018527636900292 8.253350059382659e-07 0.2989872106339772 8.253352418362775e-07 0.2952669081535775 8.253354431238274e-07 0.2921198200609627 \
8.253356445146313e-07 0.2889965001417216 8.253358691637942e-07 0.2855437159941698 8.253360345437677e-07 0.2830223598911593 8.253362123481056e-07 0.280330186126118 \
8.253363960043191e-07 0.277570343839212 8.253365812460764e-07 0.2748090658167894 8.253367593914542e-07 0.2721781298892599 8.253369329835173e-07 0.2696316866093095 \
8.253370933483699e-07 0.267306655456324 8.253372144595526e-07 0.2655585721882695 8.253373676543406e-07 0.2633570345323199 8.253374949857891e-07 0.2615475749425888 \
8.253375983136283e-07 0.2600830587034867 8.25337715638424e-07 0.2584225376281647 8.253378334453812e-07 0.2567591557214636 8.253379574091473e-07 0.2550199666844239 \
8.253380743933138e-07 0.2533821414201824 8.253382051894416e-07 0.2515535495016885 8.253383223995523e-07 0.2499173892700276 8.253384756526766e-07 0.2477853623028658 \
8.253386111831973e-07 0.2459029165157107 8.253387428644058e-07 0.244074199323236 8.253388994573169e-07 0.2419017673596028 8.253390246538746e-07 0.2401755227310949 \
8.253391603715014e-07 0.2383060149301216 8.253392927986628e-07 0.2364844144139329 8.253394127723238e-07 0.2348355337769661 8.253395758201609e-07 0.232606585912384 \
8.253397146272525e-07 0.230713852557009 8.253398531009718e-07 0.2288300961780371 8.253399586457212e-07 0.2273962817971701 8.253400870074011e-07 0.2256537837490921 \
8.253401911350241e-07 0.2242444877898851 8.25340291651026e-07 0.222886569499566 8.253403666954021e-07 0.2218745444235658 8.253404440284576e-07 0.2208349692306942 \
8.253405187916369e-07 0.2198305887827458 8.253405967553143e-07 0.218785487158918 8.253406516218243e-07 0.2180503923904892 8.253407081185998e-07 0.2172938400168352 \
8.253407515721192e-07 0.2167123195211523 8.253407916131654e-07 0.2161767335077376 8.253408308521132e-07 0.2156521099473339 8.253408717263501e-07 0.2151058606261434 \
8.253409258788401e-07 0.2143825797409383 8.253409642959715e-07 0.2138698309421548 8.253410035846784e-07 0.2133480458229882 8.253410651213864e-07 0.2125332203444249 \
8.253411270989154e-07 0.2117131287842428 8.253411835756643e-07 0.2109664019951111 8.253412482072544e-07 0.2101124842966758 8.25341343715876e-07 0.2088522205996687 \
8.253414310316075e-07 0.207701294711168 8.253415276412079e-07 0.2064291756790013 8.253416248707623e-07 0.2051510266126755 8.253417257178229e-07 0.2038307158897115 \
8.253418263175944e-07 0.2025192706911573 8.253419228088913e-07 0.2012627769767186 8.253420249910648e-07 0.1999338657614989 8.253421286307215e-07 0.1985898465970496 \
8.253422384047342e-07 0.1971698847140261 8.253423475797596e-07 0.1957617939809042 8.253424676778516e-07 0.1942174441246506 8.253425776973761e-07 0.1928086337505992 \
8.253426858092848e-07 0.1914295694688549 8.253428088379843e-07 0.1898652723262108 8.253428989485537e-07 0.1887234630454603 8.253430063140445e-07 0.1873671680421656 \
8.253430831253526e-07 0.1864004060894758 8.253431665706206e-07 0.1853535952511875 8.253432561024323e-07 0.1842338297700716 8.253433406678984e-07 0.1831790839553313 \
8.253434203840387e-07 0.1821880912968773 8.253435217092421e-07 0.1809331989518758 8.253436300564713e-07 0.1795959386230563 8.253437265321694e-07 0.1784102562612937 \
8.25343851909986e-07 0.1768766438339704 8.253439846934562e-07 0.1752616821119887 8.253441024642794e-07 0.1738362801839788 8.253442481158562e-07 0.1720835746408261 \
8.253443587130081e-07 0.1707596463148658 8.253445008434469e-07 0.1690680578777541 8.253446165530702e-07 0.1676985735146403 8.253447220270832e-07 0.166456424915798 \
8.253448165437425e-07 0.1653485352650968 8.253449121811145e-07 0.1642320043563913 8.253450092529584e-07 0.1631032360400927 8.253451083042124e-07 0.161956192050434 \
8.253452022277692e-07 0.1608730077890209 8.253452875034442e-07 0.1598934595213354 8.253453878832364e-07 0.1587475631033795 8.253454721860728e-07 0.1577906478848196 \
8.253455745855819e-07 0.1566342854655733 8.253456519798444e-07 0.1557646215197878 8.253457443247582e-07 0.154731814591042 8.253458145762303e-07 0.1539498814072817 \
8.253459107506593e-07 0.1528844393027091 8.253459875753224e-07 0.152038051282755 8.253460663454742e-07 0.1511758489440315 8.253461402383946e-07 0.150370438825067 \
8.253462079361381e-07 0.1496353997608715 8.25346304000026e-07 0.1485973848112393 8.25346373572453e-07 0.1478489919002561 8.253464574616254e-07 0.1469503328160803 \
8.253465185934615e-07 0.146298213254472 8.25346590861543e-07 0.1455309799806117 8.253466633001062e-07 0.1447677488542132 8.253467442811468e-07 0.1439178685120187 \
8.253468103556157e-07 0.1432275520600639 8.253468877561137e-07 0.1424219220725307 8.253469771315706e-07 0.1414956876531561 8.253470479922162e-07 0.1407644282175171 \
8.253471468792833e-07 0.1397487730030469 8.253472241981923e-07 0.1389620820751095 8.253473062434185e-07 0.1381330876879582 8.2534739435453e-07 0.1372467208126059 \
8.25347461981677e-07 0.1365690714953818 8.253475422788589e-07 0.1357674830239305 8.253476170628882e-07 0.1350239185327315 8.253476850640654e-07 0.1343502586094245 \
8.253477317469739e-07 0.1338891847862563 8.253478209985673e-07 0.1330118383700247 8.253478592216168e-07 0.1326395291833771 8.253479282135268e-07 0.1319690872918072 \
8.253479809615962e-07 0.1314578750898332 8.253480639543784e-07 0.1306559489775353 8.253481041328287e-07 0.1302688434457458 8.253481966502028e-07 0.1293805059784019 \
8.253482353685699e-07 0.1290098403727171 8.25348309129285e-07 0.1283055160094505 8.253483707572867e-07 0.1277188748199021 8.253484427849764e-07 0.1270353589407805 \
8.25348510952008e-07 0.1263909833196726 8.253485855741692e-07 0.1256908956540175 8.253486674266349e-07 0.1249253613889138 8.253487508807972e-07 0.124147338931438 \
8.253488238325109e-07 0.1234692772477456 8.253488965594407e-07 0.122795332839617 8.253489565494355e-07 0.1222410931008323 8.253490429174471e-07 0.121445549533078 \
8.253491038861646e-07 0.1208856452315438 8.253491622719555e-07 0.1203507897957366 8.253492279066197e-07 0.119751336354628 8.253492872608612e-07 0.1192111367930785 \
8.253493552926419e-07 0.1185941868697126 8.25349452587012e-07 0.11771710490035 8.253495310789917e-07 0.1170124163111649 8.25349621315123e-07 0.1162055395685231 \
8.253497171618085e-07 0.1153523005684616 8.253497921195047e-07 0.1146878351828532 8.253498964789212e-07 0.1137670532163148 8.25349983267518e-07 0.1130053589403202 \
8.253500929249339e-07 0.1120476726212376 8.253501744789968e-07 0.1113387926087848 8.253502700926292e-07 0.1105114393564785 8.253503468048225e-07 0.10985058581598 \
8.253504417232868e-07 0.1090364400125625 8.253505175463918e-07 0.1083889268999046 8.253505952460493e-07 0.1077282965354292 8.253506775775e-07 0.1070311517075373 \
8.253507371427637e-07 0.1065286079538068 8.253508009005013e-07 0.1059924133642201 8.253508619951088e-07 0.1054803128126646 8.253509578588471e-07 0.1046801683739134 \
8.253510027219415e-07 0.1043071445723913 8.253510859626871e-07 0.1036173314376927 8.25351135082509e-07 0.1032117000904133 8.253512441312713e-07 0.1023149933518279 \
8.253512889673534e-07 0.1019479364619093 8.253513792285847e-07 0.1012117400678687 8.25351420105203e-07 0.1008795969612472 8.25351490563617e-07 0.1003088525914566 \
8.253515768510382e-07 0.09961307626065434 8.253516686285973e-07 0.09887705578174606 8.253517381566897e-07 0.09832225024344161 8.25351816683849e-07 0.09769854072774181 \
8.253519074125254e-07 0.09698178745350861 8.253519832286639e-07 0.09638605854785212 8.253520652414071e-07 0.09574500473888557 8.253521469944435e-07 0.09510943278387665 \
8.253522375022672e-07 0.09440967388330095 8.253523270615646e-07 0.09372126988887708 8.253524126713984e-07 0.09306698857649189 8.253525054508964e-07 0.09236212353634379 \
8.25352586338857e-07 0.0917510971760913 8.253526874678274e-07 0.09099177263830999 8.253527679613525e-07 0.09039108594384238 8.253528522042178e-07 0.08976589684797046 \
8.253529260492652e-07 0.08922077348043934 8.253530028987434e-07 0.08865632925481931 8.253530910391124e-07 0.08801255002475737 8.253531711034816e-07 0.08743108261130086 \
8.253532641396717e-07 0.08675939571108145 8.253533821403849e-07 0.08591369538214398 8.253535245136123e-07 0.08490278100234279 8.253536687619621e-07 0.08388867104764453 \
8.253538110896711e-07 0.08289807427203813 8.253539606674147e-07 0.08186746790234835 8.253540969811605e-07 0.08093761126893445 8.253542391015918e-07 0.0799778356000513 \
8.253543736550196e-07 0.07907840240745091 8.253545140077295e-07 0.07814980287393705 8.253546616898023e-07 0.0771833418413561 8.253548118052992e-07 0.07621180464723754 \
8.253549765257764e-07 0.07515824360926991 8.25355140155128e-07 0.07412455432658185 8.25355314933688e-07 0.07303438636984133 8.253555021863042e-07 0.07188220095900363 \
8.253557122313082e-07 0.07060976590783831 8.253559304415312e-07 0.06930979572898451 8.253561638986196e-07 0.06794333957253913 8.253564187446379e-07 0.06648001693367038 \
8.253567118391949e-07 0.06483321328442151 8.253570141789572e-07 0.06317411115207273 8.253573287658325e-07 0.06148945259513613 8.253577250265267e-07 0.05942677493938087 \
8.253580587436719e-07 0.05774249301432461 8.253584660545011e-07 0.05574994498853819 8.253587939392599e-07 0.05419380357502902 8.25359150629899e-07 0.05254809000207299 \
8.253594638680598e-07 0.05114243792209583 8.25359766835193e-07 0.04981740498512215 8.253600643757185e-07 0.04854875663330436 8.253603431552737e-07 0.04739109061078805 \
8.253606261551693e-07 0.04624570307560639 8.253608878954772e-07 0.04521055793698023 8.253611671343698e-07 0.04413130357485813 8.253614392402902e-07 0.0431040186124033 \
8.253617466070471e-07 0.04197194005652995 8.253619684099479e-07 0.04117329707315532 8.253622748704283e-07 0.04009446155587663 8.253625010598812e-07 0.03931650950691581 \
8.253627399772065e-07 0.03851359500741255 8.253629644010393e-07 0.03777663690506906 8.253631666633204e-07 0.03712468825868943 8.253633677059489e-07 0.03648814235703791 \
8.253637194799833e-07 0.03540095449820539 8.253639697258209e-07 0.03464776841732944 8.253642160441007e-07 0.03392252499723709 8.253644973769646e-07 0.03311308780599518 \
8.253647404679503e-07 0.03242954897046491 8.253649759417007e-07 0.03178112583711486 8.25365217601206e-07 0.03113119522156456 8.253654544834836e-07 0.03050988948014832 \
8.25365685016041e-07 0.02991733361391674 8.253658989845686e-07 0.02937801894285819 8.253661049271157e-07 0.02886851641492237 8.253664976516027e-07 0.02792196059063811 \
8.25366685729283e-07 0.02747992420741849 8.253670611682489e-07 0.02661861215736662 8.253672360424774e-07 0.02622659266649364 8.253676593654916e-07 0.02530049759795254 \
8.253677806148756e-07 0.02504150687334681 8.253682211765282e-07 0.02412433837770948 8.253683636746476e-07 0.02383402682615681 8.253686957281575e-07 0.02316883068419595 \
8.25368878693682e-07 0.02280879143785283 8.25369267997886e-07 0.02205689891561978 8.253694363435941e-07 0.02173705378531499 8.253699084579933e-07 0.02085107653961301 \
8.253700482027269e-07 0.0205916297664938 8.253705437828047e-07 0.01969297428531048 8.253706710082374e-07 0.01946923320191776 8.253712389173419e-07 0.01851512288677271 \
8.253714031712902e-07 0.0182513999453204 8.253720130430286e-07 0.0173209960017622 8.253721727282571e-07 0.01708922829277545 8.253726996397978e-07 0.01635462467776483 \
8.253729041570907e-07 0.01608193551804103 8.253736276344778e-07 0.01515939662837778 8.253737930766099e-07 0.01495683325581705 8.253745396363563e-07 0.01408081084911163 \
8.253746729395689e-07 0.01393008075245666 8.253755331241552e-07 0.01299799962960837 8.2537566920557e-07 0.01285670227674402 8.253766097994594e-07 0.01192267652923807 \
8.253767735725333e-07 0.01176632439256516 8.253777747514646e-07 0.01084959205883911 8.253779122291873e-07 0.01072929995296418 8.253790829267985e-07 0.009787962024485789 \
8.253791753231659e-07 0.009718668544398181 8.253805933990138e-07 0.008725931027897449 8.253806803751621e-07 0.00866912727384293 8.253822213707925e-07 0.00770199130002063 \
8.253823306868067e-07 0.007633428668288294 8.253839739346292e-07 0.006673746291950173 8.253841067919082e-07 0.006603544020797993 8.253862011722062e-07 0.005605323336654431 \
8.25386409576941e-07 0.00551468736035817 8.25388763913366e-07 0.004577307911602986 8.253892374721228e-07 0.004407121484391641 8.253921229089796e-07 0.003492041675788492 \
8.253926525733265e-07 0.00334538389506189 8.253968608005518e-07 0.00237996320858989 8.253973742348032e-07 0.002283557532494709 8.254031334854955e-07 0.001325291758975802 \
8.254033680667129e-07 0.001279502680325907 8.254180358940878e-07 0.0002809017338477542 8.2541814896418e-07 0.0002788534805396912 8.280551690439302e-07 -0.0006849217749926401 \
8.280553352056057e-07 -0.0009443270389602415 8.28055814074993e-07 -0.001850320037528519 8.280559067946197e-07 -0.002050462221988249 8.280562720196971e-07 -0.002913187630468476 \
8.280563636768137e-07 -0.00314709230904735 8.280567297831652e-07 -0.004133001189868674 8.280568399302907e-07 -0.004442309109773816 8.280571506685428e-07 -0.005311341427314526 \
8.280572524071878e-07 -0.005583925258601597 8.280576161113131e-07 -0.00638370916272213 8.280577809576365e-07 -0.006585924750287024 8.280583607549565e-07 -0.005792290386912202 \
8.280585355894154e-07 -0.004916934050781314 8.280586522790152e-07 -0.00413641027497409 8.280587787087077e-07 -0.00310656561120747 8.280588807309105e-07 -0.002137079422087956 \
8.28059000577393e-07 -0.0008406209844352954 8.280590912146293e-07 0.0002489246187367611 8.280591896346795e-07 0.001536790859923857 8.280592893583235e-07 0.002948496343048522 \
8.280594568423325e-07 0.005545701385567424 8.280596754209339e-07 0.009327395936412004 8.280598614912559e-07 0.0128572688386996 8.280600828738638e-07 0.01737012273305725 \
8.280602435339974e-07 0.02082840415615294 8.28060406999647e-07 0.02447866954313523 8.280605576351642e-07 0.02794359528291388 8.280607066909169e-07 0.03145289236167962 \
8.280608561536706e-07 0.03504014479003619 8.280610101846837e-07 0.03879791952579481 8.280611723009431e-07 0.04280891157365373 8.280613383304076e-07 0.04696567134311741 \
8.28061514283228e-07 0.05141478668696391 8.280616949538655e-07 0.05602187592747932 8.280618867748117e-07 0.06094655248807559 8.280620938803164e-07 0.06629309753158302 \
8.280623154520462e-07 0.07203901748582854 8.280625501862155e-07 0.07814662931008168 8.280628017257828e-07 0.08470684589377442 8.280630771678493e-07 0.09190125212984442 \
8.280633773636675e-07 0.09974607960254324 8.280637082958778e-07 0.108390578238945 8.280640839626117e-07 0.1181923833971668 8.280644815454798e-07 0.1285487285136021 \
8.280649483700823e-07 0.1406786766767902 8.280654913626172e-07 0.1547396794802719 8.280661247876399e-07 0.1710742296429572 8.280668207276906e-07 0.1889259607126788 \
8.280676362848005e-07 0.2097135943149445 8.280685463129037e-07 0.2327316641523666 8.280693395691242e-07 0.2526372689279454 8.280700450441999e-07 0.2702038474981599 \
8.280706639884678e-07 0.2855008995781749 8.280712310944079e-07 0.2994177966724069 8.28071754174414e-07 0.3121574438576628 8.280722531532068e-07 0.3242197130846058 \
8.280727371932144e-07 0.3358335658028451 8.280731924200473e-07 0.3466679577370423 8.280736669320091e-07 0.3578644504627745 8.280741068407172e-07 0.368158604789619 \
8.28074592685345e-07 0.3794271463718566 8.280751242881185e-07 0.3916316501999784 8.280756269514167e-07 0.4030538969706937 8.280760560236696e-07 0.4127111343288326 \
8.280765470403382e-07 0.4236561147984291 8.280770484704185e-07 0.434714731975362 8.280773950150088e-07 0.442288187401736 8.280777504243856e-07 0.4500000616404133 \
8.280781776521144e-07 0.4592019891792938 8.28078569851637e-07 0.4675774400278049 8.280788702333951e-07 0.4739448723400065 8.280792120451548e-07 0.4811381049525967 \
8.280795554849687e-07 0.4883107756756314 8.280798162200955e-07 0.4937186470393492 8.280800582500486e-07 0.4987071765458648 8.280803241952914e-07 0.5041573145298286 \
8.280805814645869e-07 0.509394255416739 8.280807715836905e-07 0.5132422368582924 8.280809851098511e-07 0.5175451019736222 8.280811248001571e-07 0.5203466115392713 \
8.28081271000449e-07 0.5232668091041763 8.280814849883501e-07 0.5275186200231483 8.280816930046097e-07 0.5316389396023125 8.280818854658791e-07 0.5354321131715788 \
8.280820705821105e-07 0.5390651926504321 8.280822449555567e-07 0.5424725330931349 8.280825494976334e-07 0.5484058192982523 8.280828100565151e-07 0.5534602958276967 \
8.280831114875445e-07 0.5592859190791987 8.280833658051381e-07 0.5641865993769294 8.280836586613277e-07 0.5698153316805189 8.280839178744798e-07 0.5747800306938655 \
8.280841889508118e-07 0.579963273174682 8.280844307945713e-07 0.5845680738798381 8.280846882997289e-07 0.5894577538325241 8.280849150436047e-07 0.5937419314630586 \
8.280851520444244e-07 0.5982006324572362 8.280853622309863e-07 0.6021379329905048 8.280855749915204e-07 0.6061060319396779 8.28085827870286e-07 0.6107954169450593 \
8.280860315335545e-07 0.6145509252949414 8.280862222509359e-07 0.6180531102377972 8.280864095873744e-07 0.6214768531423983 8.28086598465652e-07 0.6249070011644339 \
8.280868066654474e-07 0.6286671070650327 8.280870509975621e-07 0.6330499453121026 8.280872505640949e-07 0.6366057789565548 8.280874547098356e-07 0.6402215701419991 \
8.280876393490899e-07 0.643474671963314 8.28087908884781e-07 0.6481901084955864 8.280881365916373e-07 0.652149230294136 8.280883242633751e-07 0.6553888277830079 \
8.280885051635202e-07 0.6584949378977958 8.280886647046018e-07 0.661221510907812 8.280888351670024e-07 0.6641177016088209 8.280889869184431e-07 0.6666817235716488 \
8.28089124561455e-07 0.6689905419339194 8.280892735563185e-07 0.6714784915997724 8.280894012981822e-07 0.6736028790357499 8.280895442846951e-07 0.675968899142866 \
8.280896660677513e-07 0.6779749688503388 8.28089802351161e-07 0.6802121872853304 8.280899221800625e-07 0.682172759947357 8.280900687756233e-07 0.6845626218370968 \
8.280901872485649e-07 0.6864845934661837 8.280902831819268e-07 0.6880368302455475 8.280903757015115e-07 0.6895284278106264 8.280904807620224e-07 0.6912169000724893 \
8.280905788439078e-07 0.6927871490736753 8.280907159592253e-07 0.6949707622226827 8.280908351578679e-07 0.6968607547931925 8.280909450978383e-07 0.6985951241089645 \
8.280910825970815e-07 0.7007503743809057 8.280912140269831e-07 0.7027960765825516 8.280913462564986e-07 0.7048392108129343 8.280914594338973e-07 0.7065756917706891 \
8.280916138667517e-07 0.708927873976708 8.280917446467452e-07 0.7109048231498766 8.280918673154548e-07 0.7127465601965561 8.280919735837111e-07 0.7143329262278221 \
8.280920959637349e-07 0.7161490373358268 8.280921978172317e-07 0.7176517022913665 8.280923319551315e-07 0.7196190116794019 8.280924526481716e-07 0.7213783352064487 \
8.280925717899705e-07 0.7231049829175343 8.280926968079846e-07 0.7249059312823601 8.280928266477907e-07 0.7267645120560844 8.280929464599616e-07 0.7284691779696002 \
8.280930754532131e-07 0.730293808329565 8.280932075602773e-07 0.7321507998840678 8.280933258660953e-07 0.7338038328985433 8.280934691267862e-07 0.7357927618453034 \
8.280935715814729e-07 0.7372070005703254 8.280936677883585e-07 0.7385290937783453 8.280937728059804e-07 0.7399656334130889 8.280938835775113e-07 0.7414708009413548 \
8.280939852560522e-07 0.7428439364018735 8.280940882175065e-07 0.7442258341871242 8.280942051436606e-07 0.7457850038572696 8.280943339039365e-07 0.747489965072781 \
8.28094435062908e-07 0.7488201182152049 8.280945839319522e-07 0.7507626302114226 8.280947316114891e-07 0.75267249971878 8.280948509768551e-07 0.7542038164026367 \
8.280949974606995e-07 0.7560679527984652 8.280951206361903e-07 0.7576223900169708 8.280952614398646e-07 0.7593848990234215 8.28095398032531e-07 0.7610800595258669 \
8.280955201903811e-07 0.7625841275516777 8.280956328467786e-07 0.7639610711610054 8.280957745729196e-07 0.7656796138775311 8.280959007394198e-07 0.767196844592689 \
8.280960161567243e-07 0.768574452686535 8.280961464649039e-07 0.7701179991486644 8.280962621775717e-07 0.7714782821591826 8.280963850018603e-07 0.7729116492687436 \
8.280965028461285e-07 0.7742769236963016 8.280966084761185e-07 0.7754922619072108 8.280967238495533e-07 0.7768108638983861 8.280968291127157e-07 0.7780056027231214 \
8.28096940062529e-07 0.7792565499870431 8.280970264670305e-07 0.7802246528436213 8.280971305008505e-07 0.7813823422463088 8.28097244396594e-07 0.7826398494046257 \
8.280973474300136e-07 0.7837684443710583 8.280974555127141e-07 0.7849432998269023 8.280975637643696e-07 0.7861107422109641 8.280976991816163e-07 0.7875582910536544 \
8.280978118557238e-07 0.7887521292973186 8.280979362797841e-07 0.7900592323105087 8.28098054252648e-07 0.7912877959129118 8.280981987206026e-07 0.7927781272271259 \
8.280983163897418e-07 0.7939806363584788 8.280984522695814e-07 0.7953567374150946 8.280985870139538e-07 0.7967081403609936 8.280986980849332e-07 0.7978123285366109 \
8.280987979742731e-07 0.7987978371087655 8.280988996542306e-07 0.7997937268659365 8.280990328678971e-07 0.8010867894381996 8.280991512407162e-07 0.8022243628210853 \
8.280992727817905e-07 0.8033812848148773 8.280993921454424e-07 0.8045065422543012 8.280995132768188e-07 0.80563739819571 8.280996449762361e-07 0.8068544426691319 \
8.280997679845128e-07 0.8079795872959963 8.280998958281203e-07 0.8091371804586788 8.281000267346398e-07 0.8103101881504271 8.28100150327798e-07 0.8114062915203997 \
8.281002575003029e-07 0.8123479140825919 8.281003649295024e-07 0.8132835730547656 8.281004475986206e-07 0.8139979974227743 8.281005653103806e-07 0.8150069815425507 \
8.281006559159858e-07 0.8157770472204025 8.281007865694307e-07 0.8168774959419571 8.28100930959301e-07 0.8180800468042847 8.281010641337151e-07 0.8191766687328477 \
8.281011740251065e-07 0.8200725423139092 8.281013176239916e-07 0.8212302325252553 8.281014710146832e-07 0.8224508494407716 8.28101599092908e-07 0.8234574467428303 \
8.281017388802764e-07 0.8245431382086058 8.281018651298391e-07 0.8255122018650548 8.281020197283917e-07 0.8266841987320058 8.281021519393684e-07 0.8276738265999063 \
8.281022781661507e-07 0.8286078934539939 8.281023959138743e-07 0.8294698388787296 8.281025449866676e-07 0.8305480062617677 8.281027123182206e-07 0.8317406852496945 \
8.281028455394968e-07 0.8326770812274722 8.281030183208196e-07 0.8338744310092966 8.281031868261935e-07 0.8350236380668206 8.281033562054924e-07 0.8361608866600232 \
8.281035378407611e-07 0.8373606451951652 8.281036801740827e-07 0.8382866867625347 8.281037940110689e-07 0.8390185116470331 8.28103925192579e-07 0.8398522525089582 \
8.28104026724794e-07 0.8404903982372576 8.281041430090542e-07 0.8412135669902132 8.281042776438077e-07 0.8420406924792603 8.281044746666438e-07 0.8432316292878405 \
8.281046647721864e-07 0.8443592803112207 8.281048748954985e-07 0.8455816023960827 8.281050552136043e-07 0.8466107566581813 8.281052526767047e-07 0.8477171937062282 \
8.281054267458196e-07 0.8486750118570332 8.2810560906524e-07 0.8496608982186138 8.281057804803757e-07 0.8505716849290491 8.281059545936528e-07 0.8514808063694008 \
8.281061303246211e-07 0.8523822271368225 8.281063064363214e-07 0.8532696099472232 8.281064960541732e-07 0.8542074684498208 8.281066868356705e-07 0.8551330189126392 \
8.281068884317469e-07 0.8560917259710515 8.281070811660048e-07 0.856990088884472 8.281072900378257e-07 0.8579439907476532 8.281075207402632e-07 0.8589743400177088 \
8.281077851832272e-07 0.8601259267840322 8.281080840059149e-07 0.8613896125360476 8.281083639602158e-07 0.8625380186322354 8.281086480860816e-07 0.8636694076724545 \
8.28108922855057e-07 0.8647317823994775 8.281091947122167e-07 0.8657531067718063 8.281094650893343e-07 0.8667403371654003 8.281097221678555e-07 0.8676533221001362 \
8.281099947926866e-07 0.868594905839151 8.281102707598355e-07 0.8695208838709013 8.281105408640933e-07 0.8704012674911344 8.281108407401038e-07 0.8713491368600049 \
8.281112118011625e-07 0.8724801680184872 8.2811150674079e-07 0.8733472453740196 8.281117610365479e-07 0.8740729094291386 8.281120592974737e-07 0.8748989982677786 \
8.281123329040153e-07 0.8756336613858092 8.281125690299577e-07 0.876250392688866 8.281128093740556e-07 0.8768621356511911 8.281130317061817e-07 0.8774140071409635 \
8.28113225712247e-07 0.8778848105679672 8.281135554349973e-07 0.8786625669521169 8.281137106085255e-07 0.8790190643519731 8.281140283876061e-07 0.879730644938159 \
8.281142072488645e-07 0.8801204696806418 8.281145497107611e-07 0.8808457867651537 8.28114733837363e-07 0.8812245477320809 8.28115208711942e-07 0.8821665346129511 \
8.281153761083518e-07 0.8824869809105039 8.281158419518538e-07 0.883348261932613 8.281160227735482e-07 0.8836708855253055 8.281165168126507e-07 0.8845204537290557 \
8.28116658162059e-07 0.8847551796839913 8.281172645001218e-07 0.8857215808967022 8.281174165693362e-07 0.8859539944113424 8.281180632563559e-07 0.8869009218298172 \
8.281181915512386e-07 0.8870812460539503 8.28118839667745e-07 0.8879562712787433 8.281189694676407e-07 0.8881245027440973 8.281197476783403e-07 0.8890830197250962 \
8.281198627254718e-07 0.8892171882189283 8.281207183963142e-07 0.8901564861234483 8.281208637440773e-07 0.8903061494816453 8.281218494996487e-07 0.8912466483555094 \
8.281220706077111e-07 0.8914402669210102 8.281232157277145e-07 0.892367747196105 8.281233469391585e-07 0.8924695935232408 8.281246882116237e-07 0.8934615053489913 \
8.281248396029e-07 0.8935661991834861 8.281263210551204e-07 0.8944951400107031 8.281265599348161e-07 0.8946288932334222 8.281283293566539e-07 0.895502508848118 \
8.281287184779452e-07 0.895670668133377 8.281311122106538e-07 0.8965556062201232 8.281315877505926e-07 0.8967047758494365 8.281356508198176e-07 0.8977025964496719 \
8.281361422956534e-07 0.8977953148389237 8.281444588927963e-07 0.8987880790885289 8.281453787942481e-07 0.8988514070442593 8.282992423701678e-07 0.8998485708192639 \
8.283028854964575e-07 0.8998628537402877 8.285296142766717e-07 0.8989664306490068 8.285298446165833e-07 0.8988008565867064 8.285314595368805e-07 0.897804750401333 \
8.285316372691665e-07 0.8977103535805105 8.285484036692715e-07 0.8986978311584225 8.285485397684024e-07 0.8987160394686986 8.285637106086718e-07 0.8997133888183054 \
8.285639877135077e-07 0.899719468756186 8.290480289064218e-07 0.9005852143835333 8.290482022410388e-07 0.9007408621809421 8.290488627306383e-07 0.9015135064485434 \
8.290490287958205e-07 0.9017527716291757 8.29049555130528e-07 0.9026184054967997 8.290497462444476e-07 0.9029704910143604 8.290501104654996e-07 0.9036902342402512 \
8.290502896649215e-07 0.9040628043424317 8.290506515515937e-07 0.9048333795345931 8.290508466611638e-07 0.9052442844328937 8.290513790595253e-07 0.9062266394381637 \
8.290515614131638e-07 0.9064623886473868 8.29052553393556e-07 0.905594670761786 8.290527149341232e-07 0.9049318860608667 8.290528829265756e-07 0.9040378649110347 \
8.290530427580612e-07 0.9029782421366458 8.29053180254799e-07 0.9018984154159868 8.290533131621115e-07 0.9007052793196499 8.290534395875787e-07 0.8994328447569792 \
8.290535469868187e-07 0.8982475863895881 8.290536514834768e-07 0.8970047013543965 8.290537655331467e-07 0.8955451342423859 8.290538555027342e-07 0.8943225684615312 \
8.290539603213726e-07 0.8928208677113324 8.290540497696119e-07 0.891473284704788 8.290541321453926e-07 0.8901820884368528 8.290542232383925e-07 0.8887006634027688 \
8.290543605744705e-07 0.8863657732814155 8.290544590674027e-07 0.8846195012157601 8.290545711411527e-07 0.8825649218508906 8.290547020241858e-07 0.880080778639088 \
8.290548384952158e-07 0.8774018563482072 8.290549919493788e-07 0.8742910281085086 8.290551510437468e-07 0.8709679977889497 8.290553153276493e-07 0.867445283300377 \
8.290554719957507e-07 0.8640104344288071 8.290556240865311e-07 0.860615744772629 8.290557778002063e-07 0.857132398554192 8.290559373623814e-07 0.853469801378647 \
8.290560924510828e-07 0.8498714074018293 8.290562661304016e-07 0.8458039138600054 8.290564291612694e-07 0.8419559450883216 8.29056590803684e-07 0.8381170660338335 \
8.290567534504205e-07 0.8342344554797501 8.290569148689274e-07 0.8303657475978833 8.29057083463406e-07 0.8263109424305363 8.290572663565043e-07 0.8219002364007665 \
8.290574341852181e-07 0.8178440888239877 8.290576024710332e-07 0.8137703061148112 8.290577732990846e-07 0.8096302849976138 8.290579454736421e-07 0.8054541271740473 \
8.290581132355611e-07 0.8013830614994394 8.290582968650184e-07 0.7969255463994016 8.290584682714962e-07 0.7927646873948894 8.290586537148024e-07 0.7882638003278283 \
8.290588203854535e-07 0.7842196820467244 8.290589892715847e-07 0.7801233737411432 8.290591734278819e-07 0.7756572567105651 8.290593680379105e-07 0.7709405333854473 \
8.290595152932414e-07 0.7673736106648734 8.29059641923832e-07 0.7643079795643375 8.290597837806442e-07 0.7608754495129878 8.290598881844221e-07 0.7583505812556488 \
8.290600205770739e-07 0.7551502542766809 8.290601301612704e-07 0.7525028097975122 8.29060263325923e-07 0.7492875979647342 8.290604195076852e-07 0.7455190770546114 \
8.29060532737112e-07 0.7427887939149777 8.290606952584764e-07 0.7388718945951063 8.290608674392915e-07 0.7347246296492568 8.29061063444044e-07 0.7300078517193382 \
8.290612278340228e-07 0.7260553905833119 8.290613802307035e-07 0.7223944885043934 8.290615439058578e-07 0.718466402706526 8.29061711831558e-07 0.7144406657912139 \
8.290618916719357e-07 0.7101336212543717 8.29062067965886e-07 0.7059164985576465 8.290622390405214e-07 0.7018286413152719 8.29062407358697e-07 0.6978099102718778 \
8.290625606248286e-07 0.6941537154717222 8.290627225083983e-07 0.6902960245155986 8.290629014599385e-07 0.6860364417190952 8.290630356714899e-07 0.6828448068431195 \
8.290631391777878e-07 0.6803854168085423 8.290632384622004e-07 0.6780286039046017 8.290633399166766e-07 0.6756220912380299 8.290634323732757e-07 0.6734303711245889 \
8.29063516962075e-07 0.6714267031582685 8.290636105394115e-07 0.6692114082407524 8.290637270816306e-07 0.6664546942583044 8.290638365591918e-07 0.6638675763958631 \
8.29063949672203e-07 0.6611971533414394 8.290640727909702e-07 0.6582923426231613 8.290641970172829e-07 0.6553636581362478 8.29064367777427e-07 0.6513432847262797 \
8.290645262260143e-07 0.6476181700514572 8.290646985138371e-07 0.6435738126612673 8.290648444919037e-07 0.6401512360303271 8.290649862851196e-07 0.6368325564797357 \
8.290651178835739e-07 0.6337564355289309 8.290652480468588e-07 0.630718219665797 8.290653735717995e-07 0.6277924818644975 8.290655053547071e-07 0.6247239543970449 \
8.290656352782026e-07 0.6217046839485236 8.290657715867779e-07 0.6185408917806742 8.290659162003453e-07 0.615188962872713 8.290660756925359e-07 0.611499189008522 \
8.290662491526524e-07 0.6074939486938447 8.290664201599543e-07 0.6035554342946753 8.290666515285226e-07 0.5982402936372396 8.290668949905284e-07 0.5926661367297537 \
8.29067069111016e-07 0.5886942528256315 8.290672153830935e-07 0.5853638081576373 8.290673497553116e-07 0.58231230528805 8.290674668502066e-07 0.5796585826255305 \
8.290675626145532e-07 0.5774900935424465 8.290676614610954e-07 0.5752566196463251 8.290677454384143e-07 0.5733628024369305 8.290678230524634e-07 0.571614165956722 \
8.290678843779372e-07 0.5702331258704825 8.290679490585756e-07 0.5687779664863769 8.290680303667114e-07 0.5669528575016536 8.290680804367073e-07 0.5658306078972934 \
8.290681297572688e-07 0.5647256890740617 8.29068191677069e-07 0.5633393552914843 8.290682395088942e-07 0.5622690492396486 8.290682900136796e-07 0.5611395143522533 \
8.290683500757169e-07 0.559799205480933 8.290684093585123e-07 0.5584782058326896 8.290684844152261e-07 0.5568072508052372 8.290685540978827e-07 0.5552574373576753 \
8.290686396864491e-07 0.5533559356568912 8.290687267538207e-07 0.5514265885063823 8.290688104163413e-07 0.5495763264044081 8.290688965613662e-07 0.5476734676082877 \
8.290689922659868e-07 0.5455621222678217 8.290690965509387e-07 0.5432673229847179 8.290692112181133e-07 0.5407497407899529 8.290693199365745e-07 0.5383664115638558 \
8.290694295088142e-07 0.5359693749054023 8.290695418135745e-07 0.5335193270114367 8.290696685891956e-07 0.530759392645703 8.290697908664272e-07 0.5281021910076299 \
8.290699309524049e-07 0.5250685463469849 8.290700679697626e-07 0.5221084647952599 8.29070218271135e-07 0.5188705764247719 8.290703771663761e-07 0.5154582091324615 \
8.290705515002589e-07 0.5117250894133971 8.29070738517481e-07 0.5077378180012799 8.290709438354859e-07 0.5033745272871338 8.290711556776788e-07 0.498891131759938 \
8.29071408479721e-07 0.4935662239713107 8.290716105673699e-07 0.4893264048484654 8.290718451606752e-07 0.4844277613141263 8.290720812752721e-07 0.4795194943790256 \
8.290723344517689e-07 0.474283574581623 8.290726449817316e-07 0.4679020429045382 8.290728630397102e-07 0.4634451779596257 8.290730364853444e-07 0.4599153839204358 \
8.290732129777809e-07 0.4563351808422506 8.290734924595774e-07 0.4506930409909046 8.290737247034844e-07 0.4460279192631412 8.290740117970731e-07 0.44029020239849 \
8.290742296431808e-07 0.435960758243863 8.290744396957687e-07 0.4318042429497612 8.290746408936045e-07 0.4278406951573778 8.290748233137655e-07 0.4242617300271556 \
8.290749972087507e-07 0.4208637793449936 8.290751620728668e-07 0.4176529694331993 8.290753208268398e-07 0.4145718140694327 8.290754870737866e-07 0.4113577680628809 \
8.290756357189934e-07 0.4084923702366076 8.29075788087249e-07 0.4055658186126443 8.290759301504317e-07 0.4028468403491589 8.290760995263099e-07 0.3996150665462138 \
8.290762199082301e-07 0.3973276483660343 8.290763298814939e-07 0.3952449223617059 8.290764448068948e-07 0.3930732253581283 8.29076597048475e-07 0.3902080468194818 \
8.290767092695402e-07 0.3881039677199808 8.290768164620408e-07 0.386098874836553 8.290769689902896e-07 0.383254723448244 8.290770971374193e-07 0.380874963946598 \
8.290772199854116e-07 0.3786015923730871 8.290773990837881e-07 0.375299968600122 8.290775481684201e-07 0.3725653942578417 8.290777158758077e-07 0.3695018296724824 \
8.290778712734425e-07 0.3666748141177644 8.290779954402882e-07 0.3644243980538668 8.290781093321554e-07 0.3623666676050148 8.290782307755259e-07 0.3601804966264144 \
8.290784109272934e-07 0.3569532670533712 8.290785774151136e-07 0.3539878629329621 8.290787678342229e-07 0.3506138544217919 8.290789595908185e-07 0.3472380408565978 \
8.29079142640212e-07 0.344035729794033 8.290792916122767e-07 0.3414435189591631 8.290794115521823e-07 0.3393660536257183 8.29079534213665e-07 0.3372483242714233 \
8.290796572441514e-07 0.3351324902755385 8.29079802148562e-07 0.3326515017845288 8.290799054613372e-07 0.3308907757076019 8.290799991908464e-07 0.3292979229163631 \
8.290800898511484e-07 0.3277620998585528 8.29080200972602e-07 0.3258853746017661 8.290803081455789e-07 0.3240820510456246 8.290804064202303e-07 0.3224338250618513 \
8.290805188247763e-07 0.3205545940512134 8.290806827646764e-07 0.3178277446588927 8.290808444025551e-07 0.3151576097143818 8.290809921893013e-07 0.3127316247504084 \
8.290811544345159e-07 0.3100832165115083 8.290813144650734e-07 0.3074868334344322 8.290814667283718e-07 0.3050304870660137 8.290816201002421e-07 0.3025703731928215 \
8.29081778808771e-07 0.3000411640344692 8.290819432578998e-07 0.297437246442505 8.290821104849764e-07 0.2948063590562646 8.290822635965136e-07 0.292412731930112 \
8.290824466944405e-07 0.2895700146919417 8.290826370021783e-07 0.2866380344427262 8.290827859052364e-07 0.2843603072871506 8.290829598425416e-07 0.2817165165722222 \
8.290831367199302e-07 0.2790484233348025 8.290832843171486e-07 0.2768363681311815 8.290834739488486e-07 0.2740172295061162 8.290836239507675e-07 0.2718052906662373 \
8.290837610609577e-07 0.2697943906627059 8.290839025914008e-07 0.2677397479842996 8.290840160502698e-07 0.2661005451260196 8.290841523405964e-07 0.2641384584581135 \
8.290842824172175e-07 0.2622807416655737 8.290844006714701e-07 0.2606037730704709 8.290845185270662e-07 0.2589348966568543 8.290846494208768e-07 0.2570853888657079 \
8.290847896596348e-07 0.2551145527343576 8.290849051542211e-07 0.2534976852533538 8.290850340055979e-07 0.2516957519945816 8.290851491515796e-07 0.2500885525459272 \
8.290853024625469e-07 0.2479513765689386 8.290854403163083e-07 0.2460367343642474 8.290855797779604e-07 0.2441002375748529 8.29085735245815e-07 0.2419427021952501 \
8.290858600284302e-07 0.2402176526454788 8.290859998933384e-07 0.2382916534360561 8.290861285955144e-07 0.2365220787132559 8.290862495543662e-07 0.234860341242685 \
8.290863665996657e-07 0.2332541163798121 8.290864926007301e-07 0.2315368940272461 8.290865893203229e-07 0.2302195772445239 8.29086681409196e-07 0.2289683907689286 \
8.290867958266674e-07 0.2274152998827935 8.290868941973141e-07 0.2260807986508055 8.290870113441077e-07 0.2244933520241092 8.290871144352257e-07 0.2231010305483718 \
8.290872199499517e-07 0.2216798666278746 8.290873008680116e-07 0.2205933880575098 8.290873745391968e-07 0.2196046443759679 8.290874172684338e-07 0.2190314036349237 \
8.290874603985789e-07 0.2184540235451489 8.290875111960606e-07 0.217774515685755 8.290875483709394e-07 0.217277430841393 8.29087589041954e-07 0.2167338127731004 \
8.290876318337554e-07 0.2161620985357572 8.290876682448971e-07 0.2156758299561118 8.290877101698877e-07 0.2151161507306283 8.290877647120985e-07 0.2143884526296278 \
8.290878031708564e-07 0.2138756926875936 8.290878427976257e-07 0.2133496230586122 8.290879046301276e-07 0.212531488259555 8.290879663565786e-07 0.2117156525305126 \
8.290880224938542e-07 0.210974237875411 8.290880861490836e-07 0.210134110843225 8.290881802401171e-07 0.2088936328424611 8.290882670483761e-07 0.2077505933124353 \
8.290883610050201e-07 0.2065146061917991 8.290884590472536e-07 0.2052266823513323 8.290885606346195e-07 0.2038976009052371 8.290886615435678e-07 0.2025832113009377 \
8.290887582793767e-07 0.2013244528083448 8.290888604043477e-07 0.1999972806373927 8.290889637359055e-07 0.1986583046056677 8.290890736185069e-07 0.1972379690671278 \
8.290891825607647e-07 0.1958337611883887 8.290893023958846e-07 0.1942937175364915 8.290894126797513e-07 0.1928822800638286 8.290895205584963e-07 0.191507108810815 \
8.290896466212543e-07 0.1899051957406391 8.290897364889607e-07 0.1887671190866151 8.290898469673e-07 0.1873723090993208 8.290899245002487e-07 0.1863971337376019 \
8.290900088239918e-07 0.1853400660204312 8.2909009641205e-07 0.1842452710069853 8.290901842046442e-07 0.18315095174413 8.290902659245155e-07 0.1821357652581398 \
8.290903634861928e-07 0.1809282658474054 8.29090470197344e-07 0.1796118512064394 8.29090570679026e-07 0.178377576484793 8.290906948502375e-07 0.1768595317522179 \
8.290908287417607e-07 0.1752320886156309 8.290909476539533e-07 0.1737937102924047 8.290910980541469e-07 0.1719851742607024 8.290912088892401e-07 0.1706594030660365 \
8.290913486559821e-07 0.168997130456427 8.290914671812901e-07 0.1675953052211382 8.290915726085209e-07 0.1663548750207849 8.290916673183802e-07 0.1652455210322802 \
8.290917606281543e-07 0.1641568522804657 8.290918615342705e-07 0.1629842804551663 8.290919569521023e-07 0.1618800504313296 8.290920541430254e-07 0.1607598891027116 \
8.29092135704507e-07 0.1598237474547246 8.290922410209518e-07 0.1586229753023833 8.290923245006587e-07 0.1576763029943549 8.290924260299495e-07 0.1565306813704828 \
8.290925032604858e-07 0.1556635090415242 8.29092594132523e-07 0.154647919213242 8.290926634838334e-07 0.1538765336840219 8.290927480678846e-07 0.1529397840535594 \
8.290928224610911e-07 0.1521208717489242 8.290929018312932e-07 0.151251902275755 8.290929764189645e-07 0.1504388356812226 8.290930456405211e-07 0.1496871728711989 \
8.29093140321328e-07 0.1486640077242138 8.29093210087093e-07 0.1479134441579097 8.290932945316557e-07 0.147008717574758 8.290933560970015e-07 0.1463518850554192 \
8.290934301394933e-07 0.1455673550676988 8.290935035250169e-07 0.1447940960774066 8.290935849602585e-07 0.1439395015691976 8.290936544094048e-07 0.1432139999234875 \
8.290937295111024e-07 0.1424323701137583 8.290938194231735e-07 0.1415006120834361 8.290938965067932e-07 0.1407052977810757 8.290939956173774e-07 0.1396885207473417 \
8.290940651574397e-07 0.138983077430453 8.290941464759156e-07 0.1381612812129989 8.290942166443246e-07 0.1374549162714094 8.290942956124377e-07 0.1366629455350578 \
8.290943745907205e-07 0.1358740351737466 8.290944469125105e-07 0.1351544405911459 8.290945162779692e-07 0.1344667589602006 8.290945649819765e-07 0.1339854049281765 \
8.290946557443482e-07 0.1330945614011112 8.290946877658758e-07 0.1327823711724506 8.290947758698441e-07 0.131925672678654 8.290948083638864e-07 0.1316105445757083 \
8.290949070315436e-07 0.1306564447580443 8.290949506875192e-07 0.130235859061297 8.290950286693357e-07 0.1294866595045693 8.290950660002936e-07 0.1291289430202982 \
8.290951681516937e-07 0.128153223240932 8.290952355956539e-07 0.1275115375392494 8.290953007486116e-07 0.1268935577290946 8.290953666546259e-07 0.1262729746041904 \
8.290954378066093e-07 0.1256052797936485 8.290955207439704e-07 0.1248293808775363 8.290956061394508e-07 0.1240331657139879 8.290956822268445e-07 0.1233259817834828 \
8.290957626875213e-07 0.1225806238777534 8.290958207714622e-07 0.1220441728027253 8.29095892104936e-07 0.1213870835332726 8.290959768933693e-07 0.1206085709991845 \
8.290960380484021e-07 0.1200487744399507 8.290961081348534e-07 0.1194096117168642 8.290961706401422e-07 0.1188419501154776 8.290962366450903e-07 0.1182453094891599 \
8.290963054178569e-07 0.1176255789053269 8.290963748744814e-07 0.1170017375875525 8.29096458038731e-07 0.1162574953874909 8.290965311562548e-07 0.1156056107435251 \
8.29096601870241e-07 0.1149774116339468 8.290966612219237e-07 0.1144518657417393 8.290967665191356e-07 0.1135239342411639 8.290968123866298e-07 0.1131212254602471 \
8.290968993406833e-07 0.1123603821649216 8.290969423544638e-07 0.1119852310621949 8.290969872212111e-07 0.1115947726395539 8.29097076954706e-07 0.1108164664143028 \
8.290971478390573e-07 0.110204256460374 8.290972266925708e-07 0.109525796983828 8.290972894703462e-07 0.1089876103666232 8.290973494647018e-07 0.1084750215669379 \
8.290974604624741e-07 0.1075310013968523 8.2909754121676e-07 0.1068475792877216 8.290976536800858e-07 0.1059005796323111 8.290977048246292e-07 0.1054717782906781 \
8.290977878097979e-07 0.1047785948356612 8.290978459745031e-07 0.1042945647727652 8.29097960212503e-07 0.1033482075721767 8.2909801011597e-07 0.1029366076865433 \
8.290980958575694e-07 0.1022320954501846 8.290981448890196e-07 0.1018307629303728 8.290982274554409e-07 0.101157455862875 8.290982983877772e-07 0.1005815064560546 \
8.290983665381274e-07 0.1000302812267231 8.290984441484433e-07 0.0994053199805509 8.290985164918144e-07 0.09882546240595018 8.29098594067778e-07 0.09820656846618626 \
8.290986827384394e-07 0.09750287271560702 8.290987565532273e-07 0.09692010793638871 8.290988381442347e-07 0.09627924899616347 8.290989162827031e-07 0.09566870926115327 \
8.290990020324936e-07 0.09500229249765579 8.290990897294021e-07 0.09432453920671229 8.290991836389667e-07 0.09360304191323381 8.290992800982852e-07 0.09286661217778783 \
8.290993587289458e-07 0.09226977907248698 8.290994614525455e-07 0.09149473120661993 8.290995452801959e-07 0.09086620530027881 8.290996660323777e-07 0.08996702094116031 \
8.29099795302029e-07 0.08901247130467421 8.290999511904932e-07 0.08787237469953549 8.291001062900762e-07 0.08675000010972149 8.291002633058824e-07 0.08562614142917294 \
8.291004433267348e-07 0.08435280068725284 8.291005938476015e-07 0.08330035525696428 8.291007422216238e-07 0.08227363395463329 8.291008798388548e-07 0.08133079092382095 \
8.291010197585049e-07 0.08038162993974078 8.291011563654933e-07 0.07946425488810546 8.291012950927907e-07 0.07854214404995859 8.291014404036529e-07 0.07758663187171365 \
8.29101588151466e-07 0.07662571164688473 8.291017467483332e-07 0.07560598447141591 8.291019110008509e-07 0.07456266320243836 8.291020800179273e-07 0.07350246718885647 \
8.29102261906921e-07 0.07237646636762114 8.291024625290194e-07 0.07115268999588262 8.291026764065622e-07 0.0698691158856425 8.291029040406938e-07 0.0685263410462881 \
8.291031456262355e-07 0.06712722147996912 8.29103427215414e-07 0.06552977831071743 8.291037243695346e-07 0.06388229915275011 8.291040478026115e-07 0.06213267023812474 \
8.291044389620309e-07 0.0600758559534558 8.29104840456333e-07 0.05803293250078725 8.291052173970594e-07 0.05617754872181892 8.291055845107909e-07 0.05442503025024555 \
8.291059346274713e-07 0.05280240270907886 8.291062539331247e-07 0.05136309724710254 8.291065582574072e-07 0.05002640192327024 8.291068551633126e-07 0.04875503464657577 \
8.291071371636386e-07 0.04757867888787161 8.291074175969432e-07 0.04643900623749339 8.291076823205669e-07 0.04538777697325767 8.291079582182789e-07 0.04431704973151576 \
8.291082326831433e-07 0.04327654260273706 8.291085311024235e-07 0.04217254828989973 8.291087576184799e-07 0.04135316230013186 8.291090695313175e-07 0.04025053053625379 \
8.291092897861088e-07 0.03948972371590862 8.291095070508635e-07 0.03875470657060948 8.291097167735125e-07 0.03806113111453101 8.291100269559001e-07 0.03705828856757609 \
8.291102495537778e-07 0.03635538859683734 8.291104969192789e-07 0.03559019656168042 8.291107693256556e-07 0.03476651972027592 8.291109899582094e-07 0.03411384091885184 \
8.291112742384597e-07 0.03329124852897781 8.291115121517525e-07 0.0326183788879464 8.291117502411637e-07 0.03195887699386461 8.291119854964916e-07 0.03132132139405813 \
8.291122142751987e-07 0.03071728735992773 8.291124470059478e-07 0.03011490821398154 8.291126663089891e-07 0.02955843195412813 8.291128702520595e-07 0.02905055018162466 \
8.291132691617956e-07 0.02808303002558106 8.291134563160508e-07 0.02764052191221165 8.29113828521772e-07 0.0267814187683372 8.29114015473295e-07 0.02635997027055515 \
8.291143848272417e-07 0.02554620807076183 8.291145384804101e-07 0.02521471147941385 8.291149546945643e-07 0.02434161493068329 8.291151601823807e-07 0.02392065165079968 \
8.291154991903413e-07 0.02323955384462723 8.291156818850693e-07 0.02287916718068597 8.291161389789784e-07 0.02199597290476789 8.291162687197143e-07 0.02174967209293581 \
8.291167221401377e-07 0.02089828923199067 8.2911686451243e-07 0.0206336680476187 8.291173940791906e-07 0.01967289368906444 8.291175202861975e-07 0.01945139161001456 \
8.291180825206353e-07 0.01850749734048266 8.29118245259022e-07 0.01824627541187189 8.291188094390871e-07 0.01738327200207762 8.291189611831538e-07 0.01716165742474803 \
8.291196628626383e-07 0.01618760396393164 8.291198329517282e-07 0.01596324388168 8.291204880096043e-07 0.01513221026437959 8.291206545239163e-07 0.01492874613340729 \
8.291213876376757e-07 0.01406966818047924 8.291215209008542e-07 0.01391906482409888 8.291223725580289e-07 0.01299647369571925 8.291225105004774e-07 0.01285324185793544 \
8.291234505599668e-07 0.0119198170026788 8.291236143216039e-07 0.01176347583728811 8.291246015550385e-07 0.01085909507266535 8.291247361441145e-07 0.0107410715025141 \
8.291258775835447e-07 0.009819907073012045 8.291259858224433e-07 0.009738548299709823 8.29127309069827e-07 0.00880579379490502 8.291274418155253e-07 0.008718202093769473 \
8.291289643166501e-07 0.007760835273143199 8.29129076858719e-07 0.007690148685505111 8.29130769150306e-07 0.00669558715138598 8.291309094168914e-07 0.00662113250846694 \
8.291329824261937e-07 0.005629132576249021 8.291331749877106e-07 0.005545002188831318 8.291353851975589e-07 0.004656096148610405 8.291357919842319e-07 0.004507219767123045 \
8.291386137242085e-07 0.003590578528330178 8.291391350199586e-07 0.00344214578404881 8.291433471210094e-07 0.002447529662748036 8.291438996838773e-07 0.002340875287107731 \
8.291497829734168e-07 0.001359168649576994 8.291500322464151e-07 0.001311490127959886 8.291631823674653e-07 0.0003136950974005476 8.291632991504353e-07 0.0003112730584132499 \
8.589900000000113e-07 3.042397160644726e-06 9.027466670270133e-07 -0.0009024818035526668 9.027467394426294e-07 -0.001022682652537627 9.02747175467347e-07 -0.001858525046639076 \
9.027472623617301e-07 -0.002046124893065343 9.027476170650433e-07 -0.00288168582347465 9.027477166116441e-07 -0.003135075204051477 9.027479768813486e-07 -0.003828199033013717 \
9.027481172037501e-07 -0.004216406518003108 9.027483446898323e-07 -0.004856871791621592 9.027484818972713e-07 -0.005239031028659006 9.0274886679612e-07 -0.006187559915121 \
9.027489988933069e-07 -0.006423332025500122 9.027496873363354e-07 -0.005917035979538006 9.027498442650688e-07 -0.005202654566481615 9.027499719142314e-07 -0.004414133290428114 \
9.027500994560215e-07 -0.003433350487145549 9.027502171302334e-07 -0.002355902309038119 9.0275031626992e-07 -0.001320627313728655 9.027504216526298e-07 -9.507383675133965e-05 \
9.02750535559933e-07 0.001369964538583592 9.027506666153286e-07 0.003229572948258866 9.027507919785475e-07 0.005172303930030842 9.027509838204114e-07 0.008432154569684791 \
9.027511274902043e-07 0.01107975669588844 9.027512854720173e-07 0.01417105828876112 9.027514340716642e-07 0.01723098336859398 9.02751587122593e-07 0.02051714008521248 \
9.027517461875692e-07 0.02405720796424875 9.027518992577779e-07 0.02756764950178633 9.027520476048421e-07 0.03105219347129199 9.027521967112841e-07 0.03462388853332505 \
9.02752351275713e-07 0.03838854885099419 9.027525119616768e-07 0.04235886888523473 9.027526766408631e-07 0.04647718198980624 9.027528531638066e-07 0.05093664320808645 \
9.027530321756059e-07 0.05549818742091989 9.027532229484479e-07 0.0603932190016783 9.027534277958001e-07 0.06567927942044927 9.02753648293053e-07 0.07139554989571946 \
9.027538812110213e-07 0.07745499876455469 9.027541304587991e-07 0.08395499695136356 9.027544033803265e-07 0.09108394918256098 9.027547001733835e-07 0.09884095133633181 \
9.027550276098956e-07 0.1073964775374675 9.027553974236945e-07 0.1170487607486894 9.027557923699755e-07 0.1273407304921971 9.027562504585283e-07 0.1392499850125259 \
9.02756782558388e-07 0.1530377249371455 9.027574081103967e-07 0.169180864038255 9.027580941024627e-07 0.1867931863309214 9.027588969458781e-07 0.2072766958045763 \
9.027597962582095e-07 0.2300508264895909 9.027606966983226e-07 0.2526618731709107 9.027614985898552e-07 0.2726215666318766 9.027621940969962e-07 0.2897857674353052 \
9.02762826931282e-07 0.3052728323588638 9.027634223397734e-07 0.3197161646377594 9.027639693828152e-07 0.3328722959176427 9.027645031431616e-07 0.3455929446372428 \
9.027650223825863e-07 0.3578476146335662 9.027655297740486e-07 0.3697097539883151 9.02766033395218e-07 0.3813674725871593 9.027665451381145e-07 0.3930934709428262 \
9.027670522991229e-07 0.404595334768291 9.027675825951367e-07 0.4164962117964878 9.027680687086257e-07 0.4272847049163567 9.027685468169473e-07 0.437781779057129 \
9.027689862490711e-07 0.4473362978389137 9.027691094085349e-07 0.4500002106608159 9.027693557274626e-07 0.4553046876287923 9.027696989994585e-07 0.4626558934952216 \
9.027700104364589e-07 0.4692815017887791 9.027702611477243e-07 0.4745855323881177 9.027705319768676e-07 0.480281321066213 9.027708684587769e-07 0.4873122872019196 \
9.027712244673881e-07 0.4946959640027882 9.027715417375557e-07 0.5012322602315481 9.027717806181048e-07 0.506122906570856 9.027720216462867e-07 0.5110269393752048 \
9.027722735779908e-07 0.5161276795544476 9.027725137318345e-07 0.5209621749612534 9.027727364832964e-07 0.5254248476203834 9.027729250409435e-07 0.5291850880529715 \
9.027731397909866e-07 0.5334523706207774 9.027733543393783e-07 0.5376948565446859 9.0277361310367e-07 0.5427871977552768 9.027738639312417e-07 0.5477009885064807 \
9.027741193501039e-07 0.5526782776843104 9.027744703926294e-07 0.5594898819265107 9.027747350009544e-07 0.5645984056527484 9.027750014175096e-07 0.569709962982798 \
9.027752619318197e-07 0.5746801970751495 9.027755290218824e-07 0.5797469183389945 9.027757721599624e-07 0.5843213438768613 9.02776027852189e-07 0.5890994944692448 \
9.027762556711592e-07 0.5933243819692556 9.027764932159792e-07 0.5976999800355528 9.027767046064655e-07 0.6015679915939678 9.027769167472246e-07 0.6054277082074113 \
9.027771059366022e-07 0.6088479815213901 9.027772370949196e-07 0.6112112531841202 9.027773693914781e-07 0.6135871094428261 9.02777554614204e-07 0.6169015645304802 \
9.027777166365907e-07 0.6197943209800671 9.027778750557552e-07 0.6226100751126036 9.027780091676215e-07 0.6249846001944386 9.027781814887287e-07 0.6280247049765127 \
9.027783104275314e-07 0.6302937061188456 9.027784308050438e-07 0.6324061607157294 9.027785713339148e-07 0.634864734791624 9.027787644194074e-07 0.6382321981637986 \
9.027789142301852e-07 0.6408363654380513 9.027790815377796e-07 0.6437327988167145 9.027792625920029e-07 0.6468572757970242 9.027794659184326e-07 0.6503523798695617 \
9.027796487715879e-07 0.6534819287355287 9.027798193958343e-07 0.6563879501053153 9.027799968600742e-07 0.6594029650344411 9.027801628390247e-07 0.6622113135173925 \
9.027803200758144e-07 0.6648594636266301 9.02780460561866e-07 0.6672075432495704 9.027806042919945e-07 0.6695987751186935 9.027807373389854e-07 0.6718055529208897 \
9.02780879311128e-07 0.6741523780906628 9.027809993716612e-07 0.6761293215200647 9.027811443097483e-07 0.6785098354674278 9.027812603067977e-07 0.6804095298668216 \
9.027813798866854e-07 0.6823647593763783 9.027814788466604e-07 0.68397755359623 9.027815973550784e-07 0.6859039329668146 9.027816843993602e-07 0.6873150904607619 \
9.027818064101794e-07 0.6892866586554622 9.027819053327907e-07 0.6908817703737582 9.027819972281661e-07 0.6923536807698466 9.027820971967053e-07 0.6939486118486815 \
9.02782195442366e-07 0.6955126686751646 9.027822871561283e-07 0.6969676095571918 9.027823912890697e-07 0.698613189139943 9.02782527015812e-07 0.7007470979739818 \
9.027826816242741e-07 0.7031613517373301 9.027828167319862e-07 0.7052558942641604 9.027829630685318e-07 0.7075085519458914 9.027830915360734e-07 0.7094732734147607 \
9.02783215720207e-07 0.7113609898537658 9.027833256245073e-07 0.7130225953369277 9.027834422075758e-07 0.7147759898693785 9.027835423854066e-07 0.7162749667021007 \
9.027836794742156e-07 0.7183149847558421 9.027837994632423e-07 0.7200901405411056 9.027839185766902e-07 0.7218426783097279 9.02784045072077e-07 0.723693513465353 \
9.02784170939449e-07 0.7255245570057045 9.027842935604676e-07 0.7272980597885179 9.027844211779915e-07 0.7291334326655684 9.027845514267828e-07 0.7309957624152177 \
9.02784673019733e-07 0.73272442801297 9.027848117884253e-07 0.7346853525547948 9.02784912196869e-07 0.7360963845229137 9.027850155842573e-07 0.7375412410987998 \
9.027851092446997e-07 0.7388443755773992 9.027852208662966e-07 0.7403895158541485 9.027853073348996e-07 0.7415798421827293 9.027854081980103e-07 0.7429609798983192 \
9.027855402947323e-07 0.7447573558536402 9.027856494960337e-07 0.7462323422761349 9.027857540276638e-07 0.747635567415085 9.027858776741446e-07 0.7492836897664436 \
9.027860263705797e-07 0.7512497161812216 9.027861482512389e-07 0.7528480713857697 9.02786261855803e-07 0.7543274008692354 9.027864023754882e-07 0.7561429069656862 \
9.027865435649301e-07 0.7579511824827749 9.027866613111062e-07 0.7594470562859095 9.027867900007657e-07 0.7610693809796742 9.027869325554126e-07 0.7628512182523866 \
9.027870484119641e-07 0.7642872416835913 9.027871941752297e-07 0.7660789429779771 9.02787316007677e-07 0.7675637574673733 9.02787434476374e-07 0.7689965471136999 \
9.027875572640059e-07 0.7704700089613156 9.027876834168886e-07 0.7719718272910862 9.027877937859393e-07 0.7732757954107932 9.02787919217035e-07 0.7747465774777432 \
9.027880246987463e-07 0.775974259539018 9.027881578651757e-07 0.7775122819577122 9.027882805466309e-07 0.7789173428708996 9.027884153096743e-07 0.7804473432620218 \
9.027885259809625e-07 0.7816923373676121 9.027886353025911e-07 0.7829118427552927 9.027887704350255e-07 0.7844048889494442 9.027889212140503e-07 0.7860523747618094 \
9.02789061582958e-07 0.7875692293014268 9.027891812944827e-07 0.7888502570533434 9.027893195488234e-07 0.7903153082715967 9.027894429191593e-07 0.7916096503654788 \
9.027895880177844e-07 0.7931164937536124 9.027897277580434e-07 0.7945521172774316 9.027898549394667e-07 0.7958455533278409 9.027899739792201e-07 0.7970449251022731 \
9.02790086337411e-07 0.7981670522831598 9.027901905661905e-07 0.79919939674296 9.027902859050021e-07 0.8001364844871954 9.027904221931121e-07 0.8014634245741865 \
9.027905390856556e-07 0.8025894467082511 9.02790658725145e-07 0.8037305025474466 9.027907806067165e-07 0.8048811831579785 9.027909029850537e-07 0.8060245537852575 \
9.027910310137332e-07 0.8072081965553952 9.027911556585316e-07 0.8083483262222385 9.027912861572794e-07 0.8095291977395493 9.027914126177069e-07 0.8106611567088965 \
9.027915397436747e-07 0.8117869190804841 9.027916448611512e-07 0.8127087429624065 9.027917501113405e-07 0.8136235164943317 9.027918412515906e-07 0.8144090748259969 \
9.027919646696249e-07 0.8154632009865571 9.027920517482738e-07 0.8162003374872545 9.02792151070959e-07 0.8170344894488412 9.027922959927027e-07 0.8182390501293432 \
9.027924322612063e-07 0.8193582434421302 9.027925417234846e-07 0.8202477434185359 9.027926878435863e-07 0.8214214001843773 9.02792839202198e-07 0.8226208465286928 \
9.027929650061201e-07 0.8236052915965452 9.027931094167793e-07 0.824721541823094 9.027932340177295e-07 0.8256729463037898 9.027933847297913e-07 0.8268094083523665 \
9.027935201010499e-07 0.8278169867326588 9.02793645303979e-07 0.8287379047458127 9.027937629733617e-07 0.829593908450195 9.027939088013387e-07 0.8306418458276996 \
9.027940752973201e-07 0.8318207857986918 9.027942061544082e-07 0.8327345044534114 9.027943796038484e-07 0.833928356718921 9.027945477223224e-07 0.8350667646575466 \
9.027947175961246e-07 0.8361988603660855 9.027948984507536e-07 0.8373843006762304 9.027950416331349e-07 0.8383085120571983 9.027951557464787e-07 0.8390361588138326 \
9.027952858124697e-07 0.8398559950134801 9.027953876877057e-07 0.8404909448220066 9.027955045669982e-07 0.8412116130393378 9.027956416789287e-07 0.8420465258793415 \
9.027958395595721e-07 0.843231707656198 9.027960313457652e-07 0.8443585547012582 9.027962407088286e-07 0.8455646258450146 9.027964228224063e-07 0.846593677725298 \
9.027966199171782e-07 0.8476867969181797 9.02796793185875e-07 0.8486305714188691 9.02796976264561e-07 0.8496104335327738 9.027971474015872e-07 0.8505103231661706 \
9.027973220804384e-07 0.8514128411730317 9.02797497318728e-07 0.8523022053693007 9.027976734583674e-07 0.8531802340241421 9.027978638096238e-07 0.8541115036082744 \
9.027980543867704e-07 0.855025905954957 9.027982548181928e-07 0.8559685891497206 9.027984474106692e-07 0.8568563992305701 9.027986582738063e-07 0.8578086227668252 \
9.027988861871822e-07 0.8588150784816577 9.027991522177188e-07 0.8599606428795262 9.027994507388009e-07 0.8612090806949765 9.027997266924815e-07 0.8623286542354505 \
9.028000109545961e-07 0.8634483918036945 9.028002851030457e-07 0.8644969441068078 9.028005573923129e-07 0.8655088801415273 9.028008275580887e-07 0.8664846790737442 \
9.028010847361862e-07 0.8673881555543895 9.028013572993529e-07 0.868319368003445 9.02801633304697e-07 0.8692355072818493 9.028019034186286e-07 0.870106770567397 \
9.028022032450017e-07 0.8710447971670072 9.028025742222908e-07 0.8721640818024149 9.028028691540118e-07 0.8730224021943973 9.028031234323761e-07 0.873740732376842 \
9.028034216772072e-07 0.8745584461000401 9.028036952852192e-07 0.8752856917963749 9.028039314154437e-07 0.8758961959341748 9.028041717609792e-07 0.8765017794770257 \
9.028043940971677e-07 0.8770481951318053 9.028045881024505e-07 0.8775144010549708 9.028049178237935e-07 0.8782846129827527 9.028050729968194e-07 0.8786376896881318 \
9.028053907524075e-07 0.8793424631377607 9.028055696169827e-07 0.8797286397841958 9.028059120784622e-07 0.8804474051285093 9.028060962178168e-07 0.880822800830328 \
9.028065711184754e-07 0.881756283451624 9.028067385131538e-07 0.8820737784441692 9.028072043462e-07 0.8829272622221894 9.028073851704931e-07 0.8832470363605239 \
9.028078792047928e-07 0.8840891816604841 9.028080205486687e-07 0.8843218944112644 9.028086269405856e-07 0.8852805359894154 9.028087790117662e-07 0.8855111592597558 \
9.028094256914359e-07 0.8864506941541785 9.028095539876422e-07 0.8866295550025313 9.028102021648148e-07 0.8874976172723908 9.028103319236754e-07 0.8876644392549727 \
9.028111001444974e-07 0.8886037370453904 9.02811229881009e-07 0.8887539063021698 9.028120833066544e-07 0.8896836309705964 9.028122265650877e-07 0.8898301468060963 \
9.02813212785821e-07 0.890764641901611 9.028134342672269e-07 0.8909571971396437 9.028145773086277e-07 0.8918770673440963 9.028147072981167e-07 0.8919774876506176 \
9.028160589233886e-07 0.8929731820841386 9.028162092835701e-07 0.89307657739048 9.028176899161688e-07 0.8939986636922405 9.028179288179339e-07 0.8941315911431026 \
9.028196933116327e-07 0.894999985510941 9.02820000994978e-07 0.8951330875684044 9.028225222661808e-07 0.8960612226716312 9.02822959317422e-07 0.8961978289811912 \
9.028268627296431e-07 0.8971619289239613 9.028271095114498e-07 0.8972094058147089 9.028346860012844e-07 0.8981998139535015 9.028348019130314e-07 0.8982099955090975 \
9.028539004457352e-07 0.8992062631372056 9.028542978885091e-07 0.8992194728667773 9.030047133235902e-07 0.9002121614362558 9.03004979381947e-07 0.9002436812458944 \
9.030102475320152e-07 0.8993470931706574 9.030104539029323e-07 0.899191170936528 9.030119320157425e-07 0.8982046351054961 9.030121124663984e-07 0.8981003355419954 \
9.030143349480612e-07 0.8971299612768925 9.030145410405756e-07 0.897079983173831 9.030249493066813e-07 0.8980580240048047 9.03025087164257e-07 0.8980839755683444 \
9.030318845132984e-07 0.8990685088718567 9.030320700847659e-07 0.8990874390200084 9.035282992589679e-07 0.9000706848616691 9.03528359054814e-07 0.9000975977971888 \
9.03529612605432e-07 0.9010828413531861 9.035297182980353e-07 0.9012097231395001 9.035303764287524e-07 0.9021613947651476 9.035305136110212e-07 0.9023918767045529 \
9.035310366376408e-07 0.9033649777562528 9.035310995012334e-07 0.9034908765919824 9.035315720967825e-07 0.904476514442582 9.035316234105955e-07 0.9045863669199017 \
9.035320893739313e-07 0.9055619780118375 9.035321215783922e-07 0.9056252631670594 9.035328386771295e-07 0.9066212416280413 9.035329231134018e-07 0.9066528951765993 \
9.035335231797813e-07 0.9059679814895146 9.035336430373927e-07 0.9055903401525059 9.035337742001719e-07 0.9050640446667092 9.035339090199248e-07 0.9043926011431642 \
9.035340571549842e-07 0.9034897747335404 9.035341947143353e-07 0.902493211317788 9.035343349260954e-07 0.9013135799985507 9.035344335882046e-07 0.9003872218501816 \
9.035345192720141e-07 0.8995148096066522 9.035346018362133e-07 0.8986166894493001 9.035347166188419e-07 0.8972773101170661 9.035347977170859e-07 0.8962642459447687 \
9.03534877134364e-07 0.8952218112132616 9.035349825888917e-07 0.8937633947192651 9.035351052301954e-07 0.8919606744930825 9.035352049542743e-07 0.890414036797163 \
9.035353751486854e-07 0.8876203405523397 9.035355213337766e-07 0.8850727273800474 9.035356895519253e-07 0.8819879035815887 9.035358617130214e-07 0.8786780617039783 \
9.035360460991142e-07 0.8749807502679057 9.035362306654577e-07 0.8711418063496947 9.035364149129436e-07 0.8671917613865908 9.035366002486072e-07 0.8631174608718694 \
9.035367746363354e-07 0.8592060069639053 9.035369573402717e-07 0.8550405244181323 9.035371326873658e-07 0.8509893565349284 9.035373150168772e-07 0.8467313026054767 \
9.035375053303061e-07 0.8422468264612591 9.035376756604352e-07 0.838204894125699 9.035378421840737e-07 0.8342320488410089 9.035380047549371e-07 0.830337741667393 \
9.035381546161599e-07 0.8267359097041467 9.03538305792179e-07 0.8230937075736249 9.035384949376529e-07 0.8185270080344306 9.035386406557074e-07 0.8150026134285653 \
9.035388156466743e-07 0.8107652770601156 9.035389641182174e-07 0.807166938184282 9.035391360056827e-07 0.8029987283123258 9.035393050739222e-07 0.7988973224349885 \
9.035394692526315e-07 0.7949140139776875 9.035396285801686e-07 0.7910485911592836 9.035397890297763e-07 0.7871568543472617 9.035399908491573e-07 0.7822630953020117 \
9.035401392968916e-07 0.7786646206504594 9.03540293464276e-07 0.77492821376164 9.035404305476362e-07 0.7716074476660475 9.035405399330824e-07 0.7689587163513494 \
9.035406458665383e-07 0.7663946531324515 9.035407728808854e-07 0.7633217481666642 9.035408872438541e-07 0.7605561828888391 9.03540990091676e-07 0.7580702160470256 \
9.035411116819926e-07 0.7551325442760125 9.035412224592672e-07 0.7524575925939972 9.035413393080924e-07 0.7496376180588871 9.035414500928178e-07 0.7469652567786068 \
9.035415684589191e-07 0.7441116745915923 9.035416932860144e-07 0.7411038668912771 9.035418458478099e-07 0.7374292753756717 9.035419797447979e-07 0.7342062928952946 \
9.035421007762373e-07 0.7312947572377408 9.035422649737523e-07 0.7273475399259534 9.035424423346987e-07 0.7230877912371642 9.035426245451075e-07 0.7187161681757385 \
9.035428055423725e-07 0.7143786395952922 9.035429862063158e-07 0.7100537072471783 9.035431763578828e-07 0.7055071781827296 9.035433641177768e-07 0.7010230964996226 \
9.035435646508815e-07 0.696237807975249 9.035437733363431e-07 0.6912646166759551 9.035439809799077e-07 0.6863227581165517 9.03544208547776e-07 0.6809140411171237 \
9.035444008226102e-07 0.6763521085712711 9.035446380878581e-07 0.6707310800019505 9.035448313661221e-07 0.6661595641347996 9.035450640988685e-07 0.6606646229758047 \
9.035452696563363e-07 0.6558174602470968 9.035455020097575e-07 0.6503484594495911 9.035456970117276e-07 0.6457674053103037 9.035459002403361e-07 0.6410004262200759 \
9.035460800928814e-07 0.6367906205544323 9.035462591993118e-07 0.6326052789263827 9.035464225765257e-07 0.628795088826817 9.035465946259304e-07 0.6247880828503264 \
9.035467581187693e-07 0.6209892715878097 9.035469339085876e-07 0.6169100951581823 9.035471158475732e-07 0.6126978430086294 9.035473043313055e-07 0.6083422542008314 \
9.035475107637273e-07 0.6035858951323969 9.035476900783896e-07 0.5994633272559844 9.035478872572566e-07 0.5949432360761027 9.035480963453974e-07 0.5901646611556908 \
9.035483020946604e-07 0.5854760387944159 9.035485426053479e-07 0.5800160304866983 9.035487157334495e-07 0.5760958285528379 9.035488806274519e-07 0.5723746772837877 \
9.035490614880266e-07 0.5683014035092815 9.035492187741232e-07 0.5647722902613652 9.035493877569178e-07 0.5609879409349005 9.03549567863379e-07 0.5569709657351898 \
9.035497208465059e-07 0.5535669615732179 9.035498525609506e-07 0.5506462283231492 9.035499999486508e-07 0.5473865746199473 9.03550087374242e-07 0.5454560063082221 \
9.035501722454816e-07 0.5435860258811447 9.03550270874694e-07 0.5414171943998213 9.035503429668553e-07 0.5398340751058975 9.035504400578744e-07 0.5377039800781129 \
9.035505256482576e-07 0.5358302678688993 9.03550590729134e-07 0.5344081412607664 9.03550714329502e-07 0.5317121235594142 9.035508087537724e-07 0.52965475734789 \
9.035509062769941e-07 0.5275349985745696 9.035510791376451e-07 0.5237893654184622 9.035512141331662e-07 0.5208709659121862 9.035513683166277e-07 0.5175498113398643 \
9.03551542781984e-07 0.5138002600288881 9.035516945879704e-07 0.510550000123414 9.03551840818953e-07 0.5074290310664136 9.03551984717826e-07 0.5043644611166801 \
9.035521277396694e-07 0.5013276181140283 9.035522233495175e-07 0.499301733014788 9.035523177934733e-07 0.4973032961550828 9.03552438849414e-07 0.4947494705229025 \
9.035525337277098e-07 0.4927525559781179 9.035526495585532e-07 0.4903172469328811 9.035527368224019e-07 0.4884854516151125 9.035528192528481e-07 0.4867593351188191 \
9.035529146608015e-07 0.484765406725184 9.035530153710815e-07 0.4826639978995959 9.03553112231473e-07 0.4806459052877932 9.035532509612246e-07 0.4777646955734051 \
9.035533866660861e-07 0.4749532752442271 9.035535871508093e-07 0.4708139964547478 9.03553802464962e-07 0.4663911383470885 9.03553984040267e-07 0.462674698484628 \
9.035541830122363e-07 0.4586189944293299 9.035543535777573e-07 0.455154096457448 9.035545279314447e-07 0.4516251957269069 9.035546968646987e-07 0.4482170126441485 \
9.035548694618603e-07 0.4447467276163349 9.035550520681902e-07 0.4410867902598327 9.035552406170554e-07 0.4373240875354826 9.035554340845929e-07 0.4334777823509549 \
9.035556424052317e-07 0.4293535036700135 9.035558567504624e-07 0.4251286740881063 9.035560824557922e-07 0.4207018662297695 9.035563089991605e-07 0.4162771402745992 \
9.035565711759108e-07 0.4111844468197049 9.035568202097347e-07 0.4063709766754009 9.035571213084326e-07 0.4005865607947761 9.035574107292502e-07 0.3950673729298416 \
9.03557718243529e-07 0.3892455819062323 9.035580404399245e-07 0.3831936848847286 9.035583681704071e-07 0.3770882112794804 9.035587006001628e-07 0.3709500980558715 \
9.035590303291706e-07 0.3649083177186754 9.035593515587581e-07 0.3590729273462687 9.035596823750819e-07 0.3531219177045733 9.035600247306453e-07 0.3470224718704957 \
9.035603243716774e-07 0.3417374346434491 9.035606541592421e-07 0.3359723367088904 9.035609810531851e-07 0.3303128110141857 9.03561319032532e-07 0.3245206193888226 \
9.035616280036957e-07 0.3192755432624759 9.035619528016686e-07 0.31382336954194 9.035622684318663e-07 0.3085864885517507 9.035625734190322e-07 0.3035810258414895 \
9.035628287576776e-07 0.2994330834535801 9.035630936208339e-07 0.295170851203172 9.035633807035186e-07 0.2905978071194348 9.035636036732975e-07 0.2870801635277143 \
9.035638032125665e-07 0.2839591363066187 9.035640128685797e-07 0.2807045410859125 9.035641931251209e-07 0.2779290029372279 9.035643554698415e-07 0.2754463208250681 \
9.035645059048155e-07 0.2731629026725527 9.035646569101241e-07 0.2708866524077067 9.035648538007149e-07 0.2679392949564011 9.035649849454786e-07 0.2659970646012914 \
9.035651096820175e-07 0.2641561221543183 9.035652612740598e-07 0.2619266655689588 9.03565357242231e-07 0.2605306204207966 9.035654537935995e-07 0.2591282589302421 \
9.035655784133887e-07 0.2573209601776467 9.035657209899234e-07 0.255257422470362 9.035658799234579e-07 0.25296979123958 9.035660125895253e-07 0.251062957019046 \
9.035661961582939e-07 0.2484301322588876 9.035663773934596e-07 0.2458327969660818 9.035665889075645e-07 0.2428051031600066 9.035667914973991e-07 0.2399069804317323 \
9.035669580538466e-07 0.2375282895552967 9.03567168273059e-07 0.2345337828133105 9.03567341690945e-07 0.2320692345528927 9.035675705336728e-07 0.2288260787734411 \
9.035677911684243e-07 0.2257162440502939 9.035679668301377e-07 0.2232503232699662 9.035681472906432e-07 0.2207258962977968 9.035683180470208e-07 0.2183528725291195 \
9.035684982432871e-07 0.2158619697278009 9.035686649739047e-07 0.2135675266585953 9.03568814095326e-07 0.2115251542210239 9.035689699053442e-07 0.2094125291275523 \
9.035691050857695e-07 0.2075875692769576 9.035692551671966e-07 0.2055694209972212 9.035693876128229e-07 0.2037957203154137 9.035695281573595e-07 0.2019220745191926 \
9.035696452261238e-07 0.2003748851744883 9.035697749337301e-07 0.1986681706274326 9.035698969911991e-07 0.1970700654731777 9.035700195346348e-07 0.1954731161836187 \
9.035701375539584e-07 0.1939418157697267 9.035702725767313e-07 0.1921981789937757 9.035704172011819e-07 0.1903420634523806 9.035705455516812e-07 0.1887049708672087 \
9.03570669186156e-07 0.1871351133418249 9.035707667362788e-07 0.1859021016257166 9.035708818092081e-07 0.1844539912642748 9.035709755078879e-07 0.1832809848801438 \
9.035710742920116e-07 0.1820493959460708 9.035711972265529e-07 0.1805230483556907 9.035712929805559e-07 0.1793400249325384 9.035714220681073e-07 0.177753298391591 \
9.035715245334772e-07 0.1764993061988986 9.035716227869744e-07 0.1753029542432101 9.035717428741866e-07 0.1738483570896001 9.035718454234049e-07 0.1726127298531683 \
9.035719558810641e-07 0.1712877101305652 9.035720843709282e-07 0.1697552709290656 9.035721758557693e-07 0.1686698090598139 9.035722803403581e-07 0.1674358120019214 \
9.035723552770941e-07 0.1665544493622226 9.03572444845591e-07 0.1655049734124585 9.035724954106002e-07 0.164914347906921 9.035725453889763e-07 0.1643318187475747 \
9.035726103580609e-07 0.163576534137217 9.035726458720287e-07 0.1631646263336159 9.035727180712023e-07 0.162329174921529 9.035727852002974e-07 0.1615546732967998 \
9.035728444300317e-07 0.160873195114598 9.035728881756304e-07 0.1603710314414745 9.035729358224586e-07 0.1598254649913795 9.03573006202993e-07 0.1590230739426561 \
9.03573088541159e-07 0.1580883269013631 9.035731667127594e-07 0.1572048664554128 9.035732487657084e-07 0.1562816770844126 9.035733414693307e-07 0.1552436243401225 \
9.035734642494946e-07 0.153877370231325 9.035735633955881e-07 0.1527810927807017 9.035736648959354e-07 0.1516651170047695 9.035737661711264e-07 0.1505582666538253 \
9.035738626629106e-07 0.1495093242781697 9.035739620809454e-07 0.1484346886615803 9.03574046381569e-07 0.1475281828465028 9.035741393202594e-07 0.1465342051547719 \
9.035742219212e-07 0.1456551508734999 9.03574330687285e-07 0.1445034822456445 9.035744363302651e-07 0.1433917535370727 9.035745179898545e-07 0.1425365900703354 \
9.03574611735024e-07 0.1415598856352903 9.035747053029709e-07 0.1405903867550886 9.035747881874616e-07 0.139735765814107 9.035748763466362e-07 0.1388313836440244 \
9.035749561327221e-07 0.1380170907865772 9.035750497281216e-07 0.1370669869522621 9.035751396606458e-07 0.1361590166429519 9.035752102110423e-07 0.1354501541392388 \
9.035752799712188e-07 0.1347521119166949 9.035753941201258e-07 0.1336164586193709 9.035754760987401e-07 0.1328058651355588 9.035755637040425e-07 0.1319440719770354 \
9.035756632052385e-07 0.1309710196939938 9.035757723852409e-07 0.1299110174488692 9.03575874550573e-07 0.1289256009328031 9.035759820107788e-07 0.1278959836800649 \
9.035761020450569e-07 0.1267549558890445 9.035761962530915e-07 0.1258657925752028 9.035763272321949e-07 0.1246390638240933 9.035764266598964e-07 0.1237164070883829 \
9.035765357815822e-07 0.1227104370444639 9.035766446347502e-07 0.1217138859540913 9.035767369441535e-07 0.120874257454373 9.035768497844843e-07 0.1198547128626846 \
9.035769467965243e-07 0.118986084968971 9.035770510628723e-07 0.1180628196869088 9.035771600298026e-07 0.1171053395831002 9.035772595693682e-07 0.1162371554254778 \
9.035773765620782e-07 0.1152245300989246 9.035774636628685e-07 0.1144761644999183 9.0357757295452e-07 0.1135478691973115 9.035776544795827e-07 0.1128618460838699 \
9.035777542545759e-07 0.1120273350449922 9.035778716797259e-07 0.1110526766231405 9.035779734648438e-07 0.1102143708571793 9.035780612037922e-07 0.1094962336869811 \
9.035781420032999e-07 0.1088432886892514 9.035782289543191e-07 0.1081456845520918 9.035783097409447e-07 0.1075007757815706 9.035783999475114e-07 0.1067842832273628 \
9.03578490898266e-07 0.1060655611559195 9.035785795687901e-07 0.1053685613006139 9.035786785836106e-07 0.1045946508745568 9.035787722897869e-07 0.1038723470842792 \
9.035788661490627e-07 0.1031520741219857 9.035789669765109e-07 0.1023817709659086 9.035790716074087e-07 0.1015861061604995 9.03579195570165e-07 0.1006484085638475 \
9.035792929694782e-07 0.09991551135558702 9.035794132274253e-07 0.09901872452754552 9.035795240953005e-07 0.09819831936474602 9.035796285683363e-07 0.09742874659471555 \
9.035797458050451e-07 0.09656937225591002 9.035798475993662e-07 0.09582695326576983 9.035799455749167e-07 0.09511577589263259 9.035800860794065e-07 0.09410164141823299 \
9.035801911572026e-07 0.09334832721827611 9.035802897700187e-07 0.09264549593674179 9.035803824848273e-07 0.09198739948435641 9.035804686832123e-07 0.09137785861853052 \
9.035805625961876e-07 0.09071637432184691 9.035806596969337e-07 0.09003559055802626 9.03580769117988e-07 0.08927317549644689 9.035808701015371e-07 0.08857281843916648 \
9.035809637594832e-07 0.08792605868920525 9.035810379341552e-07 0.08741581771673042 9.03581175834007e-07 0.08647193599618339 9.035812481910108e-07 0.08597917321277694 \
9.035813835122141e-07 0.08506274029062395 9.035814694238194e-07 0.08448410751389913 9.03581614152054e-07 0.08351486081643937 9.035817103826188e-07 0.0828744112740944 \
9.035817982183981e-07 0.08229260392026354 9.035819140173063e-07 0.08152964121883956 9.035820291457576e-07 0.08077575264951149 9.035821429121899e-07 0.08003553900012179 \
9.035822831696827e-07 0.0791300282244784 9.035824245457161e-07 0.07822490276368012 9.035825741817576e-07 0.07727536491519127 9.035827186706131e-07 0.07636690312463701 \
9.035828698447241e-07 0.07542565384097814 9.035830192155436e-07 0.07450459906593411 9.03583168562251e-07 0.0735926433331697 9.035833285177668e-07 0.07262574717347114 \
9.035834846646777e-07 0.07169171823582712 9.035836591531124e-07 0.07065947636250877 9.035838288622191e-07 0.0696671357044583 9.035840140413029e-07 0.0685979885997255 \
9.035842107623799e-07 0.06747763456279594 9.035844212801998e-07 0.06629631776014881 9.03584643312255e-07 0.06507007089066431 9.035848735242763e-07 0.0638195278444372 \
9.035851160353819e-07 0.06252626147401 9.035853766894672e-07 0.06116236403900636 9.035856565885314e-07 0.05972739422233359 9.035859501722554e-07 0.05825544847408989 \
9.035862651082392e-07 0.05671370145268265 9.035866079141644e-07 0.05507846134953124 9.035869573807585e-07 0.0534565727116736 9.035873662849151e-07 0.05161746230842366 \
9.035877129499425e-07 0.05010669351290297 9.035881003649954e-07 0.04846839895323611 9.035884445827877e-07 0.04705645202362623 9.035887680090468e-07 0.04576625679949029 \
9.03589073054809e-07 0.04458093278443617 9.035893659168059e-07 0.04347099288378908 9.035896500577228e-07 0.04242242262004604 9.035899260780149e-07 0.04142902112907627 \
9.03590192930566e-07 0.04049015932812138 9.035904618227892e-07 0.03956531631184226 9.035907378832112e-07 0.03863769040165695 9.035910254787821e-07 0.03769451689421055 \
9.035912650444082e-07 0.03692662498323904 9.03591554211835e-07 0.03602084344675294 9.03591770003438e-07 0.03535960341037672 9.035919577204763e-07 0.03479599077274986 \
9.035921558495825e-07 0.03421285035004928 9.03592518724446e-07 0.03317032497347058 9.03592776866276e-07 0.03244834222605905 9.035930865791899e-07 0.0316030971185694 \
9.035933520493286e-07 0.03089664771451467 9.035936201684082e-07 0.03019941363307669 9.03593899042439e-07 0.02949128999862272 9.035941452288756e-07 0.02888043298519722 \
9.035943758602852e-07 0.02832033800396738 9.035946141502041e-07 0.02775711540944564 9.035948491575684e-07 0.02721270742060762 9.03595076940031e-07 0.02669509678424227 \
9.035954855523029e-07 0.02579039168486155 9.035956618546319e-07 0.02540904040268441 9.03596016332316e-07 0.02465798827491217 9.035962002032882e-07 0.02427641469830137 \
9.035965351520103e-07 0.02359448510613503 9.035966990607275e-07 0.02326678168937357 9.035970913313035e-07 0.02249905491676728 9.035972473220689e-07 0.02220010404946675 \
9.035976789254263e-07 0.02138321689778962 9.035978163148065e-07 0.0211255367654138 9.03598333123589e-07 0.02017559010600388 9.035984586594828e-07 0.01995091418019728 \
9.035989159010076e-07 0.01915998482559782 9.035990750469891e-07 0.01889493739859509 9.035996822854669e-07 0.01793263500095189 9.03599816822955e-07 0.01772934138481063 \
9.036004800869477e-07 0.01678091027541291 9.036006734103789e-07 0.01651856846389665 9.036013410670396e-07 0.01565087920017967 9.03601502655887e-07 0.01544858341705342 \
9.0360225789114e-07 0.01454101846553843 9.036024074521069e-07 0.01436800730673201 9.036032977899311e-07 0.01338293844200974 9.036033964478168e-07 0.01327873262558703 \
9.03604353121314e-07 0.01230993787860994 9.036044742310215e-07 0.01219243157195396 9.036054657237297e-07 0.01126376273051215 9.036056292524602e-07 0.01111855113153209 \
9.036067591745355e-07 0.01018247077230436 9.036068716217738e-07 0.01009565848301377 9.036082494452622e-07 0.009103273453806031 9.036083883905334e-07 0.009009747578659758 \
9.036099427888683e-07 0.008018073335410726 9.0361005485534e-07 0.00794673960805117 9.036116998381698e-07 0.006958154532207958 9.036118070906645e-07 0.006899512253112593 \
9.036137515841525e-07 0.005937533026687714 9.036139584821097e-07 0.005843834961138424 9.036162973698525e-07 0.00487227039639981 9.036167213562637e-07 0.004712306502041247 \
9.036194935894604e-07 0.003780857497341114 9.036199418985521e-07 0.003647790772321777 9.03623582397237e-07 0.00272553831825111 9.036240790530716e-07 0.002619503085887757 \
9.036298301734959e-07 0.001650572925599863 9.036301169553824e-07 0.001609446887446839 9.036354719440668e-07 0.0006353228983793809 9.036356773006917e-07 0.0005920420449145349 \
9.062827120745073e-07 -0.0002718533828215428 9.062828679501106e-07 -0.0004579010352009555 9.062834162652027e-07 -0.001326296959495401 9.062835290488786e-07 -0.001543805653187533 \
9.062839635410184e-07 -0.002491429791030493 9.062840393661748e-07 -0.002673591589873599 9.062843960167732e-07 -0.003590195133438418 9.062845230658532e-07 -0.003936807634339821 \
9.062848015662471e-07 -0.004716444651655622 9.062849096507304e-07 -0.005020876868076652 9.06285253249855e-07 -0.00592430224391268 9.062853602437201e-07 -0.006162325733041658 \
9.062862596141159e-07 -0.005653094509861465 9.062864380475456e-07 -0.004687598829536962 9.062865437709605e-07 -0.003940993102967527 9.062866688337377e-07 -0.002883597584075996 \
9.062867624178337e-07 -0.001971418478057775 9.062868402573964e-07 -0.001132968824455395 9.062869203293945e-07 -0.0001977429743171 9.062870427022046e-07 0.001370578777960296 \
9.062871609580771e-07 0.003041212838230153 9.062872796071872e-07 0.004860750887681821 9.062873930896259e-07 0.006730904986417607 9.062874965327644e-07 0.008536402178002854 \
9.062876111920181e-07 0.01064190690353853 9.062878017758113e-07 0.0143607330143792 9.062879355659492e-07 0.01711819191720031 9.062880858195148e-07 0.02033933849841947 \
9.062882409887624e-07 0.02378599874269359 9.062883963808114e-07 0.0273434151175349 9.062885440880426e-07 0.03080849965087477 9.062886930776679e-07 0.03437359286003162 \
9.06288848068751e-07 0.03814545786868043 9.062890074393647e-07 0.04208062121327779 9.062891723727756e-07 0.04620305710844342 9.062893473191045e-07 0.0506208066052034 \
9.062895264491763e-07 0.05518387280380205 9.062897162384316e-07 0.06005265756871143 9.062899199354002e-07 0.06530840376289772 9.062901397459318e-07 0.07100650943730057 \
9.062903714973765e-07 0.07703584544314998 9.062906193226736e-07 0.08349927754587044 9.062908906436034e-07 0.09058756662233436 9.062911853563813e-07 0.09829181712822582 \
9.062915106140292e-07 0.106792896697727 9.062918768597349e-07 0.1163551101154179 9.062922701564476e-07 0.1266079356677421 9.062927228093434e-07 0.1383809089651769 \
9.062932485245107e-07 0.1520098384503803 9.06293867738049e-07 0.1679979965193872 9.062945484823656e-07 0.1854865650013753 9.062953421573203e-07 0.2057488551561759 \
9.062962309229533e-07 0.2282732214494322 9.062970443122153e-07 0.2487218262351868 9.062977660617924e-07 0.2667261628598245 9.062984017258004e-07 0.282460740414376 \
9.062989734425617e-07 0.2965101025186013 9.062995089968458e-07 0.3095696210007924 9.063000123552588e-07 0.3217495654069301 9.063004886827014e-07 0.3331878525640654 \
9.063009626063057e-07 0.3444754071334732 9.063014200780244e-07 0.3552759747331513 9.063018860582939e-07 0.3661792384270033 9.063023350461038e-07 0.376592601923634 \
9.063028311526456e-07 0.3879857357798637 9.063033509145082e-07 0.3998002499051578 9.063037303191525e-07 0.4083447473225827 9.063041703278756e-07 0.4181679450526055 \
9.063046400968135e-07 0.4285466970600206 9.063051256177521e-07 0.4391589006481625 9.063055650658585e-07 0.4486701556983262 9.063056268188068e-07 0.4500002248264944 \
9.063057503247037e-07 0.4526540461147197 9.063059973364976e-07 0.4579447795386873 9.063062499314088e-07 0.463325462421476 9.063064475025244e-07 0.467511453725808 \
9.063066730742714e-07 0.4722681264242033 9.06306994642268e-07 0.4790073975813253 9.063072634214966e-07 0.4846013351959894 9.0630748207297e-07 0.4891262574467725 \
9.063076921769364e-07 0.4934547887280634 9.063079185824616e-07 0.4980921872304203 9.063081276876521e-07 0.5023516957637455 9.063083170899106e-07 0.5061927337048852 \
9.06308441251129e-07 0.5086969563931187 9.063085680062259e-07 0.5112441466129884 9.06308728004704e-07 0.5144514110933732 9.063089756476561e-07 0.5193914248715521 \
9.063091542341148e-07 0.5229351592435862 9.063093251876918e-07 0.5263079149198099 9.063095865372878e-07 0.5314455197962068 9.063098126088702e-07 0.5358634945234868 \
9.063100157405373e-07 0.5398188128751134 9.063101809712675e-07 0.5430252218652345 9.063103377582877e-07 0.5460612552756139 9.063105269149052e-07 0.5497137532216215 \
9.063107287826585e-07 0.5535976061995346 9.06310952933981e-07 0.5578986282275192 9.063111913163462e-07 0.5624617013850463 9.06311426077985e-07 0.566941985223824 \
9.063116563486904e-07 0.5713275351537204 9.063118621413239e-07 0.5752375533958141 9.063120671255381e-07 0.5791255875933676 9.063123099407797e-07 0.5837094709690289 \
9.063125646983618e-07 0.588493349632063 9.063127929267933e-07 0.5927514274590796 9.063130307656652e-07 0.5971656109489694 9.063132430431007e-07 0.6010807441713891 \
9.063134548365055e-07 0.6049674646600495 9.06313708720774e-07 0.6095919957414236 9.063139133143013e-07 0.6132953190650409 9.063141650376543e-07 0.6178178328453598 \
9.063143528271743e-07 0.6211736970442716 9.063146057002513e-07 0.6256587164710262 9.063148041096133e-07 0.6291560967673944 9.06314983842284e-07 0.6323071487074056 \
9.063152541130913e-07 0.6370161336915187 9.063154713968567e-07 0.6407803561788556 9.063156519232363e-07 0.6438916924996977 9.063158530841307e-07 0.6473460740030906 \
9.063160216675126e-07 0.650231451944099 9.063162260257197e-07 0.6537144072723954 9.063163716887783e-07 0.6561873372238678 9.063165362473771e-07 0.6589728476742622 \
9.063167057165935e-07 0.6618316558839334 9.063168592566751e-07 0.664412775690417 9.06317000490202e-07 0.6667750288922751 9.063171440660136e-07 0.6691685747430841 \
9.063172772961389e-07 0.6713840140331436 9.063174191964593e-07 0.6737368819239464 9.063175394300862e-07 0.6757233098298149 9.063176840811383e-07 0.6781085120392751 \
9.063178002998436e-07 0.6800197521569988 9.063179193821632e-07 0.6819757159594566 9.063180179604766e-07 0.6835903813535821 9.063181355581832e-07 0.6855122399681081 \
9.063182229941461e-07 0.6869376986921233 9.063183477402321e-07 0.6889650632873403 9.063184475472963e-07 0.6905825000046129 9.063185400370926e-07 0.6920753042469043 \
9.063186413211772e-07 0.6937043390836264 9.063187391142832e-07 0.695273833970533 9.063188303850745e-07 0.6967333967490603 9.063189328429049e-07 0.6983656370917724 \
9.063190657521355e-07 0.7004728611232253 9.063192207675414e-07 0.7029137789397926 9.063193556492268e-07 0.7050222373350452 9.063195011450183e-07 0.7072806469370021 \
9.063196289996853e-07 0.709252249158637 9.063197534579805e-07 0.7111597484283609 9.063198647836849e-07 0.7128563623504806 9.063199788137126e-07 0.7145852226468989 \
9.063200793249296e-07 0.7161013069709498 9.063202165260769e-07 0.7181590832501857 9.063203364719788e-07 0.7199473375636642 9.06320455641778e-07 0.7217141075019444 \
9.063205825867916e-07 0.7235855504531626 9.063207073542093e-07 0.7254141264975077 9.063208308495972e-07 0.7272133847865295 9.063209576308701e-07 0.7290498056238117 \
9.063210882203554e-07 0.730930225429108 9.063212104322583e-07 0.7326797786847141 9.063213474902715e-07 0.7346298644824388 9.063214487056265e-07 0.7360619656663578 \
9.063215536745618e-07 0.7375401619041119 9.06321645165995e-07 0.7388229997694907 9.06321758241356e-07 0.7404001534680551 9.063218455422403e-07 0.7416107338190071 \
9.063219500055705e-07 0.7430512000342341 9.063220807687029e-07 0.7448411286358657 9.063221906822003e-07 0.7463352048609909 9.063222953419584e-07 0.7477488743938407 \
9.0632241917362e-07 0.7494094725133206 9.063225679269713e-07 0.751387874302702 9.06322689842132e-07 0.7529958494242643 9.063228036963925e-07 0.7544867042370438 \
9.0632294419585e-07 0.7563117925204224 9.063230855193645e-07 0.7581313010100689 9.063232032989716e-07 0.7596352654099263 9.063233316974594e-07 0.7612620174900669 \
9.063234740211609e-07 0.7630496612437514 9.063235904103157e-07 0.7644991888858087 9.063237361339775e-07 0.7662987831554334 9.063238579138671e-07 0.7677897310961733 \
9.06323976478797e-07 0.7692300520321635 9.063240990922458e-07 0.7707078417740018 9.063242255436291e-07 0.77221964326554 9.06324335666584e-07 0.7735261258099556 \
9.063244611887263e-07 0.7750039859681491 9.06324566849672e-07 0.7762386743660952 9.063247020268293e-07 0.7778058706872942 9.063248256373457e-07 0.7792267957652825 \
9.06324955634725e-07 0.7807078764205345 9.06325068606223e-07 0.7819831642610904 9.063251765001111e-07 0.7831908181350914 9.063253130307933e-07 0.7847046126527283 \
9.063254631517019e-07 0.7863508260127218 9.063256054160057e-07 0.7878933964149381 9.063257249975189e-07 0.7891771019825847 9.063258618086489e-07 0.7906313890246753 \
9.063259843124129e-07 0.7919206245676671 9.06326128984341e-07 0.7934276941869095 9.063262697694142e-07 0.794878360380241 9.063263965852094e-07 0.796171745508174 \
9.063265156326017e-07 0.7973744708066829 9.063266278955628e-07 0.7984986270115709 9.063267322833333e-07 0.7995352562746869 9.063268275603949e-07 0.8004739840425704 \
9.063269639028913e-07 0.8018044219089175 9.063270807679598e-07 0.8029326473252685 9.063272003644895e-07 0.8040757482679398 9.063273222502994e-07 0.8052288531124292 \
9.063274448385593e-07 0.8063765489401953 9.063275725796179e-07 0.8075599074701925 9.06327697362526e-07 0.8087035441861687 9.063278278629006e-07 0.8098867241643505 \
9.063279542295968e-07 0.8110199871086299 9.063280815783889e-07 0.8121498004723215 9.063281867911793e-07 0.8130740322933268 9.063282914951838e-07 0.8139855427426806 \
9.063283830253901e-07 0.8147757515715357 9.063285063983601e-07 0.8158311616195392 9.063285933524083e-07 0.8165684017534872 9.063286922082446e-07 0.8173999442793862 \
9.063288367108844e-07 0.8186029267949408 9.063289730365725e-07 0.8197243345631372 9.063290824450085e-07 0.8206145128367788 9.06329228461948e-07 0.821788834531623 \
9.063293802030074e-07 0.8229927727264784 9.063295061195854e-07 0.8239792970156907 9.063296505686489e-07 0.8250971468990039 9.063297752648171e-07 0.8260503472050121 \
9.063299258788342e-07 0.8271873005969326 9.063300612493022e-07 0.8281959289694237 9.063301864729373e-07 0.8291179217777711 9.063303041288968e-07 0.8299746468143927 \
9.063304499105104e-07 0.8310230722388168 9.063306163942599e-07 0.8322027532553667 9.063307472150236e-07 0.8331167337813133 9.063309206750455e-07 0.834311196379941 \
9.063310887878414e-07 0.8354501125721271 9.063312586689692e-07 0.8365827385393307 9.063314395126275e-07 0.8377685497174457 9.06331582704692e-07 0.8386931238161603 \
9.063316968221893e-07 0.8394210074154138 9.063318268737994e-07 0.8402408682651782 9.063319287535162e-07 0.8408758513273116 9.063320456411388e-07 0.841596551294542 \
9.063321827868591e-07 0.8424315815669623 9.063323806960721e-07 0.8436167827761205 9.063325725154114e-07 0.8447436440637145 9.063327818661576e-07 0.8459494874145237 \
9.063329640177679e-07 0.8469786287449077 9.063331611039906e-07 0.8480715276019779 9.063333343567188e-07 0.8490148531186206 9.063335174509633e-07 0.8499943787178993 \
9.063336885824298e-07 0.8508936588199895 9.063338632702718e-07 0.8517955326875627 9.063340385042872e-07 0.8526841769874772 9.063342146411542e-07 0.8535614892404448 \
9.063344050084937e-07 0.8544920815553035 9.063345955808446e-07 0.8554057038167108 9.063347959768378e-07 0.8563474066245403 9.063349885664634e-07 0.8572344253714166 \
9.06335199466375e-07 0.858185963363946 9.063354273418617e-07 0.8591913103610016 9.063356934247181e-07 0.8603357477151101 9.063359919268544e-07 0.8615822374427254 \
9.063362678163234e-07 0.8627000332972231 9.063365520834926e-07 0.8638181192989086 9.063368262214432e-07 0.8648650323418529 9.06337098522366e-07 0.8658754039994767 \
9.063373686785625e-07 0.8668495780678541 9.063376258626988e-07 0.8677515347235455 9.063378984216133e-07 0.8686810999091764 9.063381744693315e-07 0.8695957110915412 \
9.063384445895985e-07 0.8704649939918846 9.063387444494889e-07 0.8714007440816277 9.063391154301144e-07 0.8725171209518352 9.063394103525362e-07 0.8733732402027278 \
9.063396646282708e-07 0.8740897163373675 9.06339962841735e-07 0.8749052413925265 9.063402364113466e-07 0.8756305047096297 9.063404725347486e-07 0.8762394088953867 \
9.063407128598863e-07 0.8768433401198644 9.063409351938211e-07 0.8773882060838187 9.063411292002539e-07 0.8778530214284207 9.063414589096811e-07 0.8786208714695904 \
9.0634161408109e-07 0.87897283049042 9.063419317234907e-07 0.8796750328643211 9.063421106040348e-07 0.8800599154915705 9.063424530647979e-07 0.8807759898408113 \
9.063426372672098e-07 0.8811501695110489 9.063431122965131e-07 0.8820806183873429 9.06343279683462e-07 0.8823969901232691 9.063437454598435e-07 0.8832471741583867 \
9.063439262991872e-07 0.8835657112976044 9.063444203088052e-07 0.8844044135654346 9.063445616237109e-07 0.8846360992458032 9.063451678673265e-07 0.8855901496945974 \
9.063453199425257e-07 0.8858196526512701 9.063459666625989e-07 0.8867549368993356 9.063460949492666e-07 0.8869330782847171 9.063467431586864e-07 0.8877977435561634 \
9.063468728829849e-07 0.8879638504720397 9.063476413020526e-07 0.8888993076310558 9.063477710739033e-07 0.8890488273083775 9.063486247365088e-07 0.8899738047157748 \
9.063487677615613e-07 0.8901192131187072 9.063497540670479e-07 0.8910487927319016 9.063499755535999e-07 0.8912403904783051 9.063511183781384e-07 0.8921548233216382 \
9.063512482580762e-07 0.8922544308366913 9.06352600758498e-07 0.8932425879319322 9.063527510414313e-07 0.8933452769452155 9.063542315756977e-07 0.8942627870546499 \
9.063544704854918e-07 0.8943950258099049 9.063562525184327e-07 0.8952625983306248 9.063566382658602e-07 0.895426813549116 9.063590404240788e-07 0.8963023915260389 \
9.063595153600486e-07 0.8964490046842035 9.063634332871646e-07 0.8974035634625627 9.063639032474093e-07 0.8974927205890085 9.063722720353867e-07 0.8984807567386782 \
9.063724925457144e-07 0.8984960697096243 9.064170720742926e-07 0.8994905034760702 9.064182734601915e-07 0.8995076493514624 9.065540832686942e-07 0.9004821828323031 \
9.065542622454191e-07 0.9005421539807538 9.065577071203374e-07 0.8996085030263692 9.065578799041917e-07 0.8994755022453073 9.065592062238996e-07 0.8985168769831137 \
9.06559392989208e-07 0.8983970610744239 9.065611771942331e-07 0.8974304740967198 9.065613893245152e-07 0.8973403978332656 9.065747300202991e-07 0.8983331062395279 \
9.065748433081446e-07 0.8983517458922662 9.065835466612413e-07 0.8993273409280406 9.065840944718199e-07 0.8993637478389299 9.070766218437148e-07 0.9003542216796759 \
9.070767175825666e-07 0.9004233209197793 9.070776601319424e-07 0.9014023545001312 9.070778225852538e-07 0.9016297223302431 9.070783892915005e-07 0.9025464066367429 \
9.070784964622122e-07 0.9027401250447874 9.07078889770564e-07 0.9035002370985188 9.07079022567928e-07 0.9037710185404622 9.070794021690343e-07 0.9045728679206633 \
9.070795323837805e-07 0.9048512534150681 9.070799937900729e-07 0.9057878278182891 9.070801130371311e-07 0.9060008176934132 9.070815426461655e-07 0.9050557440230738 \
9.070816263162926e-07 0.9046580283931719 9.07081751622122e-07 0.9039622140338933 9.070818594362906e-07 0.9032622438705011 9.070819784306371e-07 0.9023800387125585 \
9.070820938028541e-07 0.9014106868475621 9.070821838997508e-07 0.900578017289966 9.070822953474548e-07 0.8994526603282017 9.070823814266029e-07 0.8985125975436928 \
9.070824873922515e-07 0.8972736935213672 9.070825871606176e-07 0.8960214106762436 9.070826681562277e-07 0.8949470092681954 9.070827778041954e-07 0.8934133399212493 \
9.070828633916056e-07 0.8921520042367302 9.070829555142148e-07 0.8907345325087322 9.070830437335979e-07 0.8893220116766375 9.070831525083507e-07 0.8875100775672261 \
9.070832354013855e-07 0.8860780350921965 9.070833439750573e-07 0.8841400608632336 9.070834362012525e-07 0.8824412727986957 9.070835208217502e-07 0.8808423775446282 \
9.0708360666218e-07 0.8791839877465467 9.0708368587706e-07 0.8776224824828824 9.070837619650304e-07 0.8760960492665846 9.070838543013987e-07 0.874210837196514 \
9.070839141777347e-07 0.8729702140710593 9.070839715660191e-07 0.8717685933706794 9.070840335611921e-07 0.8704574090763495 9.070840968400434e-07 0.8691057216070059 \
9.07084146911381e-07 0.8680269866686803 9.070841963535335e-07 0.8669542389500936 9.070842600232402e-07 0.8655623656543436 9.070843359706592e-07 0.8638877358586781 \
9.070843848016709e-07 0.8628032002737418 9.070844333256242e-07 0.8617197496806845 9.070845090373469e-07 0.8600184098866027 9.070845762461248e-07 0.8584975010852487 \
9.070846189526311e-07 0.8575263577286506 9.070846628552044e-07 0.8565244243916033 9.070847506603508e-07 0.8545103166059256 9.070848135135196e-07 0.8530605771626394 \
9.070848721831767e-07 0.8517018597088126 9.070849083617784e-07 0.8508614974547222 9.07084943180258e-07 0.8500510151036469 9.070849782062432e-07 0.8492340038666518 \
9.070850482582133e-07 0.8475953578585981 9.07085096728698e-07 0.8464581214772323 9.070851406734991e-07 0.8454248116355969 9.070851861912554e-07 0.8443523575543517 \
9.070852500921663e-07 0.8428433081697474 9.070853162185395e-07 0.8412777165526386 9.07085421348608e-07 0.8387809254526315 9.070855092832832e-07 0.8366857089760468 \
9.070855882285648e-07 0.834800137446173 9.070856763936022e-07 0.8326899670047023 9.070857632095988e-07 0.8306078985741704 9.070858511012833e-07 0.8284959280419055 \
9.070859423503732e-07 0.8262996967350639 9.070860451122408e-07 0.8238226494465998 9.070861436157165e-07 0.8214450402687625 9.070862559486315e-07 0.8187302447322098 \
9.070863689227677e-07 0.8159967029774419 9.070864902106627e-07 0.8130591602364435 9.070866207178167e-07 0.8098958628758253 9.070867497637196e-07 0.8067658935936169 \
9.070869032393198e-07 0.8030416153605923 9.070870685235404e-07 0.799029304640783 9.070872362647446e-07 0.7949567682299736 9.070874327883338e-07 0.7901857478752816 \
9.07087637550659e-07 0.7852160332972318 9.070878502277153e-07 0.7800563994093253 9.070880508476619e-07 0.7751902022758907 9.070882517063895e-07 0.7703212856706637 \
9.070884017284074e-07 0.766686939713112 9.070885322635739e-07 0.7635264252913375 9.070886666810141e-07 0.7602735436595947 9.070887728765445e-07 0.7577048602246427 \
9.070889061828773e-07 0.754482067181252 9.070890132158028e-07 0.7518959494812111 9.070891562917044e-07 0.7484409822837247 9.070893207978459e-07 0.7444713482725677 \
9.070894416150924e-07 0.74155777711076 9.070896127217564e-07 0.7374334100931738 9.070897736123089e-07 0.733558046396253 9.070899902049296e-07 0.7283457217000903 \
9.070901834606308e-07 0.7236999380850822 9.07090362395765e-07 0.7194029726762079 9.070905292123874e-07 0.7154015770462002 9.070907154183522e-07 0.7109395231330657 \
9.070909033515934e-07 0.7064416825495208 9.070910692736985e-07 0.7024749886985119 9.07091261631787e-07 0.6978803202016938 9.07091402988682e-07 0.6945068232011449 \
9.070915599964439e-07 0.6907636199298515 9.07091755976089e-07 0.6860965106368763 9.070919184101942e-07 0.6822325558671515 9.070920795863762e-07 0.6784034260021697 \
9.070922718945738e-07 0.6738409413562468 9.070924895564538e-07 0.6686845685784016 9.070927375777556e-07 0.6628199086538362 9.07092915635219e-07 0.6586162961343578 \
9.070931641790282e-07 0.6527567611811057 9.070933667862709e-07 0.6479896840619462 9.07093536596938e-07 0.6440011601507294 9.070936952131239e-07 0.6402799599229552 \
9.070938337435587e-07 0.637035894415233 9.070939699513214e-07 0.6338503464729111 9.070940962626978e-07 0.6309003762865483 9.07094225721933e-07 0.6278810604265532 \
9.070943540536725e-07 0.6248911458464299 9.070944853836027e-07 0.6218374290191309 9.070946174102147e-07 0.6187713222160208 9.070947615700951e-07 0.6154276788919771 \
9.07094905778687e-07 0.6120888358645944 9.070950534337911e-07 0.6086753592300279 9.070952004901491e-07 0.6052842859263143 9.070953583041756e-07 0.6016504852589418 \
9.070954909098277e-07 0.5986039825107707 9.070956223747947e-07 0.5955897059985247 9.070957418045935e-07 0.5928552647156846 9.070958778732862e-07 0.5897484304797134 \
9.070959928015483e-07 0.5871283594046445 9.070961439122688e-07 0.5836892419704927 9.070962585613367e-07 0.5810871834776226 9.070963764990063e-07 0.5784138884735546 \
9.070964662802944e-07 0.576381560286313 9.070965565996887e-07 0.5743415774978985 9.070966232905592e-07 0.5728373329037385 9.070966888523723e-07 0.5713590910263378 \
9.070967398944957e-07 0.5702089751121119 9.070968015962151e-07 0.5688198806440578 9.070968646860707e-07 0.5674025889664359 9.070969290444246e-07 0.5659586381304559 \
9.070969824382235e-07 0.5647616504486359 9.070970750808061e-07 0.5626864159088959 9.070971516880784e-07 0.5609719030357503 9.070972075131406e-07 0.5597256439368602 \
9.070972765672667e-07 0.5581857825097393 9.070973834553925e-07 0.5558054549196561 9.070974611990176e-07 0.5540764009223496 9.070975620491173e-07 0.5518382286767042 \
9.070976877299716e-07 0.5490568313009737 9.070977879716568e-07 0.5468419758621708 9.070978998893402e-07 0.5443739014182352 9.070980031552469e-07 0.5421024366463116 \
9.070981229045887e-07 0.5394737463112931 9.070982246374689e-07 0.5372436950013484 9.070983401572132e-07 0.5347185748314579 9.070984551922987e-07 0.5322102907975605 \
9.07098581673211e-07 0.529456475824718 9.070987070470086e-07 0.5267350629320526 9.070988538629319e-07 0.5235577714138258 9.070989894263807e-07 0.5206304261698983 \
9.070991471246342e-07 0.5172373565578411 9.070993094436886e-07 0.5137528589513558 9.070994902675847e-07 0.5098871206809381 9.070996827159053e-07 0.5057874350093188 \
9.070998956212086e-07 0.5012700264709963 9.071001278026081e-07 0.4963634062180514 9.071003850931866e-07 0.4909555076455908 9.071006247190101e-07 0.4859407514401474 \
9.071009264344461e-07 0.479662588092526 9.071012143537997e-07 0.4737079198104491 9.071015272426188e-07 0.4672821326282255 9.071018469808238e-07 0.4607585360408045 \
9.071021865759847e-07 0.4538766993710576 9.071025134784829e-07 0.4472977926730654 9.071028490368641e-07 0.4405887635920606 9.071031661327867e-07 0.4342949501181722 \
9.071035003705415e-07 0.4277061431972559 9.071038518016635e-07 0.4208322784122511 9.071041663278176e-07 0.4147233751108969 9.071044895053079e-07 0.4084912998479469 \
9.071049306200656e-07 0.400057814108821 9.071052727361034e-07 0.3935812134363078 9.071055726806327e-07 0.3879522399691127 9.071059478116384e-07 0.3809760137481454 \
9.071062775558776e-07 0.3749002425561211 9.071065607988036e-07 0.3697269896098562 9.071068609450588e-07 0.3642865787664632 9.071071405472531e-07 0.3592589179584539 \
9.071073643233647e-07 0.3552676761685443 9.071075761036954e-07 0.3515151294490645 9.071077785371594e-07 0.3479514629380864 9.071079796284271e-07 0.3444362246481504 \
9.071081853428453e-07 0.3408632458568372 9.071084529657171e-07 0.3362478643926977 9.071086918970113e-07 0.3321601360780691 9.07108925403074e-07 0.3281974319442653 \
9.071091388684735e-07 0.3246000376975314 9.071093602460465e-07 0.3208952602338652 9.071095602096931e-07 0.3175728982722026 9.07109764482006e-07 0.3142073831356898 \
9.071099618288777e-07 0.3109812293225088 9.071101472014048e-07 0.3079732989686547 9.071103433077958e-07 0.3048147723336881 9.071105455849362e-07 0.3015820927993307 \
9.071107212432327e-07 0.2988007390096292 9.0711090711339e-07 0.295878328903569 9.071111140927824e-07 0.2926488196724605 9.071112994143739e-07 0.2897857719971084 \
9.071114946411815e-07 0.2867989994419413 9.071116504155309e-07 0.28443329608414 9.071118291723129e-07 0.2817356906084737 9.071120102032329e-07 0.2790344478478936 \
9.071121601003466e-07 0.2768142575519123 9.071123611437743e-07 0.273859574769726 9.071125102589039e-07 0.2716833853889438 9.071126487983334e-07 0.2696726034832688 \
9.071128006734089e-07 0.2674956304896134 9.071129151475376e-07 0.2658586287383957 9.071130466774682e-07 0.2639823142040156 9.071131724359563e-07 0.2622048582339201 \
9.071132767763623e-07 0.2607341604582348 9.071133897557217e-07 0.2591418073851619 9.071135060842464e-07 0.2575033437579446 9.071136490116675e-07 0.2554974228347739 \
9.071137622731725e-07 0.2539102348881249 9.071138964299053e-07 0.2520298733123076 9.071140069027096e-07 0.2504818583075984 9.071141623352846e-07 0.2483006006477398 \
9.071143032203834e-07 0.2463217957442577 9.071144546129539e-07 0.2441928603691365 9.071146097750345e-07 0.2420086586735095 9.071147391842834e-07 0.2401849910837116 \
9.071148738963765e-07 0.2382868210192302 9.071150115942014e-07 0.2363478190565156 9.071151293462172e-07 0.2346905900295477 9.071152886704099e-07 0.2324499447852502 \
9.071154259326363e-07 0.2305210708572645 9.071155666789934e-07 0.2285488733964877 9.071156724701667e-07 0.2270688194984586 9.071158024115645e-07 0.2252532503786337 \
9.071159029480281e-07 0.2238506847401111 9.071160052817357e-07 0.2224250970611539 9.071160790103171e-07 0.2214012665004395 9.071161582442603e-07 0.2203047212273054 \
9.071162292155075e-07 0.2193236206014474 9.071162806785351e-07 0.218612902325451 9.071163336269882e-07 0.2178825126218075 9.071164127819908e-07 0.2167921001391954 \
9.071164550546258e-07 0.2162104926182252 9.071164948991708e-07 0.2156628374086678 9.071165381228203e-07 0.2150692779925967 9.071165790298224e-07 0.2145080585354088 \
9.071166491522842e-07 0.2135474129702876 9.071166828372557e-07 0.2130867492099046 9.071167276666377e-07 0.212477723463 9.071167865237997e-07 0.2116792343136102 \
9.071168513092604e-07 0.2108017053965978 9.071169087900244e-07 0.2100241135398916 9.071169692190328e-07 0.209207737948094 9.071170662554631e-07 0.2078991976528634 \
9.07117150945123e-07 0.2067595417901527 9.071172598558851e-07 0.2052972881712416 9.071173562566921e-07 0.2040065614180294 9.071174512733293e-07 0.2027428333585779 \
9.071175547051275e-07 0.2013717100485363 9.071176496344727e-07 0.2001158751783069 9.071177526548994e-07 0.198757993281026 9.071178577373321e-07 0.1973779917312911 \
9.071179670461462e-07 0.1959482000350934 9.07118077489628e-07 0.1945091075764383 9.071181937799036e-07 0.1929996650696684 9.071183037098964e-07 0.1915811184357085 \
9.071184133723204e-07 0.1901717999899754 9.071185150889654e-07 0.1888694322720079 9.071186080436791e-07 0.1876837490531375 9.071187007725689e-07 0.1865049219968967 \
9.07118774458125e-07 0.1855719169757668 9.071188572993398e-07 0.1845269810791141 9.071189318853364e-07 0.1835895008849975 9.071190016086783e-07 0.1827150226754214 \
9.071190683270854e-07 0.1818808699270075 9.071191641704113e-07 0.1806871657728035 9.071192468771838e-07 0.1796611249561687 9.071193404410075e-07 0.1785035608809835 \
9.071194353370949e-07 0.1773351434884491 9.071195467074052e-07 0.1759704596301353 9.071196883497589e-07 0.1742450478777388 9.071198035966122e-07 0.1728486436789435 \
9.071199481442513e-07 0.1711076225712051 9.071200597399285e-07 0.1697708811114609 9.07120200958902e-07 0.1680898955975501 9.071203166961755e-07 0.1667201145354908 \
9.071204226568607e-07 0.1654722325850081 9.071205214164775e-07 0.164314417410061 9.071206177596497e-07 0.1631901152369615 9.071207064174022e-07 0.1621596955203892 \
9.071208317516727e-07 0.1607099933926625 9.071209262770884e-07 0.1596224416957933 9.0712102401604e-07 0.1585042187118262 9.071211321109171e-07 0.1572745454417887 \
9.071212267786046e-07 0.1562036643369483 9.071213342264514e-07 0.1549951394274829 9.071214253154951e-07 0.1539767092330788 9.071215320872067e-07 0.1527896463435911 \
9.071216354804728e-07 0.1516469620792683 9.071217465609577e-07 0.1504267727114754 9.071218357869394e-07 0.1494522115900035 9.071219212668682e-07 0.1485231035185812 \
9.071220051920548e-07 0.1476157397758405 9.071220748986192e-07 0.1468658175993407 9.071221535366968e-07 0.1460232248551682 9.071222318479541e-07 0.1451880611912267 \
9.071223024838273e-07 0.1444378248611795 9.071223879746948e-07 0.1435337156153706 9.071224753636722e-07 0.1426139614481139 9.071225569511858e-07 0.1417594571206545 \
9.071226542701372e-07 0.1407454482154784 9.071227349596596e-07 0.139910090776864 9.071228257446906e-07 0.1389752404035735 9.07122947088963e-07 0.1377336220260025 \
9.071230361386038e-07 0.13682812281983 9.071231346554539e-07 0.1358318692385875 9.071232217417228e-07 0.1349560640726983 9.071233321526109e-07 0.1338550874529322 \
9.071234206114333e-07 0.1329791517134813 9.071235213400266e-07 0.1319874611681985 9.071236261295802e-07 0.1309622419763913 9.07123720519813e-07 0.1300442429014473 \
9.07123817024605e-07 0.1291112112475518 9.071239165112583e-07 0.1281591654439075 9.071240029124292e-07 0.1273384721630967 9.071240978925598e-07 0.1264411177628728 \
9.071242020813879e-07 0.1254629331099751 9.071243112001386e-07 0.124445178694 9.071244055505945e-07 0.1235704029653004 9.07124517846343e-07 0.1225411084520107 \
9.071246133096966e-07 0.1216733466577494 9.071247175205872e-07 0.1207311846737792 9.071248068659445e-07 0.1199276649878674 9.071248772532174e-07 0.1192980345746366 \
9.071249526392512e-07 0.1186268760051257 9.071250287714207e-07 0.1179522201461119 9.071250977489184e-07 0.1173458504859956 9.071251802680908e-07 0.1166263596898966 \
9.071252522115779e-07 0.1160015972854393 9.071253342903043e-07 0.1152916772467617 9.0712541862478e-07 0.1145654108773922 9.071254964186189e-07 0.113898375935255 \
9.071255891835211e-07 0.1131065723182637 9.071257047873425e-07 0.1121254933399327 9.071258106929114e-07 0.1112341778178403 9.071258883498311e-07 0.1105854195321705 \
9.071259766463023e-07 0.1098504899494786 9.071260567033545e-07 0.1091866403929743 9.071261536294793e-07 0.1083861389179563 9.07126248864964e-07 0.1076031391441806 \
9.071263374361586e-07 0.1068780200140514 9.071264387442598e-07 0.1060523297458165 9.071265442899472e-07 0.1051963702337609 9.071266534843118e-07 0.1043160928234657 \
9.071267616019328e-07 0.1034503663302994 9.071268815196937e-07 0.1024949450012773 9.071269828815214e-07 0.1016914181115986 9.071270888911508e-07 0.100855068690839 \
9.071272146827802e-07 0.09986840123414902 9.071273442400856e-07 0.09885896724496235 9.071274799154405e-07 0.09780904711780367 9.071276559873036e-07 0.09645781830037269 \
9.071278197878237e-07 0.09521257997344186 9.071279826125652e-07 0.09398642071914091 9.071280677512003e-07 0.09334985726464029 9.07128137589223e-07 0.09282999162688726 \
9.071282070848283e-07 0.09231474740697931 9.071282810434879e-07 0.09176875214326782 9.071283771983754e-07 0.09106241641841166 9.071284516137407e-07 0.09051841344162129 \
9.071285296033096e-07 0.08995079828656057 9.071286060521395e-07 0.08939693755534793 9.071286935462239e-07 0.08876614459792892 9.071287957229341e-07 0.08803382885421264 \
9.071288842873223e-07 0.08740269463919083 9.071289939528099e-07 0.08662585268124241 9.071291100092175e-07 0.08580942306245626 9.07129251558034e-07 0.0848216759818637 \
9.071293844270175e-07 0.08390253510334872 9.071295251873281e-07 0.08293727564630923 9.071296748969478e-07 0.08192024575105315 9.071298106088348e-07 0.08100683753927941 \
9.07129952125717e-07 0.08006309454860433 9.071300872475906e-07 0.07917070961097784 9.071302285200282e-07 0.07824718349428782 9.071303756129204e-07 0.07729532867436953 \
9.07130527122786e-07 0.07632524417621221 9.071306924984999e-07 0.07527819040792309 9.071308562596902e-07 0.07425356708383206 9.071310323896319e-07 0.07316505371836476 \
9.071312215286099e-07 0.07201151367936541 9.071314322022336e-07 0.07074528708793332 9.071316517688555e-07 0.06944624562626683 9.071318865352622e-07 0.06808094281860989 \
9.071321449277002e-07 0.06660616301228137 9.071324395923604e-07 0.06496103773121734 9.071327436716829e-07 0.06330286177969326 9.071331045821629e-07 0.06138472526627536 \
9.071334404990351e-07 0.05964719353945821 9.07133880676406e-07 0.05743991201668189 9.071342590438092e-07 0.05560437501227136 9.071347015027716e-07 0.05352996728430704 \
9.071350555229165e-07 0.05192508193542229 9.071354420396717e-07 0.05022502935509546 9.071357866437289e-07 0.04875485597254389 9.071361086186649e-07 0.04741934964807833 \
9.07136412152492e-07 0.04619304551845941 9.071367070734883e-07 0.04503122626702559 9.071369895557667e-07 0.04394770877170886 9.071372666361775e-07 0.04291147062934708 \
9.071375323636684e-07 0.04194013461971725 9.071378035943552e-07 0.0409708748276704 9.071380798533722e-07 0.04000619535229137 9.071383697525942e-07 0.03901828782233653 \
9.071385981289875e-07 0.03825741181922668 9.071389030130544e-07 0.03726495139513845 9.071391196849105e-07 0.03657573971894532 9.071393110416373e-07 0.03597943984071691 \
9.071395096361558e-07 0.03537298232318693 9.071398395514966e-07 0.03438820140908775 9.071400814971701e-07 0.03368375433354889 9.071403968092222e-07 0.03278771666975258 \
9.071406669292072e-07 0.03203957074185158 9.071409233008807e-07 0.03134567005659093 9.071412033128806e-07 0.03060515313352298 9.071414489686567e-07 0.02997014710356035 \
9.071416817043017e-07 0.02938120249260199 9.07141924434299e-07 0.02878348292867495 9.071421611615635e-07 0.02821317433052753 9.071423898079743e-07 0.0276732289298247 \
9.071428070936344e-07 0.02671456010533928 9.071430022743283e-07 0.02627749693639509 9.071433834414109e-07 0.02544369227895442 9.071435606942329e-07 0.02506446942885681 \
9.071439031456877e-07 0.02434654114125227 9.0714405641412e-07 0.02403127656358269 9.071444314325841e-07 0.02327616399748992 9.071445690667252e-07 0.02300530455388665 \
9.071450533333593e-07 0.02207084195640928 9.071451729527604e-07 0.02184403312078184 9.071455899915635e-07 0.02106026682208277 9.07145733393791e-07 0.02079332360769017 \
9.071462546051726e-07 0.01984598817089831 9.071463823790427e-07 0.0196205814374062 9.071469667914166e-07 0.01863359713481367 9.071471392268229e-07 0.01835589372257288 \
9.071477433235728e-07 0.01743644241612937 9.071479047552141e-07 0.01720262545858322 9.071485447014338e-07 0.01631831686205014 9.071487230176005e-07 0.016083210242981 \
9.071493710016487e-07 0.01526127675881721 9.071495362552397e-07 0.01505930898173208 9.071502725571753e-07 0.01419381259610907 9.071504068332254e-07 0.01404154276213586 \
9.071512039327432e-07 0.01317592498067951 9.071513445303545e-07 0.01302934089458718 9.07152309873577e-07 0.0120661300044765 9.071524742123827e-07 0.01190857475316222 \
9.071534749435119e-07 0.01099048917119646 9.071536122133689e-07 0.01087009009405628 9.071547509078863e-07 0.009949273443646761 9.071548650857871e-07 0.009863136028526375 \
9.071562457306217e-07 0.008889755784408603 9.071564000878327e-07 0.00878832203975914 9.071579465820611e-07 0.00781340401000951 9.071580309437644e-07 0.007760176032106158 \
9.07159716371082e-07 0.006770348169342283 9.071598398995725e-07 0.00670487246831437 9.071618897141387e-07 0.005720970231232756 9.071620861142965e-07 0.005634691917282852 \
9.071644047936537e-07 0.004698942116576918 9.071648654079885e-07 0.004530544077955615 9.071676055035305e-07 0.003639937533647344 9.071681236485673e-07 0.00349159181499799 \
9.071722742898753e-07 0.002502201117031859 9.071728121398824e-07 0.002396807933581942 9.0717889437533e-07 0.001421603691354927 9.071791533557404e-07 0.001378272220758726 \
9.071844761190904e-07 0.0003814093765652445 9.071845892761344e-07 0.0003711807182531981 9.098307063923701e-07 -0.0004615907568095335 9.098308688313385e-07 -0.0006852153244161934 \
9.098313698328068e-07 -0.001554404032531494 9.098314540153696e-07 -0.001725199767551738 9.098318555381937e-07 -0.002626792336557519 9.098319448731606e-07 -0.002845673237760077 \
9.098322314649697e-07 -0.0035898660494722 9.098323590334992e-07 -0.003937855927128601 9.098326777451613e-07 -0.004830400105952924 9.098327919463135e-07 -0.00515011308870196 \
9.098330743466381e-07 -0.005887653497963378 9.098332045728569e-07 -0.006177415671381139 9.09834182925754e-07 -0.005220113099403402 9.098343702332871e-07 -0.004004368716724641 \
9.098345016776888e-07 -0.002901539130564616 9.098346071052425e-07 -0.001869327786897239 9.098346928227261e-07 -0.0009323217369615201 9.098347747492128e-07 4.151965372454519e-05 \
9.098348957860361e-07 0.001618129410352471 9.098349947146828e-07 0.003024565667809575 9.098351531113568e-07 0.005482561958548801 9.098353705585866e-07 0.00923691162542661 \
9.098355517808095e-07 0.0126653356758144 9.09835763874906e-07 0.01697021734206094 9.098359268985627e-07 0.02046388365739064 9.098360875209785e-07 0.02403759527126768 \
9.09836241061221e-07 0.02755862871109176 9.098363891179021e-07 0.031036270750196 9.098365381988111e-07 0.03460722192241437 9.098366927287224e-07 0.03837091703902212 \
9.098368533795379e-07 0.04234026030123839 9.098370180342185e-07 0.04645786783841532 9.098371945751168e-07 0.05091770581196236 9.098373735379687e-07 0.05547793877747508 \
9.098375642811338e-07 0.0603721650098247 9.09837769062163e-07 0.06565647483694508 9.098379895344492e-07 0.07137203566208646 9.098382223941741e-07 0.0774299331224613 \
9.098384715816505e-07 0.08392829098722057 9.098387444237776e-07 0.09105513637423955 9.098390411275777e-07 0.09880974921055499 9.098393684539683e-07 0.1073623706929605 \
9.098397381053549e-07 0.11701033799881 9.098401329771689e-07 0.1273002725707723 9.098405908154096e-07 0.1392030195235975 9.098411226222497e-07 0.1529832553757746 \
9.09841747860046e-07 0.1691182447448397 9.098424336075175e-07 0.1867241161332086 9.098432360033912e-07 0.2071957342970069 9.098441348021829e-07 0.2299563735557614 \
9.098449404156324e-07 0.2501946571168963 9.098456541669657e-07 0.2679877251922811 9.098462837288477e-07 0.2835633151515627 9.098468540922982e-07 0.2975737963344939 \
9.098473850476803e-07 0.3105173405876944 9.098478868351306e-07 0.3226580892822354 9.098483661296844e-07 0.3341673054699896 9.098488316851033e-07 0.3452566901045974 \
9.098492954815109e-07 0.3562094254686541 9.098497512295406e-07 0.3668794056881832 9.098502114496752e-07 0.3775613305945491 9.098507497336462e-07 0.3899285626759094 \
9.098512505841795e-07 0.4013172511919189 9.098516508068632e-07 0.4103337945930838 9.09852157667644e-07 0.421642452039157 9.098526436338564e-07 0.4323669409017459 \
9.098530431485677e-07 0.4410997362599856 9.098534537606271e-07 0.4500002277813482 9.098538826870601e-07 0.4592207708982954 9.098542842014423e-07 0.4677760623951868 \
9.098545915918887e-07 0.4742753916877908 9.098549418336473e-07 0.4816249679276425 9.098552950738506e-07 0.4889795533930016 9.0985554824443e-07 0.4942125642332652 \
9.098557811883198e-07 0.4989990073547648 9.098560228316108e-07 0.5039392821429431 9.098562478222295e-07 0.5085102868389438 9.098564398583375e-07 0.5123881070394828 \
9.098566246700342e-07 0.5161059569497825 9.098568469603498e-07 0.5205538992744256 9.098570136717574e-07 0.5238726938135662 9.098572308883525e-07 0.5281726418673847 \
9.098574339672442e-07 0.5321820613122353 9.098576113786994e-07 0.5356681922482178 9.098577994510862e-07 0.5393528234657015 9.098580354832655e-07 0.5439555888699217 \
9.098583013652895e-07 0.5491186112539347 9.098585231271782e-07 0.5534070305875756 9.098588031850331e-07 0.5588091140818973 9.098590461848179e-07 0.5634839438879177 \
9.09859321538161e-07 0.5687575845994758 9.098595665335016e-07 0.5734440561015828 9.098598068277204e-07 0.5780305526007354 9.098600478670233e-07 0.5826153106864888 \
9.09860305457841e-07 0.5874946531182738 9.098605408246178e-07 0.5919209497705462 9.09860772126727e-07 0.5962518282209535 9.098609946534481e-07 0.6003950532231523 \
9.098612030130559e-07 0.6042587207462122 9.098614408548706e-07 0.6086392006348278 9.098616517150854e-07 0.612499186772883 9.09861907322267e-07 0.617151767543529 \
9.098621060500327e-07 0.620751700070918 9.098623816826772e-07 0.6257066023742009 9.098626044387981e-07 0.6296824120643636 9.098628978099215e-07 0.6348814180513288 \
9.098631305799232e-07 0.6389753720667986 9.098633507813091e-07 0.6428252659334456 9.098635520519211e-07 0.6463216644290061 9.098637693407936e-07 0.6500784077528632 \
9.098639440567036e-07 0.6530842133917786 9.098641303213334e-07 0.6562672470877895 9.098643090603858e-07 0.6593113758161715 9.098644717643993e-07 0.6620700940033843 \
9.098646370334098e-07 0.6648583661366954 9.098647803012238e-07 0.6672607123132118 9.098649195316479e-07 0.669583864918244 9.098650593322145e-07 0.6719085596965743 \
9.098651941074222e-07 0.6741424479378803 9.098653216016632e-07 0.6762463034350935 9.098654545557746e-07 0.6784344250006583 9.098655761601248e-07 0.680430207161383 \
9.098657045733663e-07 0.6825336955632141 9.098658203404209e-07 0.6844241240890321 9.098659183815936e-07 0.686020684362688 9.098660190776996e-07 0.687656981754083 \
9.098661288314626e-07 0.689434454762776 9.098662455994179e-07 0.6913211166705923 9.098663368261915e-07 0.6927889453402305 9.098664460316049e-07 0.6945396927028351 \
9.098665471403262e-07 0.6961566646470493 9.098666425406181e-07 0.6976767415743361 9.098667520226425e-07 0.6994136821864276 9.098668864742773e-07 0.7015344809028976 \
9.098670354932137e-07 0.7038694457768003 9.098671644232324e-07 0.7058755144243859 9.09867311083691e-07 0.7081418729260142 9.098674378680718e-07 0.7100885084081828 \
9.098675624659611e-07 0.7119899232102255 9.098676743197281e-07 0.7136874821928206 9.098677872756922e-07 0.7153928249203609 9.098678878290892e-07 0.716903336497302 \
9.098680251105923e-07 0.7189542886859326 9.098681449794517e-07 0.7207346491296758 9.09868264162204e-07 0.7224952472954583 9.098683911643136e-07 0.7243608783177121 \
9.098685157126647e-07 0.726179956024653 9.098686393836757e-07 0.7279757435764195 9.09868765971953e-07 0.7298035010246171 9.098688965411881e-07 0.7316777339938921 \
9.098690190562223e-07 0.7334262671520465 9.098691552997129e-07 0.7353588786631546 9.09869256742486e-07 0.7367901064855561 9.098693627659689e-07 0.7382789144707947 \
9.098694532971524e-07 0.7395446819117977 9.098695671233782e-07 0.7411267287627761 9.098696547849604e-07 0.742338113895605 9.098697606802377e-07 0.7437932991468792 \
9.098698910335325e-07 0.7455718205320391 9.098700016011402e-07 0.7470699275523445 9.098701062716114e-07 0.7484790865773925 9.098702302331429e-07 0.7501360792234356 \
9.098703787905969e-07 0.752105598322839 9.098705004731933e-07 0.7537054667443914 9.098706145848825e-07 0.7551949470168074 9.098707550054834e-07 0.7570132059451244 \
9.098708965335436e-07 0.7588296197226846 9.098710143228134e-07 0.7603289862386273 9.098711425226351e-07 0.7619481626911874 9.098712845904682e-07 0.7637269294216019 \
9.098714014655762e-07 0.7651780119234867 9.098715471393621e-07 0.7669714049983392 9.098716688778096e-07 0.7684572223066155 9.098717875183015e-07 0.7698939375992205 \
9.098719099845945e-07 0.7713653733660819 9.098720367016846e-07 0.7728756341192486 9.098721466036787e-07 0.7741754302862822 9.098722722190222e-07 0.7756497674172792 \
9.098723780294307e-07 0.7768823528242577 9.098725141995533e-07 0.7784559787239111 9.098726385466015e-07 0.7798807766277074 9.098727659718769e-07 0.7813271999647126 \
9.098728805279563e-07 0.7826155184370988 9.098729872082258e-07 0.7838050786084815 9.098731251508229e-07 0.785328674235108 9.098732746003192e-07 0.7869612315653352 \
9.098734194525363e-07 0.7885256944569791 9.098735388882871e-07 0.7898026796320731 9.098736743131599e-07 0.7912364721526877 9.098737958074809e-07 0.7925100718437531 \
9.098739391665555e-07 0.7939977458315933 9.098740826002369e-07 0.7954699260458764 9.098742084112467e-07 0.7967479640295563 9.098743274579285e-07 0.7979459892863545 \
9.098744394715731e-07 0.7990632136113104 9.098745442634543e-07 0.8000996927221937 9.098746394563032e-07 0.8010335634530776 9.098747758668286e-07 0.8023587211299719 \
9.098748926790048e-07 0.8034813603122919 9.098750121402484e-07 0.8046180202255495 9.098751341806002e-07 0.8057672874017472 9.098752570806968e-07 0.8069126780167393 \
9.098753842000532e-07 0.8080849010520604 9.098755093419151e-07 0.8092265787736463 9.098756398931421e-07 0.8104047139317369 9.09875765969389e-07 0.811530109085512 \
9.098758939660489e-07 0.8126603425876329 9.09875999427297e-07 0.8135823118114501 9.098761026965977e-07 0.814477091043954 9.098761953499457e-07 0.8152732203909091 \
9.098763190441811e-07 0.8163262937528154 9.098764066640956e-07 0.8170655553659417 9.098765053301514e-07 0.8178914289762149 9.098766488771538e-07 0.819080619224994 \
9.098767844633065e-07 0.8201904093102529 9.09876893653288e-07 0.8210742465492874 9.09877041102747e-07 0.8222539401850584 9.09877191506449e-07 0.8234410273756358 \
9.098773169754117e-07 0.8244188977545531 9.098774611413952e-07 0.8255287290252299 9.098775854299598e-07 0.8264738611628292 9.098777359002562e-07 0.8276038147969816 \
9.098778715066145e-07 0.8286089145501508 9.098779966016159e-07 0.8295251220930787 9.098781143174533e-07 0.8303776282987162 9.098782602030521e-07 0.8314210189912619 \
9.098784266961482e-07 0.8325942517713072 9.098785575628507e-07 0.833503494447128 9.098787310074617e-07 0.8346911703335461 9.098788991402021e-07 0.8358239212093587 \
9.098790689939496e-07 0.8369500705213252 9.098792498869552e-07 0.838129582835239 9.098793930212162e-07 0.8390486258646698 9.098795071191619e-07 0.8397723391454259 \
9.098796372463217e-07 0.8405879656882547 9.098797391021787e-07 0.8412191375388212 9.098798559475988e-07 0.8419354178465567 9.098799929193963e-07 0.84276453896487 \
9.098801907591422e-07 0.843942473808897 9.098803824446297e-07 0.8450620046306492 9.09880591850993e-07 0.8462610422160779 9.098807738618767e-07 0.8472832413425977 \
9.098809709773334e-07 0.8483697584184032 9.098811442904469e-07 0.8493077402131245 9.098813273256562e-07 0.8502809338042043 9.098814984787831e-07 0.8511747489972419 \
9.098816731317363e-07 0.8520708361396651 9.098818483828913e-07 0.8529540285731302 9.098820245303913e-07 0.8538259128238825 9.098822148367787e-07 0.8547503816925358 \
9.098824054277478e-07 0.8556583881771193 9.098826059797908e-07 0.8565949481971697 9.098827985825884e-07 0.8574764650234362 9.098830093312883e-07 0.8584213553684483 \
9.098832373621856e-07 0.8594210644592908 9.098835032419521e-07 0.8605573106989262 9.098838018200941e-07 0.8617960322792503 9.098840779837291e-07 0.8629075153790151 \
9.098843622302292e-07 0.8640180616030438 9.098846364142308e-07 0.8650581816846495 9.098849086694401e-07 0.8660616517296992 9.098851788589146e-07 0.8670295451208139 \
9.098854360232381e-07 0.8679256252637404 9.098857085969722e-07 0.8688492356117473 9.098859846024351e-07 0.8697577927663542 9.09886254710518e-07 0.8706213441784563 \
9.098865545689378e-07 0.8715508809746347 9.098869255828163e-07 0.8726599440782473 9.09887220515529e-07 0.873510245983525 9.098874748008954e-07 0.8742218447789023 \
9.098877730441707e-07 0.8750318897722944 9.098880466409288e-07 0.8757523113099853 9.098882827679075e-07 0.8763571312809064 9.098885231072055e-07 0.876957042728428 \
9.098887454408612e-07 0.8774982514557473 9.098889394467936e-07 0.8779599514934209 9.098892691652286e-07 0.8787226653583874 9.09889424338019e-07 0.8790722725343518 \
9.098897420714095e-07 0.8797700114458387 9.098899209390604e-07 0.880152324917399 9.098902634005339e-07 0.8808637455080008 9.098904475523682e-07 0.8812353200296749 \
9.098909224784184e-07 0.8821594045029107 9.098910898716537e-07 0.8824737723885729 9.098915556929604e-07 0.8833186808430151 9.098917365204472e-07 0.883635209600208 \
9.098922305497856e-07 0.8844687288968743 9.098923718877728e-07 0.8846990198924604 9.098929782491027e-07 0.8856473543416146 9.098931303209552e-07 0.8858754372639542 \
9.098937770089477e-07 0.8868048391838264 9.09893905303109e-07 0.8869818633102416 9.098945534965822e-07 0.8878410756373726 9.098946832451334e-07 0.8880061989117775 \
9.098954514986009e-07 0.8889361126992519 9.098955812406254e-07 0.8890847997417872 9.098964346975574e-07 0.8900046759307325 9.098965779246734e-07 0.8901495209380393 \
9.098975641580769e-07 0.8910738355210844 9.09897785636141e-07 0.8912643084423501 9.098989286536885e-07 0.8921737958641509 9.098990586319893e-07 0.8922730011388891 \
9.099004103389882e-07 0.8932565980587214 9.099005606923423e-07 0.8933589605607284 9.09902041315768e-07 0.8942730372387374 9.0990228021907e-07 0.8944047337041336 \
9.099040613442277e-07 0.8952702388217941 9.099044473255946e-07 0.8954343910560414 9.099068488716344e-07 0.896309305076933 9.099073238084202e-07 0.8964562995603377 \
9.099111419701395e-07 0.8973944547681553 9.099116244593364e-07 0.897487269196476 9.099195104748493e-07 0.898471373493449 9.099201266375397e-07 0.8985180228791175 \
9.100152826123789e-07 0.899508178894561 9.100167732145567e-07 0.8995204306067698 9.101280612887406e-07 0.9005118233983579 9.101282376257435e-07 0.9005706457326812 \
9.10131860757067e-07 0.8996048713171836 9.101320419550935e-07 0.8994654179496379 9.101333530765703e-07 0.8985275682722235 9.101335349539762e-07 0.8984123497545736 \
9.101353579441702e-07 0.8974436520388238 9.101355178574243e-07 0.8973766233009967 9.10148668688723e-07 0.8983720910457982 9.101487796702764e-07 0.8983905835035384 \
9.101576012543832e-07 0.8993863063850064 9.101581480238466e-07 0.8994226481040219 9.106507199766804e-07 0.9003987622903815 9.106507897691655e-07 0.9004496773542636 \
9.106516224219291e-07 0.9012853800543292 9.10651748468094e-07 0.9014513953152168 9.106523289889574e-07 0.9023435091985418 9.106524699532118e-07 0.9025895326188698 \
9.106528690912907e-07 0.9033428289365844 9.106530192408315e-07 0.9036449200440446 9.106534623221535e-07 0.9045762589490434 9.106536194942561e-07 0.9049121924877023 \
9.106540651209874e-07 0.9058152254958243 9.106541635773263e-07 0.9059929146639856 9.106555802587203e-07 0.9052304871087643 9.10655711415865e-07 0.904616184869324 \
9.10655880423041e-07 0.9036290332250884 9.106560457149166e-07 0.9024406226812831 9.106561519806978e-07 0.9015554774641358 9.106562554175281e-07 0.9006052096506509 \
9.106563411842469e-07 0.8997486040545581 9.106564306782332e-07 0.8987887485205278 9.106565549226324e-07 0.8973492764100613 9.106566730035805e-07 0.8958624931586439 \
9.10656760219672e-07 0.8946938835082598 9.106568845267161e-07 0.8929289312882503 9.106569915106438e-07 0.8913158670103165 9.106570913423478e-07 0.8897378501708729 \
9.106572176331742e-07 0.8876466417139378 9.106573858217852e-07 0.884705368138502 9.10657541521538e-07 0.8818365157686672 9.106577381263672e-07 0.8780362649814708 \
9.106579217476166e-07 0.8743271923380105 9.106581332550105e-07 0.8698916163736473 9.106583140648105e-07 0.8659808238081558 9.106584986458582e-07 0.8618945354625286 \
9.106586716498537e-07 0.8579913311618118 9.106588570505038e-07 0.8537436868396935 9.106590361336512e-07 0.8495884889292737 9.106592197227131e-07 0.8452850234109005 \
9.106593864844182e-07 0.8413449312544377 9.10659554574996e-07 0.8373487193315756 9.106597176841669e-07 0.8334514816705533 9.106598728704026e-07 0.829729402178684 \
9.10660045969282e-07 0.8255639501984255 9.106602319597376e-07 0.8210763864673301 9.106603965802215e-07 0.8170961425007568 9.106605614501323e-07 0.8131038678717658 \
9.106607367821645e-07 0.8088537582860886 9.10660901208668e-07 0.8048648186953292 9.106610698442787e-07 0.8007719922541914 9.106612606476452e-07 0.7961398815555145 \
9.106614461718183e-07 0.7916360074082958 9.106616551006281e-07 0.7865651471012967 9.10661879917618e-07 0.7811107659751856 9.106620697327054e-07 0.77650678233121 \
9.106622715901883e-07 0.7716133355283564 9.106624158608268e-07 0.76811790639139 9.106625575043926e-07 0.7646880872338248 9.106626852021021e-07 0.7615975116975136 \
9.106627962479434e-07 0.7589113686396982 9.106629248105796e-07 0.7558028559024855 9.106630573760869e-07 0.7525995467138866 9.106631706977831e-07 0.7498629233610832 \
9.106633070324095e-07 0.7465723252212872 9.106634134316607e-07 0.7440058350410135 9.106635726504468e-07 0.7401674766516904 9.10663745028142e-07 0.7360137588823189 \
9.106639072753859e-07 0.7321074183421575 9.106640796243437e-07 0.7279612819449855 9.10664239010527e-07 0.7241302920521341 9.106644468157139e-07 0.7191408067115369 \
9.106646073553789e-07 0.7152908836069264 9.106647998447152e-07 0.7106793324906435 9.106649853610639e-07 0.7062404417184839 9.106651552371092e-07 0.7021802791355866 \
9.106653471069472e-07 0.6975984806629684 9.106654933309622e-07 0.6941099299715526 9.106656536173094e-07 0.6902897983225644 9.106658560061449e-07 0.6854719661536142 \
9.106660372946089e-07 0.681161582477689 9.106662061160357e-07 0.6771536053116509 9.106663919619109e-07 0.6727470762459599 9.106665978927512e-07 0.6678715161770782 \
9.10666765819558e-07 0.6639016226084196 9.106669260812615e-07 0.6601182542089066 9.106671649337354e-07 0.65448589698252 9.106673326948485e-07 0.6505369020837752 \
9.10667513768288e-07 0.6462813620835641 9.106676749231988e-07 0.642499550819208 9.106678211904597e-07 0.6390715923276049 9.106679598785689e-07 0.6358268652274862 \
9.106680892356149e-07 0.6328040340451749 9.106682186201701e-07 0.6297855584526113 9.106683469414899e-07 0.6267952385336898 9.106684771436295e-07 0.6237652412672913 \
9.106686061600736e-07 0.6207683673242944 9.10668744735633e-07 0.6175525629501428 9.1066889281122e-07 0.6141227553162802 9.106690791385051e-07 0.60981438109949 \
9.106692268222044e-07 0.6064079319686639 9.106694619864099e-07 0.600995965122186 9.106696544341405e-07 0.5965821560879089 9.106698950039548e-07 0.5910808370261941 \
9.106700640513256e-07 0.587228367631822 9.1067020171775e-07 0.5840969866928536 9.106703298227265e-07 0.581191110277254 9.106704434094219e-07 0.5786182870235701 \
9.106705347742257e-07 0.5765512826027382 9.106706241961132e-07 0.5745328691003393 9.106706914578463e-07 0.573016830490748 9.106707574780488e-07 0.5715297341779608 \
9.106708095317241e-07 0.5703577032508095 9.106708737705931e-07 0.5689124506700958 9.106709353071159e-07 0.5675311492520995 9.106709995886598e-07 0.5660899724818867 \
9.106710527797555e-07 0.5648985048860162 9.106711451255398e-07 0.5628316153148989 9.106712217014408e-07 0.5611191615154557 9.10671277545091e-07 0.5598732849310241 \
9.106713468881998e-07 0.5583285932816697 9.106714527394756e-07 0.5559733466166974 9.106715304312799e-07 0.5542469170533902 9.106716310298676e-07 0.5520159549745236 \
9.106717590630782e-07 0.5491849411292137 9.106718585604598e-07 0.5469885705929382 9.106719711258113e-07 0.544508366501287 9.106720741701315e-07 0.5422442603473754 \
9.106721942190172e-07 0.5396115972585003 9.106722958334261e-07 0.5373863339265779 9.10672411457693e-07 0.5348611538529422 9.106725265738741e-07 0.5323536236546169 \
9.106726530109181e-07 0.529604142030661 9.106727785251858e-07 0.5268822104345234 9.106729252048618e-07 0.5237112381511962 9.106730608755697e-07 0.5207845659358002 \
9.106732186414087e-07 0.5173942078023266 9.106733810633495e-07 0.5139116507621072 9.106735619718178e-07 0.5100482739823553 9.106737545639722e-07 0.5059503908118104 \
9.106739675557428e-07 0.5014368974673542 9.106741999884594e-07 0.4965308659362653 9.106744575093731e-07 0.49112491222925 9.106746974735513e-07 0.4861095397820235 \
9.106749986779056e-07 0.4798501326413723 9.106752869755341e-07 0.4738957353990632 9.106756000618611e-07 0.4674739717793394 9.106759195881406e-07 0.4609631488871989 \
9.106762590854062e-07 0.4540919149088484 9.106765852755183e-07 0.4475353831519197 9.106769217567802e-07 0.4408159131180407 9.106772384675872e-07 0.4345373385230166 \
9.106775725526604e-07 0.4279587671099637 9.106779242615286e-07 0.4210864038135054 9.106782387463783e-07 0.4149846225409808 9.106785621928357e-07 0.4087533091618546 \
9.106790031209485e-07 0.400331870031168 9.106793449160247e-07 0.3938679283557566 9.106796443500685e-07 0.3882534014213259 9.10680018872672e-07 0.3812944595528024 \
9.106803482503896e-07 0.375233915169682 9.106806313546939e-07 0.3700684563936956 9.106809310997049e-07 0.3646408765157301 9.106812105955488e-07 0.3596219010422631 \
9.10681434267487e-07 0.3556377385586224 9.106816459791946e-07 0.3518907610576284 9.106818484819267e-07 0.3483292724130969 9.10682049543475e-07 0.3448190020587957 \
9.106822552213836e-07 0.3412518188287665 9.106824735968597e-07 0.3374887625241871 9.106827173592565e-07 0.3333167726275162 9.106829441158294e-07 0.3294678078423895 \
9.106831640268007e-07 0.3257615367192951 9.106833824514083e-07 0.3221060038181086 9.106835864764178e-07 0.318715141566024 9.106837883342075e-07 0.3153870758963987 \
9.106839886575955e-07 0.3121102802474151 9.106841752715021e-07 0.309079115007194 9.106843725731086e-07 0.3058982938882217 9.10684581156335e-07 0.3025606704206737 \
9.106847867910569e-07 0.2992974534031506 9.106850115231367e-07 0.2957609785165763 9.106852284189794e-07 0.2923771984023277 9.106854360983307e-07 0.2891642611511841 \
9.106856671491776e-07 0.2856239464683982 9.10685841949429e-07 0.2829684481899911 9.10686021147604e-07 0.2802647299798244 9.106861900221201e-07 0.2777348429135014 \
9.106864183453933e-07 0.274348458173166 9.106865950826614e-07 0.2717528218126659 9.106867633653918e-07 0.2693020894036587 9.106869358321621e-07 0.2668230333489093 \
9.10687069934441e-07 0.264903804409765 9.10687215894446e-07 0.2628277003548514 9.106873545899465e-07 0.2608803500812688 9.106874768715512e-07 0.2591684246570544 \
9.106876109903814e-07 0.2572942758553639 9.106877400914858e-07 0.2554978336754472 9.106878595252204e-07 0.2538430842138498 9.106879863604196e-07 0.2520939183506197 \
9.106881060014414e-07 0.2504447954274527 9.106882556176352e-07 0.2483797066042054 9.106883904811462e-07 0.2465170278296022 9.106885200385602e-07 0.2447289494531232 \
9.106886771033789e-07 0.2425624627506451 9.106888010990138e-07 0.2408491463446025 9.106889412471492e-07 0.2389135279283614 9.106890711400503e-07 0.2371200701944942 \
9.106891917576704e-07 0.2354534357320198 9.106893542306007e-07 0.2332087289724075 9.106895002846996e-07 0.2311905595759856 9.106896386054838e-07 0.2292825126447264 \
9.106897465327019e-07 0.2277949627009887 9.106898773176092e-07 0.225993474229161 9.106899758236256e-07 0.22463752857886 9.106900799069717e-07 0.2232056532573264 \
9.106901527838363e-07 0.2222046546567725 9.10690234937313e-07 0.2210804129356655 9.106903023463979e-07 0.2201585377209549 9.106903490506606e-07 0.2195201149856669 \
9.106903984680202e-07 0.2188449488487562 9.10690489422163e-07 0.2176035744446363 9.10690555816576e-07 0.2166983392055156 9.106906027798693e-07 0.2160586379972232 \
9.106906530910749e-07 0.2153737902794619 9.106907122404248e-07 0.2145693142997165 9.106907550863284e-07 0.2139870779821451 9.10690798893629e-07 0.2133941263688522 \
9.106908684238941e-07 0.2124566309962414 9.106909553407081e-07 0.2112864027023158 9.106910365295632e-07 0.2101949018929156 9.106911224290263e-07 0.2090416531541652 \
9.106912165752074e-07 0.2077796428137634 9.10691308329081e-07 0.2065517647617813 9.106914036255171e-07 0.2052788208685862 9.106915001042082e-07 0.2039945431316728 \
9.106916009294901e-07 0.2026602783061639 9.106916968855022e-07 0.2013924147365721 9.10691799571213e-07 0.2000377255165624 9.106919026075664e-07 0.1986831378210229 \
9.10692012697906e-07 0.1972405340748948 9.106921214497938e-07 0.1958206085628783 9.106922411717489e-07 0.1942631948714586 9.106923516146512e-07 0.1928328887741874 \
9.106924596174587e-07 0.1914411844406488 9.10692584973803e-07 0.1898318066870429 9.106926779079788e-07 0.1886434908940876 9.106927562787551e-07 0.1876443873000938 \
9.10692832918829e-07 0.1866698667869858 9.106929154301432e-07 0.1856249297118943 9.106929849397591e-07 0.1847473639743596 9.106930508953873e-07 0.1839166514106665 \
9.106931151627221e-07 0.1831089953192083 9.106932271462069e-07 0.1817072258029639 9.106933212001736e-07 0.1805353135896268 9.106934288419354e-07 0.1791985758407087 \
9.106935353149933e-07 0.1778827552324552 9.106936553069198e-07 0.1764073736674057 9.106937933595455e-07 0.174720142305475 9.106939095201005e-07 0.1733081217455876 \
9.106940716169029e-07 0.1713503924599185 9.106941867054195e-07 0.1699688234017716 9.106943266910192e-07 0.1682987764548305 9.106944438970947e-07 0.1669083002780509 \
9.106945548164474e-07 0.1655990025649634 9.106946524449327e-07 0.1644521190704843 9.106947472954812e-07 0.1633427224865242 9.106948633498935e-07 0.161991523106341 \
9.106949548984438e-07 0.1609305136382055 9.106950510074198e-07 0.1598214181625073 9.106951452255533e-07 0.1587403933520305 9.106952387261563e-07 0.1576732160104884 \
9.106953323234783e-07 0.1566104070550305 9.106954280050165e-07 0.1555300824433628 9.106955185929211e-07 0.1545132165873678 9.106956096060781e-07 0.1534969984004868 \
9.106957051545556e-07 0.1524358767948732 9.106957958202681e-07 0.1514342506187442 9.106958988926308e-07 0.1503020548964867 9.106959713440796e-07 0.1495100717445464 \
9.106960504448726e-07 0.148649146151682 9.106961249930914e-07 0.1478424742503694 9.106961960245004e-07 0.1470770917224498 9.106962687889816e-07 0.1462962409077327 \
9.106963434061566e-07 0.1454990959398698 9.106964133891184e-07 0.1447543557055888 9.106964875500381e-07 0.143968261688537 9.106965412953772e-07 0.1434005634796054 \
9.106965945789318e-07 0.1428396203849428 9.106966597746903e-07 0.1421555039833398 9.106967310807313e-07 0.141411576573238 9.106967954507931e-07 0.1407432786314442 \
9.106968688027537e-07 0.1399847409254479 9.106969294203206e-07 0.1393607073002494 9.106970154538046e-07 0.1384787080092832 9.106970914048206e-07 0.1377037134581418 \
9.106971813727261e-07 0.1367902106004182 9.106972630996835e-07 0.1359645165492482 9.106973457896614e-07 0.1351360437760365 9.106974283459692e-07 0.1343145513298757 \
9.106975339081246e-07 0.1332698421778018 9.106976157754082e-07 0.1324642397250402 9.106977131428679e-07 0.1315110876582503 9.106978031437286e-07 0.130634908321232 \
9.106978911139875e-07 0.1297829978838479 9.106979740438425e-07 0.1289892226181523 9.106980482809344e-07 0.1282822873521282 9.106981479319927e-07 0.1273377645104763 \
9.106982436870517e-07 0.1264350619688987 9.106983305344565e-07 0.1256206895242312 9.106984205359939e-07 0.1247808744623497 9.106985008686745e-07 0.1240346855852102 \
9.10698587562703e-07 0.1232365419604467 9.106986863930319e-07 0.1223331159004786 9.106987764751697e-07 0.1215131568528167 9.106988867184272e-07 0.1205141992263624 \
9.106989739498661e-07 0.1197275966302077 9.106990425230002e-07 0.1191120727131645 9.106991271853926e-07 0.1183553887582162 9.106991936928736e-07 0.1177634990399222 \
9.106992651487992e-07 0.1171309945267847 9.10699334822604e-07 0.1165184920865242 9.106994121596921e-07 0.1158409171037389 9.106995079029744e-07 0.1150054407698888 \
9.106995791578869e-07 0.1143861389207103 9.106996465274203e-07 0.1138025718558601 9.106997149641909e-07 0.113211685696446 9.106997905545423e-07 0.1125613765304429 \
9.106998812963886e-07 0.1117840233035959 9.106999640001163e-07 0.1110788257213999 9.107000775991873e-07 0.1101151050704521 9.107001874748991e-07 0.1091895325357105 \
9.107002796742131e-07 0.1084169374841771 9.107004036235445e-07 0.1073835127717347 9.107004919878672e-07 0.1066505015902263 9.107006314468373e-07 0.1055001025916527 \
9.107007307435381e-07 0.1046863788921388 9.107008233935897e-07 0.1039306459201802 9.107009335981019e-07 0.1030359883605075 9.107010188925421e-07 0.1023467905686673 \
9.107011037933451e-07 0.101663637589173 9.107011867443086e-07 0.1009989740617136 9.107013092542103e-07 0.1000225794851696 9.107014311960625e-07 0.09905761200121259 \
9.10701557818349e-07 0.09806258992746317 9.107016706304718e-07 0.09718220909187772 9.107018152059564e-07 0.09606278874246346 9.107019529198845e-07 0.09500564015228773 \
9.107020696106742e-07 0.09411672853020667 9.107021973542415e-07 0.0931507147971556 9.107022970187577e-07 0.09240236948627445 9.107023764526374e-07 0.09180921593916676 \
9.107024751879353e-07 0.09107599640376031 9.107025530632389e-07 0.09050081472416407 9.107026345291548e-07 0.08990210528957472 9.107027092464628e-07 0.0893557072655629 \
9.107027897762005e-07 0.08876971652456604 9.107029086085258e-07 0.08791061481419053 9.107029982690621e-07 0.08726673116015753 9.107031031831091e-07 0.08651800316437093 \
9.107032346576667e-07 0.08558693768262025 9.107033957658019e-07 0.08445695903909305 9.107035359474972e-07 0.08348350561263763 9.107036844501031e-07 0.08246223579158835 \
9.10703821170292e-07 0.08153124812726546 9.107039611820024e-07 0.08058696725890066 9.10704098179202e-07 0.07967195061625794 9.107042367898133e-07 0.07875532825288725 \
9.107043812626999e-07 0.07780967510081127 9.107045288089374e-07 0.07685421131041187 9.107046863126477e-07 0.07584560580436887 9.107048507078841e-07 0.07480523464991846 \
9.107050187999819e-07 0.07375451744755303 9.10705199799341e-07 0.07263751640721161 9.107053985126234e-07 0.07142823309373261 9.10705611921415e-07 0.07014922396308329 \
9.107058380853001e-07 0.06881630383186611 9.107060786456225e-07 0.06742468841361035 9.107063562065354e-07 0.06585179211508728 9.107066534109385e-07 0.06420523370201831 \
9.107069717116617e-07 0.06248365192299224 9.10707361695962e-07 0.06043183534616462 9.107077605227481e-07 0.05839861031494715 9.10708202994687e-07 0.05621846258761681 \
9.107085879755897e-07 0.05438828987170503 9.107090000221824e-07 0.05249218901100536 9.10709351759698e-07 0.05092353490091287 9.107096872643497e-07 0.04946969867921969 \
9.107099977632445e-07 0.04816021644386199 9.107102917000642e-07 0.04695194805701195 9.107105844309969e-07 0.04577883625507727 9.107108592742044e-07 0.04470700909733757 \
9.107111331179271e-07 0.04366353526031765 9.107113988076876e-07 0.04267398813878486 9.107116741167033e-07 0.04167180388267511 9.107119586736206e-07 0.04066026046469497 \
9.107122549717361e-07 0.03963283340811159 9.107125138471216e-07 0.03875659098599576 9.107127418035276e-07 0.03800131046948733 9.107129605287219e-07 0.03729095380188759 \
9.107131803834488e-07 0.03659437723507575 9.107135212495135e-07 0.03554043311314246 9.107137972903942e-07 0.03470953269536187 9.107140907211691e-07 0.03384790442147732 \
9.107143732890922e-07 0.03303898052111545 9.107146281985287e-07 0.03232625790162248 9.107149088829883e-07 0.03155947796597136 9.107151547163818e-07 0.03090318379665042 \
9.107153868776701e-07 0.03029616297556957 9.107156272150079e-07 0.02968398395812225 9.107158628518432e-07 0.02909722707395018 9.107160910630208e-07 0.0285403787496557 \
9.107165078357495e-07 0.02755138287878544 9.107167023611269e-07 0.02710176794309662 9.107170886015322e-07 0.02623051698020805 9.10717267770925e-07 0.0258356865503758 \
9.107176189981086e-07 0.02507792837274256 9.107177869041566e-07 0.0247229612172224 9.107181711668123e-07 0.02392944198669211 9.107182864485405e-07 0.02369675911063252 \
9.107187284963782e-07 0.02282172072611499 9.107189503116516e-07 0.02239223679446916 9.107194739313108e-07 0.02139838041889957 9.107196292938196e-07 0.02110714647916685 \
9.107201469998876e-07 0.02015295207761772 9.10720272033152e-07 0.01992792118872039 9.107207962346589e-07 0.01901759738223179 9.107209324540342e-07 0.01879045572456909 \
9.107215387304897e-07 0.01783210191617334 9.107217057396231e-07 0.01758082406519646 9.107223489472666e-07 0.01666064795441237 9.107225280915353e-07 0.0164167113061686 \
9.107232182502689e-07 0.01551958953683085 9.107233818701531e-07 0.01531511209162885 9.107241423508397e-07 0.01440332854054019 9.107242893929629e-07 0.01423371673427115 \
9.107251072646214e-07 0.01333087949608782 9.107252268131343e-07 0.01320411419549955 9.107261426746556e-07 0.01227329163592313 9.107262840275722e-07 0.01213544173166964 \
9.107272325031483e-07 0.01124488043697059 9.107273911425863e-07 0.01110230805801717 9.1072857354363e-07 0.01011356759191894 9.107286716440201e-07 0.01003725601038859 \
9.107299332554799e-07 0.009120360285939955 9.107300676693303e-07 0.009028655389366201 9.107316082406548e-07 0.008043892937307966 9.107316892739986e-07 0.007992925041580451 \
9.107332778679313e-07 0.007023242357651564 9.10733410759078e-07 0.006948518507451114 9.107353874624202e-07 0.005952856104192286 9.107355692005682e-07 0.005869662958407677 \
9.107376715542283e-07 0.004980929874643355 9.107381123459968e-07 0.004810448874467742 9.107407675608551e-07 0.003892108290451164 9.107412441403943e-07 0.003745909362026665 \
9.107448822226149e-07 0.00279447349697209 9.107454077460605e-07 0.002678838783887205 9.107510138108453e-07 0.001700248310874221 9.107513248985468e-07 0.001653333728976835 \
9.107564592262457e-07 0.0006858192122199529 9.107566532060193e-07 0.0006440832883579712 9.134045769148617e-07 -0.0002037173203380238 9.13404741115283e-07 -0.0003889174928863678 \
9.134053144580911e-07 -0.001270938904608877 9.134053893922784e-07 -0.001411855863724778 9.134058499760551e-07 -0.002393592696522268 9.134059619168068e-07 -0.002660411672198376 \
9.134062151887948e-07 -0.003300974950034667 9.134063815720996e-07 -0.003745951779090856 9.134066765678696e-07 -0.004566571567208835 9.134067880554425e-07 -0.00488071790655901 \
9.134070674282164e-07 -0.005641221413069743 9.134071883865554e-07 -0.005938820066262044 9.134082823393885e-07 -0.005180465225493313 9.134084064716309e-07 -0.004410796826645887 \
9.134085308790491e-07 -0.003456122327429311 9.134086504354286e-07 -0.002364170815481491 9.134087485798049e-07 -0.001341064316055312 9.13408855004127e-07 -0.0001052154991983786 \
9.134089672399721e-07 0.001336046702817826 9.134091021958209e-07 0.003249882807978809 9.134092247823306e-07 0.005149402351921401 9.134094136442457e-07 0.008353592055059769 \
9.134095548265784e-07 0.01094873860302964 9.134097081879224e-07 0.01393943619118621 9.134098515614266e-07 0.01687898420971235 9.13410005752867e-07 0.02017576688295359 \
9.134101618928252e-07 0.02363796584892512 9.134103176188778e-07 0.02719811802828209 9.134104651125568e-07 0.03065407560139007 9.134106137843234e-07 0.03420778369279751 \
9.134107691144076e-07 0.03798436241030867 9.134109277402875e-07 0.04189786275883118 9.134110926734479e-07 0.0460171220807938 9.134112670963364e-07 0.05041857973200652 \
9.134114460857363e-07 0.05497510627343041 9.134116353855968e-07 0.05982852266675163 9.134118383936027e-07 0.06506368941101938 9.134120578706689e-07 0.07075025585284363 \
9.134122889353304e-07 0.07675903373893865 9.134125359956494e-07 0.08319974270080552 9.134128064206373e-07 0.0902619122132732 9.134130999843244e-07 0.09793335781011638 \
9.13413424033306e-07 0.1064001814721126 9.134137882548562e-07 0.1159066558703892 9.134141808063258e-07 0.1261372395632307 9.134146303042508e-07 0.1378252442462487 \
9.134151530964836e-07 0.1513754922073403 9.134157666942191e-07 0.1672157090591849 9.134164444550933e-07 0.184625848284817 9.134172327202124e-07 0.2047487967247964 \
9.134181155530716e-07 0.22712469896725 9.134189338390288e-07 0.2476994923478653 9.13419661268608e-07 0.2658503723959502 9.134203013816357e-07 0.2817009601644404 \
9.134208756853502e-07 0.2958213763442377 9.134214132513172e-07 0.3089396094373287 9.134219172487761e-07 0.3211464104224903 9.134223933714299e-07 0.3325930942309646 \
9.134228712594449e-07 0.3439912352478621 9.134233245925507e-07 0.3547121966731367 9.134237958852586e-07 0.3657614311162562 9.134242385610846e-07 0.3760518588326446 \
9.134247570598719e-07 0.3879885572071845 9.134252842219919e-07 0.3999987293386327 9.134256631316233e-07 0.4085537955782026 9.134261930471662e-07 0.4204060347738258 \
9.13426622963746e-07 0.429919877745455 9.134270766645208e-07 0.4398653393542544 9.134275433780368e-07 0.4500002271552926 9.134279810592672e-07 0.4594210430579985 \
9.134283890215308e-07 0.468120704286539 9.134287084545645e-07 0.4748816926501604 9.134290805898365e-07 0.4826992142337162 9.134293155719776e-07 0.4876010339127531 \
9.13429549178225e-07 0.4924491904621348 9.134297971906478e-07 0.4975647713404599 9.134300955920777e-07 0.5036796627825791 9.134303519484798e-07 0.5088948470128004 \
9.134305642417897e-07 0.5131878547336713 9.134307582598615e-07 0.5170959594548015 9.134309052463941e-07 0.5200432695146362 9.134310592244046e-07 0.523118600542271 \
9.134312771061537e-07 0.5274469616807909 9.134315302104803e-07 0.5324525256580425 9.134317400493245e-07 0.5365797337241586 9.134319515026335e-07 0.5407247601751553 \
9.134322337095338e-07 0.5462280430697679 9.134324632548168e-07 0.5506821559930507 9.134326791510235e-07 0.5548604062613707 9.134329613725408e-07 0.560308769190463 \
9.134332126802681e-07 0.5651538146135803 9.134335103411598e-07 0.5708625224168123 9.134337605680606e-07 0.5756519166658941 9.134340169315557e-07 0.5805516059354519 \
9.134342573415698e-07 0.585116682128892 9.134345155213862e-07 0.5900038400537884 9.134347391135916e-07 0.5942175703762435 9.134349776231627e-07 0.5986919452581434 \
9.134351852078614e-07 0.6025689278491061 9.134354017304865e-07 0.6065904171332736 9.134356510330918e-07 0.6111939272561876 9.134358561065347e-07 0.6149609706257601 \
9.134361073788606e-07 0.6195555361399968 9.134363106008859e-07 0.6232455818254186 9.134365074727913e-07 0.6267987644955494 9.134367007643072e-07 0.630267737067843 \
9.134369555427622e-07 0.6348113783570861 9.13437185753374e-07 0.638887973644319 9.134374031071848e-07 0.6427143472883045 9.134377015129075e-07 0.6479268061885751 \
9.134379169157571e-07 0.6516657345437264 9.134381181394756e-07 0.6551344108237934 9.134382930609835e-07 0.6581323437428509 9.134384581262539e-07 0.6609495238976936 \
9.134386275947745e-07 0.6638251431769452 9.134387797316125e-07 0.666392827642013 9.134389176422984e-07 0.6687037209181631 9.134390664784122e-07 0.6711867545200138 \
9.134391945930142e-07 0.6733159837320549 9.134393378158276e-07 0.6756849429836936 9.134394590900776e-07 0.6776819274526149 9.134395966887616e-07 0.6799401191146522 \
9.13439716069216e-07 0.6818929034138137 9.134398631769623e-07 0.6842914131385206 9.134399803786277e-07 0.6861933934268433 9.13440073884205e-07 0.6877071857403232 \
9.134401648738969e-07 0.6891752279197846 9.134402676159613e-07 0.6908280855439021 9.134403691335248e-07 0.6924555900607121 9.134404875166308e-07 0.6943444167618776 \
9.134405996372169e-07 0.6961264383846065 9.13440717192718e-07 0.6979868779962457 9.134409023430049e-07 0.7008959348649784 9.134410335352131e-07 0.7029413755586562 \
9.134411697037527e-07 0.7050491462541959 9.13441291222456e-07 0.7069171228306749 9.134414311454678e-07 0.7090538254196674 9.134415350881169e-07 0.7106315721465845 \
9.134416462491006e-07 0.712309798010818 9.134417505089649e-07 0.7138759052437967 9.134418801470564e-07 0.7158124745844324 9.134419770777692e-07 0.7172526339884565 \
9.134421160000041e-07 0.7193052800722975 9.134422355492926e-07 0.7210612846995991 9.134423551218654e-07 0.7228080613301419 9.134424808972429e-07 0.7246353354365959 \
9.134426076155856e-07 0.7264656873164689 9.134427296554369e-07 0.728218443613998 9.134428578038805e-07 0.7300486655261287 9.13442987872205e-07 0.7318956587421809 \
9.134431088632273e-07 0.7336041830685722 9.134432496338107e-07 0.7355801168346318 9.134433506033799e-07 0.7369898206659778 9.134434522042367e-07 0.7384020079314992 \
9.13443548224548e-07 0.7397310783624924 9.134436591374028e-07 0.7412570822736337 9.134437467850298e-07 0.7424563811251772 9.134438466394006e-07 0.7438154404043728 \
9.134439814045385e-07 0.7456370856934184 9.13444097699018e-07 0.747198032089633 9.13444201190815e-07 0.7485782798032956 9.134443254462628e-07 0.7502239458264747 \
9.134444703592029e-07 0.7521280942578691 9.134445883397714e-07 0.753666143975803 9.134447072708787e-07 0.7552056331692281 9.134448468504184e-07 0.7569980918234445 \
9.134449912028081e-07 0.7588357421297242 9.134451092636163e-07 0.7603265096672839 9.134452340853355e-07 0.7618908200857619 9.134453739165311e-07 0.7636286950759973 \
9.134454986794279e-07 0.7651662633748356 9.134456421928986e-07 0.7669199865864609 9.134457628783764e-07 0.7683824344671055 9.13445883722124e-07 0.7698356273746885 \
9.134460033670484e-07 0.7712633747646481 9.134461330746873e-07 0.7727989859455529 9.134462418184901e-07 0.7740766298596218 9.134463644662266e-07 0.7755070372682662 \
9.134464742429112e-07 0.7767778749889983 9.13446603267025e-07 0.7782599816788072 9.134467350433437e-07 0.7797610257751375 9.134468483559198e-07 0.7810403609326458 \
9.134469694418617e-07 0.7823954393038701 9.134470733144949e-07 0.7835479431998941 9.134472155975173e-07 0.785111775748914 9.134473638006659e-07 0.7867227488076519 \
9.134475226942011e-07 0.7884297907063792 9.134476428872233e-07 0.7897074707829422 9.134477924539297e-07 0.7912811323018302 9.134479165691468e-07 0.7925734175081853 \
9.134480422734438e-07 0.7938699048627912 9.134481452190108e-07 0.7949224966762399 9.134482595901654e-07 0.7960823495211882 9.134483720644088e-07 0.7972131756542409 \
9.134484623369832e-07 0.7981137961420948 9.134485516778793e-07 0.7989989930139054 9.134486769038166e-07 0.800229513878344 9.134487846751798e-07 0.8012785338618679 \
9.134489143429785e-07 0.8025281307685926 9.134490357222573e-07 0.8036855380110038 9.134491522780568e-07 0.8047859282369955 9.134492730834528e-07 0.80591497746663 \
9.134494057087579e-07 0.8071413435168892 9.134495275023783e-07 0.8082555056211007 9.13449654106103e-07 0.8094015704683005 9.134497797196214e-07 0.8105266036187198 \
9.13449899211046e-07 0.8115857443778658 9.134500374092988e-07 0.8127973981963581 9.134501469085475e-07 0.8137473213416323 9.134502310566626e-07 0.8144713378799666 \
9.134503518607202e-07 0.8155017394983226 9.134504473695571e-07 0.8163089346032877 9.134505836603602e-07 0.8174496006492775 9.134507264244139e-07 0.8186303638797883 \
9.13450860857535e-07 0.8197292014569521 9.13450970729519e-07 0.8206175763825388 9.134511146291366e-07 0.8217677661037901 9.134512679567201e-07 0.8229768690765377 \
9.134513958055741e-07 0.8239722812379519 9.134515362029048e-07 0.8250521595273246 9.134516621078439e-07 0.8260088941474263 9.134518167240101e-07 0.8271688948348412 \
9.134519490793395e-07 0.8281489842609937 9.134520753461681e-07 0.8290730392392056 9.134521930066954e-07 0.8299245984162376 9.134523414090921e-07 0.8309852945996649 \
9.134525086032604e-07 0.8321626230293395 9.134526413805715e-07 0.8330844501529713 9.134528142817686e-07 0.8342675727345584 9.134529826990627e-07 0.8354015168591284 \
9.134531521935362e-07 0.8365246342267009 9.134533336304179e-07 0.8377070668209077 9.134534761865592e-07 0.8386219603417975 9.134535900974499e-07 0.8393441765511721 \
9.134537209736585e-07 0.8401643924869071 9.134538225966329e-07 0.8407940582489307 9.134539390368715e-07 0.8415078269750864 9.134540743300576e-07 0.8423269142909066 \
9.134542715951592e-07 0.8435017451489455 9.134544621144826e-07 0.844614933042255 9.13454672039296e-07 0.8458175693076773 9.134548528178267e-07 0.8468334846981137 \
9.134550501858461e-07 0.8479221976595614 9.134552240443405e-07 0.8488638701886076 9.134554065585833e-07 0.8498353939890455 9.134555779026935e-07 0.8507314120859523 \
9.13455752248258e-07 0.8516272398309612 9.134559276512582e-07 0.8525125793730954 9.134561038964482e-07 0.8533864315694911 9.134562936653265e-07 0.8543099749208749 \
9.134564844233441e-07 0.8552205033559714 9.1345668621255e-07 0.8561646193034282 9.134568789161161e-07 0.8570482883232282 9.134570883567926e-07 0.8579892478796384 \
9.134573180985592e-07 0.8589986827500428 9.134575835675109e-07 0.8601360945383778 9.134578822138556e-07 0.8613786760148464 9.134581606012222e-07 0.8625023989005415 \
9.134584447911769e-07 0.8636161469557806 9.134587192857839e-07 0.8646608622318305 9.134589913772806e-07 0.8656672252055042 9.134592615937267e-07 0.8666387059277968 \
9.134595187619145e-07 0.8675381145236246 9.134597913209795e-07 0.8684653318325959 9.1346006734232e-07 0.8693777905953765 9.134603374841709e-07 0.8702455402709716 \
9.134606372319546e-07 0.8711796653984102 9.134610081058123e-07 0.872294745819888 9.134613030287966e-07 0.8731503023941 9.134615572848448e-07 0.8738665406311316 \
9.134618555155771e-07 0.8746822274488602 9.134621291339016e-07 0.8754080260278182 9.13462365269549e-07 0.8760175227551726 9.134626056214058e-07 0.876622281264788 \
9.134628279637853e-07 0.8771680781109068 9.134630219681284e-07 0.8776338860468618 9.134633516912074e-07 0.8784037109613512 9.1346350686397e-07 0.8787567114621292 \
9.134638246164967e-07 0.879461652496718 9.134640034818579e-07 0.8798480920375044 9.134643459433237e-07 0.8805675499479563 9.134645300848474e-07 0.8809434933546246 \
9.134650049902839e-07 0.8818790560183651 9.134651723847029e-07 0.8821975058309585 9.134656382161285e-07 0.8830540251881659 9.134658190409674e-07 0.8833751042472839 \
9.134663130743468e-07 0.8842212008576973 9.134664544170556e-07 0.884455124402366 9.13467060806836e-07 0.8854193259359495 9.134672128789829e-07 0.8856514227360587 \
9.134678595574705e-07 0.8865980751852495 9.134679878538246e-07 0.8867785329419297 9.13468635979926e-07 0.8876550049536978 9.134687657724471e-07 0.8878236738033012 \
9.134695440340946e-07 0.8887860366092379 9.134696590259732e-07 0.8889208282599539 9.134705147583919e-07 0.8898661633196656 9.134706600215368e-07 0.8900169066926564 \
9.134716457777221e-07 0.8909664261264102 9.134718668828627e-07 0.8911622482549515 9.134730119973067e-07 0.8921020388386462 9.134731432072641e-07 0.8922053928944147 \
9.134743308657994e-07 0.8931033243919096 9.134744844860915e-07 0.8932130731307282 9.13475894522803e-07 0.8941348173026452 9.134761173296219e-07 0.8942660193790342 \
9.134777980203303e-07 0.8951452796684343 9.134781256415096e-07 0.8952966652167414 9.134803555826309e-07 0.8961896554712738 9.134809084965923e-07 0.8963788593752812 \
9.134844767111233e-07 0.8973573335043913 9.134848002235382e-07 0.8974284307984646 9.134911566318258e-07 0.8984120886469452 9.134917055346727e-07 0.8984686671268907 \
9.13544207609024e-07 0.8994658645395698 9.135448506378864e-07 0.8994692460188505 9.137369893085194e-07 0.9004073346715066 9.137371907224907e-07 0.9004708280105613 \
9.137411505004317e-07 0.8995366825576255 9.137413345272296e-07 0.8993953949813248 9.137426511245044e-07 0.8984641879157507 9.137428231683586e-07 0.8983566564859006 \
9.137447195446537e-07 0.8973720929359315 9.137448932508418e-07 0.897304621671452 9.137574671778748e-07 0.8982933655523699 9.137575523681117e-07 0.8983081509245614 \
9.137658192411513e-07 0.8993078551592517 9.137662939605717e-07 0.8993433667976791 9.142597948700116e-07 0.9002974142054325 9.142599143497356e-07 0.9003767372269074 \
9.142608071727864e-07 0.9012336455299185 9.142609534294226e-07 0.901423267690772 9.142615483221008e-07 0.9023325668564308 9.142616832929175e-07 0.9025673929107925 \
9.142621879687069e-07 0.9035294259428087 9.142623205796079e-07 0.9038000271808221 9.142627212069726e-07 0.9046475051114249 9.142628655723708e-07 0.9049556543240072 \
9.142632886935801e-07 0.9058123566484279 9.142633841506385e-07 0.9059850892484415 9.142648087094547e-07 0.9052205906349737 9.142649337473087e-07 0.9046352442223391 \
9.14265060157898e-07 0.9039223775493039 9.142651628066418e-07 0.9032486771507763 9.142652900219319e-07 0.9022944222362175 9.142654088677579e-07 0.9012801950564071 \
9.14265506520237e-07 0.9003603330664713 9.142655885222584e-07 0.8995243596151602 9.142656681858213e-07 0.8986589236008835 9.142657789639895e-07 0.8973708307079206 \
9.142658801400035e-07 0.8961049472956977 9.142659630844751e-07 0.8950067229086057 9.142660715298925e-07 0.8934921260891034 9.1426617999385e-07 0.8918872687155874 \
9.14266275049989e-07 0.8904106867557802 9.142663959226416e-07 0.8884444419111864 9.14266516699262e-07 0.8863849482818795 9.142666297444326e-07 0.8843763393508186 \
9.142667329151817e-07 0.8824794505619851 9.142668185153381e-07 0.8808620855018965 9.142668929893991e-07 0.8794251273161163 9.142669873129417e-07 0.8775673968166831 \
9.142670757738576e-07 0.8757888800524039 9.142671548468696e-07 0.8741711975775893 9.142672488342246e-07 0.872216793437976 9.142673301795292e-07 0.8704993514258973 \
9.14267425093555e-07 0.8684673705816817 9.14267518136275e-07 0.8664480751909672 9.142676149220692e-07 0.8643215060814092 9.142677382174413e-07 0.8615778533848952 \
9.142678516644525e-07 0.859022019682563 9.142679775164912e-07 0.8561558571929792 9.142681008446355e-07 0.8533196845306243 9.142682300229265e-07 0.850323637950593 \
9.14268370619783e-07 0.8470370034914 9.142684793995044e-07 0.8444782910716596 9.142686144592575e-07 0.8412850455921466 9.142687241195659e-07 0.8386804253780991 \
9.142688532993453e-07 0.8356002443501571 9.14268979483175e-07 0.8325812421138936 9.142691065735304e-07 0.8295317031556502 9.142692355958039e-07 0.826427745883674 \
9.142693446760448e-07 0.8237985689995477 9.142694845267009e-07 0.8204223029647078 9.142696239548932e-07 0.8170507778356514 9.142697567085239e-07 0.8138366863616762 \
9.142698867771992e-07 0.8106848159989707 9.142700104726457e-07 0.8076853837479523 9.142701474270357e-07 0.8043627031572629 9.142702611388824e-07 0.8016030849198694 \
9.142703886159226e-07 0.7985086235398901 9.14270499416994e-07 0.7958187897651571 9.142706186034521e-07 0.7929254985494992 9.142707319825085e-07 0.7901733724735396 \
9.142708662929012e-07 0.7869138859547327 9.142709733871686e-07 0.7843152933129034 9.142710894043116e-07 0.7815009627552112 9.142712185952753e-07 0.778367508739124 \
9.142713162077106e-07 0.7760002683782802 9.142714217871509e-07 0.773440790716327 9.142715304693198e-07 0.7708069008430674 9.142716328855832e-07 0.7683258101021144 \
9.142717262792411e-07 0.7660641808432364 9.142718458350171e-07 0.7631702213567544 9.142719383073787e-07 0.7609327305817616 9.14272030945494e-07 0.7586922094322426 \
9.142721293703097e-07 0.7563124992069843 9.142722373479616e-07 0.7537030947613649 9.142723336164742e-07 0.7513778334636231 9.142724198728768e-07 0.7492952979736797 \
9.142725227366661e-07 0.7468128004450286 9.14272601580994e-07 0.744910856519283 9.142727023870358e-07 0.7424801602439853 9.142728369152764e-07 0.7392377693660663 \
9.142729741401358e-07 0.7359316755186537 9.142731176199872e-07 0.7324773442723981 9.142732660441767e-07 0.7289066083419234 9.142734093054719e-07 0.7254625447335662 \
9.142735493824514e-07 0.7220977259655398 9.142737058083174e-07 0.7183435968963056 9.142738302100673e-07 0.715360858370426 9.14273951271848e-07 0.7124600029613375 \
9.1427410478411e-07 0.7087850045121084 9.142742395660554e-07 0.7055614325718365 9.142743656650877e-07 0.7025479112911024 9.142745088393713e-07 0.6991289103945657 \
9.142746289211628e-07 0.6962626602560111 9.142747581554913e-07 0.6931807499479741 9.142748646405391e-07 0.6906432840523983 9.142749769163615e-07 0.6879696524977363 \
9.142750732516476e-07 0.6856773754336868 9.142751760613401e-07 0.683232326200841 9.14275270865193e-07 0.6809792012818872 9.14275376187123e-07 0.6784784437814733 \
9.14275484625777e-07 0.6759058899658261 9.142755836350576e-07 0.673558569590366 9.142757003916503e-07 0.6707929011939652 9.142758084769278e-07 0.6682347329991606 \
9.142759184831365e-07 0.6656332609774134 9.142760045709786e-07 0.6635992664604092 9.142761341661182e-07 0.6605400273835189 9.142762267673658e-07 0.6583552307294462 \
9.142763225550924e-07 0.6560965362104854 9.142764075070783e-07 0.6540950852804182 9.142765268016021e-07 0.6512869789851043 9.142766140715398e-07 0.6492343850333612 \
9.142767047785614e-07 0.6471030993779646 9.142768059435359e-07 0.6447280068361273 9.142768857743593e-07 0.6428551652550211 9.142769745601937e-07 0.6407732405330839 \
9.142770522504205e-07 0.6389536101386547 9.142771140193683e-07 0.6375081226244841 9.142771777840134e-07 0.6360167668935747 9.142772410182331e-07 0.634538653569437 \
9.142772802588059e-07 0.6336218002627473 9.142773208978281e-07 0.6326726453797233 9.142774009823624e-07 0.6308039353694699 9.142774708865426e-07 0.6291742390428672 \
9.142775215232567e-07 0.6279942052995945 9.142775602728994e-07 0.6270914175114127 9.142775992678786e-07 0.6261832343283663 9.142776438826266e-07 0.6251445623164014 \
9.142776867390832e-07 0.6241478292286105 9.142777370536866e-07 0.6229782634938205 9.142777889908641e-07 0.6217719122409077 9.142778740584486e-07 0.6197972300178722 \
9.142779340388659e-07 0.6184052992407258 9.142780238260749e-07 0.61632338076978 9.142781002901565e-07 0.6145529519516876 9.142781798544471e-07 0.6127119801362371 \
9.142782608910593e-07 0.6108383709630588 9.142783501053817e-07 0.6087775861620425 9.142784409653937e-07 0.6066826282541496 9.142785281841023e-07 0.6046739453334793 \
9.142786219572931e-07 0.6025158549334848 9.142787236427564e-07 0.6001788642681311 9.142788232408484e-07 0.5978941858483342 9.142789350958888e-07 0.5953317151711254 \
9.14279051129026e-07 0.5926772450523136 9.142791727501318e-07 0.5899020947998995 9.142792771339458e-07 0.5875236635596754 9.142794219241657e-07 0.5842296531729801 \
9.142795345841267e-07 0.5816734289694181 9.14279643596094e-07 0.5792035939892568 9.142797360755373e-07 0.5771100174076607 9.142798295261765e-07 0.5749994714793375 \
9.142799218520404e-07 0.5729181236728181 9.142799944387413e-07 0.571283073141143 9.142800503929671e-07 0.5700232888304386 9.142801114612484e-07 0.5686498830286455 \
9.142802099507645e-07 0.5664400707212188 9.142802731622084e-07 0.5650238531380825 9.142803335881769e-07 0.5636708824310654 9.142804105365601e-07 0.5619492451093103 \
9.142804736951014e-07 0.5605380106414651 9.142805620087099e-07 0.558569506627369 9.14280633210033e-07 0.5569845302974165 9.14280719745787e-07 0.555060151797141 \
9.142808410985601e-07 0.5523665438352664 9.142809690278082e-07 0.5495364947125975 9.142810671584391e-07 0.5473694328713704 9.142811802824346e-07 0.5448752016832871 \
9.14281282350254e-07 0.5426314425864434 9.142814012991244e-07 0.5400217272291628 9.142815043868321e-07 0.5377630705755105 9.142816185939864e-07 0.5352670017334624 \
9.142817320096582e-07 0.532794946211756 9.142818590807129e-07 0.5300302694710822 9.142819829008019e-07 0.5273426867079006 9.14282127689607e-07 0.5242103332418484 \
9.142822635131097e-07 0.5212782585303676 9.142824185679683e-07 0.5179428401013338 9.142825794198527e-07 0.5144913885072363 9.142827581493005e-07 0.5106699876709851 \
9.1428294832834e-07 0.5066200804011861 9.142831582303622e-07 0.5021665212646098 9.142833869363468e-07 0.4973332357952056 9.142836408642852e-07 0.4919960258408594 \
9.142838817977506e-07 0.4869529241725989 9.142841779602358e-07 0.4807889695952298 9.14284467957623e-07 0.4747910561470179 9.142847742009557e-07 0.4684976697011882 \
9.142850948768875e-07 0.4619520863481486 9.142854227440541e-07 0.4553041925245184 9.142857629891091e-07 0.4484521981997251 9.142860884146544e-07 0.4419418052309769 \
9.142864103218021e-07 0.4355465312739703 9.142867405359072e-07 0.4290298934287748 9.142870965284996e-07 0.4220583188787752 9.142874154069286e-07 0.4158579595363656 \
9.14287752858691e-07 0.4093433989943853 9.142881807254075e-07 0.4011531841887147 9.142885294373556e-07 0.3945419525178304 9.142888370733193e-07 0.388759214407489 \
9.142892168998105e-07 0.3816861832573664 9.142895480893721e-07 0.3755780492082042 9.142898316974524e-07 0.370391509977049 9.142901425163967e-07 0.3647512908748707 \
9.142904218330044e-07 0.3597258263082204 9.142906483291526e-07 0.3556836811642302 9.142908640115378e-07 0.3518598964090484 9.142910612955428e-07 0.3483842179544538 \
9.142912662800023e-07 0.3447988491770444 9.142914785019664e-07 0.3411119200457455 9.142917338071541e-07 0.33670771290924 9.142919753294026e-07 0.3325734463267218 \
9.14292206706731e-07 0.3286464933807047 9.142924215592308e-07 0.3250253651850565 9.142926421183882e-07 0.3213332986541765 9.142928435443551e-07 0.3179852906236645 \
9.14293046612606e-07 0.3146379646143546 9.142932445082156e-07 0.3114011111455273 9.142934314693022e-07 0.3083651674074345 9.142936252695217e-07 0.3052406640298299 \
9.142938291861338e-07 0.3019773030815858 9.142940082554677e-07 0.2991336297844484 9.14294243846324e-07 0.2954229173226265 9.142944446504233e-07 0.2922868215109002 \
9.142946458293146e-07 0.2891696385850206 9.142948696390573e-07 0.2857334090862961 9.142950342018032e-07 0.2832271910241367 9.142952111291889e-07 0.2805503385691353 \
9.14295396922194e-07 0.2777610713150803 9.142955787376701e-07 0.2750538970423583 9.142957577624632e-07 0.2724132377985424 9.142959251076164e-07 0.2699606650006489 \
9.142960855365337e-07 0.2676371805838822 9.142962081102854e-07 0.2658719571410424 9.142963578748139e-07 0.2637236906090554 9.142964855719403e-07 0.2619099339733745 \
9.14296592880312e-07 0.2603957336038235 9.142967088809744e-07 0.2587625259947361 9.142968191895705e-07 0.2572125806747212 9.142969450687671e-07 0.2554509781935611 \
9.142970605506182e-07 0.2538402638894013 9.142971951315211e-07 0.2519757335310172 9.142973071947753e-07 0.2504255755821768 9.142974575341346e-07 0.2483447107137444 \
9.142975971599892e-07 0.2464124269747185 9.142977430518096e-07 0.2444035064209518 9.142978760124476e-07 0.2425734862730615 9.14297999574161e-07 0.2408709992523319 \
9.142981467838532e-07 0.2388417729476062 9.142982633706824e-07 0.2372355665500016 9.142984028258316e-07 0.23532008003217 9.142985370003013e-07 0.2334768281602104 \
9.142986629767574e-07 0.2317465561243653 9.142987823761605e-07 0.2301094434087779 9.142988772305854e-07 0.2288105340759602 9.142989903681845e-07 0.2272617792622066 \
9.142990706846421e-07 0.2261626001158484 9.142991582496985e-07 0.2249657246820506 9.142992837868356e-07 0.2232507767215072 9.142993894805427e-07 0.2218101326756785 \
9.142994791350539e-07 0.2205921574607158 9.14299549986253e-07 0.2196300825522397 9.142995930147826e-07 0.2190460135436258 9.142996353053263e-07 0.2184724035808872 \
9.142996776470424e-07 0.2178984240735344 9.142997498424615e-07 0.2169203674089526 9.142997922358173e-07 0.2163464205126744 9.14299827490656e-07 0.2158693585303403 \
9.142998716822394e-07 0.2152716287340076 9.142999412904664e-07 0.2143309212991285 9.142999756337965e-07 0.2138672544767182 9.143000200933248e-07 0.2132698436071631 \
9.143000877718061e-07 0.2123628126304402 9.143001741990649e-07 0.2112058698236149 9.143002488356675e-07 0.2102078598594563 9.143003301376756e-07 0.2091219706754807 \
9.143004270150593e-07 0.2078300362310651 9.143005529985482e-07 0.2061528795789772 9.143006555333841e-07 0.2047906894256944 9.143007570169013e-07 0.2034500128132261 \
9.143008580825968e-07 0.202119416354989 9.143009546968166e-07 0.2008491615811921 9.143010566612395e-07 0.1995112314821507 9.143011633834835e-07 0.1981153840927639 \
9.143012717886237e-07 0.1967018790395962 9.143013837827796e-07 0.1952465002768531 9.143014962499069e-07 0.1937897263683151 9.143016083232463e-07 0.1923454332378671 \
9.143017162157206e-07 0.1909603537828802 9.143018175986493e-07 0.1896629368444172 9.143019092360985e-07 0.1884941330679491 9.143020032117072e-07 0.1872990757663449 \
9.14302074478072e-07 0.1863957871745983 9.143021511533599e-07 0.1854271890400033 9.143022548124748e-07 0.184122202819407 9.143023284795955e-07 0.1831974022686171 \
9.143024018254955e-07 0.1822796569444652 9.143025152158448e-07 0.1808667181969195 9.143026030744852e-07 0.1797760932362061 9.143026869231621e-07 0.1787387947787487 \
9.143028158855897e-07 0.1771515524267008 9.143029177720844e-07 0.1759040172436072 9.143030234727907e-07 0.1746156056808686 9.143031251208657e-07 0.1733818993219825 \
9.143032559825841e-07 0.1718019019596718 9.143033631792215e-07 0.1705140034701537 9.14303492508118e-07 0.168969083715685 9.143036042046102e-07 0.167642098072289 \
9.143037045351886e-07 0.1664555496840579 9.143038003357432e-07 0.1653276075899142 9.143039111480153e-07 0.1640289617085985 9.143039985482962e-07 0.1630090521997956 \
9.143041098694133e-07 0.1617156184952586 9.143042028212722e-07 0.1606409001560029 9.143042903941501e-07 0.1596330843918451 9.143043920250233e-07 0.1584700928658864 \
9.14304476479078e-07 0.1575086241734052 9.143045515834574e-07 0.1566573095634876 9.143046294056998e-07 0.1557789554714152 9.143047097635688e-07 0.1548759612316424 \
9.143048108183988e-07 0.1537464547857493 9.143048932519626e-07 0.1528311848879565 9.143049855565143e-07 0.1518114053368895 9.143050624909871e-07 0.150965812476358 \
9.143051454135576e-07 0.1500585909391909 9.143052169442981e-07 0.1492793026301012 9.143053133277974e-07 0.1482344968214558 9.143053835562832e-07 0.1474766665551334 \
9.143054665365612e-07 0.1465853655470201 9.143055279788246e-07 0.1459298106834085 9.143055996612093e-07 0.1451677491870439 9.14305668289752e-07 0.1444408762699853 \
9.143057185582615e-07 0.1439102090153988 9.143057661380673e-07 0.143409423336876 9.143058201874179e-07 0.1428423132663369 9.143058795295158e-07 0.1422216078256897 \
9.143059475649227e-07 0.1415124633834424 9.14306023828345e-07 0.1407207186008814 9.143060921081446e-07 0.1400161356079559 9.143061868943229e-07 0.1390460813732662 \
9.143062764481351e-07 0.1381341561933974 9.143063481336088e-07 0.1374075731330657 9.143064320850176e-07 0.1365606113096345 9.143064973974727e-07 0.1359045398875483 \
9.143065588405982e-07 0.1352895588344758 9.143066331170967e-07 0.1345490408254265 9.143066953273574e-07 0.1339328028964004 9.143067632983656e-07 0.133265236037424 \
9.143068225054054e-07 0.1326856657519672 9.143068951778785e-07 0.1319767402814105 9.143069701979877e-07 0.1312477270463112 9.143070556514106e-07 0.1304208267333309 \
9.143071417517503e-07 0.1295914604616623 9.143072418772051e-07 0.1286317929389105 9.143073231668748e-07 0.127857435971709 9.143074249342227e-07 0.1268981149578782 \
9.143075091821821e-07 0.1261072369695883 9.143076079989111e-07 0.1251836587365037 9.143076808394557e-07 0.1245055382686853 9.143077608655429e-07 0.1237631876254407 \
9.143078313513379e-07 0.1231117958237987 9.143079038817605e-07 0.1224439308288319 9.143079813507563e-07 0.1217331219782777 9.143080887021039e-07 0.1207554316575004 \
9.143081893401195e-07 0.1198442997624752 9.143082619276735e-07 0.1191899427853172 9.143083307595137e-07 0.1185715582611356 9.143083965463339e-07 0.1179824683205609 \
9.143084661751317e-07 0.1173610347366148 9.143085365588769e-07 0.1167350538439435 9.143086117372495e-07 0.1160688810594495 9.143087159914846e-07 0.1151493019715505 \
9.143087911261386e-07 0.114489769343061 9.14308860041223e-07 0.1138870655592168 9.143089232460945e-07 0.1133369146236164 9.143089927874598e-07 0.1127339156958381 \
9.14309050088964e-07 0.1122385190692166 9.14309121730019e-07 0.1116210355509516 9.143091795650924e-07 0.1111240709857579 9.143092516865272e-07 0.1105063809580559 \
9.1430931410261e-07 0.1099736279351742 9.143093984241316e-07 0.1092565349771765 9.143094660201e-07 0.1086842173446869 9.143095748160323e-07 0.1077671916889585 \
9.143096791265638e-07 0.1068924975608609 9.14309758614772e-07 0.1062289053282379 9.143098461831824e-07 0.1055008617114655 9.143099096395349e-07 0.1049752776433979 \
9.143099713506517e-07 0.10446579874651 9.14310075190416e-07 0.103612238268202 9.143101578711175e-07 0.1029362225408096 9.143102563391439e-07 0.1021348761715451 \
9.14310340785582e-07 0.101450818648051 9.143104572630618e-07 0.1005121841703865 9.143105919965076e-07 0.09943411943161744 9.143107280660444e-07 0.0983541971400249 \
9.143108423854515e-07 0.09745369041838402 9.143109278525961e-07 0.09678457778867394 9.143110381342688e-07 0.09592640631053104 9.143111189226222e-07 0.09530159220710262 \
9.143112184734933e-07 0.09453592511176086 9.143113084215428e-07 0.09384821103094763 9.14311380924943e-07 0.09329669945188329 9.143114626670093e-07 0.09267796846073476 \
9.143115907872446e-07 0.09171467366828615 9.143116721993079e-07 0.09110674702409056 9.143117466312152e-07 0.09055373306570065 9.143118216050992e-07 0.08999936228352182 \
9.143119010240744e-07 0.08941505746347288 9.143120096849317e-07 0.08862052380504259 9.143121040449035e-07 0.08793517800096999 9.143121934400264e-07 0.08728987318634121 \
9.143123002057425e-07 0.086524181682867 9.143124187081826e-07 0.08568073755029131 9.143125602332527e-07 0.08468224831562859 9.143126933716762e-07 0.08375174214918565 \
9.143128342170072e-07 0.08277682112810406 9.143129832689884e-07 0.08175525972387458 9.143131190667175e-07 0.08083369778093191 9.143132605232322e-07 0.0798830809748103 \
9.143133957831475e-07 0.07898330517332906 9.143135371649882e-07 0.07805242629322809 9.143136842327612e-07 0.07709434677344783 9.143138359609018e-07 0.07611680364043326 \
9.143140013092032e-07 0.07506403321855706 9.143141651767208e-07 0.07403332863189842 9.143143414906486e-07 0.07293832728335037 9.143145309257505e-07 0.07177777688466977 \
9.14314741692455e-07 0.07050569389938771 9.143149614649522e-07 0.06920150027616521 9.143151964331044e-07 0.06783224552442871 9.143154553336539e-07 0.06635227408830123 \
9.14315750264117e-07 0.06470266364809808 9.143160546101784e-07 0.06304001691994518 9.143164165564573e-07 0.06111393619706453 9.143167326842125e-07 0.05947639552636011 \
9.143171740066774e-07 0.0572596911373907 9.143174875727195e-07 0.05573556853365672 9.14317911072189e-07 0.0537382660685313 9.143182550240425e-07 0.05216649213267931 \
9.143185952653102e-07 0.05065508790922631 9.143189061028997e-07 0.04931137323461653 9.143192005748017e-07 0.04807062469528345 9.143194942742994e-07 0.04686392507224969 \
9.143197691455356e-07 0.04576537019482012 9.143200446857014e-07 0.04468949010490332 9.143203097762297e-07 0.04367785045825667 9.143205865333108e-07 0.04264571401740119 \
9.143208698014357e-07 0.04161414314527601 9.143211677947347e-07 0.04055545327485047 9.14321427280131e-07 0.03965542606183669 9.143216573035691e-07 0.03887446236327848 \
9.143218769951558e-07 0.03814321686473518 9.14322101935296e-07 0.0374128399305801 9.1432242218897e-07 0.0363978329183388 9.1432270998682e-07 0.03550963653148703 \
9.143229863821537e-07 0.03467738358988744 9.143232702012828e-07 0.03384352473043348 9.143235083105866e-07 0.03315996078327022 9.143237926213707e-07 0.03236211345273886 \
9.143240345332207e-07 0.03169864947531036 9.143242696733945e-07 0.03106710921041438 9.143245113809233e-07 0.03043352335444016 9.143247483338566e-07 0.02982731501219571 \
9.143249786762739e-07 0.02925002048968134 9.143251924268523e-07 0.02872465224286764 9.14325398273815e-07 0.02822791768061097 9.143257906108381e-07 0.02730524204782691 \
9.143259790028487e-07 0.02687312495148303 9.143263546143072e-07 0.02603163971789 9.143265290810819e-07 0.02564950258131362 9.143269530155409e-07 0.02474274850847508 \
9.14327073769958e-07 0.02449086781212801 9.143275440207214e-07 0.02353384026002922 9.143276932357865e-07 0.02323677291035493 9.143280868679981e-07 0.02246740853134286 \
9.143282578943424e-07 0.02213909006726131 9.143287451732744e-07 0.02121869533024997 9.143288872209832e-07 0.02095326544309953 9.143294202372519e-07 0.01997576278857772 \
9.143295424012889e-07 0.01975737097014436 9.143300645590335e-07 0.01885981776906158 9.143302351373363e-07 0.01857989792133653 9.143307224503993e-07 0.01781360777737795 \
9.143308939733226e-07 0.01755501440977742 9.143315137600803e-07 0.01666567753024489 9.14331684684406e-07 0.0164316648397145 9.143323902353963e-07 0.01551160061118263 \
9.14332552852409e-07 0.01530799450170666 9.143333097458993e-07 0.01439879525764199 9.143334506625442e-07 0.01423641007536438 9.143343506613841e-07 0.01324361033368418 \
9.143344380106346e-07 0.01315122959105692 9.14335342363989e-07 0.01223321097894121 9.143354795559379e-07 0.01209984223734439 9.14336450212214e-07 0.01118944790767422 \
9.14336578130092e-07 0.01107451071402888 9.143377285400387e-07 0.01011008206277823 9.143378223420746e-07 0.01003687265682024 9.143390783878875e-07 0.009120584045805383 \
9.143392159292007e-07 0.009026502753623255 9.143407746836019e-07 0.008029670037698805 9.143408584862873e-07 0.007977066150721189 9.143424638651058e-07 0.00699828665725172 \
9.143425747634502e-07 0.006935886594503895 9.143445070098237e-07 0.005959177461785255 9.143446867147596e-07 0.005876661013304485 9.14346798505876e-07 0.004981749118765498 \
9.143471412910116e-07 0.004848482978762325 9.143496544570452e-07 0.003966891390423618 9.143501241787149e-07 0.003819799497680527 9.143537644949896e-07 0.002847564273158896 \
9.143542802321751e-07 0.002731633924241866 9.143596220620139e-07 0.001773027297371861 9.143599073822989e-07 0.001729522787584184 9.143651360301289e-07 0.0007540451492352357 \
9.143653101766958e-07 0.0007162692714263865 9.17013698769002e-07 -0.0001123232525192561 9.170138717942902e-07 -0.0002901710972538241 9.170144915460445e-07 -0.001202022686018724 \
9.170145801152216e-07 -0.001365806793032466 9.170149410863549e-07 -0.002110727959526865 9.1701506578065e-07 -0.002395793696299351 9.170154296225313e-07 -0.003299857180474864 \
9.170156008981996e-07 -0.003758114451912169 9.170158948960376e-07 -0.004576312838821549 9.170160051044431e-07 -0.004886880824040592 9.170162833584409e-07 -0.005643955697619643 \
9.170164046322499e-07 -0.00594200199557267 9.170174982543479e-07 -0.00517389603226481 9.170176213582281e-07 -0.004409713243767066 9.170177448263028e-07 -0.003462788751204457 \
9.170178649920999e-07 -0.002366010162083454 9.170179628537677e-07 -0.001346276287748183 9.170180695561039e-07 -0.0001076498664581183 9.170181813974884e-07 0.001328007358939307 \
9.170183173718548e-07 0.003256083960376262 9.170184394010113e-07 0.00514709866632534 9.170186278172891e-07 0.008343062029134115 9.17018768805819e-07 0.01093380316938193 \
9.170189215775225e-07 0.01391176330477175 9.170190642801506e-07 0.01683596409946878 9.170192186323876e-07 0.02013443377634912 9.170193744260432e-07 0.02358734537610087 \
9.170195304833402e-07 0.02715365164079262 9.170196778877403e-07 0.03060642997674319 9.170198265044852e-07 0.03415780069914553 9.170199819257017e-07 0.03793559522944389 \
9.170201403115321e-07 0.04184227512730877 9.170203052511541e-07 0.04596085539464361 9.170204795004229e-07 0.05035714787605008 9.170206584435391e-07 0.05491177248689325 \
9.17020847583032e-07 0.0597604232635115 9.170210503636104e-07 0.06498910043066243 9.170212697356368e-07 0.07067233091134768 9.170215005721334e-07 0.07667464705993039 \
9.170217473839692e-07 0.0831083675499642 9.1702201751608e-07 0.09016243555275107 9.17022310704188e-07 0.0978236474935409 9.170226343596257e-07 0.1062798466079799 \
9.17022997926912e-07 0.1157689210849182 9.170233902204302e-07 0.1259925151671456 9.170238386999148e-07 0.1376538644086695 9.170243603994003e-07 0.1511757390224034 \
9.170249727720439e-07 0.1669844191341421 9.170256494173591e-07 0.1843663871188266 9.170264363276495e-07 0.2044554566749352 9.170273175487439e-07 0.2267919980918504 \
9.170281372923844e-07 0.2474048556006221 9.170288657453285e-07 0.2655829647002126 9.17029507221317e-07 0.2814688958417333 9.170300831444853e-07 0.2956305456066151 \
9.170306204013018e-07 0.3087428400511723 9.170311242925969e-07 0.3209487846516751 9.17031601896145e-07 0.3324328152479784 9.170320800193788e-07 0.343838772307344 \
9.170325321182285e-07 0.3545331600964184 9.170330038845194e-07 0.365596737404158 9.170334475813599e-07 0.3759140547845509 9.170339695498975e-07 0.3879344734281669 \
9.170344970878305e-07 0.399956933836353 9.170348766025743e-07 0.4085271910771138 9.170354055641745e-07 0.4203606102508351 9.170358748832553e-07 0.4307444005277802 \
9.17036310038791e-07 0.4402814026247405 9.170367575161174e-07 0.4500002273945978 9.170371975395924e-07 0.4594737646471725 9.170376008413354e-07 0.4680814138276727 \
9.170379192411012e-07 0.4748254127722248 9.170382892190147e-07 0.4826007100982719 9.170385254720969e-07 0.4875314737878706 9.170387605434931e-07 0.4924129045770672 \
9.170390118828311e-07 0.4975994385012801 9.170393182698655e-07 0.5038799449729535 9.170395752283188e-07 0.5091120301871851 9.170397837026154e-07 0.5133309170973237 \
9.170399840849047e-07 0.5173683849445317 9.170401264786058e-07 0.5202244049244739 9.170402754030717e-07 0.5231993726577677 9.170404869493287e-07 0.5274019882470222 \
9.170407130069516e-07 0.5318780389403845 9.170409075493335e-07 0.5357103559602913 9.170410966812289e-07 0.539423417888626 9.170413261282767e-07 0.5439012399750046 \
9.170415086340828e-07 0.5474563135343053 9.170417459969518e-07 0.5520623276458133 9.1704201499126e-07 0.5572695987004129 9.170422639017101e-07 0.5620706638085723 \
9.170425079185314e-07 0.5667633705755619 9.170427802737437e-07 0.5719926523718327 9.170430416698736e-07 0.5769928369418796 9.170432993012793e-07 0.5819084237686675 \
9.17043546144628e-07 0.586601202059797 9.170437918903538e-07 0.5912552023551558 9.170440184678743e-07 0.5955288021520931 9.170442496200641e-07 0.5998646534936181 \
9.170444559004441e-07 0.6037202012184053 9.17044684021204e-07 0.6079592993751251 9.170449064011852e-07 0.6120725203834017 9.17045133377667e-07 0.6162454422471376 \
9.170453484306168e-07 0.6201823359462864 9.170455778001902e-07 0.6243500782103125 9.170458468230648e-07 0.6292041961704016 9.170460698367117e-07 0.6331993632081415 \
9.170462820912892e-07 0.6369772451758789 9.170464934888789e-07 0.6407176358819484 9.17046693558109e-07 0.644236566349866 9.170469231519586e-07 0.6482486956559365 \
9.170471639888862e-07 0.6524328529570182 9.170473457382733e-07 0.6555667906748446 9.170475342864999e-07 0.6588018260593631 9.170476873661394e-07 0.6614154033769962 \
9.170478593744213e-07 0.6643352515471471 9.170480095472396e-07 0.6668697017322168 9.170481460645293e-07 0.6691578850264722 9.170482956937163e-07 0.6716547631652277 \
9.170484234340851e-07 0.673777752640997 9.170485630202225e-07 0.6760856948620949 9.170486872589102e-07 0.6781310478824312 9.170488184087495e-07 0.6802827752320969 \
9.170489428500932e-07 0.6823179209931315 9.170490800809157e-07 0.6845542421253382 9.170492003290863e-07 0.6865048414796368 9.170493416605294e-07 0.6887891282595083 \
9.170494419916407e-07 0.6904033553735033 9.170495631093426e-07 0.6923460943304175 9.170496538868777e-07 0.6937948943079848 9.170497511453436e-07 0.6953408241330762 \
9.170498473532237e-07 0.6968660703265798 9.17049935967068e-07 0.6982647859968389 9.170500332550912e-07 0.6997938110311075 9.170501657237293e-07 0.7018622871835729 \
9.170503209139279e-07 0.7042674555997347 9.170504587918793e-07 0.7063866855441746 9.170506036461533e-07 0.7085960165693863 9.170507307079098e-07 0.7105202221428537 \
9.170508553934701e-07 0.7123960184768648 9.170509680988463e-07 0.7140814553427599 9.170510798891907e-07 0.7157437310299281 9.170511806678399e-07 0.7172341607972841 \
9.170513179462953e-07 0.7192525454101454 9.170514376303672e-07 0.7210013704967912 9.170515570598379e-07 0.7227365757678518 9.170516839430602e-07 0.7245692610776365 \
9.170518083607121e-07 0.7263556789600311 9.170519320935366e-07 0.728121726658988 9.170520586890633e-07 0.7299181396522603 9.170521890744641e-07 0.7317573312219798 \
9.170523118842844e-07 0.7334798522758219 9.170524473200596e-07 0.7353678990088863 9.170525486098379e-07 0.7367723836293941 9.170526562323338e-07 0.7382576460517265 \
9.170527457604157e-07 0.7394878879617913 9.170528603087849e-07 0.7410528648863303 9.170529483370413e-07 0.7422487366778059 9.170530554151067e-07 0.7436953530868765 \
9.170531854801004e-07 0.7454403311053276 9.170532967597954e-07 0.7469230742113165 9.170534013783547e-07 0.7483084058091373 9.170535254613401e-07 0.7499400420429273 \
9.170536737621685e-07 0.7518749696944975 9.170537951620328e-07 0.7534462209622173 9.170539096027802e-07 0.7549170836379747 9.170540499400977e-07 0.7567069362027918 \
9.170541917029811e-07 0.7584995177563068 9.170543095039188e-07 0.759977341175643 9.170544374807853e-07 0.761570846386187 9.170545791832092e-07 0.7633205808366864 \
9.170546966945226e-07 0.7647599110190483 9.170548422997917e-07 0.7665289162262866 9.170549639940993e-07 0.7679951561698679 9.170550827247088e-07 0.7694149786178283 \
9.170552050113037e-07 0.7708662727382939 9.170553320558196e-07 0.77236234268503 9.170554416997921e-07 0.7736439866494906 9.170555673867047e-07 0.7751025186690397 \
9.170556734018051e-07 0.776323977486031 9.170558089877718e-07 0.7778743028704433 9.170559339507685e-07 0.7792913979962601 9.170560598569209e-07 0.7807070123991936 \
9.17056175124167e-07 0.7819915514687489 9.170562814286401e-07 0.7831664991275713 9.17056419833432e-07 0.7846822315516878 9.170565691298821e-07 0.7862997378875561 \
9.170567146373276e-07 0.7878588534534761 9.170568340418389e-07 0.7891257303126159 9.170569691346634e-07 0.7905455128963393 9.170570903878263e-07 0.7918076974797237 \
9.170572333811047e-07 0.7932816011184505 9.170573775854105e-07 0.7947523458802197 9.170575031222391e-07 0.7960199014141693 9.170576221686117e-07 0.7972110037065316 \
9.170577341044954e-07 0.7983213107123885 9.170578389760473e-07 0.7993531099923881 9.170579342264591e-07 0.8002831901653534 9.170580705697046e-07 0.8016020813281191 \
9.170581873938354e-07 0.8027203407102198 9.170583067984452e-07 0.803852171037294 9.170584289052493e-07 0.8049980820693966 9.170585518602504e-07 0.8061401395390313 \
9.17058678828951e-07 0.8073073595000361 9.170588040685604e-07 0.8084467645495962 9.17058934640955e-07 0.8096220968518901 9.170590606314732e-07 0.8107441738369082 \
9.170591888173857e-07 0.8118738099374113 9.170592943471138e-07 0.8127947795787664 9.170593972188868e-07 0.8136847278655364 9.17059490214057e-07 0.8144826950388273 \
9.170596140106596e-07 0.8155354283166244 9.170597019789174e-07 0.8162769513478326 9.170598007099885e-07 0.8171027376706747 9.170599439751417e-07 0.8182889948057973 \
9.170600792538271e-07 0.8193962136425846 9.170601883684495e-07 0.8202800249700468 9.17060336451758e-07 0.8214657808291811 9.170604862226849e-07 0.8226492530953341 \
9.170606114572855e-07 0.8236267526687548 9.170607554487031e-07 0.8247372275730155 9.170608795047738e-07 0.8256825756473101 9.170610299680322e-07 0.8268152483647575 \
9.170611656788839e-07 0.8278240064655301 9.17061290697392e-07 0.828742521381556 9.170614084523219e-07 0.8295983347934622 9.170615544291349e-07 0.8306466023667578 \
9.170617209384522e-07 0.8318251482734692 9.170618518610281e-07 0.8327390940956469 9.170620252884657e-07 0.8339327615268647 9.170621934353481e-07 0.8350717495747054 \
9.170623632702772e-07 0.8362042975620877 9.170625441950479e-07 0.8373912937861997 9.170626872933069e-07 0.8383160748488641 9.170628013791983e-07 0.8390446117604563 \
9.170629315531841e-07 0.8398665237782376 9.170630333942663e-07 0.8405024977857931 9.170631502136154e-07 0.8412243379523001 9.170632870780449e-07 0.8420597162999857 \
9.170634848766686e-07 0.8432475311273343 9.170636764807397e-07 0.8443767279905872 9.170638859212215e-07 0.8455874169714939 9.170640678468519e-07 0.8466193100105236 \
9.170642649799574e-07 0.8477171434207121 9.170644383298479e-07 0.8486653666163242 9.170646213292317e-07 0.8496493024239481 9.17064792495495e-07 0.8505537352954988 \
9.170649671272818e-07 0.8514606693963016 9.170651423896692e-07 0.8523550102558151 9.170653185417845e-07 0.8532381479010797 9.170655088128237e-07 0.8541746551565574 \
9.170656994147745e-07 0.85509499218684 9.170659000624008e-07 0.8560449689899254 9.170660926729659e-07 0.8569390259424264 9.170663033306522e-07 0.8578972157030333 \
9.170665314560509e-07 0.8589122247267402 9.170667972133685e-07 0.8600655879592763 9.170670958378129e-07 0.8613244245924475 9.170673721693317e-07 0.862454900702886 \
9.170676564023905e-07 0.8635842083919951 9.17067930614306e-07 0.8646423892283146 9.170682028423722e-07 0.8656634505877856 9.170684730511912e-07 0.8666487272755322 \
9.170687302040671e-07 0.8675609437488442 9.170690027863351e-07 0.868501515423508 9.170692787713349e-07 0.8694269133137555 9.170695488729114e-07 0.8703069289141475 \
9.170698487348628e-07 0.8712546000783432 9.170702197689933e-07 0.8723856543073821 9.170705147067535e-07 0.8732530157608677 9.170707689975357e-07 0.8739790309043101 \
9.170710672549513e-07 0.8748056771600844 9.170713408634846e-07 0.8755409825400007 9.170715769915496e-07 0.8761583495732972 9.170718173369302e-07 0.876770807053994 \
9.17072039670212e-07 0.8773233906735478 9.170722336759598e-07 0.8777948466981503 9.17072563398506e-07 0.8785737911727464 9.170727185719444e-07 0.8789308835864816 \
9.170730363474729e-07 0.8796437246174529 9.1707321520917e-07 0.8800342982281311 9.170735576710472e-07 0.8807611334253193 9.170737417995192e-07 0.8811407335605206 \
9.170742166778565e-07 0.8820849466541889 9.170743840740528e-07 0.8824061830950772 9.170748499154564e-07 0.8832696475595492 9.17075030737665e-07 0.8835931319180218 \
9.170755247759143e-07 0.8844450822729043 9.170756661243274e-07 0.8846804878101884 9.170762724573853e-07 0.8856498028150036 9.170764245267248e-07 0.8858829444029697 \
9.170770712152002e-07 0.8868329272509302 9.170771995097231e-07 0.8870138524519416 9.170778476269279e-07 0.8878919388991984 9.170779774257915e-07 0.8880607713689423 \
9.170787556274809e-07 0.8890227771434612 9.170788706844141e-07 0.8891574578072456 9.170797263428481e-07 0.8901003239091128 9.170798717076157e-07 0.8902505899439886 \
9.170808574640299e-07 0.8911948786459364 9.170810785690402e-07 0.8913892999646706 9.170822236960191e-07 0.8923206810037944 9.170823549126185e-07 0.892422953350996 \
9.170836961242674e-07 0.8934189515818408 9.170838475232108e-07 0.8935240845833778 9.170853289614591e-07 0.8944568913393511 9.170855678408922e-07 0.8945912088657246 \
9.170873371610739e-07 0.8954685138428928 9.170877263108405e-07 0.895637400736999 9.170901199766275e-07 0.896526474291006 9.170905956894498e-07 0.8966764365754722 \
9.17094011699057e-07 0.8975478548673914 9.170946588490716e-07 0.8976786076740833 9.171021370136781e-07 0.8986646932675814 9.171028095907965e-07 0.8987192862546014 \
9.171952539953666e-07 0.8997188196574962 9.171959172280509e-07 0.8997241906476866 9.17385126389945e-07 0.900686595210158 9.173852884627891e-07 0.9007292695325627 \
9.173879339836764e-07 0.8998161167154269 9.173881025331538e-07 0.8996881690130656 9.173893792855451e-07 0.8987393243250013 9.173895814518807e-07 0.8986030018074492 \
9.173911895612673e-07 0.8976721249252815 9.173913816671926e-07 0.8975774045828077 9.174064950498387e-07 0.8985726115129884 9.174066831087563e-07 0.8986004060702872 \
9.174179880377676e-07 0.8995874924221801 9.174183614235164e-07 0.8996034751727418 9.179073737866979e-07 0.9005892719715856 9.179074845548976e-07 0.9006868984798269 \
9.179082372272589e-07 0.9015617873136611 9.179083390219455e-07 0.9017086238768567 9.179088744204902e-07 0.9025814930725723 9.179089769296628e-07 0.9027670217776843 \
9.179093691484816e-07 0.9035254014384071 9.17909509991429e-07 0.9038129158713877 9.179099510288813e-07 0.9047472953155866 9.179101365144842e-07 0.9051402477015744 \
9.179106528276013e-07 0.9061269394579334 9.17910737502694e-07 0.9062564181617988 9.179119721747438e-07 0.9053011091537977 9.179121293881559e-07 0.9045688862145235 \
9.179123212048176e-07 0.9034162411061901 9.179124880453484e-07 0.9021712267446264 9.179126350037462e-07 0.9008824031243315 9.179127491199424e-07 0.8997575350477262 \
9.179128789920322e-07 0.8983446880789033 9.179129901095502e-07 0.8970273815442567 9.179130829140294e-07 0.8958483937359277 9.17913171236719e-07 0.8946639786015808 \
9.179132744174779e-07 0.8932058048613533 9.179133666254135e-07 0.8918333298588224 9.179134541956102e-07 0.8904732289418564 9.179135681890766e-07 0.8886245408236838 \
9.179137299935004e-07 0.8858564722885236 9.179139149921176e-07 0.8825005184224666 9.179141071517853e-07 0.8788219124347386 9.179143085991385e-07 0.874780227084481 \
9.17914515009728e-07 0.8704697801294994 9.179147001816806e-07 0.8664790122147591 9.179148846894051e-07 0.862405115500708 9.179150578412963e-07 0.8585071391690239 \
9.179152428873213e-07 0.8542751393552932 9.179154202615245e-07 0.8501657390392787 9.179155970079552e-07 0.8460284987362284 9.179157631666058e-07 0.8421077870518131 \
9.179159252110445e-07 0.8382599993991456 9.17916091783925e-07 0.8342839555277276 9.179162504376617e-07 0.8304816347052207 9.179164413136869e-07 0.8258903812682129 \
9.179166162972585e-07 0.8216694867670907 9.179167862433925e-07 0.8175615830390965 9.179169514195675e-07 0.8135626411663678 9.179171246116744e-07 0.8093650119631921 \
9.179172956738768e-07 0.8052155696745213 9.179174637749139e-07 0.801136095357175 9.179176541098627e-07 0.7965156511928794 9.179178376918066e-07 0.7920591698039 \
9.179180456827317e-07 0.7870113041480956 9.179182682592422e-07 0.7816114142545842 9.17918457674258e-07 0.7770174196885687 9.17918650984654e-07 0.7723312127316435 \
9.179187944302406e-07 0.7688556734481145 9.179189438535907e-07 0.7652374066097742 9.179190630060629e-07 0.7623536300085233 9.179191757225444e-07 0.7596269484184472 \
9.179192849974512e-07 0.7569846861296079 9.179194210272094e-07 0.753697254849378 9.179195338230239e-07 0.750972995067179 9.1791965602098e-07 0.7480232093637929 \
9.179197676057526e-07 0.7453311011793381 9.179198923122156e-07 0.7423241425761796 9.179200466941668e-07 0.7386034578119585 9.179202134782327e-07 0.7345862494782525 \
9.179204306429212e-07 0.7293605768817599 9.1792062520351e-07 0.7246835946359503 9.179207855343955e-07 0.7208333202545074 9.179209609599985e-07 0.7166251500492028 \
9.179211507235728e-07 0.7120779400724765 9.179213394518973e-07 0.7075610435995559 9.179215212732643e-07 0.7032145396962334 9.179217058706759e-07 0.6988062725207448 \
9.179218429538112e-07 0.6955348514212173 9.179219962420495e-07 0.6918805091472418 9.179221916137951e-07 0.6872279990818534 9.179223477705467e-07 0.6835136309588888 \
9.179225057227664e-07 0.6797605476340507 9.179227039740297e-07 0.6750570282453686 9.179228973199278e-07 0.6704763548785364 9.179231338252739e-07 0.6648822204491218 \
9.179233200303777e-07 0.6604858901039825 9.179235576526979e-07 0.6548824851665868 9.179237444514521e-07 0.6504854738275335 9.179239250092116e-07 0.6462424706993735 \
9.179240880851561e-07 0.6424159959781919 9.179242326967205e-07 0.6390271817202816 9.179243732990705e-07 0.6357379642635244 9.179245001086568e-07 0.632774906490579 \
9.179246322451931e-07 0.6296924762754078 9.179247584891445e-07 0.6267508340255646 9.179248897527744e-07 0.6236963630311418 9.179250188505141e-07 0.6206978048938425 \
9.179251582761787e-07 0.6174624210713571 9.179253066461711e-07 0.6140261568477932 9.179255012030603e-07 0.6095278574984737 9.179256446489367e-07 0.6062198040692683 \
9.179258791091826e-07 0.6008245134060309 9.179260510074947e-07 0.5968818013610552 9.179262639280333e-07 0.5920102583789468 9.179264363946513e-07 0.5880775912131976 \
9.179265667191976e-07 0.5851108450968721 9.179266982755174e-07 0.5821241897920357 9.179268085055991e-07 0.5796262478458715 9.179269041598466e-07 0.5774603558442819 \
9.179270033938061e-07 0.5752182923213994 9.179270863119074e-07 0.5733484809858778 9.179271652275342e-07 0.5715706040143225 9.179272281563093e-07 0.5701535626562365 \
9.179272936647861e-07 0.5686800671140783 9.179273741508387e-07 0.5668736364148982 9.179274240168465e-07 0.5657560592102344 9.179274732056154e-07 0.5646541775062763 \
9.179275346754007e-07 0.5632780399140616 9.179275825969293e-07 0.5622058085646952 9.179276334416479e-07 0.5610687758404553 9.179276925419032e-07 0.5597501790023616 \
9.179277511562299e-07 0.5584442118409422 9.179278267823233e-07 0.5567607189607793 9.17927897341035e-07 0.5551915720267918 9.179279864710419e-07 0.5532116467156011 \
9.1792807569462e-07 0.5512351177508077 9.179281609982305e-07 0.5493490637975145 9.179282486251969e-07 0.5474138635528197 9.179283456271202e-07 0.545274424894262 \
9.179284499728912e-07 0.5429792414815097 9.179285662643155e-07 0.5404269323775457 9.17928672601932e-07 0.5380963700835184 9.179287843108152e-07 0.5356536306660374 \
9.179288966052949e-07 0.5332047801427824 9.179290238028543e-07 0.5304364255197962 9.17929146572528e-07 0.5277698476303582 9.179292887969246e-07 0.5246912237717902 \
9.179294251600566e-07 0.5217463069543907 9.179295773811234e-07 0.5184691491721333 9.179297370173294e-07 0.5150420887864461 9.179299129925215e-07 0.5112761258030903 \
9.179301015011087e-07 0.5072591542828934 9.179303085676897e-07 0.5028616940969075 9.179305335096623e-07 0.4981043078903621 9.179307849056188e-07 0.4928144328841237 \
9.17931021331185e-07 0.4878598554762091 9.179313184949192e-07 0.4816683149127979 9.179316091722112e-07 0.4756487143466775 9.17931917027196e-07 0.469313240945046 \
9.179322308529533e-07 0.4628991126846517 9.179325599943131e-07 0.4562163541974347 9.179328933724197e-07 0.4494927613461197 9.179332249990283e-07 0.4428490490857003 \
9.179335465484253e-07 0.4364504708187015 9.179338742242378e-07 0.4299742838549845 9.179342218438604e-07 0.4231546934710667 9.179345550651742e-07 0.4166645133789623 \
9.179349009744021e-07 0.4099771621835854 9.179353463882216e-07 0.4014400148089548 9.179357041780922e-07 0.3946500490499754 9.179360183349117e-07 0.3887397205534429 \
9.179364027453916e-07 0.3815756289527631 9.179367327200364e-07 0.3754830843203271 9.179370179301252e-07 0.3702633801070484 9.179373262203821e-07 0.3646649204592909 \
9.179376060174433e-07 0.3596257204303125 9.179378320117929e-07 0.3555880084110294 9.179380468497475e-07 0.3517755993421203 9.179382452848198e-07 0.3482769933469286 \
9.179384492243371e-07 0.3447071465415313 9.179386597603963e-07 0.3410461989361561 9.179389167345214e-07 0.3366091000429626 9.179391579951288e-07 0.3324763702393667 \
9.179393895688451e-07 0.3285420159269506 9.179396042222911e-07 0.3249208057821749 9.17939825046275e-07 0.3212218866489027 9.179400262928671e-07 0.3178749657716667 \
9.179402293821203e-07 0.3145250552959265 9.179404272269914e-07 0.3112865758726304 9.179406140799367e-07 0.3082497660855442 9.179408080166626e-07 0.3051208532403978 \
9.179410117613171e-07 0.30185834615803 9.179411904885828e-07 0.2990186060348319 9.179414281343782e-07 0.2952727068736475 9.179416278966111e-07 0.2921508861588616 \
9.179418295254275e-07 0.2890253490052915 9.179420549918855e-07 0.285561995332 9.17942221086285e-07 0.2830312764183137 9.179423997053871e-07 0.2803277612349699 \
9.179425814095884e-07 0.2775983111934518 9.179427700433048e-07 0.2747882307029562 9.179429474665079e-07 0.2721695222189568 9.179431246596455e-07 0.2695724116247911 \
9.179432847315606e-07 0.2672552081803913 9.179434051322385e-07 0.2655193337608355 9.179435529583031e-07 0.2633957862580221 9.179436815880755e-07 0.2615692882062232 \
9.179437837936585e-07 0.2601227034409412 9.179439020289392e-07 0.2584516051170885 9.179440224822997e-07 0.2567534139348401 9.179441461906176e-07 0.2550183706610066 \
9.179442644426428e-07 0.2533694204037282 9.179443922957732e-07 0.2515887492000971 9.179445125816039e-07 0.249915736161692 9.179446652612099e-07 0.2477917697339537 \
9.179448001739884e-07 0.2459264316518071 9.179449288134099e-07 0.2441493177932957 9.17945086528788e-07 0.2419705448111171 9.179452132100908e-07 0.2402201997919771 \
9.179453485361584e-07 0.2383592392624043 9.179454874487268e-07 0.2364550510890953 9.179456052210312e-07 0.2348405558720491 9.179457644918496e-07 0.2326580599570062 \
9.179459010137042e-07 0.2307878375452989 9.179460422456503e-07 0.2288626996658652 9.179461480586929e-07 0.2274220928889542 9.179462784016401e-07 0.2256484734765637 \
9.17946378112453e-07 0.2242944442559471 9.179464809338881e-07 0.2228991027388591 9.179465543495424e-07 0.2219046249368765 9.17946634181104e-07 0.2208265149641777 \
9.179467042283351e-07 0.2198809561195558 9.179467546314263e-07 0.2192009305305119 9.179468068832254e-07 0.2184966408607167 9.179468861207428e-07 0.2174292050927151 \
9.179469279646958e-07 0.2168658036437602 9.17946967304648e-07 0.216336351877609 9.179470103400575e-07 0.2157575332679269 9.179470545074837e-07 0.2151638767852215 \
9.179471282732236e-07 0.2141731338947761 9.179471637852206e-07 0.2136967174286463 9.179472115000211e-07 0.2130606706933813 9.17947272229561e-07 0.2122518321687151 \
9.179473404867867e-07 0.2113438957752176 9.179474130085659e-07 0.2103801801047663 9.179474856831929e-07 0.2094152724966429 9.179475939991808e-07 0.2079788886429202 \
9.179476916703231e-07 0.20668564243436 9.179478032218192e-07 0.2052110974836689 9.179479017572531e-07 0.2039136008387587 9.179480052503929e-07 0.2025572972554956 \
9.179481011521277e-07 0.2013021587886929 9.17948203780057e-07 0.1999606878451601 9.179483066031699e-07 0.1986207062101238 9.179484167227972e-07 0.1971897063011611 \
9.17948525418353e-07 0.1957815523781236 9.179486450955817e-07 0.1942360962608612 9.179487553732606e-07 0.192818053470401 9.179488634364806e-07 0.1914343471929882 \
9.179489885351485e-07 0.1898375077741012 9.179490785049816e-07 0.1886931806549971 9.179491571919346e-07 0.1876950225942949 9.17949234476806e-07 0.1867173468865102 \
9.179493209853824e-07 0.1856271834369256 9.179494199345929e-07 0.1843848109964498 9.179494904434582e-07 0.1835017733581451 9.179495618945114e-07 0.1826096997732476 \
9.179496670398458e-07 0.1813018727451555 9.179497462794755e-07 0.1803200401832796 9.179498273633695e-07 0.1793174195483187 9.179499208553101e-07 0.1781663090788374 \
9.179500216312847e-07 0.1769308188703378 9.179501713433883e-07 0.175105380089017 9.179502871327037e-07 0.1737009932372819 9.179504381380806e-07 0.1718807311127691 \
9.179505492465001e-07 0.1705485445502526 9.179506913729584e-07 0.168854666407182 9.179508090313791e-07 0.167460358327668 9.179509139359749e-07 0.1662230887079887 \
9.179510089985733e-07 0.1651069099307241 9.179511024298278e-07 0.1640147999883682 9.179512034764903e-07 0.1628388413495604 9.179512998233979e-07 0.1617223204899406 \
9.179513969756437e-07 0.1606011553546776 9.179514800242163e-07 0.1596469772300165 9.179515900618698e-07 0.1583897228513109 9.179516723644315e-07 0.1574542248873526 \
9.179517773641412e-07 0.156267858580057 9.179518550602102e-07 0.1553950893374849 9.179519378796887e-07 0.1544690878994293 9.179520195415937e-07 0.1535604570452941 \
9.179521088908843e-07 0.152571060794856 9.1795218460332e-07 0.1517364980793458 9.179522671659343e-07 0.1508307726525361 9.179523437473671e-07 0.1499942554682341 \
9.179524120352535e-07 0.1492531084507001 9.179525054022655e-07 0.1482449401818621 9.179525745556768e-07 0.1475015570698688 9.179526501800083e-07 0.1466917482325688 \
9.179527117291285e-07 0.1460354497178591 9.179527789778923e-07 0.1453208357145237 9.179528500398917e-07 0.1445684785944268 9.179529255373203e-07 0.143772322008306 \
9.179529844488598e-07 0.1431546944759192 9.179530611224699e-07 0.1423563022825049 9.179531414432115e-07 0.1415233898163201 9.179532145945195e-07 0.1407682091691316 \
9.179533087509407e-07 0.139800669784813 9.179533803551247e-07 0.1390684367429364 9.179534538159004e-07 0.1383201464810226 9.179535373276515e-07 0.1374732033664194 \
9.179536268067953e-07 0.1365744208092838 9.179536918717002e-07 0.1359252211013016 9.179538039977228e-07 0.1348115665849295 9.179538691838634e-07 0.1341670699454539 \
9.179539392221084e-07 0.1334770515823289 9.179539995271633e-07 0.1328849371768329 9.179540545379868e-07 0.1323464455745446 9.17954142654965e-07 0.1314871014507438 \
9.179541834412594e-07 0.131090685705856 9.179542871440104e-07 0.1300923774523848 9.179543304565801e-07 0.1296773144713907 9.17954391675178e-07 0.1290920262082728 \
9.179544365118974e-07 0.1286643765206081 9.179545241079233e-07 0.127831527987147 9.179545656618794e-07 0.1274377589706847 9.179546255233895e-07 0.1268718307679372 \
9.179546973671149e-07 0.1261946708524367 9.179547535798413e-07 0.1256664967939027 9.179548160673401e-07 0.125081039250218 9.179548902953231e-07 0.1243877959456236 \
9.179549649763283e-07 0.1236954937854857 9.179550521595407e-07 0.1228905551604285 9.179551205580918e-07 0.1222610287411191 9.17955201128775e-07 0.1215216597888775 \
9.179552824242559e-07 0.120778012781285 9.179553493407808e-07 0.1201677797529914 9.179554321577255e-07 0.1194156054679852 9.179554913464481e-07 0.1188799972037829 \
9.179555572674477e-07 0.1182853617472536 9.179556371414916e-07 0.1175675408705869 9.179557136372899e-07 0.1168828806096336 9.179557950994005e-07 0.1161574242846086 \
9.179558935702815e-07 0.1152852106851665 9.179559686806302e-07 0.114622623867465 9.179560716684202e-07 0.1137180076826871 9.179561458523715e-07 0.1130691786503039 \
9.17956243471825e-07 0.1122190343868764 9.179563392827803e-07 0.1113890351962442 9.179564351312053e-07 0.110562946039519 9.179565160694118e-07 0.1098685209805978 \
9.179566044526832e-07 0.1091134439098378 9.179567030526615e-07 0.108274944429282 9.179567758368655e-07 0.1076586405352824 9.17956865109775e-07 0.1069058608836731 \
9.179569270917884e-07 0.1063852406583179 9.179569896849556e-07 0.1058613310701875 9.179570749071042e-07 0.105150777260444 9.179571803694781e-07 0.1042758147594986 \
9.179572601999606e-07 0.1036167065755082 9.179573409142144e-07 0.1029530974056021 9.179574235279495e-07 0.1022768941101355 9.179574939725616e-07 0.1017026162492672 \
9.179575972319282e-07 0.1008648142128753 9.179576700720535e-07 0.1002767039768694 9.17957755712335e-07 0.09958839426015198 9.179578745140727e-07 0.09863954321822334 \
9.179579421518978e-07 0.09810250133474645 9.179580119020204e-07 0.09755100310752296 9.17958089237e-07 0.09694230106952094 9.179581816572539e-07 0.09621870517595056 \
9.17958253354782e-07 0.09566033062548993 9.179583391719417e-07 0.09499542738017568 9.17958441597192e-07 0.09420660575030523 9.17958534892083e-07 0.09349264652734962 \
9.179586312085565e-07 0.09276005482712441 9.179587081108176e-07 0.09217843893134048 9.179588015908053e-07 0.09147541043939374 9.179588808332317e-07 0.09088281005358793 \
9.17958995455426e-07 0.0900310686188453 9.179591250636858e-07 0.08907580221142102 9.179592583208766e-07 0.08810234090122065 9.179594023507657e-07 0.08705990691030199 \
9.179595595189095e-07 0.08593388720602639 9.179597092953871e-07 0.08487214151476249 9.179598717629785e-07 0.08373303262435308 9.179600149429843e-07 0.08273971668837025 \
9.179601676221069e-07 0.0816913199659166 9.179603018918778e-07 0.08077856892457436 9.179604436441554e-07 0.07982444400446118 9.179605786438163e-07 0.07892500874648442 \
9.179607206012136e-07 0.07798882638923543 9.179608674486441e-07 0.07703088995320664 9.17961019894053e-07 0.07604750978240994 9.179611851127757e-07 0.07499422991502351 \
9.179613492506213e-07 0.07396067809208305 9.179615261120239e-07 0.07286119333145537 9.179617164535802e-07 0.07169407515132428 9.179619274100931e-07 0.07042030845332216 \
9.179621478192316e-07 0.0691121699798517 9.17962383344393e-07 0.06773900533435212 9.179626437937673e-07 0.0662496528900723 9.179629394591772e-07 0.06459579389282195 \
9.179632445814627e-07 0.06292902455725519 9.179636095760241e-07 0.06098725515092194 9.179640044568393e-07 0.05894944116461652 9.179644108474933e-07 0.05692211719668253 \
9.179648265730353e-07 0.05491854459141238 9.179651893793582e-07 0.0532251207245777 9.179655339806477e-07 0.05166301626031383 9.179658491605098e-07 0.05027284652491828 \
9.179661446898748e-07 0.04900240867073854 9.179664426703825e-07 0.04775344010203557 9.179667184691725e-07 0.04662857640242725 9.179669972437683e-07 0.04551884372531381 \
9.179672611786382e-07 0.04449205559535935 9.179675372013766e-07 0.04344260531795661 9.179678161576297e-07 0.04240676967887352 9.179681298509632e-07 0.04127097799875453 \
9.179683658512502e-07 0.04043636567030678 9.179686216459875e-07 0.03955075129286261 9.17968881769487e-07 0.03867033103466553 9.179691519047594e-07 0.03778142289416799 \
9.179694311247467e-07 0.03688501536902895 9.179697129633963e-07 0.03600226561751176 9.17969989839066e-07 0.03515600409566183 9.179702689326649e-07 0.03432349610146775 \
9.179705018102724e-07 0.03364444121149882 9.179707856469893e-07 0.03283527291840588 9.179710257519236e-07 0.03216626441466421 9.179712655507463e-07 0.0315119836023277 \
9.179715048279204e-07 0.03087436846876356 9.179717400849421e-07 0.03026290129608995 9.179719710119639e-07 0.02967475842909434 9.17972186001007e-07 0.02913788335257221 \
9.179725881554596e-07 0.02816043724496065 9.179727868782784e-07 0.02768988489927659 9.179731605612946e-07 0.0268265706552881 9.179733473596173e-07 0.02640514011949098 \
9.179736949193038e-07 0.02563810810034544 9.179738168487671e-07 0.0253740445387235 9.179741993202075e-07 0.02456430406701914 9.179743700282367e-07 0.02421180751242828 \
9.179748271256211e-07 0.02328894863848502 9.179750127580068e-07 0.0229225623309489 9.179753762152597e-07 0.02221803970155307 9.179755965826125e-07 0.02179832126591805 \
9.179760543089696e-07 0.02093867417890744 9.179761897285987e-07 0.02068687731869814 9.179767196240474e-07 0.01972418011126781 9.17976838945017e-07 0.01951377505543128 \
9.179774047306961e-07 0.01856069823426573 9.17977569110437e-07 0.0182962226476828 9.179781876557338e-07 0.01735107502432094 9.179783577099332e-07 0.01710418363667701 \
9.17978889842166e-07 0.01636278834442301 9.179790869261418e-07 0.01610013864443424 9.179798100452149e-07 0.01517806887136661 9.179799746753809e-07 0.01497647803580381 \
9.179807238007678e-07 0.01409711804523418 9.179808571001203e-07 0.01394643716836554 9.179817173537587e-07 0.01301449210748497 9.179818524573793e-07 0.01287422877142914 \
9.179827950348197e-07 0.01193816285908547 9.179829586305737e-07 0.01178202925388569 9.179839599872008e-07 0.0108653384673985 9.179840975299883e-07 0.01074500730514941 \
9.179853196363712e-07 0.009765086624518643 9.179854265890839e-07 0.00968516078425012 9.179868307805774e-07 0.008707372520026449 9.179869356112841e-07 0.008639312158696611 \
9.179884704482461e-07 0.00767719340797631 9.179885657315476e-07 0.007617466071856052 9.179901745288685e-07 0.006680264535635283 9.179903086056076e-07 0.006609506832171614 \
9.179924056185594e-07 0.005610918814474722 9.179926361631908e-07 0.005510783990371394 9.179949591584346e-07 0.004586584533412417 9.179954404886379e-07 0.004413562233393853 \
9.179982780502688e-07 0.003511943147855551 9.179988229699549e-07 0.003360532104877318 9.180029471783516e-07 0.002408309874554541 9.180034909020111e-07 0.002305347543005144 \
9.180093621912368e-07 0.001333291345955189 9.180096050564211e-07 0.001286469439319215 9.180239329487719e-07 0.0002880570268237783 9.180240775074142e-07 0.0002853642807229123 \
9.206613564285127e-07 -0.0006859155495331031 9.206614959836498e-07 -0.000901903561740745 9.206620050775826e-07 -0.001859438188174024 9.206620945650851e-07 -0.002052812934985279 \
9.206624579599451e-07 -0.00291126965001638 9.206625489820155e-07 -0.003143482006111167 9.206629144200523e-07 -0.004127275145644371 9.206630246806194e-07 -0.004436819103926468 \
9.206633367277739e-07 -0.005309594399865315 9.206634394426211e-07 -0.005584800160857357 9.206638032904767e-07 -0.006384516484886619 9.206639680812085e-07 -0.006586298968823262 \
9.206645476774082e-07 -0.005791490933239759 9.206647227875511e-07 -0.004914057272375438 9.206648394794852e-07 -0.004132845175365214 9.206649660640905e-07 -0.003100877896798674 \
9.206650678730126e-07 -0.002132773363901063 9.206651883617227e-07 -0.0008283127610571584 9.206652788087988e-07 0.0002599396317828252 9.206653766989304e-07 0.001541559978017447 \
9.206654757632395e-07 0.002943971508909197 9.206656465705158e-07 0.005594911825788154 9.206658683385387e-07 0.00944046646559993 9.206660642423845e-07 0.01317281463966807 \
9.206662231237663e-07 0.01639870563256729 9.206663875522632e-07 0.01989779506365397 9.206665419182936e-07 0.02331070396473752 9.20666700690818e-07 0.02693200463312963 \
9.20666847428777e-07 0.03036422445567413 9.206669960527481e-07 0.0339113704936035 9.20667151667245e-07 0.03768995713197771 9.206673089092589e-07 0.04156499463828727 \
9.206674738020576e-07 0.04567927910670353 9.206676472215783e-07 0.05005184210758699 9.20667825915293e-07 0.05459761989277153 9.206680145311307e-07 0.05943075613080645 \
9.206682154312735e-07 0.06460909294799391 9.206684348880646e-07 0.0702927970720964 9.206686644343515e-07 0.07626037976612585 9.20668910133291e-07 0.08266408948881369 \
9.206691786982297e-07 0.08967663153997742 9.206694700401444e-07 0.09728936802005522 9.206697917081718e-07 0.1056939239977524 9.20670152022263e-07 0.1150987971742611 \
9.206705430017012e-07 0.1252892839303718 9.206709864165172e-07 0.1368209045172546 9.206715027296045e-07 0.1502062239570841 9.206721089348208e-07 0.16586000516691 \
9.206727801918477e-07 0.1831102247110778 9.206735596915048e-07 0.20301830483439 9.206744320013885e-07 0.2251413938832897 9.206752623367137e-07 0.2460320778586349 \
9.206759936670634e-07 0.264292249712138 9.206766416128433e-07 0.280346965484095 9.206772249233171e-07 0.29469740877147 9.20677760655584e-07 0.3077798509628869 \
9.206782639141689e-07 0.3199778888071559 9.206787491176699e-07 0.3316516836183861 9.206792280403756e-07 0.3430829066939081 9.20679674471008e-07 0.3536501814456421 \
9.20680148800718e-07 0.3647819492304352 9.206805979917124e-07 0.3752331958288908 9.206810884639695e-07 0.3865396207984229 9.206816170367225e-07 0.3985997842463301 \
9.206819881810624e-07 0.4069920784971888 9.20682515935418e-07 0.4188173133762567 9.206829782921778e-07 0.4290642331729484 9.206834506243178e-07 0.4394285229343968 \
9.206839324090407e-07 0.4498981261869666 9.206839654481592e-07 0.4506126593745911 9.206840032071518e-07 0.45142837879914 9.206840787251369e-07 0.4530572051633331 \
9.206842297611073e-07 0.4563088938659436 9.206844372803726e-07 0.460764549126051 9.206846253191842e-07 0.4647825567212808 9.206848443283984e-07 0.469441659996985 \
9.206850871594094e-07 0.4745824626509371 9.206853869350374e-07 0.4808894567257585 9.206856247281871e-07 0.4858624696070272 9.206858879495879e-07 0.4913374535260851 \
9.206861488471327e-07 0.4967277906005185 9.206863784012197e-07 0.5014431429135263 9.206866014614136e-07 0.506003872007333 9.206868030374043e-07 0.5100983586086808 \
9.206869518674631e-07 0.51310967141356 9.206871961785156e-07 0.5180317772556589 9.206873287837491e-07 0.5206893064287169 9.206874681403308e-07 0.5234717264876519 \
9.206876791057241e-07 0.5276623644271943 9.206878539796058e-07 0.5311266030493931 9.206881220278524e-07 0.5364094032095129 9.206883170535098e-07 0.5402319029111832 \
9.206884966150174e-07 0.5437361368949839 9.206887475711459e-07 0.5486228351952749 9.206890249792569e-07 0.5540035987981641 9.206893089285589e-07 0.5594901708581531 \
9.206895645658505e-07 0.5644152233389156 9.206898555480696e-07 0.570006772487656 9.206901158537539e-07 0.5749917787111524 9.206903842978736e-07 0.5801232573974072 \
9.206906270630042e-07 0.5847450403362237 9.20690883594205e-07 0.5896146675871002 9.206911097576483e-07 0.59388771440121 9.206913470991426e-07 0.5983512154742827 \
9.206915564878602e-07 0.6022720321566808 9.206917702606284e-07 0.6062574570422776 9.206920237134688e-07 0.6109557890491497 9.206922265678164e-07 0.6146943332140289 \
9.206924193723377e-07 0.6182333111593361 9.206926096773651e-07 0.6217090173923294 9.20692800335854e-07 0.6251694921350958 9.206930029137796e-07 0.6288260100903066 \
9.206932656625421e-07 0.6335359534764116 9.20693494630232e-07 0.6376100987349322 9.206937145778672e-07 0.6414991146358265 9.206939402625401e-07 0.6454625140719233 \
9.206941491499661e-07 0.6491091855837361 9.206943708035853e-07 0.652957810138281 9.206945556930106e-07 0.6561429680377227 9.206947457075644e-07 0.6594017273991298 \
9.206948958626861e-07 0.6619630641908443 9.206950707405929e-07 0.6649292185271485 9.206952164613094e-07 0.6673855496832628 9.206953524938416e-07 0.6696641287411549 \
9.206955008561211e-07 0.672138295335571 9.206956303038335e-07 0.6742883907026684 9.206957641695307e-07 0.6764996355878535 9.206958925139303e-07 0.6786115243545502 \
9.206960179020585e-07 0.6806677490053815 9.206961473677549e-07 0.6827843190971332 9.206962783489701e-07 0.6849171426143115 9.206964267220724e-07 0.6873221141612875 \
9.206965347848267e-07 0.6890667486235877 9.206966633164996e-07 0.6911333958680312 9.206967987562836e-07 0.6933004139195943 9.206969236906071e-07 0.6952876996714908 \
9.20697049447875e-07 0.6972799977491608 9.206971559637662e-07 0.6989584331773744 9.206972730816549e-07 0.7007929859467624 9.206973916214007e-07 0.7026383448210159 \
9.206975149247975e-07 0.704545102273978 9.206976180976957e-07 0.7061304255463237 9.206977690688591e-07 0.7084341141567283 9.206978853230652e-07 0.7101955266062138 \
9.206980158834539e-07 0.7121605601685687 9.206981344459821e-07 0.7139335830373704 9.206982405198518e-07 0.7155108922888329 9.206983405447915e-07 0.716990346352101 \
9.206984778700066e-07 0.719009255813789 9.206985965313623e-07 0.7207429633399333 9.20698718230586e-07 0.7225107522614664 9.206988434131514e-07 0.7243181860083944 \
9.206989654329652e-07 0.7260693242762759 9.206990934647186e-07 0.7278954552757622 9.206992179464579e-07 0.7296603419865877 9.206993462457807e-07 0.7314685590147565 \
9.20699473339584e-07 0.7332489547570846 9.206995993644231e-07 0.7350034830462163 9.2069970210311e-07 0.7364262918236342 9.206998167758556e-07 0.7380063527755659 \
9.206998981819179e-07 0.7391232259175492 9.207000173814378e-07 0.7407496908814458 9.20700110023778e-07 0.7420059782745783 9.207002481828348e-07 0.7438668850244906 \
9.207003792383343e-07 0.7456179978167152 9.207005093705019e-07 0.7473439783685625 9.207006143445769e-07 0.7487266533969134 9.207007534844189e-07 0.7505456565005918 \
9.207009074287187e-07 0.7525407731682957 9.207010293729986e-07 0.7541080835708853 9.207011769193594e-07 0.7559892974429111 9.20701298924537e-07 0.7575320275232224 \
9.207014476244666e-07 0.7593968175435225 9.207015816710922e-07 0.7610632318338031 9.207017039243472e-07 0.7625711443351471 9.207018167902567e-07 0.763953046884334 \
9.207019596412246e-07 0.7656882893306027 9.207020863641194e-07 0.7672149413549471 9.207022021689945e-07 0.7685995877768005 9.207023319108228e-07 0.7701390587657672 \
9.207024476492105e-07 0.7715019052061673 9.207025706016372e-07 0.7729391548276606 9.20702688317297e-07 0.7743051053122872 9.207027942872732e-07 0.7755262985206828 \
9.207029106984675e-07 0.7768586864857919 9.207030173164003e-07 0.7780703956921795 9.207031295151206e-07 0.7793369495935717 9.207032161836896e-07 0.7803089322889447 \
9.207033195691813e-07 0.7814603789665585 9.207034327334326e-07 0.7827108149434853 9.207035383807155e-07 0.783868819044773 9.207036477202729e-07 0.7850578567336689 \
9.207037548972878e-07 0.786214126597127 9.20703884303365e-07 0.7875981444497275 9.207039967207505e-07 0.7887899291890393 9.207041201084897e-07 0.7900869036018625 \
9.207042375588255e-07 0.7913106402786101 9.207043810857437e-07 0.7927918312347375 9.207044960053219e-07 0.7939667362870242 9.207046347277351e-07 0.7953719780830618 \
9.207047727598755e-07 0.7967562205547866 9.207048822530294e-07 0.7978444364842524 9.207049832714595e-07 0.7988406866985471 9.207050843594197e-07 0.7998302780396641 \
9.207052167466157e-07 0.8011146558616069 9.207053354720369e-07 0.8022550163876687 9.207054572565424e-07 0.8034134048507504 9.207055763463359e-07 0.8045351524060473 \
9.207056975508532e-07 0.8056657048884367 9.207058291946645e-07 0.8068811249615274 9.207059522127028e-07 0.8080052413861453 9.207060798230233e-07 0.8091594649786741 \
9.20706210891683e-07 0.8103325925767672 9.207063342120463e-07 0.8114249716726942 9.207064421363105e-07 0.8123719892944993 9.207065499317031e-07 0.8133095350680949 \
9.20706631652631e-07 0.8140147772069938 9.207067485202474e-07 0.815015186305849 9.207068395812563e-07 0.8157880755829442 9.207069737498875e-07 0.8169164295805346 \
9.2070711832076e-07 0.8181184617099191 9.207072518231266e-07 0.8192158725965917 9.207073617890375e-07 0.8201107352847025 9.207075056546974e-07 0.8212684563313245 \
9.207076589602621e-07 0.8224861772268215 9.207077866985553e-07 0.8234883060891934 9.207079273408908e-07 0.8245786478120171 9.207080531244555e-07 0.8255423809867173 \
9.207082077424273e-07 0.8267124309768116 9.207083401541937e-07 0.8277017767197102 9.207084664337981e-07 0.8286345641820314 9.20708584064113e-07 0.8294941055817234 \
9.207087322309758e-07 0.8305638349826423 9.207088993752207e-07 0.8317531470681401 9.207090319938809e-07 0.832683775428688 9.207092049385689e-07 0.8338803479528284 \
9.207093733252244e-07 0.8350269493631071 9.207095428597541e-07 0.8361634673386688 9.207097242289089e-07 0.8373596561587384 9.207098668614913e-07 0.8382862741713709 \
9.207099807973396e-07 0.8390176620397163 9.207101115711344e-07 0.8398476357987267 9.207102132250741e-07 0.8404856735008092 9.207103297188026e-07 0.8412091703399448 \
9.207104652363492e-07 0.8420405885319162 9.20710662580143e-07 0.8432318270427018 9.20710853245141e-07 0.8443612543037786 9.207110631019802e-07 0.8455804035625291 \
9.207112440391043e-07 0.8466117334714958 9.207114413745908e-07 0.8477160230260256 9.207116151614274e-07 0.8486711109012058 9.207117977428814e-07 0.8496572451898022 \
9.207119690624607e-07 0.850566499179887 9.207121434475074e-07 0.8514760798656241 9.207123188310518e-07 0.8523748177975867 9.207124950632093e-07 0.8532619682996843 \
9.207126849014517e-07 0.8542000584728613 9.207128756376654e-07 0.8551245802328369 9.20713077434399e-07 0.856083442102113 9.207132701277752e-07 0.8569809170305027 \
9.207134797560764e-07 0.857937542729613 9.207137091938401e-07 0.8589615588718806 9.207139749904801e-07 0.8601183337444025 9.207142735657076e-07 0.8613802063570262 \
9.207145514672209e-07 0.8625196921548358 9.207148356776948e-07 0.8636511027355716 9.207151100894824e-07 0.8647118800460076 9.207153822523641e-07 0.8657341977214618 \
9.207156524214556e-07 0.8667205537246333 9.207159096161393e-07 0.8676338760342862 9.207161821558104e-07 0.868575115807136 9.207164581902908e-07 0.8695013130444248 \
9.207167283429861e-07 0.8703818891200001 9.207170280497876e-07 0.8713292845176382 9.207173988672581e-07 0.8724597217497643 9.207176937859212e-07 0.8733269024855727 \
9.207179480301993e-07 0.8740525764960509 9.207182462541984e-07 0.8748787854419284 9.20718519878969e-07 0.8756137195941651 9.207187560179586e-07 0.8762307200963571 \
9.207189963736862e-07 0.8768427579093606 9.20719218719338e-07 0.8773949085683344 9.207194127230722e-07 0.877865919014753 9.207197424471962e-07 0.878644045115768 \
9.207198976198553e-07 0.8790007149587372 9.207202153732479e-07 0.879712598742095 9.207203942386052e-07 0.8801026384247937 9.207207367000935e-07 0.8808283583858193 \
9.207209208412926e-07 0.8812073588304842 9.207213957461144e-07 0.8821499412898334 9.207215631406012e-07 0.8824705695712217 9.207220289718891e-07 0.8833323038036038 \
9.207222097967714e-07 0.8836551183393088 9.207227038300281e-07 0.8845051821644966 9.207228451726029e-07 0.8847400410050358 9.207234515631179e-07 0.8857071861637142 \
9.207236036356849e-07 0.8859397703602404 9.207242503137576e-07 0.8868873789663725 9.207243786102466e-07 0.8870678433440622 9.207250267232453e-07 0.8879435266410994 \
9.207251565285235e-07 0.8881118897635528 9.20725934785608e-07 0.8890711781604964 9.207260497804227e-07 0.8892053868933587 9.207269055110619e-07 0.8901454611437621 \
9.207270507776287e-07 0.8902951528450479 9.207280365337324e-07 0.8912364417375994 9.207282576409459e-07 0.8914302300078862 9.20729402752027e-07 0.892358484239638 \
9.207295339601743e-07 0.8924604119362172 9.207308752633694e-07 0.8934531785430913 9.207310266510304e-07 0.8935579568409697 9.207325081098674e-07 0.8944876667405802 \
9.207327469902294e-07 0.894621531696939 9.207345164619858e-07 0.8954958910368339 9.207349055688235e-07 0.8956641700186337 9.207372993342322e-07 0.8965498195158238 \
9.207377748942228e-07 0.8966991754584082 9.20741837950387e-07 0.8976977719002629 9.207423294244079e-07 0.8977905759376156 9.207506459514872e-07 0.8987839664765119 \
9.207515658053768e-07 0.8988472044554419 9.208777709459031e-07 0.8998441026240215 9.208787847542549e-07 0.8998514601858095 9.210704973474114e-07 0.8990059056521554 \
9.21070727348974e-07 0.8988405173838494 9.210723422215349e-07 0.8978439928078279 9.210725199353885e-07 0.8977495532019018 9.210892857104285e-07 0.8987316330193963 \
9.210894216988253e-07 0.8987497732072308 9.211048844279385e-07 0.8997471920221268 9.211051522925305e-07 0.8997526389354535 9.215889776197985e-07 0.9006560548284696 \
9.215890984089986e-07 0.9007687033315858 9.215898861800374e-07 0.9017381658104292 9.215900203187565e-07 0.901943163319478 9.215905139335305e-07 0.9027850367016239 \
9.21590658833145e-07 0.9030569221572713 9.215910546405301e-07 0.9038490360455199 9.215911744361842e-07 0.9041001886668685 9.215915586097176e-07 0.9049189780371781 \
9.215916707313647e-07 0.9051556495331843 9.215921780523356e-07 0.9061253139956988 9.215922720511916e-07 0.90626859229291 9.215934307008981e-07 0.9055667778886739 \
9.215935336638317e-07 0.9051589876696525 9.215936175067006e-07 0.9047707260375384 9.215937512467522e-07 0.9040404158978201 9.215938519641334e-07 0.9033957423200318 \
9.215939595799192e-07 0.9026166239542108 9.215940771531732e-07 0.9016533104038295 9.215941654182229e-07 0.90085556431878 9.215942850516912e-07 0.8996698288011099 \
9.215943823733892e-07 0.8986166602050341 9.215944933908277e-07 0.8973222354192386 9.215945955004155e-07 0.8960407982554908 9.21594678931815e-07 0.8949326975987755 \
9.215947831128826e-07 0.8934749428758865 9.215948741996462e-07 0.8921321265381427 9.215949667404319e-07 0.8907058396397178 9.215950618944299e-07 0.8891776325191247 \
9.215951764494068e-07 0.88725933118288 9.215952652925089e-07 0.8857137884271823 9.215953635316906e-07 0.8839502506198179 9.215954489018647e-07 0.8823735982707064 \
9.215955298021067e-07 0.8808434949738935 9.215956027633997e-07 0.8794355441897157 9.215956697820454e-07 0.8781198554636557 9.215957383931237e-07 0.8767515715160701 \
9.215958218880357e-07 0.8750591081124355 9.215958840153663e-07 0.8737811510706814 9.215959469979637e-07 0.8724704924326797 9.215960421537152e-07 0.8704632161180945 \
9.215961427643534e-07 0.8683077530860182 9.215962226435446e-07 0.8665738309361769 9.21596306905814e-07 0.8647250601592834 9.215963860160736e-07 0.8629723295901451 \
9.215964488315189e-07 0.8615696597604833 9.215965362885537e-07 0.8596016864744445 9.215966021820844e-07 0.8581079708060287 9.215966702436265e-07 0.856556281928966 \
9.215967195561343e-07 0.8554267461646872 9.215967747929236e-07 0.85415654045335 9.215968155325295e-07 0.8532164928603474 9.215968618342831e-07 0.8521450198670055 \
9.21596892048343e-07 0.8514441160591502 9.215969210896252e-07 0.8507691938976955 9.215969517282201e-07 0.8500558939662993 9.215970130054096e-07 0.8486254874746039 \
9.215970660779718e-07 0.8473828229799116 9.215971197331653e-07 0.8461232012188223 9.215971823904472e-07 0.8446482873934593 9.215972456733951e-07 0.8431545995644786 \
9.21597336171269e-07 0.8410121009440262 9.215974331690495e-07 0.8387078554355326 9.215975161465499e-07 0.8367307351423475 9.215975981509053e-07 0.8347721678896715 \
9.215976872193065e-07 0.8326403548070889 9.215977717326431e-07 0.8306135893189693 9.215978625915234e-07 0.8284303722590877 9.21597954526378e-07 0.8262176456275642 \
9.215980569573085e-07 0.8237486178045141 9.215981570753404e-07 0.8213320995840899 9.215982718962233e-07 0.8185572053828121 9.215983841027604e-07 0.8158423448209959 \
9.215985090963053e-07 0.8128151787794674 9.215986403567132e-07 0.8096337870015397 9.215987856277547e-07 0.8061104108175116 9.215989401353681e-07 0.8023613213197434 \
9.215991115759888e-07 0.7981999722344618 9.215992756257814e-07 0.794217661721315 9.215994600412032e-07 0.7897413884478564 9.215996665335768e-07 0.7847307375046715 \
9.215998560274197e-07 0.7801344622909899 9.216000494211825e-07 0.775444374634302 9.216002499880374e-07 0.7705834242206392 9.21600397552439e-07 0.7670092004965298 \
9.216005275638895e-07 0.7638619034739171 9.216006624283031e-07 0.7605987503374771 9.216007689187539e-07 0.7580234999254772 9.216009006085467e-07 0.7548403390839162 \
9.216010070329759e-07 0.7522693550468039 9.21601150211605e-07 0.7488125398635642 9.216013113387162e-07 0.7449250928176189 9.216014295655331e-07 0.7420746008290786 \
9.21601599798354e-07 0.7379721584775248 9.216017657246235e-07 0.7339761998059781 9.216019852669538e-07 0.7286940862104242 9.216021784540779e-07 0.724050920820232 \
9.216023533680413e-07 0.719851304223293 9.216025203151388e-07 0.7158476177432674 9.216027078061003e-07 0.711355754450834 9.216028952345367e-07 0.7068709122373377 \
9.216030635710959e-07 0.7028473835914892 9.216032564016301e-07 0.6982428782038785 9.216033964513774e-07 0.694901318858167 9.216035527086664e-07 0.6911769338170629 \
9.216037468781132e-07 0.6865540563080536 9.216039059846016e-07 0.6827702245679255 9.216040643446318e-07 0.679008548037742 9.216042596617401e-07 0.6743756772263459 \
9.216044700905193e-07 0.6693917663527935 9.216047227926646e-07 0.6634173774538097 9.216049024606154e-07 0.6591769455535931 9.216051540374889e-07 0.6532475027332399 \
9.21605354410306e-07 0.6485340174553987 9.216055260641582e-07 0.6445032789616798 9.216056847562747e-07 0.6407814961122935 9.21605823964202e-07 0.637522316374186 \
9.216059602882518e-07 0.6343349641335875 9.216060875012758e-07 0.6313646237382058 9.216062169938336e-07 0.6283457899522861 9.216063449851212e-07 0.6253646753452949 \
9.2160647605963e-07 0.6223174651643489 9.216066067717051e-07 0.6192830747181834 9.216067493797575e-07 0.6159760732208495 9.216068921032355e-07 0.612672916206165 \
9.216070446510366e-07 0.6091471600588 9.216071891550245e-07 0.6058158037532523 9.216073531732721e-07 0.6020406322262999 9.216074906379333e-07 0.5988837056407329 \
9.216076254549489e-07 0.5957940466067043 9.216077469535923e-07 0.5930134750293682 9.216078858038965e-07 0.5898448108574432 9.216079994507128e-07 0.5872554148224447 \
9.216081508608853e-07 0.5838116422847746 9.216082645795603e-07 0.5812320812748947 9.216083839926513e-07 0.5785269636915771 9.216084726731778e-07 0.5765205397309219 \
9.216085638182693e-07 0.5744630259469776 9.216086291571447e-07 0.5729901393713442 9.216086936268468e-07 0.5715377831648228 9.21608744447459e-07 0.5703933076453638 \
9.216088034223983e-07 0.569066051987989 9.216088708671063e-07 0.5675516747474645 9.216089379592979e-07 0.5660472084764079 9.216089908797418e-07 0.5648615894615425 \
9.216090865272254e-07 0.5627204246953637 9.216091437083616e-07 0.5614413394337 9.216091975109775e-07 0.5602399192081799 9.216092592530825e-07 0.5588634520375642 \
9.216093450862141e-07 0.5569525037715509 9.216094277818617e-07 0.5551133137453282 9.216095539105889e-07 0.552313430559463 9.216096890096645e-07 0.5493247407981657 \
9.21609787329828e-07 0.5471534914294828 9.216098999078897e-07 0.5446716589975775 9.216100024523052e-07 0.5424173856211837 9.216101225611308e-07 0.5397821662853191 \
9.216102242487819e-07 0.5375541863492928 9.216103397527456e-07 0.5350300289250629 9.216104546438613e-07 0.5325260225312031 9.216105811211341e-07 0.5297740207092871 \
9.216107063383296e-07 0.5270565158317848 9.216108531843122e-07 0.5238798967507053 9.216109886424457e-07 0.5209557060405445 9.216111462030545e-07 0.5175672114705414 \
9.216113083572293e-07 0.5140875588169389 9.216114890683071e-07 0.5102248342695275 9.216116813160603e-07 0.5061308236654174 9.216118940383231e-07 0.5016182665703952 \
9.216121259434839e-07 0.4967183500883584 9.216123831371877e-07 0.4913135654247419 9.216126226904983e-07 0.4863004534671564 9.216129246203734e-07 0.4800178499336004 \
9.216132123868145e-07 0.4740665530855001 9.216135251890574e-07 0.4676409412178996 9.21613845020806e-07 0.4611139840073785 9.216141846574089e-07 0.4542292677834274 \
9.216145118732278e-07 0.4476411633207955 9.216148470347967e-07 0.4409363684817221 9.216151642914576e-07 0.4346351592989786 9.216154981114363e-07 0.4280489847791872 \
9.2161584979678e-07 0.4211625252737479 9.21616163864498e-07 0.4150547397555842 9.216164868937019e-07 0.4088175946446666 9.216169278730989e-07 0.4003732788922496 \
9.216172702759421e-07 0.3938810608698495 9.216175707238305e-07 0.3882325136127223 9.216179460534016e-07 0.3812375944419973 9.216182761286298e-07 0.3751439175705365 \
9.216185594064112e-07 0.3699597784791666 9.216188599137726e-07 0.3645020109013299 9.216191395612329e-07 0.3594637112692664 9.216193634235237e-07 0.3554634414471464 \
9.216195752745134e-07 0.35170280677964 9.216197776231135e-07 0.3481338771034005 9.216199787581392e-07 0.3446120049995081 9.216201845356566e-07 0.3410324794262659 \
9.216204455143708e-07 0.3365252478245505 9.216206850045531e-07 0.3324209773202946 9.216209176796239e-07 0.3284665339262754 9.216211317612159e-07 0.3248537323113044 \
9.21621352906983e-07 0.3211475567840967 9.21621553789873e-07 0.3178053707831449 9.216217571810749e-07 0.3144500223650613 9.216219548494876e-07 0.3112139453100684 \
9.216221410931751e-07 0.3081862077816076 9.216223360742573e-07 0.3050391973134606 9.216225395365023e-07 0.3017803754370622 9.216227174774077e-07 0.2989521325826759 \
9.216229532011122e-07 0.2952356640875101 9.216231513339656e-07 0.2921385263640672 9.216233526780327e-07 0.2890160050544278 9.216235769672296e-07 0.2855690750291008 \
9.216237418971287e-07 0.2830551950838826 9.216239195258139e-07 0.2803657404651576 9.216241039249613e-07 0.2775946687427531 9.216242877463063e-07 0.2748547260732712 \
9.216244662029787e-07 0.2722194282383935 9.216246381032459e-07 0.2696976713509589 9.216247986436533e-07 0.2673699088296289 9.216249201257115e-07 0.265617282026588 \
9.216250730472386e-07 0.2634201198254058 9.21625200480934e-07 0.2616085083773952 9.216253046546046e-07 0.2601317890528609 9.216254215590815e-07 0.2584775571399547 \
9.216255365705729e-07 0.2568557450124987 9.216256609328034e-07 0.2551103168403305 9.216257765070865e-07 0.2534925198640895 9.216259106146075e-07 0.2516172680784447 \
9.216260256018485e-07 0.2500177396912131 9.216261793514453e-07 0.2478798443778067 9.216263161546457e-07 0.2459790966208961 9.216264507404529e-07 0.2441094379339017 \
9.216266066045887e-07 0.2419575875351012 9.216267312534115e-07 0.2402378086535915 9.216268704689346e-07 0.2383186229544463 9.2162700069296e-07 0.236525770455347 \
9.216271210458007e-07 0.2348769158236033 9.216272564390845e-07 0.233027137746051 9.216274076440629e-07 0.2309620730808924 9.21627542400533e-07 0.2291249940296414 \
9.216276470867202e-07 0.2277003186426776 9.216277696228612e-07 0.2260366668203369 9.2162790456742e-07 0.2242086518061946 9.216279996831675e-07 0.2229209267876512 \
9.216281149432223e-07 0.2213657311907907 9.216281974762018e-07 0.2202562617028589 9.216282686815329e-07 0.2192992955643472 9.216283173890172e-07 0.2186449771734718 \
9.216283645839733e-07 0.2180112263680214 9.216284111327915e-07 0.2173864029843717 9.216284645213553e-07 0.2166701476649976 9.216285018980251e-07 0.2161690444847812 \
9.216285392831377e-07 0.2156680710113931 9.216285796045079e-07 0.2151283464800275 9.216286508546475e-07 0.2141753141901174 9.216286850689041e-07 0.2137180869447317 \
9.216287314635346e-07 0.2131018213873352 9.216287919072008e-07 0.2122998083652294 9.216288609101201e-07 0.2113853596849882 9.216289262050715e-07 0.210520730631805 \
9.216289941831954e-07 0.2096212333552783 9.21629110629525e-07 0.2080823984153433 9.216292005517136e-07 0.2068957989735914 9.216293082176197e-07 0.2054771097790837 \
9.216294042789353e-07 0.2042146625011118 9.216295076575089e-07 0.2028641889872041 9.216296043425436e-07 0.2016026287683381 9.216297071523967e-07 0.2002625524503448 \
9.216298079123679e-07 0.1989526210414513 9.216299190580346e-07 0.1975116692735505 9.216300260975285e-07 0.1961279675313261 9.216301440040637e-07 0.1946083430154048 \
9.216302521143875e-07 0.1932197128021231 9.216303614129877e-07 0.1918224631760269 9.216304820447391e-07 0.1902849927564414 9.216305769453309e-07 0.1890796997295432 \
9.216307055062502e-07 0.18745262875399 9.216307985410385e-07 0.1862801166370808 9.216309009375946e-07 0.1849947785893032 9.216309889048857e-07 0.1838942174288659 \
9.216310871755573e-07 0.182668828510528 9.216311837761789e-07 0.1814691026470878 9.216312704146923e-07 0.1803971466393716 9.216313568237044e-07 0.1793305247657973 \
9.216314526608142e-07 0.1781527189679156 9.216315573876885e-07 0.1768710765218302 9.216317031999754e-07 0.1750963017969037 9.216318191679068e-07 0.1736923427161618 \
9.216319756317111e-07 0.1718092975148396 9.2163208681163e-07 0.1704786474822015 9.216322270616305e-07 0.1688098560703619 9.216323500730352e-07 0.1673544160765056 \
9.216324565640335e-07 0.1661007559767333 9.216325528894916e-07 0.1649724583647661 9.216326503229586e-07 0.1638357962207703 9.216327541762373e-07 0.1626293386330815 \
9.216328459768101e-07 0.1615673458739011 9.216329443645254e-07 0.1604337426303964 9.216330272831698e-07 0.1594828374885931 9.216331226515033e-07 0.1583950132920943 \
9.216332052138515e-07 0.1574587876231885 9.216333077985371e-07 0.1563016192679324 9.21633384076854e-07 0.1554454316211293 9.216334726624787e-07 0.1544557264474612 \
9.216335448319838e-07 0.1536532700165102 9.21633626541473e-07 0.1527486200895024 9.216337002202809e-07 0.1519363404455653 9.216337804404094e-07 0.1510573496788611 \
9.216338521684844e-07 0.1502755532525617 9.216339204254628e-07 0.149534520573691 9.216340181414224e-07 0.1484788062294206 9.216340875916062e-07 0.147731872792437 \
9.216341703430852e-07 0.1468455801890639 9.216342303799947e-07 0.1462052652532956 9.216343006186586e-07 0.1454587420502366 9.216343720461929e-07 0.1447037411390827 \
9.216344525596947e-07 0.1438588888651768 9.216345158225991e-07 0.1431977449412327 9.216345934965784e-07 0.1423892845091393 9.216346828063428e-07 0.141463758692191 \
9.216347521699288e-07 0.1407479403162204 9.216348501181492e-07 0.1397418416088305 9.216349404626691e-07 0.1388188591118084 9.216350262429942e-07 0.1379520826379384 \
9.216350938967789e-07 0.1372719511642241 9.216351602046293e-07 0.1366075914250998 9.216352388243209e-07 0.1358227655030745 9.216353195192301e-07 0.135020537018139 \
9.216353779218939e-07 0.1344419857224206 9.216354386744167e-07 0.1338420332148588 9.21635532580729e-07 0.1329184183639811 9.216355749782324e-07 0.1325029080242558 \
9.21635654222426e-07 0.1317336600863391 9.216356945925846e-07 0.1313430593815061 9.216357842934633e-07 0.130477658168832 9.216358232415503e-07 0.1301029732927899 \
9.216359188572358e-07 0.1291862249441596 9.216359577410651e-07 0.1288146335111444 9.216360509758409e-07 0.1279263274670414 9.2163611931843e-07 0.1272775968534341 \
9.216361716392852e-07 0.1267823325594629 9.21636253739999e-07 0.1260075984242486 9.216363249033783e-07 0.1253406747583812 9.216364028563663e-07 0.1246136378429537 \
9.216364819761022e-07 0.1238779526756392 9.21636560619333e-07 0.1231489004754178 9.216366406542416e-07 0.122409328367501 9.216367023886578e-07 0.1218405706457005 \
9.216367759836405e-07 0.1211645344030958 9.216368593634578e-07 0.120401093559758 9.216369234601888e-07 0.1198161795466899 9.216369928987768e-07 0.119184869057559 \
9.216370659217155e-07 0.1185234239195788 9.216371507966272e-07 0.1177582144838446 9.216372301594785e-07 0.117046673033812 9.21637314893136e-07 0.1162898833629492 \
9.216374056044255e-07 0.1154830714735263 9.216374811875037e-07 0.1148135241260771 9.216375469154283e-07 0.1142333070693714 9.21637606975201e-07 0.1137047561823949 \
9.216376765809174e-07 0.1130943456353956 9.216377429999685e-07 0.1125141752866663 9.216378224112315e-07 0.1118230150855203 9.216379126741611e-07 0.1110406875128299 \
9.216379817184612e-07 0.1104447270551955 9.216380562735805e-07 0.1098035355921305 9.216381447575012e-07 0.1090456469739195 9.216382238656482e-07 0.1083709350695736 \
9.216382937340289e-07 0.1077773127978274 9.216383747433987e-07 0.1070920034756896 9.216384309482126e-07 0.106618206733547 9.216384936074922e-07 0.1060916009495399 \
9.216385587540975e-07 0.105545887371837 9.216386300897257e-07 0.1049504956797945 9.216387503861013e-07 0.1039516085561449 9.216388019396736e-07 0.103525508500865 \
9.216388570887417e-07 0.1030709598036589 9.216389477859257e-07 0.1023262935955709 9.216390301757782e-07 0.1016530765296615 9.216391257555855e-07 0.1008759670630478 \
9.216392329651519e-07 0.1000092507657299 9.216393366245584e-07 0.09917656019160864 9.21639422832161e-07 0.09848810438956324 9.216395090743862e-07 0.09780303991321163 \
9.216395886154605e-07 0.09717448010577609 9.216396686283335e-07 0.09654538840876434 9.216397599166613e-07 0.09583163072761708 9.216398416620796e-07 0.09519620281310773 \
9.216399305889172e-07 0.09450872319168514 9.216400203662241e-07 0.09381864801001834 9.216400973288722e-07 0.09323024625953365 9.216401876536891e-07 0.0925435244861572 \
9.216402514624153e-07 0.09206084550525626 9.216403239259826e-07 0.09151514907748673 9.216403880546354e-07 0.09103438864950099 9.216404663020107e-07 0.09045054736970405 \
9.216405660032922e-07 0.08971110930136832 9.216406400564437e-07 0.08916512281998501 9.216407266649787e-07 0.08852997392441805 9.216408729646849e-07 0.08746544055362569 \
9.216409836769482e-07 0.08666684197409438 9.216410939866262e-07 0.08587717033461532 9.216412361822689e-07 0.08486839672072237 9.216413762347203e-07 0.08388450488753585 \
9.216415188805342e-07 0.08289222299161547 9.21641667651249e-07 0.08186778387581196 9.216418043639349e-07 0.08093569403044946 9.21641946484565e-07 0.07997640434545976 \
9.21642081061545e-07 0.07907728405019222 9.216422212814229e-07 0.07814997945867638 9.216423690282293e-07 0.07718353387841098 9.216425189824149e-07 0.07621348085094087 \
9.216426836982467e-07 0.07516037195605636 9.216428472843634e-07 0.07412732798506308 9.216430219327157e-07 0.07303837372665309 9.21643208986408e-07 0.07188781219077654 \
9.216434189729257e-07 0.0706159374129187 9.216436370461739e-07 0.06931715807027321 9.216438703663275e-07 0.06795188046253516 9.216441248458817e-07 0.0664909822812602 \
9.2164441780254e-07 0.06484528303377844 9.21644719953089e-07 0.06318745987130532 9.216450576747916e-07 0.06138078634948794 9.21645452783393e-07 0.05932807220464856 \
9.21645820234636e-07 0.05747953410674719 9.216462378424018e-07 0.05544691527644593 9.216465828383762e-07 0.0538196438399016 9.216469333806655e-07 0.05221302159193914 \
9.21647248341029e-07 0.0508087490907442 9.216475475823956e-07 0.049508488261462 9.216478469482477e-07 0.04824029756235761 9.216481221909582e-07 0.04710512226277328 \
9.216484056545245e-07 0.04596497870754415 9.216486672549465e-07 0.04493681260994405 9.216489447070712e-07 0.04387103439794762 9.216492207665063e-07 0.04283531238677037 \
9.216495290362429e-07 0.04170718945545093 9.216497514688635e-07 0.0409114719535993 9.21650039009947e-07 0.03990505631995635 9.216502752428795e-07 0.0390969788355163 \
9.216505937045547e-07 0.03803800466874574 9.21650844115589e-07 0.03722710566490722 9.216511671003914e-07 0.03620720400565681 9.216514254364062e-07 0.03541203096995557 \
9.216517154102846e-07 0.03454066075983582 9.216519452051025e-07 0.0338658635512188 9.216522301004436e-07 0.03304787219836024 9.216524698465629e-07 0.03237513696606491 \
9.216527104811323e-07 0.03171392889024889 9.216529495996188e-07 0.03107212555077287 9.216531855385298e-07 0.03045460689686571 9.21653416367391e-07 0.02986254663395104 \
9.216536313939185e-07 0.02932175456294728 9.216540335597597e-07 0.0283374222946415 9.2165423211788e-07 0.02786401170979088 9.216546058190658e-07 0.02699470773596776 \
9.216547926322608e-07 0.02657042318767052 9.216551386335081e-07 0.02580176906824739 9.216552605769465e-07 0.02553595448027303 9.216556434299635e-07 0.02472011952872977 \
9.216558038641491e-07 0.02438657631284594 9.216562468653031e-07 0.02348572425118655 9.216564174793446e-07 0.02314627247835563 9.216567380559406e-07 0.02251902970747987 \
9.21656938340868e-07 0.0221336684630111 9.216573852788009e-07 0.02128811173678137 9.216575132229166e-07 0.02104854104185888 9.21658001100276e-07 0.02014826272243131 \
9.216581360775529e-07 0.01990454278080647 9.216586183290713e-07 0.0190640092473091 9.216587806551861e-07 0.01879235028057063 9.216592670495271e-07 0.01801148170254873 \
9.216594300771863e-07 0.01776103207540622 9.216601102988766e-07 0.01676849304257711 9.216602493826144e-07 0.01657541006259178 9.216609818771476e-07 0.01560782569993242 \
9.216611407707804e-07 0.01540693214221847 9.21661923851867e-07 0.01445869962397344 9.216620696444218e-07 0.01428952172302696 9.216629204257814e-07 0.01334248985256295 \
9.21663031529053e-07 0.01322388191882306 9.216639648234165e-07 0.0122699293983148 9.216640986614658e-07 0.01213902814618388 9.21665057199482e-07 0.01123495036716388 \
9.216651783165509e-07 0.01112486091825863 9.216663004003486e-07 0.01017270671243764 9.216664059016017e-07 0.01008921053061839 9.216677349760139e-07 0.009112307258623473 \
9.216678551802884e-07 0.009029744095492466 9.21669403542048e-07 0.008036808760534916 9.216694843298185e-07 0.007986285493236449 9.216710552093519e-07 0.007024564730313319 \
9.216711226255508e-07 0.006986095570813155 9.216730433922295e-07 0.006001386377072119 9.21673230194113e-07 0.005914747648762168 9.216755456080605e-07 0.0049318160947762 \
9.216759451349076e-07 0.004777795182599986 9.216785089444082e-07 0.003889929704329555 9.216790078153284e-07 0.003736330440833864 9.216826375393169e-07 0.002784984367379526 \
9.216831882332917e-07 0.002663729254427667 9.216885866736713e-07 0.001711392372544448 9.216888999412434e-07 0.001662511220227468 9.216938922337913e-07 0.0006970413096974805 \
9.216940762528259e-07 0.0006571176749162138 9.243425553956096e-07 -0.0002691198397987355 9.243427114545721e-07 -0.0004551674219448388 9.243432594384271e-07 -0.001322174727784445 \
9.243433723764198e-07 -0.001539785040943742 9.243438016313498e-07 -0.002474302920374066 9.24343907888515e-07 -0.002730173903076456 9.243441906906666e-07 -0.003454402452283872 \
9.243443042852103e-07 -0.003760966378165151 9.24344642839789e-07 -0.004705104513819927 9.243447552637498e-07 -0.005021586953003071 9.243450835416506e-07 -0.005887841248467669 \
9.243451910801718e-07 -0.006130875888161453 9.243460710062032e-07 -0.005789627805322099 9.243462462122502e-07 -0.004910736584223327 9.243463630430133e-07 -0.004127745010746014 \
9.243464899101376e-07 -0.00309221842859156 9.243465914428628e-07 -0.002125750314016509 9.243467128641333e-07 -0.0008095618968406578 9.243468030290462e-07 0.0002767910803854594 \
9.243469002126957e-07 0.001550247908954045 9.243469982869597e-07 0.002938803805678211 9.243471655080454e-07 0.005530627736217106 9.243473878133234e-07 0.009378371294171852 \
9.24347573551714e-07 0.01290572951649239 9.243477976330495e-07 0.01747895571448658 9.243479572777817e-07 0.02091945933227325 9.243481217671113e-07 0.02459614091902196 \
9.243482715915693e-07 0.0280452875125503 9.243484209914613e-07 0.03156498790849799 9.243485705227667e-07 0.03515592969144176 9.243487246026613e-07 0.03891669635189081 \
9.243488867868089e-07 0.0429309674228065 9.24349053210035e-07 0.0470989728378523 9.243492291435082e-07 0.05154884981278444 9.24349410271779e-07 0.05616867911875007 \
9.243496024027047e-07 0.06110225049351239 9.243498100981169e-07 0.0664648391313285 9.243500320181979e-07 0.07222051812179281 9.243502672196803e-07 0.07834079218654426 \
9.243505194059892e-07 0.08491829088081257 9.24350795545224e-07 0.09213111703448683 9.243510966667007e-07 0.1000001933597138 9.243514285865621e-07 0.1086702418150647 \
9.243518059053303e-07 0.1185147411083515 9.243522041953866e-07 0.1288888856248832 9.243526735037065e-07 0.1410822143415975 9.243532195292308e-07 0.1552200475789812 \
9.243538544895379e-07 0.1715918832733369 9.243545538901292e-07 0.1895291194622146 9.243553721290551e-07 0.2103807608661494 9.243562778230217e-07 0.2332840710921665 \
9.243570673340878e-07 0.253091928008631 9.243577710929056e-07 0.2706124241987875 9.243583889437195e-07 0.2858796548825839 9.243589545671311e-07 0.2997575097153312 \
9.243594763024047e-07 0.3124620269501652 9.243599740861211e-07 0.3244932238414255 9.24360457724081e-07 0.3360954048923613 9.243609145982154e-07 0.3469667650518959 \
9.243613874391095e-07 0.3581213589834248 9.243618270524661e-07 0.3684065070151987 9.24362314929562e-07 0.379719432411247 9.243628457299845e-07 0.3919028193132517 \
9.243633436253595e-07 0.4032143644097119 9.24363775002613e-07 0.41292177789323 9.243642618898012e-07 0.4237731225600331 9.243647619892433e-07 0.4348012155672935 \
9.243651066099338e-07 0.4423321287141763 9.243654600037776e-07 0.4500000647748709 9.243658877736168e-07 0.4592134948422093 9.243662796346881e-07 0.4675816212925634 \
9.243665799290445e-07 0.4739471552041949 9.243669218601248e-07 0.4811428413521782 9.243672651945704e-07 0.4883132334011818 9.24367525955058e-07 0.4937215836208605 \
9.243677680115876e-07 0.4987106167174703 9.243680340100556e-07 0.5041617362307154 9.243682934982395e-07 0.5094435946950286 9.243684834145396e-07 0.5132872703533161 \
9.243686986491408e-07 0.5176241792560061 9.243688371999001e-07 0.5204025546691405 9.243689820806791e-07 0.5232962183003332 9.243691954947458e-07 0.5275364624051522 \
9.243693975193604e-07 0.5315382148201082 9.243695902480239e-07 0.5353370730264509 9.243697755034039e-07 0.5389735557287745 9.243699525009277e-07 0.5424323215059959 \
9.243702617642632e-07 0.5484573594957171 9.243705229123106e-07 0.5535233414883098 9.243708247314805e-07 0.5593562770234363 9.243710801601218e-07 0.5642781701956761 \
9.243713725156194e-07 0.5698968483756405 9.243716319698132e-07 0.5748654731717864 9.243719020897901e-07 0.5800301911327002 9.243721441003478e-07 0.5846380733684551 \
9.243724016101459e-07 0.5895273573494454 9.243726280544834e-07 0.5938057549890672 9.243728649429657e-07 0.5982619499065401 9.24373074987873e-07 0.6021962733001386 \
9.243732879185846e-07 0.6061670177072124 9.24373541397282e-07 0.6108668889270118 9.24373744692931e-07 0.6146150465592417 9.243739363811141e-07 0.6181346807088086 \
9.243741250074785e-07 0.6215812235468744 9.243743123254166e-07 0.6249823889551316 9.243745179374062e-07 0.6286953279350977 9.243747677606248e-07 0.6331759959753138 \
9.243749715724034e-07 0.6368063379741715 9.243751792111211e-07 0.6404826298163093 9.24375371862737e-07 0.6438748386876914 9.243756164748105e-07 0.6481531432733096 \
9.243758643733136e-07 0.6524620620600715 9.243760442082188e-07 0.6555644139995785 9.243762349822552e-07 0.6588391718544121 9.24376388158437e-07 0.6614554104590837 \
9.243765598271469e-07 0.6643705886591137 9.243767102939677e-07 0.6669108747194671 9.243768468979714e-07 0.6692010654183506 9.243769963383726e-07 0.6716954191563786 \
9.243771240725234e-07 0.6738189269502312 9.2437726394477e-07 0.6761323074508511 9.243773880219049e-07 0.6781756764962316 9.243775193832699e-07 0.6803315871556701 \
9.243776435547311e-07 0.6823627547057004 9.243777813315919e-07 0.6846081866267727 9.243779015758122e-07 0.6865586181592046 9.243780436284174e-07 0.6888545186016138 \
9.243781438561225e-07 0.6904668682779994 9.243782651601134e-07 0.6924123325129877 9.243783561353879e-07 0.6938641504265992 9.243784535186707e-07 0.695411869780077 \
9.24378550601538e-07 0.6969507228893711 9.243786398841583e-07 0.6983595753378042 9.243787378559427e-07 0.699898781449533 9.243788681310304e-07 0.7019319515314388 \
9.243790215432551e-07 0.7043083163565919 9.243791571090672e-07 0.7063909659299702 9.24379301449562e-07 0.708591461371511 9.243794273204452e-07 0.710496752775434 \
9.24379552347831e-07 0.712376488910674 9.243796666301914e-07 0.7140841686551523 9.243797776133355e-07 0.7157331888171029 9.243798773084045e-07 0.7172065512867005 \
9.243800143526226e-07 0.7192196995505324 9.243801333798347e-07 0.7209572005600779 9.24380253677943e-07 0.7227029412191364 9.243803801768634e-07 0.7245276185835638 \
9.243805041084668e-07 0.7263044524160376 9.243806283948001e-07 0.7280754330070212 9.243807547599529e-07 0.7298652243312684 9.243808845716946e-07 0.7316925631262517 \
9.243810084102137e-07 0.7334254795816325 9.243811411911006e-07 0.735272086289578 9.243812420423058e-07 0.7366670415914529 9.243813552339755e-07 0.738224777043618 \
9.243814420199563e-07 0.7394137384482823 9.243815586452529e-07 0.7410021813026957 9.243816479345105e-07 0.7422110784210975 9.243817591113937e-07 0.7437075443329063 \
9.243818883701577e-07 0.7454347509364776 9.243820022291937e-07 0.7469455276109591 9.243821066334058e-07 0.74832188588007 9.243822310004373e-07 0.7499498655229884 \
9.243823782406158e-07 0.7518616907275563 9.243824985209068e-07 0.753411006437983 9.243826144254458e-07 0.7548933175676444 9.243827545012897e-07 0.7566706674475765 \
9.243828971129601e-07 0.7584645678799224 9.243830150672032e-07 0.7599365027959469 9.243831418837122e-07 0.7615071445339606 9.243832827668561e-07 0.7632375905494565 \
9.243834025603537e-07 0.7646969139886852 9.243835475192107e-07 0.7664484133613445 9.243836690779962e-07 0.7679052725436226 9.243837881174897e-07 0.7693214142140735 \
9.243839097488533e-07 0.7707575700077021 9.243840377178316e-07 0.772256936813787 9.243841469330139e-07 0.7735272422640712 9.243842718238922e-07 0.774969549136603 \
9.24384378939953e-07 0.7761978171588899 9.243845121931473e-07 0.7777146071439789 9.243846392965933e-07 0.7791497354387434 9.243847610475684e-07 0.7805132846941326 \
9.243848776321507e-07 0.7818078758210534 9.24384983459753e-07 0.7829735233300771 9.243851228258954e-07 0.7844949153190801 9.243852718976943e-07 0.786105286864636 \
9.24385419626362e-07 0.7876841235632186 9.243855389322396e-07 0.7889471147195867 9.243856729390521e-07 0.7903527806482344 9.243857933652268e-07 0.791604423795974 \
9.243859349104042e-07 0.7930616786923709 9.243860823364166e-07 0.7945638089648995 9.243862068109251e-07 0.7958198087139573 9.24386325854918e-07 0.7970105506108808 \
9.243864374452016e-07 0.7981174590942314 9.243865426744905e-07 0.7991530841216606 9.24386638185594e-07 0.8000862307887144 9.243867742475476e-07 0.8014036057482816 \
9.243868911236816e-07 0.8025237700417888 9.243870102773536e-07 0.8036549841722296 9.24387132589548e-07 0.8048050501807249 9.243872558616217e-07 0.8059526272620129 \
9.243873823583983e-07 0.8071184350969989 9.243875078610622e-07 0.8082633544790385 9.243876385869669e-07 0.8094437311890262 9.243877641549387e-07 0.8105658358439867 \
9.243878932098035e-07 0.8117072367686948 9.243879990659605e-07 0.8126345588578442 9.243881002348365e-07 0.8135133322873783 9.243881948546566e-07 0.8143286754242188 \
9.243883191357402e-07 0.8153900871385379 9.243884088474262e-07 0.816149614585347 9.243885078849502e-07 0.8169816577628611 9.243886456628271e-07 0.8181280288377792 \
9.243887801986772e-07 0.81923501721715 9.243888886049435e-07 0.8201180631035904 9.243890385184473e-07 0.8213254631869725 9.243891890970255e-07 0.8225223201378843 \
9.243893145921802e-07 0.8235077122548546 9.243894584387069e-07 0.8246238332260477 9.243895830219706e-07 0.8255790649890803 9.243897318751914e-07 0.8267066458678887 \
9.24389868023775e-07 0.827725029289517 9.243899930476024e-07 0.8286494160599757 9.243901107545823e-07 0.8295103773055483 9.243902563935804e-07 0.8305630309532103 \
9.243904227748752e-07 0.8317484146982921 9.243905533585645e-07 0.8326660250626342 9.243907268806749e-07 0.8338683097812621 9.243908950025776e-07 0.8350147136930499 \
9.243910648651803e-07 0.8361549927788252 9.243912457668832e-07 0.8373497079260466 9.24391388876165e-07 0.8382806519784776 9.24391502965127e-07 0.839013953006387 \
9.243916331276035e-07 0.8398410866028793 9.243917349727342e-07 0.8404811280669765 9.243918517989402e-07 0.8412075886390841 9.243919886903802e-07 0.8420483852080155 \
9.243921864976039e-07 0.843243620449199 9.243923781227506e-07 0.8443797466267589 9.24392587554618e-07 0.8455974227529048 9.243927695012998e-07 0.8466352798309468 \
9.243929666301539e-07 0.8477391449715804 9.243931399710144e-07 0.8486924050423899 9.243933229793209e-07 0.8496814535024207 9.243934941423556e-07 0.8505903669473519 \
9.243936687794506e-07 0.851501688465695 9.243938440392814e-07 0.8524001683007644 9.243940201897297e-07 0.8532872510191711 9.243942104700294e-07 0.8542278331088334 \
9.243944010691599e-07 0.8551519386507073 9.243946016923949e-07 0.8561055033533737 9.243947943009499e-07 0.8570028516027762 9.243950049816413e-07 0.8579644845832216 \
9.243952330831089e-07 0.8589827023971403 9.243954988710916e-07 0.860139640227508 9.243957974838522e-07 0.8614018215255795 9.243960737724907e-07 0.8625348754565382 \
9.243963580090102e-07 0.8636666213345715 9.243966322137804e-07 0.8647267940813509 9.243969044486385e-07 0.8657495569722869 9.243971746527798e-07 0.8667361702337206 \
9.243974318083904e-07 0.867649441901348 9.24397704388604e-07 0.8685908808535525 9.2439798037489e-07 0.8695169452638583 9.24398250477721e-07 0.870397355937691 \
9.243985503347982e-07 0.8713451925332844 9.243989213624563e-07 0.8724761722512941 9.243992162997666e-07 0.8733433185969293 9.243994705892065e-07 0.8740690226522811 \
9.243997688459906e-07 0.874895168896023 9.244000424554269e-07 0.8756299040683481 9.244002785839136e-07 0.8762466977562872 9.244005189298274e-07 0.8768585021646264 \
9.244007412634921e-07 0.8774104263690854 9.244009352691695e-07 0.8778812671168952 9.244012649918855e-07 0.8786590883967833 9.244014201653189e-07 0.8790156160651978 \
9.244017379413894e-07 0.8797272612331356 9.244019168030317e-07 0.8801171459162566 9.244022592648612e-07 0.8808425821290963 9.244024433930206e-07 0.881221400612852 \
9.244029182707539e-07 0.8821634994206867 9.24403085666965e-07 0.8824839765989225 9.244035515089055e-07 0.8833452998114757 9.244037323309576e-07 0.8836679564577563 \
9.244042263693833e-07 0.8845176198113115 9.24404367718007e-07 0.8847523712107549 9.244049740520726e-07 0.8857188576377059 9.244051261213959e-07 0.8859512996759633 \
9.244057728095585e-07 0.8868983431897121 9.244059011041699e-07 0.8870786909355212 9.244065492212318e-07 0.8879538337624689 9.244066790202949e-07 0.8881220828502663 \
9.244074572237723e-07 0.8890807033877333 9.244075722787339e-07 0.8892148977954012 9.244084279402064e-07 0.8901543051721961 9.244085733010758e-07 0.8903040038307473 \
9.244095590571272e-07 0.8912446482480114 9.244097801624956e-07 0.8914382978987679 9.244109252894233e-07 0.8923659558950503 9.244110565064392e-07 0.8924678262926897 \
9.244123977150129e-07 0.8934599079028542 9.244125491142719e-07 0.8935646301988298 9.244140305519949e-07 0.8944937559627255 9.244142694313731e-07 0.8946275407274444 \
9.24416038746979e-07 0.8955013787854181 9.244164278981914e-07 0.8956696032899972 9.244188215611417e-07 0.8965547188539188 9.244192972701398e-07 0.8967039926079825 \
9.244233604302104e-07 0.8977020505850396 9.244238518542689e-07 0.8977948037134476 9.244321684538219e-07 0.898787348739254 9.244330883529499e-07 0.8988506593152591 \
9.245765735834803e-07 0.8998476076348748 9.245776920164557e-07 0.8998537475785264 9.247827836359558e-07 0.898985773748599 9.247830107254573e-07 0.8988224379910277 \
9.247846203322555e-07 0.8978282360369357 9.247847977407987e-07 0.8977338482811539 9.248017048890995e-07 0.8987315468430059 9.248018143281978e-07 0.8987460089186867 \
9.248175950494439e-07 0.8997418097871094 9.248178913753395e-07 0.8997476966799167 9.25301325027745e-07 0.9007060148833608 9.253014540780854e-07 0.9008313386292994 \
9.253021042279306e-07 0.9016292186224167 9.253022937236613e-07 0.9019133038041363 9.253027969456399e-07 0.9027675859898705 9.253029324182996e-07 0.9030208676018907 \
9.253033328770163e-07 0.9038195223753869 9.253034648149532e-07 0.9040958310886574 9.253038660300166e-07 0.9049509627747726 9.253039642901936e-07 0.9051582028152527 \
9.253044301640042e-07 0.9060587574877488 9.253045916627274e-07 0.9063060456044927 9.253057356752504e-07 0.9055153668657776 9.253058806545959e-07 0.9049059606760256 \
9.253060592073535e-07 0.9039396653125833 9.253062394026313e-07 0.9027054491383806 9.253063820935605e-07 0.9015369228101149 9.253064992531646e-07 0.9004524619440171 \
9.253065882345255e-07 0.8995505656965809 9.253066798781776e-07 0.8985529714258781 9.253068129901104e-07 0.8969831049011855 9.253069067111929e-07 0.8957895978311226 \
9.253069978500017e-07 0.8945634483845346 9.253071111423133e-07 0.8929516940777753 9.253072142512257e-07 0.8913998138690341 9.253073105184064e-07 0.8898830246517148 \
9.253074296555228e-07 0.8879200664089764 9.253075982407715e-07 0.8849885378698126 9.253077600122727e-07 0.8820195265790133 9.253079532313317e-07 0.8782956415026882 \
9.253081387944431e-07 0.8745571577041361 9.253083490607478e-07 0.8701566079887386 9.253085313097885e-07 0.8662213066841463 9.253087161731834e-07 0.8621339172744639 \
9.253088888583302e-07 0.8582419637438897 9.253090749664033e-07 0.8539816046497358 9.253092527824913e-07 0.849858603441091 9.253094334990721e-07 0.8456251963850057 \
9.253095986373312e-07 0.8417258760277182 9.253097639114333e-07 0.837798995916667 9.253099271590958e-07 0.8339004324287677 9.253100857493695e-07 0.8300982805770993 \
9.253102626737713e-07 0.8258418712800655 9.253104591875839e-07 0.8211009660847696 9.253106267441254e-07 0.8170498602679914 9.253107934845439e-07 0.8130123908857781 \
9.253109679080616e-07 0.8087844286215062 9.253111372776842e-07 0.8046757316210446 9.253113054767785e-07 0.8005936994537799 9.25311494325046e-07 0.7960093488074458 \
9.253116851408819e-07 0.7913773844868103 9.253118935230917e-07 0.7863203192056716 9.25312119942597e-07 0.7808277108969495 9.253123091427939e-07 0.7762391340290878 \
9.253125192894832e-07 0.7711455503222944 9.253126680579875e-07 0.7675418410361046 9.25312799050976e-07 0.7643705172588006 9.25312936616212e-07 0.7610417440783073 \
9.253130423674413e-07 0.7584842184275663 9.253131771410751e-07 0.7552262509102785 9.253132889738005e-07 0.7525244432456109 9.253134184089644e-07 0.7493992292091655 \
9.253135735976883e-07 0.7456545577979357 9.253136852334406e-07 0.7429626190147979 9.253138448080549e-07 0.7391166470929011 9.253140201296881e-07 0.7348935218456193 \
9.253142325051509e-07 0.7297828120356423 9.253144253876789e-07 0.7251458607116523 9.253145820889711e-07 0.7213823872711312 9.253147687636618e-07 0.716903961299824 \
9.253149576500111e-07 0.7123775767926828 9.253151485342027e-07 0.70780884692282 9.253153352821382e-07 0.7033444557767304 9.253155183669542e-07 0.698972331957095 \
9.253156556859353e-07 0.6956951921588121 9.253158089288925e-07 0.6920418367118417 9.253160040575431e-07 0.6873949992893974 9.253161613518718e-07 0.6836535194673684 \
9.25316320746467e-07 0.6798660670227984 9.253165164902601e-07 0.6752219404489795 9.253167086893939e-07 0.6706682621108646 9.253169436410222e-07 0.6651105611269369 \
9.2531713111727e-07 0.6606839627962382 9.253173683544038e-07 0.6550894036851447 9.253175575343661e-07 0.6506361170423679 9.253177381501784e-07 0.6463915264929231 \
9.253179018447415e-07 0.6425504277539856 9.253180463961504e-07 0.6391628119244788 9.2531818686792e-07 0.6358764726647652 9.253183139687074e-07 0.6329064225879303 \
9.253184462761836e-07 0.6298198307262635 9.253185728632297e-07 0.626870110582017 9.253187034434976e-07 0.62383130535404 9.253188327128966e-07 0.6208285625908692 \
9.253189718197928e-07 0.6176004736356133 9.253191203301029e-07 0.6141606483517721 9.253193098786583e-07 0.6097777958748198 9.253194555819144e-07 0.6064170107178907 \
9.253196906324778e-07 0.601007464699683 9.253198736317494e-07 0.5968099615921 9.253200979734226e-07 0.5916778694808832 9.253202691466717e-07 0.5877753019413697 \
9.253204014804909e-07 0.5847634284691802 9.253205332770303e-07 0.5817721407249107 9.253206398209335e-07 0.5793579518205488 9.25320735711292e-07 0.5771868999037388 \
9.253208282115419e-07 0.5750974572268882 9.25320920638905e-07 0.5730134868920421 9.253209930672115e-07 0.5713818265150021 9.25321048796317e-07 0.5701269325864891 \
9.253211099054046e-07 0.5687522410723198 9.253212066700799e-07 0.5665806864277688 9.253212681615945e-07 0.5652027770813386 9.253213272142164e-07 0.5638802801505602 \
9.253214028408818e-07 0.5621878686488651 9.253214698636601e-07 0.5606896577364279 9.253215434607697e-07 0.5590483558003441 9.253216110667723e-07 0.5575429304381756 \
9.253217271358289e-07 0.5549610936632026 9.253218273422345e-07 0.5527359403974305 9.253219393494243e-07 0.5502565947066531 9.253220338414751e-07 0.5481686943853854 \
9.253221549961725e-07 0.5454955387196141 9.253222551839389e-07 0.5432910220514219 9.253223711744508e-07 0.5407443765731218 9.253224788782884e-07 0.5383833065966291 \
9.253225884569768e-07 0.5359861028148916 9.253227005784206e-07 0.5335400310751951 9.253228275156047e-07 0.5307765704644959 9.253229496651232e-07 0.5281221248815906 \
9.253230894260376e-07 0.525095489155881 9.253232265641538e-07 0.522132778766487 9.253233765292441e-07 0.5189020692106626 9.253235353022474e-07 0.5154923220538846 \
9.253237093279043e-07 0.511765695450105 9.25323896158028e-07 0.5077823379664483 9.253241011259935e-07 0.5034264211640872 9.253243238349422e-07 0.4987133299464507 \
9.25324576739139e-07 0.4933874474923696 9.253248116930461e-07 0.4884604410272814 9.253251079613078e-07 0.4822828691822955 9.253253977512661e-07 0.4762763831984252 \
9.253257040870847e-07 0.4699660956099861 9.253260164056119e-07 0.4635767846525711 9.253263549710683e-07 0.4566963260653934 9.25326678082485e-07 0.4501741115777416 \
9.253270164777878e-07 0.4433881855507311 9.253273403090533e-07 0.4369378830387565 9.25327664703474e-07 0.4305204627449936 9.253280076377602e-07 0.4237851826852676 \
9.253283469185779e-07 0.4171698123421442 9.253286863932123e-07 0.4105997181257849 9.253291295050583e-07 0.4020958655332711 9.253294915732268e-07 0.3952155038183801 \
9.253298121249644e-07 0.3891775711374149 9.253301990595345e-07 0.3819561902961204 9.253305269297949e-07 0.3758957719299574 9.253308120888516e-07 0.3706704968427373 \
9.253311304576463e-07 0.3648820026298218 9.253314132885732e-07 0.3597820188690578 9.253316419773369e-07 0.3556924369094372 9.253318598701416e-07 0.3518226517641353 \
9.253320551194862e-07 0.3483769517668343 9.253322620275856e-07 0.344751588202948 9.253324768243417e-07 0.3410137651016431 9.253327290508921e-07 0.3366564674340092 \
9.253329710462047e-07 0.3325077909124976 9.253332018984844e-07 0.3285822460490526 9.253334167466747e-07 0.3249550452085373 9.253336371033643e-07 0.3212604562488142 \
9.25333838674264e-07 0.3179050685021769 9.253340417582105e-07 0.3145531374773136 9.253342396555968e-07 0.3113121771742085 9.253344267548364e-07 0.3082694484595072 \
9.253346206551794e-07 0.3051385396431291 9.253348257035143e-07 0.3018527636900292 9.253350059382659e-07 0.2989872106339772 9.253352418362774e-07 0.2952669081535775 \
9.253354431238275e-07 0.2921198200609627 9.253356445146313e-07 0.2889965001417216 9.253358691637942e-07 0.2855437159941698 9.253360345437677e-07 0.2830223598911593 \
9.253362123481056e-07 0.280330186126118 9.253363960043191e-07 0.277570343839212 9.253365812460764e-07 0.2748090658167894 9.253367593914542e-07 0.2721781298892599 \
9.253369329835173e-07 0.2696316866093095 9.253370933483699e-07 0.267306655456324 9.253372144595526e-07 0.2655585721882695 9.253373676543406e-07 0.2633570345323199 \
9.253374949857891e-07 0.2615475749425888 9.253375983136284e-07 0.2600830587034867 9.253377156384239e-07 0.2584225376281647 9.253378334453811e-07 0.2567591557214636 \
9.253379574091473e-07 0.2550199666844239 9.253380743933137e-07 0.2533821414201824 9.253382051894417e-07 0.2515535495016885 9.253383223995523e-07 0.2499173892700276 \
9.253384756526766e-07 0.2477853623028658 9.253386111831973e-07 0.2459029165157107 9.253387428644058e-07 0.244074199323236 9.253388994573169e-07 0.2419017673596028 \
9.253390246538746e-07 0.2401755227310949 9.253391603715014e-07 0.2383060149301216 9.253392927986628e-07 0.2364844144139329 9.253394127723238e-07 0.2348355337769661 \
9.253395758201609e-07 0.232606585912384 9.253397146272525e-07 0.230713852557009 9.253398531009718e-07 0.2288300961780371 9.253399586457211e-07 0.2273962817971701 \
9.253400870074011e-07 0.2256537837490921 9.253401911350241e-07 0.2242444877898851 9.253402916510259e-07 0.222886569499566 9.253403666954021e-07 0.2218745444235658 \
9.253404440284576e-07 0.2208349692306942 9.253405187916369e-07 0.2198305887827458 9.253405967553143e-07 0.218785487158918 9.253406516218243e-07 0.2180503923904892 \
9.253407081185998e-07 0.2172938400168352 9.253407515721192e-07 0.2167123195211523 9.253407916131654e-07 0.2161767335077376 9.253408308521132e-07 0.2156521099473339 \
9.2534087172635e-07 0.2151058606261434 9.253409258788401e-07 0.2143825797409383 9.253409642959715e-07 0.2138698309421548 9.253410035846784e-07 0.2133480458229882 \
9.253410651213864e-07 0.2125332203444249 9.253411270989155e-07 0.2117131287842428 9.253411835756643e-07 0.2109664019951111 9.253412482072544e-07 0.2101124842966758 \
9.25341343715876e-07 0.2088522205996687 9.253414310316075e-07 0.207701294711168 9.253415276412079e-07 0.2064291756790013 9.253416248707622e-07 0.2051510266126755 \
9.253417257178228e-07 0.2038307158897115 9.253418263175943e-07 0.2025192706911573 9.253419228088912e-07 0.2012627769767186 9.253420249910648e-07 0.1999338657614989 \
9.253421286307215e-07 0.1985898465970496 9.253422384047342e-07 0.1971698847140261 9.253423475797596e-07 0.1957617939809042 9.253424676778517e-07 0.1942174441246506 \
9.253425776973761e-07 0.1928086337505992 9.253426858092847e-07 0.1914295694688549 9.253428088379842e-07 0.1898652723262108 9.253428989485537e-07 0.1887234630454603 \
9.253430063140445e-07 0.1873671680421656 9.253430831253526e-07 0.1864004060894758 9.253431665706206e-07 0.1853535952511875 9.253432561024323e-07 0.1842338297700716 \
9.253433406678984e-07 0.1831790839553313 9.253434203840386e-07 0.1821880912968773 9.253435217092421e-07 0.1809331989518758 9.253436300564713e-07 0.1795959386230563 \
9.253437265321694e-07 0.1784102562612937 9.253438519099859e-07 0.1768766438339704 9.253439846934562e-07 0.1752616821119887 9.253441024642794e-07 0.1738362801839788 \
9.253442481158562e-07 0.1720835746408261 9.25344358713008e-07 0.1707596463148658 9.253445008434469e-07 0.1690680578777541 9.253446165530702e-07 0.1676985735146403 \
9.253447220270831e-07 0.166456424915798 9.253448165437424e-07 0.1653485352650968 9.253449121811146e-07 0.1642320043563913 9.253450092529585e-07 0.1631032360400927 \
9.253451083042123e-07 0.161956192050434 9.253452022277692e-07 0.1608730077890209 9.253452875034443e-07 0.1598934595213354 9.253453878832364e-07 0.1587475631033795 \
9.253454721860728e-07 0.1577906478848196 9.253455745855819e-07 0.1566342854655733 9.253456519798444e-07 0.1557646215197878 9.253457443247582e-07 0.154731814591042 \
9.253458145762303e-07 0.1539498814072817 9.253459107506593e-07 0.1528844393027091 9.253459875753224e-07 0.152038051282755 9.253460663454741e-07 0.1511758489440315 \
9.253461402383946e-07 0.150370438825067 9.253462079361381e-07 0.1496353997608715 9.25346304000026e-07 0.1485973848112393 9.25346373572453e-07 0.1478489919002561 \
9.253464574616254e-07 0.1469503328160803 9.253465185934615e-07 0.146298213254472 9.253465908615431e-07 0.1455309799806117 9.253466633001062e-07 0.1447677488542132 \
9.253467442811468e-07 0.1439178685120187 9.253468103556157e-07 0.1432275520600639 9.253468877561137e-07 0.1424219220725307 9.253469771315706e-07 0.1414956876531561 \
9.253470479922162e-07 0.1407644282175171 9.253471468792833e-07 0.1397487730030469 9.253472241981922e-07 0.1389620820751095 9.253473062434185e-07 0.1381330876879582 \
9.253473943545299e-07 0.1372467208126059 9.253474619816769e-07 0.1365690714953818 9.253475422788589e-07 0.1357674830239305 9.253476170628882e-07 0.1350239185327315 \
9.253476850640654e-07 0.1343502586094245 9.253477317469739e-07 0.1338891847862563 9.253478209985673e-07 0.1330118383700247 9.253478592216168e-07 0.1326395291833771 \
9.253479282135268e-07 0.1319690872918072 9.253479809615963e-07 0.1314578750898332 9.253480639543783e-07 0.1306559489775353 9.253481041328288e-07 0.1302688434457458 \
9.253481966502028e-07 0.1293805059784019 9.253482353685699e-07 0.1290098403727171 9.25348309129285e-07 0.1283055160094505 9.253483707572868e-07 0.1277188748199021 \
9.253484427849764e-07 0.1270353589407805 9.253485109520081e-07 0.1263909833196726 9.253485855741692e-07 0.1256908956540175 9.253486674266349e-07 0.1249253613889138 \
9.253487508807972e-07 0.124147338931438 9.25348823832511e-07 0.1234692772477456 9.253488965594407e-07 0.122795332839617 9.253489565494355e-07 0.1222410931008323 \
9.253490429174471e-07 0.121445549533078 9.253491038861646e-07 0.1208856452315438 9.253491622719555e-07 0.1203507897957366 9.253492279066196e-07 0.119751336354628 \
9.253492872608612e-07 0.1192111367930785 9.253493552926419e-07 0.1185941868697126 9.253494525870119e-07 0.11771710490035 9.253495310789918e-07 0.1170124163111649 \
9.25349621315123e-07 0.1162055395685231 9.253497171618085e-07 0.1153523005684616 9.253497921195046e-07 0.1146878351828532 9.253498964789213e-07 0.1137670532163148 \
9.25349983267518e-07 0.1130053589403202 9.25350092924934e-07 0.1120476726212376 9.253501744789968e-07 0.1113387926087848 9.253502700926292e-07 0.1105114393564785 \
9.253503468048225e-07 0.10985058581598 9.253504417232868e-07 0.1090364400125625 9.253505175463918e-07 0.1083889268999046 9.253505952460492e-07 0.1077282965354292 \
9.253506775774999e-07 0.1070311517075373 9.253507371427637e-07 0.1065286079538068 9.253508009005013e-07 0.1059924133642201 9.253508619951089e-07 0.1054803128126646 \
9.253509578588471e-07 0.1046801683739134 9.253510027219415e-07 0.1043071445723913 9.253510859626872e-07 0.1036173314376927 9.25351135082509e-07 0.1032117000904133 \
9.253512441312713e-07 0.1023149933518279 9.253512889673535e-07 0.1019479364619093 9.253513792285847e-07 0.1012117400678687 9.25351420105203e-07 0.1008795969612472 \
9.25351490563617e-07 0.1003088525914566 9.253515768510381e-07 0.09961307626065434 9.253516686285974e-07 0.09887705578174606 9.253517381566897e-07 0.09832225024344161 \
9.25351816683849e-07 0.09769854072774181 9.253519074125254e-07 0.09698178745350861 9.25351983228664e-07 0.09638605854785212 9.253520652414071e-07 0.09574500473888557 \
9.253521469944435e-07 0.09510943278387665 9.253522375022672e-07 0.09440967388330095 9.253523270615645e-07 0.09372126988887708 9.253524126713984e-07 0.09306698857649189 \
9.253525054508964e-07 0.09236212353634379 9.25352586338857e-07 0.0917510971760913 9.253526874678274e-07 0.09099177263830999 9.253527679613525e-07 0.09039108594384238 \
9.253528522042178e-07 0.08976589684797046 9.253529260492651e-07 0.08922077348043934 9.253530028987433e-07 0.08865632925481931 9.253530910391124e-07 0.08801255002475737 \
9.253531711034815e-07 0.08743108261130086 9.253532641396716e-07 0.08675939571108145 9.253533821403849e-07 0.08591369538214398 9.253535245136123e-07 0.08490278100234279 \
9.253536687619621e-07 0.08388867104764453 9.253538110896711e-07 0.08289807427203813 9.253539606674147e-07 0.08186746790234835 9.253540969811606e-07 0.08093761126893445 \
9.253542391015918e-07 0.0799778356000513 9.253543736550197e-07 0.07907840240745091 9.253545140077296e-07 0.07814980287393705 9.253546616898023e-07 0.0771833418413561 \
9.253548118052992e-07 0.07621180464723754 9.253549765257764e-07 0.07515824360926991 9.253551401551281e-07 0.07412455432658185 9.25355314933688e-07 0.07303438636984133 \
9.253555021863042e-07 0.07188220095900363 9.253557122313081e-07 0.07060976590783831 9.253559304415311e-07 0.06930979572898451 9.253561638986196e-07 0.06794333957253913 \
9.253564187446379e-07 0.06648001693367038 9.253567118391949e-07 0.06483321328442151 9.253570141789572e-07 0.06317411115207273 9.253573287658326e-07 0.06148945259513613 \
9.253577250265267e-07 0.05942677493938087 9.253580587436718e-07 0.05774249301432461 9.253584660545011e-07 0.05574994498853819 9.253587939392599e-07 0.05419380357502902 \
9.253591506298989e-07 0.05254809000207299 9.253594638680598e-07 0.05114243792209583 9.25359766835193e-07 0.04981740498512215 9.253600643757184e-07 0.04854875663330436 \
9.253603431552737e-07 0.04739109061078805 9.253606261551692e-07 0.04624570307560639 9.253608878954772e-07 0.04521055793698023 9.253611671343698e-07 0.04413130357485813 \
9.253614392402902e-07 0.0431040186124033 9.253617466070471e-07 0.04197194005652995 9.25361968409948e-07 0.04117329707315532 9.253622748704282e-07 0.04009446155587663 \
9.253625010598812e-07 0.03931650950691581 9.253627399772065e-07 0.03851359500741255 9.253629644010393e-07 0.03777663690506906 9.253631666633204e-07 0.03712468825868943 \
9.253633677059489e-07 0.03648814235703791 9.253637194799833e-07 0.03540095449820539 9.253639697258209e-07 0.03464776841732944 9.253642160441007e-07 0.03392252499723709 \
9.253644973769646e-07 0.03311308780599518 9.253647404679504e-07 0.03242954897046491 9.253649759417007e-07 0.03178112583711486 9.25365217601206e-07 0.03113119522156456 \
9.253654544834836e-07 0.03050988948014832 9.25365685016041e-07 0.02991733361391674 9.253658989845686e-07 0.02937801894285819 9.253661049271158e-07 0.02886851641492237 \
9.253664976516027e-07 0.02792196059063811 9.253666857292829e-07 0.02747992420741849 9.253670611682488e-07 0.02661861215736662 9.253672360424774e-07 0.02622659266649364 \
9.253676593654915e-07 0.02530049759795254 9.253677806148756e-07 0.02504150687334681 9.253682211765283e-07 0.02412433837770948 9.253683636746476e-07 0.02383402682615681 \
9.253686957281575e-07 0.02316883068419595 9.253688786936821e-07 0.02280879143785283 9.25369267997886e-07 0.02205689891561978 9.253694363435941e-07 0.02173705378531499 \
9.253699084579932e-07 0.02085107653961301 9.253700482027269e-07 0.0205916297664938 9.253705437828048e-07 0.01969297428531048 9.253706710082374e-07 0.01946923320191776 \
9.253712389173419e-07 0.01851512288677271 9.253714031712902e-07 0.0182513999453204 9.253720130430285e-07 0.0173209960017622 9.253721727282571e-07 0.01708922829277545 \
9.253726996397978e-07 0.01635462467776483 9.253729041570907e-07 0.01608193551804103 9.253736276344778e-07 0.01515939662837778 9.253737930766099e-07 0.01495683325581705 \
9.253745396363563e-07 0.01408081084911163 9.253746729395688e-07 0.01393008075245666 9.253755331241552e-07 0.01299799962960837 9.2537566920557e-07 0.01285670227674402 \
9.253766097994594e-07 0.01192267652923807 9.253767735725333e-07 0.01176632439256516 9.253777747514646e-07 0.01084959205883911 9.253779122291872e-07 0.01072929995296418 \
9.253790829267985e-07 0.009787962024485789 9.253791753231659e-07 0.009718668544398181 9.253805933990138e-07 0.008725931027897449 9.253806803751621e-07 0.00866912727384293 \
9.253822213707925e-07 0.00770199130002063 9.253823306868067e-07 0.007633428668288294 9.253839739346292e-07 0.006673746291950173 9.253841067919082e-07 0.006603544020797993 \
9.253862011722062e-07 0.005605323336654431 9.25386409576941e-07 0.00551468736035817 9.25388763913366e-07 0.004577307911602986 9.253892374721227e-07 0.004407121484391641 \
9.253921229089795e-07 0.003492041675788492 9.253926525733264e-07 0.00334538389506189 9.253968608005519e-07 0.00237996320858989 9.253973742348033e-07 0.002283557532494709 \
9.254031334854955e-07 0.001325291758975802 9.254033680667128e-07 0.001279502680325907 9.254180358940879e-07 0.0002809017338477542 9.2541814896418e-07 0.0002788534805396912 \
9.280551690439302e-07 -0.0006849217749926401 9.280553352056057e-07 -0.0009443270389602415 9.28055814074993e-07 -0.001850320037528519 9.280559067946197e-07 -0.002050462221988249 \
9.280562720196971e-07 -0.002913187630468476 9.280563636768137e-07 -0.00314709230904735 9.280567297831652e-07 -0.004133001189868674 9.280568399302907e-07 -0.004442309109773816 \
9.280571506685428e-07 -0.005311341427314526 9.280572524071878e-07 -0.005583925258601597 9.280576161113131e-07 -0.00638370916272213 9.280577809576364e-07 -0.006585924750287024 \
9.280583607549565e-07 -0.005792290386912202 9.280585355894154e-07 -0.004916934050781314 9.280586522790152e-07 -0.00413641027497409 9.280587787087076e-07 -0.00310656561120747 \
9.280588807309105e-07 -0.002137079422087956 9.280590005773929e-07 -0.0008406209844352954 9.280590912146293e-07 0.0002489246187367611 9.280591896346795e-07 0.001536790859923857 \
9.280592893583236e-07 0.002948496343048522 9.280594568423325e-07 0.005545701385567424 9.280596754209339e-07 0.009327395936412004 9.280598614912559e-07 0.0128572688386996 \
9.280600828738638e-07 0.01737012273305725 9.280602435339974e-07 0.02082840415615294 9.280604069996469e-07 0.02447866954313523 9.280605576351642e-07 0.02794359528291388 \
9.280607066909169e-07 0.03145289236167962 9.280608561536706e-07 0.03504014479003619 9.280610101846836e-07 0.03879791952579481 9.28061172300943e-07 0.04280891157365373 \
9.280613383304076e-07 0.04696567134311741 9.280615142832281e-07 0.05141478668696391 9.280616949538655e-07 0.05602187592747932 9.280618867748118e-07 0.06094655248807559 \
9.280620938803163e-07 0.06629309753158302 9.280623154520462e-07 0.07203901748582854 9.280625501862155e-07 0.07814662931008168 9.280628017257828e-07 0.08470684589377442 \
9.280630771678493e-07 0.09190125212984442 9.280633773636675e-07 0.09974607960254324 9.280637082958778e-07 0.108390578238945 9.280640839626117e-07 0.1181923833971668 \
9.280644815454798e-07 0.1285487285136021 9.280649483700824e-07 0.1406786766767902 9.280654913626172e-07 0.1547396794802719 9.280661247876399e-07 0.1710742296429572 \
9.280668207276906e-07 0.1889259607126788 9.280676362848004e-07 0.2097135943149445 9.280685463129037e-07 0.2327316641523666 9.280693395691243e-07 0.2526372689279454 \
9.280700450441999e-07 0.2702038474981599 9.280706639884678e-07 0.2855008995781749 9.280712310944078e-07 0.2994177966724069 9.280717541744141e-07 0.3121574438576628 \
9.280722531532068e-07 0.3242197130846058 9.280727371932143e-07 0.3358335658028451 9.280731924200472e-07 0.3466679577370423 9.280736669320091e-07 0.3578644504627745 \
9.280741068407172e-07 0.368158604789619 9.28074592685345e-07 0.3794271463718566 9.280751242881185e-07 0.3916316501999784 9.280756269514167e-07 0.4030538969706937 \
9.280760560236697e-07 0.4127111343288326 9.280765470403381e-07 0.4236561147984291 9.280770484704186e-07 0.434714731975362 9.280773950150088e-07 0.442288187401736 \
9.280777504243856e-07 0.4500000616404133 9.280781776521143e-07 0.4592019891792938 9.280785698516369e-07 0.4675774400278049 9.280788702333951e-07 0.4739448723400065 \
9.280792120451548e-07 0.4811381049525967 9.280795554849688e-07 0.4883107756756314 9.280798162200955e-07 0.4937186470393492 9.280800582500485e-07 0.4987071765458648 \
9.280803241952914e-07 0.5041573145298286 9.280805814645868e-07 0.509394255416739 9.280807715836905e-07 0.5132422368582924 9.280809851098511e-07 0.5175451019736222 \
9.280811248001571e-07 0.5203466115392713 9.280812710004491e-07 0.5232668091041763 9.280814849883501e-07 0.5275186200231483 9.280816930046097e-07 0.5316389396023125 \
9.28081885465879e-07 0.5354321131715788 9.280820705821105e-07 0.5390651926504321 9.280822449555567e-07 0.5424725330931349 9.280825494976333e-07 0.5484058192982523 \
9.280828100565151e-07 0.5534602958276967 9.280831114875445e-07 0.5592859190791987 9.28083365805138e-07 0.5641865993769294 9.280836586613278e-07 0.5698153316805189 \
9.280839178744798e-07 0.5747800306938655 9.280841889508118e-07 0.579963273174682 9.280844307945713e-07 0.5845680738798381 9.280846882997289e-07 0.5894577538325241 \
9.280849150436047e-07 0.5937419314630586 9.280851520444243e-07 0.5982006324572362 9.280853622309862e-07 0.6021379329905048 9.280855749915204e-07 0.6061060319396779 \
9.280858278702861e-07 0.6107954169450593 9.280860315335544e-07 0.6145509252949414 9.280862222509359e-07 0.6180531102377972 9.280864095873744e-07 0.6214768531423983 \
9.28086598465652e-07 0.6249070011644339 9.280868066654473e-07 0.6286671070650327 9.280870509975622e-07 0.6330499453121026 9.280872505640949e-07 0.6366057789565548 \
9.280874547098357e-07 0.6402215701419991 9.2808763934909e-07 0.643474671963314 9.28087908884781e-07 0.6481901084955864 9.280881365916373e-07 0.652149230294136 \
9.280883242633752e-07 0.6553888277830079 9.280885051635201e-07 0.6584949378977958 9.280886647046018e-07 0.661221510907812 9.280888351670024e-07 0.6641177016088209 \
9.280889869184431e-07 0.6666817235716488 9.28089124561455e-07 0.6689905419339194 9.280892735563185e-07 0.6714784915997724 9.280894012981823e-07 0.6736028790357499 \
9.28089544284695e-07 0.675968899142866 9.280896660677513e-07 0.6779749688503388 9.28089802351161e-07 0.6802121872853304 9.280899221800626e-07 0.682172759947357 \
9.280900687756233e-07 0.6845626218370968 9.280901872485649e-07 0.6864845934661837 9.280902831819268e-07 0.6880368302455475 9.280903757015115e-07 0.6895284278106264 \
9.280904807620224e-07 0.6912169000724893 9.280905788439078e-07 0.6927871490736753 9.280907159592253e-07 0.6949707622226827 9.280908351578679e-07 0.6968607547931925 \
9.280909450978383e-07 0.6985951241089645 9.280910825970815e-07 0.7007503743809057 9.280912140269831e-07 0.7027960765825516 9.280913462564986e-07 0.7048392108129343 \
9.280914594338973e-07 0.7065756917706891 9.280916138667517e-07 0.708927873976708 9.280917446467452e-07 0.7109048231498766 9.280918673154548e-07 0.7127465601965561 \
9.280919735837112e-07 0.7143329262278221 9.280920959637349e-07 0.7161490373358268 9.280921978172318e-07 0.7176517022913665 9.280923319551315e-07 0.7196190116794019 \
9.280924526481716e-07 0.7213783352064487 9.280925717899705e-07 0.7231049829175343 9.280926968079845e-07 0.7249059312823601 9.280928266477907e-07 0.7267645120560844 \
9.280929464599616e-07 0.7284691779696002 9.280930754532131e-07 0.730293808329565 9.280932075602773e-07 0.7321507998840678 9.280933258660953e-07 0.7338038328985433 \
9.280934691267862e-07 0.7357927618453034 9.280935715814729e-07 0.7372070005703254 9.280936677883586e-07 0.7385290937783453 9.280937728059803e-07 0.7399656334130889 \
9.280938835775113e-07 0.7414708009413548 9.280939852560522e-07 0.7428439364018735 9.280940882175066e-07 0.7442258341871242 9.280942051436606e-07 0.7457850038572696 \
9.280943339039365e-07 0.747489965072781 9.28094435062908e-07 0.7488201182152049 9.280945839319522e-07 0.7507626302114226 9.280947316114891e-07 0.75267249971878 \
9.280948509768551e-07 0.7542038164026367 9.280949974606995e-07 0.7560679527984652 9.280951206361903e-07 0.7576223900169708 9.280952614398645e-07 0.7593848990234215 \
9.28095398032531e-07 0.7610800595258669 9.280955201903811e-07 0.7625841275516777 9.280956328467787e-07 0.7639610711610054 9.280957745729197e-07 0.7656796138775311 \
9.280959007394197e-07 0.767196844592689 9.280960161567243e-07 0.768574452686535 9.280961464649039e-07 0.7701179991486644 9.280962621775718e-07 0.7714782821591826 \
9.280963850018603e-07 0.7729116492687436 9.280965028461285e-07 0.7742769236963016 9.280966084761185e-07 0.7754922619072108 9.280967238495534e-07 0.7768108638983861 \
9.280968291127158e-07 0.7780056027231214 9.28096940062529e-07 0.7792565499870431 9.280970264670305e-07 0.7802246528436213 9.280971305008506e-07 0.7813823422463088 \
9.28097244396594e-07 0.7826398494046257 9.280973474300135e-07 0.7837684443710583 9.280974555127141e-07 0.7849432998269023 9.280975637643696e-07 0.7861107422109641 \
9.280976991816163e-07 0.7875582910536544 9.280978118557238e-07 0.7887521292973186 9.280979362797841e-07 0.7900592323105087 9.28098054252648e-07 0.7912877959129118 \
9.280981987206026e-07 0.7927781272271259 9.280983163897418e-07 0.7939806363584788 9.280984522695815e-07 0.7953567374150946 9.280985870139538e-07 0.7967081403609936 \
9.280986980849332e-07 0.7978123285366109 9.280987979742732e-07 0.7987978371087655 9.280988996542305e-07 0.7997937268659365 9.28099032867897e-07 0.8010867894381996 \
9.280991512407162e-07 0.8022243628210853 9.280992727817904e-07 0.8033812848148773 9.280993921454423e-07 0.8045065422543012 9.280995132768187e-07 0.80563739819571 \
9.28099644976236e-07 0.8068544426691319 9.280997679845129e-07 0.8079795872959963 9.280998958281203e-07 0.8091371804586788 9.281000267346398e-07 0.8103101881504271 \
9.281001503277979e-07 0.8114062915203997 9.28100257500303e-07 0.8123479140825919 9.281003649295023e-07 0.8132835730547656 9.281004475986205e-07 0.8139979974227743 \
9.281005653103806e-07 0.8150069815425507 9.281006559159858e-07 0.8157770472204025 9.281007865694307e-07 0.8168774959419571 9.28100930959301e-07 0.8180800468042847 \
9.281010641337151e-07 0.8191766687328477 9.281011740251065e-07 0.8200725423139092 9.281013176239916e-07 0.8212302325252553 9.281014710146833e-07 0.8224508494407716 \
9.281015990929081e-07 0.8234574467428303 9.281017388802764e-07 0.8245431382086058 9.281018651298391e-07 0.8255122018650548 9.281020197283917e-07 0.8266841987320058 \
9.281021519393684e-07 0.8276738265999063 9.281022781661507e-07 0.8286078934539939 9.281023959138743e-07 0.8294698388787296 9.281025449866676e-07 0.8305480062617677 \
9.281027123182206e-07 0.8317406852496945 9.281028455394968e-07 0.8326770812274722 9.281030183208195e-07 0.8338744310092966 9.281031868261935e-07 0.8350236380668206 \
9.281033562054924e-07 0.8361608866600232 9.281035378407611e-07 0.8373606451951652 9.281036801740827e-07 0.8382866867625347 9.281037940110689e-07 0.8390185116470331 \
9.28103925192579e-07 0.8398522525089582 9.28104026724794e-07 0.8404903982372576 9.281041430090543e-07 0.8412135669902132 9.281042776438077e-07 0.8420406924792603 \
9.281044746666439e-07 0.8432316292878405 9.281046647721864e-07 0.8443592803112207 9.281048748954985e-07 0.8455816023960827 9.281050552136042e-07 0.8466107566581813 \
9.281052526767047e-07 0.8477171937062282 9.281054267458195e-07 0.8486750118570332 9.2810560906524e-07 0.8496608982186138 9.281057804803757e-07 0.8505716849290491 \
9.281059545936528e-07 0.8514808063694008 9.281061303246211e-07 0.8523822271368225 9.281063064363213e-07 0.8532696099472232 9.281064960541732e-07 0.8542074684498208 \
9.281066868356705e-07 0.8551330189126392 9.281068884317469e-07 0.8560917259710515 9.281070811660049e-07 0.856990088884472 9.281072900378257e-07 0.8579439907476532 \
9.281075207402632e-07 0.8589743400177088 9.281077851832272e-07 0.8601259267840322 9.281080840059149e-07 0.8613896125360476 9.281083639602158e-07 0.8625380186322354 \
9.281086480860817e-07 0.8636694076724545 9.281089228550569e-07 0.8647317823994775 9.281091947122167e-07 0.8657531067718063 9.281094650893342e-07 0.8667403371654003 \
9.281097221678555e-07 0.8676533221001362 9.281099947926866e-07 0.868594905839151 9.281102707598356e-07 0.8695208838709013 9.281105408640932e-07 0.8704012674911344 \
9.281108407401039e-07 0.8713491368600049 9.281112118011625e-07 0.8724801680184872 9.2811150674079e-07 0.8733472453740196 9.281117610365479e-07 0.8740729094291386 \
9.281120592974738e-07 0.8748989982677786 9.281123329040153e-07 0.8756336613858092 9.281125690299577e-07 0.876250392688866 9.281128093740557e-07 0.8768621356511911 \
9.281130317061817e-07 0.8774140071409635 9.28113225712247e-07 0.8778848105679672 9.281135554349973e-07 0.8786625669521169 9.281137106085255e-07 0.8790190643519731 \
9.281140283876062e-07 0.879730644938159 9.281142072488645e-07 0.8801204696806418 9.28114549710761e-07 0.8808457867651537 9.28114733837363e-07 0.8812245477320809 \
9.281152087119419e-07 0.8821665346129511 9.281153761083518e-07 0.8824869809105039 9.281158419518538e-07 0.883348261932613 9.281160227735482e-07 0.8836708855253055 \
9.281165168126507e-07 0.8845204537290557 9.28116658162059e-07 0.8847551796839913 9.281172645001219e-07 0.8857215808967022 9.281174165693362e-07 0.8859539944113424 \
9.281180632563559e-07 0.8869009218298172 9.281181915512386e-07 0.8870812460539503 9.28118839667745e-07 0.8879562712787433 9.281189694676407e-07 0.8881245027440973 \
9.281197476783404e-07 0.8890830197250962 9.281198627254718e-07 0.8892171882189283 9.281207183963142e-07 0.8901564861234483 9.281208637440773e-07 0.8903061494816453 \
9.281218494996487e-07 0.8912466483555094 9.281220706077111e-07 0.8914402669210102 9.281232157277145e-07 0.892367747196105 9.281233469391586e-07 0.8924695935232408 \
9.281246882116238e-07 0.8934615053489913 9.281248396029001e-07 0.8935661991834861 9.281263210551204e-07 0.8944951400107031 9.28126559934816e-07 0.8946288932334222 \
9.281283293566538e-07 0.895502508848118 9.281287184779452e-07 0.895670668133377 9.281311122106538e-07 0.8965556062201232 9.281315877505925e-07 0.8967047758494365 \
9.281356508198176e-07 0.8977025964496719 9.281361422956534e-07 0.8977953148389237 9.281444588927962e-07 0.8987880790885289 9.281453787942481e-07 0.8988514070442593 \
9.282992423701678e-07 0.8998485708192639 9.283028854964575e-07 0.8998628537402877 9.285296142766716e-07 0.8989664306490068 9.285298446165833e-07 0.8988008565867064 \
9.285314595368805e-07 0.897804750401333 9.285316372691665e-07 0.8977103535805105 9.285484036692715e-07 0.8986978311584225 9.285485397684024e-07 0.8987160394686986 \
9.285637106086718e-07 0.8997133888183054 9.285639877135077e-07 0.899719468756186 9.290480289064218e-07 0.9005852143835333 9.290482022410387e-07 0.9007408621809421 \
9.290488627306383e-07 0.9015135064485434 9.290490287958205e-07 0.9017527716291757 9.29049555130528e-07 0.9026184054967997 9.290497462444475e-07 0.9029704910143604 \
9.290501104654996e-07 0.9036902342402512 9.290502896649214e-07 0.9040628043424317 9.290506515515937e-07 0.9048333795345931 9.290508466611638e-07 0.9052442844328937 \
9.290513790595253e-07 0.9062266394381637 9.290515614131638e-07 0.9064623886473868 9.29052553393556e-07 0.905594670761786 9.290527149341233e-07 0.9049318860608667 \
9.290528829265756e-07 0.9040378649110347 9.290530427580612e-07 0.9029782421366458 9.29053180254799e-07 0.9018984154159868 9.290533131621115e-07 0.9007052793196499 \
9.290534395875788e-07 0.8994328447569792 9.290535469868187e-07 0.8982475863895881 9.290536514834769e-07 0.8970047013543965 9.290537655331467e-07 0.8955451342423859 \
9.290538555027343e-07 0.8943225684615312 9.290539603213725e-07 0.8928208677113324 9.290540497696118e-07 0.891473284704788 9.290541321453925e-07 0.8901820884368528 \
9.290542232383925e-07 0.8887006634027688 9.290543605744706e-07 0.8863657732814155 9.290544590674026e-07 0.8846195012157601 9.290545711411527e-07 0.8825649218508906 \
9.290547020241858e-07 0.880080778639088 9.290548384952159e-07 0.8774018563482072 9.290549919493788e-07 0.8742910281085086 9.290551510437468e-07 0.8709679977889497 \
9.290553153276494e-07 0.867445283300377 9.290554719957506e-07 0.8640104344288071 9.290556240865311e-07 0.860615744772629 9.290557778002063e-07 0.857132398554192 \
9.290559373623813e-07 0.853469801378647 9.290560924510828e-07 0.8498714074018293 9.290562661304016e-07 0.8458039138600054 9.290564291612693e-07 0.8419559450883216 \
9.290565908036839e-07 0.8381170660338335 9.290567534504205e-07 0.8342344554797501 9.290569148689274e-07 0.8303657475978833 9.29057083463406e-07 0.8263109424305363 \
9.290572663565042e-07 0.8219002364007665 9.290574341852181e-07 0.8178440888239877 9.290576024710332e-07 0.8137703061148112 9.290577732990846e-07 0.8096302849976138 \
9.290579454736421e-07 0.8054541271740473 9.29058113235561e-07 0.8013830614994394 9.290582968650184e-07 0.7969255463994016 9.290584682714962e-07 0.7927646873948894 \
9.290586537148024e-07 0.7882638003278283 9.290588203854536e-07 0.7842196820467244 9.290589892715847e-07 0.7801233737411432 9.290591734278818e-07 0.7756572567105651 \
9.290593680379105e-07 0.7709405333854473 9.290595152932413e-07 0.7673736106648734 9.29059641923832e-07 0.7643079795643375 9.290597837806442e-07 0.7608754495129878 \
9.29059888184422e-07 0.7583505812556488 9.290600205770739e-07 0.7551502542766809 9.290601301612704e-07 0.7525028097975122 9.290602633259231e-07 0.7492875979647342 \
9.290604195076851e-07 0.7455190770546114 9.290605327371121e-07 0.7427887939149777 9.290606952584763e-07 0.7388718945951063 9.290608674392915e-07 0.7347246296492568 \
9.290610634440439e-07 0.7300078517193382 9.290612278340228e-07 0.7260553905833119 9.290613802307036e-07 0.7223944885043934 9.290615439058578e-07 0.718466402706526 \
9.290617118315579e-07 0.7144406657912139 9.290618916719357e-07 0.7101336212543717 9.29062067965886e-07 0.7059164985576465 9.290622390405214e-07 0.7018286413152719 \
9.29062407358697e-07 0.6978099102718778 9.290625606248286e-07 0.6941537154717222 9.290627225083983e-07 0.6902960245155986 9.290629014599385e-07 0.6860364417190952 \
9.290630356714899e-07 0.6828448068431195 9.290631391777877e-07 0.6803854168085423 9.290632384622004e-07 0.6780286039046017 9.290633399166766e-07 0.6756220912380299 \
9.290634323732756e-07 0.6734303711245889 9.29063516962075e-07 0.6714267031582685 9.290636105394115e-07 0.6692114082407524 9.290637270816306e-07 0.6664546942583044 \
9.290638365591918e-07 0.6638675763958631 9.29063949672203e-07 0.6611971533414394 9.290640727909702e-07 0.6582923426231613 9.290641970172829e-07 0.6553636581362478 \
9.290643677774271e-07 0.6513432847262797 9.290645262260144e-07 0.6476181700514572 9.290646985138371e-07 0.6435738126612673 9.290648444919037e-07 0.6401512360303271 \
9.290649862851197e-07 0.6368325564797357 9.290651178835739e-07 0.6337564355289309 9.290652480468588e-07 0.630718219665797 9.290653735717995e-07 0.6277924818644975 \
9.290655053547071e-07 0.6247239543970449 9.290656352782026e-07 0.6217046839485236 9.290657715867779e-07 0.6185408917806742 9.290659162003453e-07 0.615188962872713 \
9.290660756925359e-07 0.611499189008522 9.290662491526524e-07 0.6074939486938447 9.290664201599544e-07 0.6035554342946753 9.290666515285226e-07 0.5982402936372396 \
9.290668949905284e-07 0.5926661367297537 9.29067069111016e-07 0.5886942528256315 9.290672153830934e-07 0.5853638081576373 9.290673497553115e-07 0.58231230528805 \
9.290674668502066e-07 0.5796585826255305 9.290675626145531e-07 0.5774900935424465 9.290676614610954e-07 0.5752566196463251 9.290677454384142e-07 0.5733628024369305 \
9.290678230524635e-07 0.571614165956722 9.290678843779373e-07 0.5702331258704825 9.290679490585755e-07 0.5687779664863769 9.290680303667114e-07 0.5669528575016536 \
9.290680804367073e-07 0.5658306078972934 9.290681297572688e-07 0.5647256890740617 9.29068191677069e-07 0.5633393552914843 9.290682395088942e-07 0.5622690492396486 \
9.290682900136796e-07 0.5611395143522533 9.290683500757169e-07 0.559799205480933 9.290684093585124e-07 0.5584782058326896 9.290684844152261e-07 0.5568072508052372 \
9.290685540978827e-07 0.5552574373576753 9.290686396864491e-07 0.5533559356568912 9.290687267538207e-07 0.5514265885063823 9.290688104163413e-07 0.5495763264044081 \
9.290688965613662e-07 0.5476734676082877 9.290689922659868e-07 0.5455621222678217 9.290690965509387e-07 0.5432673229847179 9.290692112181133e-07 0.5407497407899529 \
9.290693199365744e-07 0.5383664115638558 9.290694295088142e-07 0.5359693749054023 9.290695418135745e-07 0.5335193270114367 9.290696685891956e-07 0.530759392645703 \
9.290697908664272e-07 0.5281021910076299 9.290699309524048e-07 0.5250685463469849 9.290700679697626e-07 0.5221084647952599 9.290702182711349e-07 0.5188705764247719 \
9.29070377166376e-07 0.5154582091324615 9.290705515002589e-07 0.5117250894133971 9.29070738517481e-07 0.5077378180012799 9.290709438354859e-07 0.5033745272871338 \
9.290711556776788e-07 0.498891131759938 9.29071408479721e-07 0.4935662239713107 9.290716105673699e-07 0.4893264048484654 9.290718451606752e-07 0.4844277613141263 \
9.290720812752721e-07 0.4795194943790256 9.290723344517689e-07 0.474283574581623 9.290726449817317e-07 0.4679020429045382 9.290728630397102e-07 0.4634451779596257 \
9.290730364853443e-07 0.4599153839204358 9.290732129777809e-07 0.4563351808422506 9.290734924595774e-07 0.4506930409909046 9.290737247034844e-07 0.4460279192631412 \
9.290740117970731e-07 0.44029020239849 9.290742296431808e-07 0.435960758243863 9.290744396957687e-07 0.4318042429497612 9.290746408936045e-07 0.4278406951573778 \
9.290748233137655e-07 0.4242617300271556 9.290749972087507e-07 0.4208637793449936 9.290751620728668e-07 0.4176529694331993 9.290753208268398e-07 0.4145718140694327 \
9.290754870737866e-07 0.4113577680628809 9.290756357189934e-07 0.4084923702366076 9.29075788087249e-07 0.4055658186126443 9.290759301504317e-07 0.4028468403491589 \
9.290760995263099e-07 0.3996150665462138 9.290762199082301e-07 0.3973276483660343 9.290763298814939e-07 0.3952449223617059 9.290764448068948e-07 0.3930732253581283 \
9.290765970484751e-07 0.3902080468194818 9.290767092695403e-07 0.3881039677199808 9.290768164620408e-07 0.386098874836553 9.290769689902896e-07 0.383254723448244 \
9.290770971374193e-07 0.380874963946598 9.290772199854116e-07 0.3786015923730871 9.290773990837881e-07 0.375299968600122 9.290775481684202e-07 0.3725653942578417 \
9.290777158758077e-07 0.3695018296724824 9.290778712734425e-07 0.3666748141177644 9.290779954402882e-07 0.3644243980538668 9.290781093321555e-07 0.3623666676050148 \
9.290782307755259e-07 0.3601804966264144 9.290784109272934e-07 0.3569532670533712 9.290785774151135e-07 0.3539878629329621 9.290787678342229e-07 0.3506138544217919 \
9.290789595908185e-07 0.3472380408565978 9.29079142640212e-07 0.344035729794033 9.290792916122767e-07 0.3414435189591631 9.290794115521822e-07 0.3393660536257183 \
9.290795342136651e-07 0.3372483242714233 9.290796572441513e-07 0.3351324902755385 9.29079802148562e-07 0.3326515017845288 9.290799054613373e-07 0.3308907757076019 \
9.290799991908464e-07 0.3292979229163631 9.290800898511484e-07 0.3277620998585528 9.29080200972602e-07 0.3258853746017661 9.290803081455789e-07 0.3240820510456246 \
9.290804064202303e-07 0.3224338250618513 9.290805188247763e-07 0.3205545940512134 9.290806827646764e-07 0.3178277446588927 9.290808444025551e-07 0.3151576097143818 \
9.290809921893013e-07 0.3127316247504084 9.290811544345159e-07 0.3100832165115083 9.290813144650734e-07 0.3074868334344322 9.290814667283717e-07 0.3050304870660137 \
9.290816201002421e-07 0.3025703731928215 9.29081778808771e-07 0.3000411640344692 9.290819432578998e-07 0.297437246442505 9.290821104849764e-07 0.2948063590562646 \
9.290822635965136e-07 0.292412731930112 9.290824466944405e-07 0.2895700146919417 9.290826370021783e-07 0.2866380344427262 9.290827859052364e-07 0.2843603072871506 \
9.290829598425416e-07 0.2817165165722222 9.290831367199302e-07 0.2790484233348025 9.290832843171486e-07 0.2768363681311815 9.290834739488486e-07 0.2740172295061162 \
9.290836239507675e-07 0.2718052906662373 9.290837610609577e-07 0.2697943906627059 9.290839025914007e-07 0.2677397479842996 9.290840160502698e-07 0.2661005451260196 \
9.290841523405964e-07 0.2641384584581135 9.290842824172175e-07 0.2622807416655737 9.290844006714701e-07 0.2606037730704709 9.290845185270662e-07 0.2589348966568543 \
9.290846494208768e-07 0.2570853888657079 9.290847896596348e-07 0.2551145527343576 9.290849051542211e-07 0.2534976852533538 9.290850340055979e-07 0.2516957519945816 \
9.290851491515796e-07 0.2500885525459272 9.290853024625469e-07 0.2479513765689386 9.290854403163083e-07 0.2460367343642474 9.290855797779604e-07 0.2441002375748529 \
9.290857352458149e-07 0.2419427021952501 9.290858600284303e-07 0.2402176526454788 9.290859998933384e-07 0.2382916534360561 9.290861285955143e-07 0.2365220787132559 \
9.290862495543662e-07 0.234860341242685 9.290863665996657e-07 0.2332541163798121 9.290864926007302e-07 0.2315368940272461 9.290865893203229e-07 0.2302195772445239 \
9.290866814091961e-07 0.2289683907689286 9.290867958266674e-07 0.2274152998827935 9.29086894197314e-07 0.2260807986508055 9.290870113441077e-07 0.2244933520241092 \
9.290871144352256e-07 0.2231010305483718 9.290872199499517e-07 0.2216798666278746 9.290873008680116e-07 0.2205933880575098 9.290873745391968e-07 0.2196046443759679 \
9.290874172684338e-07 0.2190314036349237 9.290874603985789e-07 0.2184540235451489 9.290875111960606e-07 0.217774515685755 9.290875483709393e-07 0.217277430841393 \
9.29087589041954e-07 0.2167338127731004 9.290876318337554e-07 0.2161620985357572 9.29087668244897e-07 0.2156758299561118 9.290877101698877e-07 0.2151161507306283 \
9.290877647120985e-07 0.2143884526296278 9.290878031708564e-07 0.2138756926875936 9.290878427976257e-07 0.2133496230586122 9.290879046301276e-07 0.212531488259555 \
9.290879663565786e-07 0.2117156525305126 9.290880224938542e-07 0.210974237875411 9.290880861490836e-07 0.210134110843225 9.290881802401171e-07 0.2088936328424611 \
9.290882670483761e-07 0.2077505933124353 9.290883610050201e-07 0.2065146061917991 9.290884590472537e-07 0.2052266823513323 9.290885606346195e-07 0.2038976009052371 \
9.290886615435679e-07 0.2025832113009377 9.290887582793767e-07 0.2013244528083448 9.290888604043477e-07 0.1999972806373927 9.290889637359054e-07 0.1986583046056677 \
9.290890736185069e-07 0.1972379690671278 9.290891825607647e-07 0.1958337611883887 9.290893023958846e-07 0.1942937175364915 9.290894126797513e-07 0.1928822800638286 \
9.290895205584963e-07 0.191507108810815 9.290896466212543e-07 0.1899051957406391 9.290897364889607e-07 0.1887671190866151 9.290898469672999e-07 0.1873723090993208 \
9.290899245002487e-07 0.1863971337376019 9.290900088239918e-07 0.1853400660204312 9.2909009641205e-07 0.1842452710069853 9.290901842046441e-07 0.18315095174413 \
9.290902659245155e-07 0.1821357652581398 9.290903634861928e-07 0.1809282658474054 9.29090470197344e-07 0.1796118512064394 9.29090570679026e-07 0.178377576484793 \
9.290906948502375e-07 0.1768595317522179 9.290908287417607e-07 0.1752320886156309 9.290909476539533e-07 0.1737937102924047 9.290910980541468e-07 0.1719851742607024 \
9.290912088892401e-07 0.1706594030660365 9.29091348655982e-07 0.168997130456427 9.290914671812901e-07 0.1675953052211382 9.29091572608521e-07 0.1663548750207849 \
9.290916673183802e-07 0.1652455210322802 9.290917606281543e-07 0.1641568522804657 9.290918615342704e-07 0.1629842804551663 9.290919569521023e-07 0.1618800504313296 \
9.290920541430254e-07 0.1607598891027116 9.29092135704507e-07 0.1598237474547246 9.290922410209518e-07 0.1586229753023833 9.290923245006587e-07 0.1576763029943549 \
9.290924260299495e-07 0.1565306813704828 9.290925032604858e-07 0.1556635090415242 9.290925941325229e-07 0.154647919213242 9.290926634838334e-07 0.1538765336840219 \
9.290927480678846e-07 0.1529397840535594 9.290928224610911e-07 0.1521208717489242 9.290929018312932e-07 0.151251902275755 9.290929764189645e-07 0.1504388356812226 \
9.290930456405211e-07 0.1496871728711989 9.290931403213281e-07 0.1486640077242138 9.290932100870929e-07 0.1479134441579097 9.290932945316557e-07 0.147008717574758 \
9.290933560970015e-07 0.1463518850554192 9.290934301394932e-07 0.1455673550676988 9.290935035250168e-07 0.1447940960774066 9.290935849602585e-07 0.1439395015691976 \
9.290936544094048e-07 0.1432139999234875 9.290937295111024e-07 0.1424323701137583 9.290938194231735e-07 0.1415006120834361 9.290938965067932e-07 0.1407052977810757 \
9.290939956173774e-07 0.1396885207473417 9.290940651574398e-07 0.138983077430453 9.290941464759156e-07 0.1381612812129989 9.290942166443246e-07 0.1374549162714094 \
9.290942956124377e-07 0.1366629455350578 9.290943745907204e-07 0.1358740351737466 9.290944469125105e-07 0.1351544405911459 9.290945162779691e-07 0.1344667589602006 \
9.290945649819766e-07 0.1339854049281765 9.290946557443483e-07 0.1330945614011112 9.290946877658758e-07 0.1327823711724506 9.290947758698441e-07 0.131925672678654 \
9.290948083638863e-07 0.1316105445757083 9.290949070315436e-07 0.1306564447580443 9.290949506875193e-07 0.130235859061297 9.290950286693357e-07 0.1294866595045693 \
9.290950660002936e-07 0.1291289430202982 9.290951681516938e-07 0.128153223240932 9.290952355956539e-07 0.1275115375392494 9.290953007486116e-07 0.1268935577290946 \
9.290953666546259e-07 0.1262729746041904 9.290954378066092e-07 0.1256052797936485 9.290955207439704e-07 0.1248293808775363 9.290956061394507e-07 0.1240331657139879 \
9.290956822268445e-07 0.1233259817834828 9.290957626875214e-07 0.1225806238777534 9.290958207714622e-07 0.1220441728027253 9.29095892104936e-07 0.1213870835332726 \
9.290959768933693e-07 0.1206085709991845 9.290960380484021e-07 0.1200487744399507 9.290961081348534e-07 0.1194096117168642 9.290961706401422e-07 0.1188419501154776 \
9.290962366450903e-07 0.1182453094891599 9.290963054178569e-07 0.1176255789053269 9.290963748744814e-07 0.1170017375875525 9.29096458038731e-07 0.1162574953874909 \
9.290965311562548e-07 0.1156056107435251 9.29096601870241e-07 0.1149774116339468 9.290966612219237e-07 0.1144518657417393 9.290967665191356e-07 0.1135239342411639 \
9.290968123866298e-07 0.1131212254602471 9.290968993406834e-07 0.1123603821649216 9.290969423544638e-07 0.1119852310621949 9.290969872212111e-07 0.1115947726395539 \
9.29097076954706e-07 0.1108164664143028 9.290971478390573e-07 0.110204256460374 9.290972266925708e-07 0.109525796983828 9.290972894703463e-07 0.1089876103666232 \
9.290973494647019e-07 0.1084750215669379 9.290974604624741e-07 0.1075310013968523 9.2909754121676e-07 0.1068475792877216 9.290976536800859e-07 0.1059005796323111 \
9.290977048246292e-07 0.1054717782906781 9.290977878097978e-07 0.1047785948356612 9.290978459745031e-07 0.1042945647727652 9.290979602125029e-07 0.1033482075721767 \
9.2909801011597e-07 0.1029366076865433 9.290980958575694e-07 0.1022320954501846 9.290981448890196e-07 0.1018307629303728 9.290982274554409e-07 0.101157455862875 \
9.290982983877772e-07 0.1005815064560546 9.290983665381274e-07 0.1000302812267231 9.290984441484433e-07 0.0994053199805509 9.290985164918144e-07 0.09882546240595018 \
9.29098594067778e-07 0.09820656846618626 9.290986827384393e-07 0.09750287271560702 9.290987565532272e-07 0.09692010793638871 9.290988381442348e-07 0.09627924899616347 \
9.290989162827031e-07 0.09566870926115327 9.290990020324936e-07 0.09500229249765579 9.290990897294021e-07 0.09432453920671229 9.290991836389667e-07 0.09360304191323381 \
9.290992800982851e-07 0.09286661217778783 9.290993587289458e-07 0.09226977907248698 9.290994614525455e-07 0.09149473120661993 9.290995452801958e-07 0.09086620530027881 \
9.290996660323776e-07 0.08996702094116031 9.29099795302029e-07 0.08901247130467421 9.290999511904931e-07 0.08787237469953549 9.291001062900762e-07 0.08675000010972149 \
9.291002633058824e-07 0.08562614142917294 9.291004433267347e-07 0.08435280068725284 9.291005938476015e-07 0.08330035525696428 9.291007422216237e-07 0.08227363395463329 \
9.291008798388548e-07 0.08133079092382095 9.291010197585049e-07 0.08038162993974078 9.291011563654933e-07 0.07946425488810546 9.291012950927907e-07 0.07854214404995859 \
9.291014404036529e-07 0.07758663187171365 9.29101588151466e-07 0.07662571164688473 9.291017467483332e-07 0.07560598447141591 9.29101911000851e-07 0.07456266320243836 \
9.291020800179273e-07 0.07350246718885647 9.291022619069209e-07 0.07237646636762114 9.291024625290194e-07 0.07115268999588262 9.291026764065622e-07 0.0698691158856425 \
9.291029040406938e-07 0.0685263410462881 9.291031456262355e-07 0.06712722147996912 9.29103427215414e-07 0.06552977831071743 9.291037243695345e-07 0.06388229915275011 \
9.291040478026115e-07 0.06213267023812474 9.291044389620309e-07 0.0600758559534558 9.29104840456333e-07 0.05803293250078725 9.291052173970595e-07 0.05617754872181892 \
9.291055845107909e-07 0.05442503025024555 9.291059346274713e-07 0.05280240270907886 9.291062539331247e-07 0.05136309724710254 9.291065582574072e-07 0.05002640192327024 \
9.291068551633125e-07 0.04875503464657577 9.291071371636386e-07 0.04757867888787161 9.291074175969432e-07 0.04643900623749339 9.291076823205669e-07 0.04538777697325767 \
9.291079582182789e-07 0.04431704973151576 9.291082326831432e-07 0.04327654260273706 9.291085311024235e-07 0.04217254828989973 9.291087576184799e-07 0.04135316230013186 \
9.291090695313176e-07 0.04025053053625379 9.291092897861088e-07 0.03948972371590862 9.291095070508635e-07 0.03875470657060948 9.291097167735126e-07 0.03806113111453101 \
9.291100269559001e-07 0.03705828856757609 9.291102495537778e-07 0.03635538859683734 9.29110496919279e-07 0.03559019656168042 9.291107693256555e-07 0.03476651972027592 \
9.291109899582094e-07 0.03411384091885184 9.291112742384597e-07 0.03329124852897781 9.291115121517525e-07 0.0326183788879464 9.291117502411636e-07 0.03195887699386461 \
9.291119854964916e-07 0.03132132139405813 9.291122142751986e-07 0.03071728735992773 9.291124470059478e-07 0.03011490821398154 9.291126663089891e-07 0.02955843195412813 \
9.291128702520595e-07 0.02905055018162466 9.291132691617956e-07 0.02808303002558106 9.291134563160508e-07 0.02764052191221165 9.29113828521772e-07 0.0267814187683372 \
9.29114015473295e-07 0.02635997027055515 9.291143848272416e-07 0.02554620807076183 9.291145384804101e-07 0.02521471147941385 9.291149546945643e-07 0.02434161493068329 \
9.291151601823807e-07 0.02392065165079968 9.291154991903412e-07 0.02323955384462723 9.291156818850693e-07 0.02287916718068597 9.291161389789784e-07 0.02199597290476789 \
9.291162687197143e-07 0.02174967209293581 9.291167221401377e-07 0.02089828923199067 9.291168645124299e-07 0.0206336680476187 9.291173940791905e-07 0.01967289368906444 \
9.291175202861975e-07 0.01945139161001456 9.291180825206353e-07 0.01850749734048266 9.29118245259022e-07 0.01824627541187189 9.291188094390871e-07 0.01738327200207762 \
9.291189611831539e-07 0.01716165742474803 9.291196628626382e-07 0.01618760396393164 9.291198329517282e-07 0.01596324388168 9.291204880096042e-07 0.01513221026437959 \
9.291206545239163e-07 0.01492874613340729 9.291213876376757e-07 0.01406966818047924 9.291215209008543e-07 0.01391906482409888 9.291223725580289e-07 0.01299647369571925 \
9.291225105004775e-07 0.01285324185793544 9.291234505599668e-07 0.0119198170026788 9.291236143216039e-07 0.01176347583728811 9.291246015550385e-07 0.01085909507266535 \
9.291247361441145e-07 0.0107410715025141 9.291258775835447e-07 0.009819907073012045 9.291259858224434e-07 0.009738548299709823 9.291273090698269e-07 0.00880579379490502 \
9.291274418155253e-07 0.008718202093769473 9.291289643166501e-07 0.007760835273143199 9.29129076858719e-07 0.007690148685505111 9.29130769150306e-07 0.00669558715138598 \
9.291309094168914e-07 0.00662113250846694 9.291329824261937e-07 0.005629132576249021 9.291331749877106e-07 0.005545002188831318 9.291353851975588e-07 0.004656096148610405 \
9.291357919842319e-07 0.004507219767123045 9.291386137242085e-07 0.003590578528330178 9.291391350199586e-07 0.00344214578404881 9.291433471210094e-07 0.002447529662748036 \
9.291438996838773e-07 0.002340875287107731 9.291497829734169e-07 0.001359168649576994 9.291500322464151e-07 0.001311490127959886 9.291631823674653e-07 0.0003136950974005476 \
9.291632991504353e-07 0.0003112730584132499 9.589900000000112e-07 3.042397160644726e-06 1.002746667027013e-06 -0.0009024818035526668 1.00274673944263e-06 -0.001022682652537627 \
1.002747175467347e-06 -0.001858525046639076 1.00274726236173e-06 -0.002046124893065343 1.002747617065043e-06 -0.00288168582347465 1.002747716611644e-06 -0.003135075204051477 \
1.002747976881348e-06 -0.003828199033013717 1.00274811720375e-06 -0.004216406518003108 1.002748344689832e-06 -0.004856871791621592 1.002748481897271e-06 -0.005239031028659006 \
1.00274886679612e-06 -0.006187559915121 1.002748998893307e-06 -0.006423332025500122 1.002749687336335e-06 -0.005917035979538006 1.002749844265069e-06 -0.005202654566481615 \
1.002749971914231e-06 -0.004414133290428114 1.002750099456021e-06 -0.003433350487145549 1.002750217130234e-06 -0.002355902309038119 1.00275031626992e-06 -0.001320627313728655 \
1.00275042165263e-06 -9.507383675133965e-05 1.002750535559933e-06 0.001369964538583592 1.002750666615328e-06 0.003229572948258866 1.002750791978547e-06 0.005172303930030842 \
1.002750983820411e-06 0.008432154569684791 1.002751127490204e-06 0.01107975669588844 1.002751285472017e-06 0.01417105828876112 1.002751434071664e-06 0.01723098336859398 \
1.002751587122593e-06 0.02051714008521248 1.002751746187569e-06 0.02405720796424875 1.002751899257778e-06 0.02756764950178633 1.002752047604842e-06 0.03105219347129199 \
1.002752196711284e-06 0.03462388853332505 1.002752351275713e-06 0.03838854885099419 1.002752511961677e-06 0.04235886888523473 1.002752676640863e-06 0.04647718198980624 \
1.002752853163807e-06 0.05093664320808645 1.002753032175606e-06 0.05549818742091989 1.002753222948448e-06 0.0603932190016783 1.0027534277958e-06 0.06567927942044927 \
1.002753648293053e-06 0.07139554989571946 1.002753881211021e-06 0.07745499876455469 1.002754130458799e-06 0.08395499695136356 1.002754403380327e-06 0.09108394918256098 \
1.002754700173383e-06 0.09884095133633181 1.002755027609895e-06 0.1073964775374675 1.002755397423695e-06 0.1170487607486894 1.002755792369975e-06 0.1273407304921971 \
1.002756250458528e-06 0.1392499850125259 1.002756782558388e-06 0.1530377249371455 1.002757408110397e-06 0.169180864038255 1.002758094102463e-06 0.1867931863309214 \
