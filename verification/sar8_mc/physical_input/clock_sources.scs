2.124384877632151e-06 0.7818078758210534 2.124384983459753e-06 0.7829735233300771 2.124385122825895e-06 0.7844949153190801 2.124385271897694e-06 0.786105286864636 \
2.124385419626362e-06 0.7876841235632186 2.12438553893224e-06 0.7889471147195867 2.124385672939052e-06 0.7903527806482344 2.124385793365227e-06 0.791604423795974 \
2.124385934910404e-06 0.7930616786923709 2.124386082336417e-06 0.7945638089648995 2.124386206810925e-06 0.7958198087139573 2.124386325854918e-06 0.7970105506108808 \
2.124386437445202e-06 0.7981174590942314 2.12438654267449e-06 0.7991530841216606 2.124386638185594e-06 0.8000862307887144 2.124386774247548e-06 0.8014036057482816 \
2.124386891123682e-06 0.8025237700417888 2.124387010277354e-06 0.8036549841722296 2.124387132589548e-06 0.8048050501807249 2.124387255861622e-06 0.8059526272620129 \
2.124387382358398e-06 0.8071184350969989 2.124387507861062e-06 0.8082633544790385 2.124387638586967e-06 0.8094437311890262 2.124387764154938e-06 0.8105658358439867 \
2.124387893209804e-06 0.8117072367686948 2.124387999065961e-06 0.8126345588578442 2.124388100234836e-06 0.8135133322873783 2.124388194854656e-06 0.8143286754242188 \
2.12438831913574e-06 0.8153900871385379 2.124388408847426e-06 0.816149614585347 2.12438850788495e-06 0.8169816577628611 2.124388645662827e-06 0.8181280288377792 \
2.124388780198677e-06 0.81923501721715 2.124388888604944e-06 0.8201180631035904 2.124389038518447e-06 0.8213254631869725 2.124389189097026e-06 0.8225223201378843 \
2.12438931459218e-06 0.8235077122548546 2.124389458438707e-06 0.8246238332260477 2.124389583021971e-06 0.8255790649890803 2.124389731875191e-06 0.8267066458678887 \
2.124389868023775e-06 0.827725029289517 2.124389993047602e-06 0.8286494160599757 2.124390110754582e-06 0.8295103773055483 2.12439025639358e-06 0.8305630309532103 \
2.124390422774875e-06 0.8317484146982921 2.124390553358565e-06 0.8326660250626342 2.124390726880675e-06 0.8338683097812621 2.124390895002578e-06 0.8350147136930499 \
2.12439106486518e-06 0.8361549927788252 2.124391245766883e-06 0.8373497079260466 2.124391388876165e-06 0.8382806519784776 2.124391502965127e-06 0.839013953006387 \
2.124391633127603e-06 0.8398410866028793 2.124391734972734e-06 0.8404811280669765 2.12439185179894e-06 0.8412075886390841 2.12439198869038e-06 0.8420483852080155 \
2.124392186497604e-06 0.843243620449199 2.12439237812275e-06 0.8443797466267589 2.124392587554618e-06 0.8455974227529048 2.1243927695013e-06 0.8466352798309468 \
2.124392966630154e-06 0.8477391449715804 2.124393139971014e-06 0.8486924050423899 2.124393322979321e-06 0.8496814535024207 2.124393494142356e-06 0.8505903669473519 \
2.124393668779451e-06 0.851501688465695 2.124393844039281e-06 0.8524001683007644 2.12439402018973e-06 0.8532872510191711 2.124394210470029e-06 0.8542278331088334 \
2.12439440106916e-06 0.8551519386507073 2.124394601692395e-06 0.8561055033533737 2.12439479430095e-06 0.8570028516027762 2.124395004981641e-06 0.8579644845832216 \
2.124395233083109e-06 0.8589827023971403 2.124395498871092e-06 0.860139640227508 2.124395797483852e-06 0.8614018215255795 2.124396073772491e-06 0.8625348754565382 \
2.12439635800901e-06 0.8636666213345715 2.12439663221378e-06 0.8647267940813509 2.124396904448638e-06 0.8657495569722869 2.12439717465278e-06 0.8667361702337206 \
2.12439743180839e-06 0.867649441901348 2.124397704388604e-06 0.8685908808535525 2.12439798037489e-06 0.8695169452638583 2.124398250477721e-06 0.870397355937691 \
2.124398550334798e-06 0.8713451925332844 2.124398921362456e-06 0.8724761722512941 2.124399216299767e-06 0.8733433185969293 2.124399470589207e-06 0.8740690226522811 \
2.124399768845991e-06 0.874895168896023 2.124400042455427e-06 0.8756299040683481 2.124400278583913e-06 0.8762466977562872 2.124400518929827e-06 0.8768585021646264 \
2.124400741263492e-06 0.8774104263690854 2.124400935269169e-06 0.8778812671168952 2.124401264991886e-06 0.8786590883967833 2.124401420165319e-06 0.8790156160651978 \
2.124401737941389e-06 0.8797272612331356 2.124401916803031e-06 0.8801171459162566 2.124402259264861e-06 0.8808425821290963 2.124402443393021e-06 0.881221400612852 \
2.124402918270754e-06 0.8821634994206867 2.124403085666965e-06 0.8824839765989225 2.124403551508906e-06 0.8833452998114757 2.124403732330958e-06 0.8836679564577563 \
2.124404226369383e-06 0.8845176198113115 2.124404367718007e-06 0.8847523712107549 2.124404974052073e-06 0.8857188576377059 2.124405126121396e-06 0.8859512996759633 \
2.124405772809558e-06 0.8868983431897121 2.12440590110417e-06 0.8870786909355212 2.124406549221232e-06 0.8879538337624689 2.124406679020295e-06 0.8881220828502663 \
2.124407457223772e-06 0.8890807033877333 2.124407572278734e-06 0.8892148977954012 2.124408427940206e-06 0.8901543051721961 2.124408573301076e-06 0.8903040038307473 \
2.124409559057127e-06 0.8912446482480114 2.124409780162495e-06 0.8914382978987679 2.124410925289423e-06 0.8923659558950503 2.124411056506439e-06 0.8924678262926897 \
2.124412397715013e-06 0.8934599079028542 2.124412549114272e-06 0.8935646301988298 2.124414030551995e-06 0.8944937559627255 2.124414269431373e-06 0.8946275407274444 \
2.124416038746979e-06 0.8955013787854181 2.124416427898191e-06 0.8956696032899972 2.124418821561142e-06 0.8965547188539188 2.12441929727014e-06 0.8967039926079825 \
2.12442336043021e-06 0.8977020505850396 2.124423851854269e-06 0.8977948037134476 2.124432168453822e-06 0.898787348739254 2.12443308835295e-06 0.8988506593152591 \
2.12457657358348e-06 0.8998476076348748 2.124577692016456e-06 0.8998537475785264 2.124782783635956e-06 0.898985773748599 2.124783010725457e-06 0.8988224379910277 \
2.124784620332256e-06 0.8978282360369357 2.124784797740799e-06 0.8977338482811539 2.124801704889099e-06 0.8987315468430059 2.124801814328198e-06 0.8987460089186867 \
2.124817595049444e-06 0.8997418097871094 2.12481789137534e-06 0.8997476966799167 2.125301325027745e-06 0.9007060148833608 2.125301454078085e-06 0.9008313386292994 \
2.12530210422793e-06 0.9016292186224167 2.125302293723661e-06 0.9019133038041363 2.12530279694564e-06 0.9027675859898705 2.125302932418299e-06 0.9030208676018907 \
2.125303332877016e-06 0.9038195223753869 2.125303464814953e-06 0.9040958310886574 2.125303866030017e-06 0.9049509627747726 2.125303964290194e-06 0.9051582028152527 \
2.125304430164004e-06 0.9060587574877488 2.125304591662727e-06 0.9063060456044927 2.12530573567525e-06 0.9055153668657776 2.125305880654596e-06 0.9049059606760256 \
2.125306059207354e-06 0.9039396653125833 2.125306239402631e-06 0.9027054491383806 2.125306382093561e-06 0.9015369228101149 2.125306499253164e-06 0.9004524619440171 \
2.125306588234525e-06 0.8995505656965809 2.125306679878177e-06 0.8985529714258781 2.12530681299011e-06 0.8969831049011855 2.125306906711193e-06 0.8957895978311226 \
2.125306997850002e-06 0.8945634483845346 2.125307111142313e-06 0.8929516940777753 2.125307214251226e-06 0.8913998138690341 2.125307310518406e-06 0.8898830246517148 \
2.125307429655523e-06 0.8879200664089764 2.125307598240772e-06 0.8849885378698126 2.125307760012273e-06 0.8820195265790133 2.125307953231332e-06 0.8782956415026882 \
2.125308138794443e-06 0.8745571577041361 2.125308349060748e-06 0.8701566079887386 2.125308531309789e-06 0.8662213066841463 2.125308716173183e-06 0.8621339172744639 \
2.12530888885833e-06 0.8582419637438897 2.125309074966403e-06 0.8539816046497358 2.125309252782491e-06 0.849858603441091 2.125309433499072e-06 0.8456251963850057 \
2.125309598637331e-06 0.8417258760277182 2.125309763911433e-06 0.837798995916667 2.125309927159096e-06 0.8339004324287677 2.125310085749369e-06 0.8300982805770993 \
2.125310262673771e-06 0.8258418712800655 2.125310459187584e-06 0.8211009660847696 2.125310626744125e-06 0.8170498602679914 2.125310793484544e-06 0.8130123908857781 \
2.125310967908062e-06 0.8087844286215062 2.125311137277684e-06 0.8046757316210446 2.125311305476778e-06 0.8005936994537799 2.125311494325046e-06 0.7960093488074458 \
2.125311685140882e-06 0.7913773844868103 2.125311893523092e-06 0.7863203192056716 2.125312119942597e-06 0.7808277108969495 2.125312309142794e-06 0.7762391340290878 \
2.125312519289483e-06 0.7711455503222944 2.125312668057987e-06 0.7675418410361046 2.125312799050976e-06 0.7643705172588006 2.125312936616212e-06 0.7610417440783073 \
2.125313042367442e-06 0.7584842184275663 2.125313177141075e-06 0.7552262509102785 2.1253132889738e-06 0.7525244432456109 2.125313418408964e-06 0.7493992292091655 \
2.125313573597688e-06 0.7456545577979357 2.125313685233441e-06 0.7429626190147979 2.125313844808055e-06 0.7391166470929011 2.125314020129688e-06 0.7348935218456193 \
2.125314232505151e-06 0.7297828120356423 2.125314425387679e-06 0.7251458607116523 2.125314582088971e-06 0.7213823872711312 2.125314768763662e-06 0.716903961299824 \
2.125314957650011e-06 0.7123775767926828 2.125315148534203e-06 0.70780884692282 2.125315335282138e-06 0.7033444557767304 2.125315518366954e-06 0.698972331957095 \
2.125315655685935e-06 0.6956951921588121 2.125315808928892e-06 0.6920418367118417 2.125316004057543e-06 0.6873949992893974 2.125316161351872e-06 0.6836535194673684 \
2.125316320746467e-06 0.6798660670227984 2.12531651649026e-06 0.6752219404489795 2.125316708689394e-06 0.6706682621108646 2.125316943641022e-06 0.6651105611269369 \
2.12531713111727e-06 0.6606839627962382 2.125317368354404e-06 0.6550894036851447 2.125317557534366e-06 0.6506361170423679 2.125317738150178e-06 0.6463915264929231 \
2.125317901844742e-06 0.6425504277539856 2.12531804639615e-06 0.6391628119244788 2.12531818686792e-06 0.6358764726647652 2.125318313968708e-06 0.6329064225879303 \
2.125318446276184e-06 0.6298198307262635 2.12531857286323e-06 0.626870110582017 2.125318703443498e-06 0.62383130535404 2.125318832712896e-06 0.6208285625908692 \
2.125318971819793e-06 0.6176004736356133 2.125319120330103e-06 0.6141606483517721 2.125319309878658e-06 0.6097777958748198 2.125319455581914e-06 0.6064170107178907 \
2.125319690632478e-06 0.601007464699683 2.125319873631749e-06 0.5968099615921 2.125320097973422e-06 0.5916778694808832 2.125320269146672e-06 0.5877753019413697 \
2.125320401480491e-06 0.5847634284691802 2.12532053327703e-06 0.5817721407249107 2.125320639820934e-06 0.5793579518205488 2.125320735711292e-06 0.5771868999037388 \
2.125320828211542e-06 0.5750974572268882 2.125320920638905e-06 0.5730134868920421 2.125320993067212e-06 0.5713818265150021 2.125321048796317e-06 0.5701269325864891 \
2.125321109905405e-06 0.5687522410723198 2.12532120667008e-06 0.5665806864277688 2.125321268161595e-06 0.5652027770813386 2.125321327214216e-06 0.5638802801505602 \
2.125321402840882e-06 0.5621878686488651 2.12532146986366e-06 0.5606896577364279 2.12532154346077e-06 0.5590483558003441 2.125321611066772e-06 0.5575429304381756 \
2.125321727135829e-06 0.5549610936632026 2.125321827342234e-06 0.5527359403974305 2.125321939349424e-06 0.5502565947066531 2.125322033841475e-06 0.5481686943853854 \
2.125322154996172e-06 0.5454955387196141 2.125322255183939e-06 0.5432910220514219 2.125322371174451e-06 0.5407443765731218 2.125322478878288e-06 0.5383833065966291 \
2.125322588456977e-06 0.5359861028148916 2.125322700578421e-06 0.5335400310751951 2.125322827515605e-06 0.5307765704644959 2.125322949665123e-06 0.5281221248815906 \
2.125323089426038e-06 0.525095489155881 2.125323226564154e-06 0.522132778766487 2.125323376529244e-06 0.5189020692106626 2.125323535302247e-06 0.5154923220538846 \
2.125323709327904e-06 0.511765695450105 2.125323896158028e-06 0.5077823379664483 2.125324101125993e-06 0.5034264211640872 2.125324323834942e-06 0.4987133299464507 \
2.125324576739139e-06 0.4933874474923696 2.125324811693046e-06 0.4884604410272814 2.125325107961308e-06 0.4822828691822955 2.125325397751266e-06 0.4762763831984252 \
2.125325704087085e-06 0.4699660956099861 2.125326016405612e-06 0.4635767846525711 2.125326354971068e-06 0.4566963260653934 2.125326678082485e-06 0.4501741115777416 \
2.125327016477788e-06 0.4433881855507311 2.125327340309053e-06 0.4369378830387565 2.125327664703474e-06 0.4305204627449936 2.12532800763776e-06 0.4237851826852676 \
2.125328346918578e-06 0.4171698123421442 2.125328686393212e-06 0.4105997181257849 2.125329129505058e-06 0.4020958655332711 2.125329491573227e-06 0.3952155038183801 \
2.125329812124964e-06 0.3891775711374149 2.125330199059534e-06 0.3819561902961204 2.125330526929795e-06 0.3758957719299574 2.125330812088851e-06 0.3706704968427373 \
2.125331130457646e-06 0.3648820026298218 2.125331413288573e-06 0.3597820188690578 2.125331641977337e-06 0.3556924369094372 2.125331859870142e-06 0.3518226517641353 \
2.125332055119486e-06 0.3483769517668343 2.125332262027585e-06 0.344751588202948 2.125332476824342e-06 0.3410137651016431 2.125332729050892e-06 0.3366564674340092 \
2.125332971046205e-06 0.3325077909124976 2.125333201898484e-06 0.3285822460490526 2.125333416746675e-06 0.3249550452085373 2.125333637103364e-06 0.3212604562488142 \
2.125333838674264e-06 0.3179050685021769 2.12533404175821e-06 0.3145531374773136 2.125334239655597e-06 0.3113121771742085 2.125334426754836e-06 0.3082694484595072 \
2.12533462065518e-06 0.3051385396431291 2.125334825703514e-06 0.3018527636900292 2.125335005938266e-06 0.2989872106339772 2.125335241836277e-06 0.2952669081535775 \
2.125335443123827e-06 0.2921198200609627 2.125335644514631e-06 0.2889965001417216 2.125335869163794e-06 0.2855437159941698 2.125336034543768e-06 0.2830223598911593 \
2.125336212348105e-06 0.280330186126118 2.125336396004319e-06 0.277570343839212 2.125336581246076e-06 0.2748090658167894 2.125336759391454e-06 0.2721781298892599 \
2.125336932983517e-06 0.2696316866093095 2.12533709334837e-06 0.267306655456324 2.125337214459553e-06 0.2655585721882695 2.12533736765434e-06 0.2633570345323199 \
2.125337494985789e-06 0.2615475749425888 2.125337598313628e-06 0.2600830587034867 2.125337715638424e-06 0.2584225376281647 2.125337833445381e-06 0.2567591557214636 \
2.125337957409147e-06 0.2550199666844239 2.125338074393314e-06 0.2533821414201824 2.125338205189442e-06 0.2515535495016885 2.125338322399552e-06 0.2499173892700276 \
2.125338475652677e-06 0.2477853623028658 2.125338611183197e-06 0.2459029165157107 2.125338742864406e-06 0.244074199323236 2.125338899457317e-06 0.2419017673596028 \
2.125339024653875e-06 0.2401755227310949 2.125339160371501e-06 0.2383060149301216 2.125339292798663e-06 0.2364844144139329 2.125339412772324e-06 0.2348355337769661 \
2.125339575820161e-06 0.232606585912384 2.125339714627253e-06 0.230713852557009 2.125339853100972e-06 0.2288300961780371 2.125339958645721e-06 0.2273962817971701 \
2.125340087007401e-06 0.2256537837490921 2.125340191135024e-06 0.2242444877898851 2.125340291651026e-06 0.222886569499566 2.125340366695402e-06 0.2218745444235658 \
2.125340444028457e-06 0.2208349692306942 2.125340518791637e-06 0.2198305887827458 2.125340596755314e-06 0.218785487158918 2.125340651621824e-06 0.2180503923904892 \
2.1253407081186e-06 0.2172938400168352 2.125340751572119e-06 0.2167123195211523 2.125340791613166e-06 0.2161767335077376 2.125340830852113e-06 0.2156521099473339 \
2.12534087172635e-06 0.2151058606261434 2.12534092587884e-06 0.2143825797409383 2.125340964295972e-06 0.2138698309421548 2.125341003584678e-06 0.2133480458229882 \
2.125341065121387e-06 0.2125332203444249 2.125341127098915e-06 0.2117131287842428 2.125341183575664e-06 0.2109664019951111 2.125341248207254e-06 0.2101124842966758 \
2.125341343715876e-06 0.2088522205996687 2.125341431031607e-06 0.207701294711168 2.125341527641208e-06 0.2064291756790013 2.125341624870762e-06 0.2051510266126755 \
2.125341725717823e-06 0.2038307158897115 2.125341826317594e-06 0.2025192706911573 2.125341922808891e-06 0.2012627769767186 2.125342024991065e-06 0.1999338657614989 \
2.125342128630721e-06 0.1985898465970496 2.125342238404734e-06 0.1971698847140261 2.12534234757976e-06 0.1957617939809042 2.125342467677851e-06 0.1942174441246506 \
2.125342577697376e-06 0.1928086337505992 2.125342685809285e-06 0.1914295694688549 2.125342808837984e-06 0.1898652723262108 2.125342898948553e-06 0.1887234630454603 \
2.125343006314044e-06 0.1873671680421656 2.125343083125352e-06 0.1864004060894758 2.125343166570621e-06 0.1853535952511875 2.125343256102432e-06 0.1842338297700716 \
2.125343340667898e-06 0.1831790839553313 2.125343420384039e-06 0.1821880912968773 2.125343521709242e-06 0.1809331989518758 2.125343630056471e-06 0.1795959386230563 \
2.125343726532169e-06 0.1784102562612937 2.125343851909986e-06 0.1768766438339704 2.125343984693456e-06 0.1752616821119887 2.125344102464279e-06 0.1738362801839788 \
2.125344248115856e-06 0.1720835746408261 2.125344358713008e-06 0.1707596463148658 2.125344500843447e-06 0.1690680578777541 2.12534461655307e-06 0.1676985735146403 \
2.125344722027083e-06 0.166456424915798 2.125344816543742e-06 0.1653485352650968 2.125344912181114e-06 0.1642320043563913 2.125345009252958e-06 0.1631032360400927 \
2.125345108304212e-06 0.161956192050434 2.125345202227769e-06 0.1608730077890209 2.125345287503444e-06 0.1598934595213354 2.125345387883236e-06 0.1587475631033795 \
2.125345472186073e-06 0.1577906478848196 2.125345574585582e-06 0.1566342854655733 2.125345651979844e-06 0.1557646215197878 2.125345744324758e-06 0.154731814591042 \
2.12534581457623e-06 0.1539498814072817 2.125345910750659e-06 0.1528844393027091 2.125345987575322e-06 0.152038051282755 2.125346066345474e-06 0.1511758489440315 \
2.125346140238394e-06 0.150370438825067 2.125346207936138e-06 0.1496353997608715 2.125346304000026e-06 0.1485973848112393 2.125346373572453e-06 0.1478489919002561 \
2.125346457461625e-06 0.1469503328160803 2.125346518593462e-06 0.146298213254472 2.125346590861543e-06 0.1455309799806117 2.125346663300106e-06 0.1447677488542132 \
2.125346744281147e-06 0.1439178685120187 2.125346810355616e-06 0.1432275520600639 2.125346887756113e-06 0.1424219220725307 2.12534697713157e-06 0.1414956876531561 \
2.125347047992216e-06 0.1407644282175171 2.125347146879283e-06 0.1397487730030469 2.125347224198192e-06 0.1389620820751095 2.125347306243418e-06 0.1381330876879582 \
2.12534739435453e-06 0.1372467208126059 2.125347461981677e-06 0.1365690714953818 2.125347542278859e-06 0.1357674830239305 2.125347617062888e-06 0.1350239185327315 \
2.125347685064065e-06 0.1343502586094245 2.125347731746974e-06 0.1338891847862563 2.125347820998567e-06 0.1330118383700247 2.125347859221617e-06 0.1326395291833771 \
2.125347928213527e-06 0.1319690872918072 2.125347980961596e-06 0.1314578750898332 2.125348063954378e-06 0.1306559489775353 2.125348104132829e-06 0.1302688434457458 \
2.125348196650203e-06 0.1293805059784019 2.12534823536857e-06 0.1290098403727171 2.125348309129285e-06 0.1283055160094505 2.125348370757287e-06 0.1277188748199021 \
2.125348442784976e-06 0.1270353589407805 2.125348510952008e-06 0.1263909833196726 2.125348585574169e-06 0.1256908956540175 2.125348667426635e-06 0.1249253613889138 \
2.125348750880797e-06 0.124147338931438 2.125348823832511e-06 0.1234692772477456 2.125348896559441e-06 0.122795332839617 2.125348956549435e-06 0.1222410931008323 \
2.125349042917447e-06 0.121445549533078 2.125349103886164e-06 0.1208856452315438 2.125349162271955e-06 0.1203507897957366 2.12534922790662e-06 0.119751336354628 \
2.125349287260861e-06 0.1192111367930785 2.125349355292642e-06 0.1185941868697126 2.125349452587012e-06 0.11771710490035 2.125349531078992e-06 0.1170124163111649 \
2.125349621315123e-06 0.1162055395685231 2.125349717161808e-06 0.1153523005684616 2.125349792119504e-06 0.1146878351828532 2.125349896478921e-06 0.1137670532163148 \
2.125349983267518e-06 0.1130053589403202 2.125350092924934e-06 0.1120476726212376 2.125350174478997e-06 0.1113387926087848 2.125350270092629e-06 0.1105114393564785 \
2.125350346804822e-06 0.10985058581598 2.125350441723287e-06 0.1090364400125625 2.125350517546392e-06 0.1083889268999046 2.125350595246049e-06 0.1077282965354292 \
2.1253506775775e-06 0.1070311517075373 2.125350737142764e-06 0.1065286079538068 2.125350800900501e-06 0.1059924133642201 2.125350861995109e-06 0.1054803128126646 \
2.125350957858847e-06 0.1046801683739134 2.125351002721941e-06 0.1043071445723913 2.125351085962687e-06 0.1036173314376927 2.125351135082509e-06 0.1032117000904133 \
2.125351244131271e-06 0.1023149933518279 2.125351288967353e-06 0.1019479364619093 2.125351379228585e-06 0.1012117400678687 2.125351420105203e-06 0.1008795969612472 \
2.125351490563617e-06 0.1003088525914566 2.125351576851038e-06 0.09961307626065434 2.125351668628597e-06 0.09887705578174606 2.12535173815669e-06 0.09832225024344161 \
2.125351816683849e-06 0.09769854072774181 2.125351907412526e-06 0.09698178745350861 2.125351983228664e-06 0.09638605854785212 2.125352065241407e-06 0.09574500473888557 \
2.125352146994443e-06 0.09510943278387665 2.125352237502267e-06 0.09440967388330095 2.125352327061564e-06 0.09372126988887708 2.125352412671398e-06 0.09306698857649189 \
2.125352505450896e-06 0.09236212353634379 2.125352586338857e-06 0.0917510971760913 2.125352687467827e-06 0.09099177263830999 2.125352767961352e-06 0.09039108594384238 \
2.125352852204218e-06 0.08976589684797046 2.125352926049265e-06 0.08922077348043934 2.125353002898743e-06 0.08865632925481931 2.125353091039112e-06 0.08801255002475737 \
2.125353171103482e-06 0.08743108261130086 2.125353264139672e-06 0.08675939571108145 2.125353382140385e-06 0.08591369538214398 2.125353524513612e-06 0.08490278100234279 \
2.125353668761962e-06 0.08388867104764453 2.125353811089671e-06 0.08289807427203813 2.125353960667414e-06 0.08186746790234835 2.125354096981161e-06 0.08093761126893445 \
2.125354239101592e-06 0.0799778356000513 2.125354373655019e-06 0.07907840240745091 2.12535451400773e-06 0.07814980287393705 2.125354661689802e-06 0.0771833418413561 \
2.125354811805299e-06 0.07621180464723754 2.125354976525776e-06 0.07515824360926991 2.125355140155128e-06 0.07412455432658185 2.125355314933688e-06 0.07303438636984133 \
2.125355502186304e-06 0.07188220095900363 2.125355712231308e-06 0.07060976590783831 2.125355930441531e-06 0.06930979572898451 2.125356163898619e-06 0.06794333957253913 \
2.125356418744638e-06 0.06648001693367038 2.125356711839195e-06 0.06483321328442151 2.125357014178957e-06 0.06317411115207273 2.125357328765832e-06 0.06148945259513613 \
2.125357725026526e-06 0.05942677493938087 2.125358058743672e-06 0.05774249301432461 2.125358466054501e-06 0.05574994498853819 2.12535879393926e-06 0.05419380357502902 \
2.125359150629899e-06 0.05254809000207299 2.12535946386806e-06 0.05114243792209583 2.125359766835193e-06 0.04981740498512215 2.125360064375718e-06 0.04854875663330436 \
2.125360343155274e-06 0.04739109061078805 2.125360626155169e-06 0.04624570307560639 2.125360887895477e-06 0.04521055793698023 2.12536116713437e-06 0.04413130357485813 \
2.12536143924029e-06 0.0431040186124033 2.125361746607047e-06 0.04197194005652995 2.125361968409948e-06 0.04117329707315532 2.125362274870428e-06 0.04009446155587663 \
2.125362501059881e-06 0.03931650950691581 2.125362739977206e-06 0.03851359500741255 2.125362964401039e-06 0.03777663690506906 2.12536316666332e-06 0.03712468825868943 \
2.125363367705949e-06 0.03648814235703791 2.125363719479983e-06 0.03540095449820539 2.125363969725821e-06 0.03464776841732944 2.125364216044101e-06 0.03392252499723709 \
2.125364497376965e-06 0.03311308780599518 2.12536474046795e-06 0.03242954897046491 2.1253649759417e-06 0.03178112583711486 2.125365217601206e-06 0.03113119522156456 \
2.125365454483483e-06 0.03050988948014832 2.125365685016041e-06 0.02991733361391674 2.125365898984568e-06 0.02937801894285819 2.125366104927116e-06 0.02886851641492237 \
2.125366497651603e-06 0.02792196059063811 2.125366685729283e-06 0.02747992420741849 2.125367061168249e-06 0.02661861215736662 2.125367236042478e-06 0.02622659266649364 \
2.125367659365491e-06 0.02530049759795254 2.125367780614876e-06 0.02504150687334681 2.125368221176528e-06 0.02412433837770948 2.125368363674647e-06 0.02383402682615681 \
2.125368695728157e-06 0.02316883068419595 2.125368878693682e-06 0.02280879143785283 2.125369267997886e-06 0.02205689891561978 2.125369436343594e-06 0.02173705378531499 \
2.125369908457993e-06 0.02085107653961301 2.125370048202727e-06 0.0205916297664938 2.125370543782805e-06 0.01969297428531048 2.125370671008237e-06 0.01946923320191776 \
2.125371238917342e-06 0.01851512288677271 2.12537140317129e-06 0.0182513999453204 2.125372013043028e-06 0.0173209960017622 2.125372172728257e-06 0.01708922829277545 \
2.125372699639798e-06 0.01635462467776483 2.125372904157091e-06 0.01608193551804103 2.125373627634478e-06 0.01515939662837778 2.12537379307661e-06 0.01495683325581705 \
2.125374539636356e-06 0.01408081084911163 2.125374672939569e-06 0.01393008075245666 2.125375533124155e-06 0.01299799962960837 2.12537566920557e-06 0.01285670227674402 \
2.12537660979946e-06 0.01192267652923807 2.125376773572533e-06 0.01176632439256516 2.125377774751464e-06 0.01084959205883911 2.125377912229187e-06 0.01072929995296418 \
2.125379082926798e-06 0.009787962024485789 2.125379175323166e-06 0.009718668544398181 2.125380593399014e-06 0.008725931027897449 2.125380680375162e-06 0.00866912727384293 \
2.125382221370793e-06 0.00770199130002063 2.125382330686807e-06 0.007633428668288294 2.125383973934629e-06 0.006673746291950173 2.125384106791908e-06 0.006603544020797993 \
2.125386201172206e-06 0.005605323336654431 2.125386409576941e-06 0.00551468736035817 2.125388763913366e-06 0.004577307911602986 2.125389237472123e-06 0.004407121484391641 \
2.125392122908979e-06 0.003492041675788492 2.125392652573327e-06 0.00334538389506189 2.125396860800552e-06 0.00237996320858989 2.125397374234803e-06 0.002283557532494709 \
2.125403133485495e-06 0.001325291758975802 2.125403368066713e-06 0.001279502680325907 2.125418035894088e-06 0.0002809017338477542 2.12541814896418e-06 0.0002788534805396912 \
2.12805516904393e-06 -0.0006849217749926401 2.128055335205606e-06 -0.0009443270389602415 2.128055814074993e-06 -0.001850320037528519 2.12805590679462e-06 -0.002050462221988249 \
2.128056272019697e-06 -0.002913187630468476 2.128056363676813e-06 -0.00314709230904735 2.128056729783165e-06 -0.004133001189868674 2.128056839930291e-06 -0.004442309109773816 \
2.128057150668543e-06 -0.005311341427314526 2.128057252407188e-06 -0.005583925258601597 2.128057616111313e-06 -0.00638370916272213 2.128057780957637e-06 -0.006585924750287024 \
2.128058360754956e-06 -0.005792290386912202 2.128058535589415e-06 -0.004916934050781314 2.128058652279015e-06 -0.00413641027497409 2.128058778708708e-06 -0.00310656561120747 \
2.128058880730911e-06 -0.002137079422087956 2.128059000577393e-06 -0.0008406209844352954 2.128059091214629e-06 0.0002489246187367611 2.128059189634679e-06 0.001536790859923857 \
2.128059289358323e-06 0.002948496343048522 2.128059456842332e-06 0.005545701385567424 2.128059675420934e-06 0.009327395936412004 2.128059861491256e-06 0.0128572688386996 \
2.128060082873864e-06 0.01737012273305725 2.128060243533997e-06 0.02082840415615294 2.128060406999647e-06 0.02447866954313523 2.128060557635164e-06 0.02794359528291388 \
2.128060706690917e-06 0.03145289236167962 2.128060856153671e-06 0.03504014479003619 2.128061010184683e-06 0.03879791952579481 2.128061172300943e-06 0.04280891157365373 \
2.128061338330408e-06 0.04696567134311741 2.128061514283228e-06 0.05141478668696391 2.128061694953866e-06 0.05602187592747932 2.128061886774812e-06 0.06094655248807559 \
2.128062093880316e-06 0.06629309753158302 2.128062315452046e-06 0.07203901748582854 2.128062550186215e-06 0.07814662931008168 2.128062801725783e-06 0.08470684589377442 \
2.128063077167849e-06 0.09190125212984442 2.128063377363668e-06 0.09974607960254324 2.128063708295878e-06 0.108390578238945 2.128064083962612e-06 0.1181923833971668 \
2.12806448154548e-06 0.1285487285136021 2.128064948370082e-06 0.1406786766767902 2.128065491362617e-06 0.1547396794802719 2.12806612478764e-06 0.1710742296429572 \
2.128066820727691e-06 0.1889259607126788 2.1280676362848e-06 0.2097135943149445 2.128068546312904e-06 0.2327316641523666 2.128069339569124e-06 0.2526372689279454 \
2.1280700450442e-06 0.2702038474981599 2.128070663988468e-06 0.2855008995781749 2.128071231094408e-06 0.2994177966724069 2.128071754174414e-06 0.3121574438576628 \
2.128072253153207e-06 0.3242197130846058 2.128072737193214e-06 0.3358335658028451 2.128073192420047e-06 0.3466679577370423 2.128073666932009e-06 0.3578644504627745 \
2.128074106840717e-06 0.368158604789619 2.128074592685345e-06 0.3794271463718566 2.128075124288118e-06 0.3916316501999784 2.128075626951417e-06 0.4030538969706937 \
2.128076056023669e-06 0.4127111343288326 2.128076547040338e-06 0.4236561147984291 2.128077048470419e-06 0.434714731975362 2.128077395015009e-06 0.442288187401736 \
2.128077750424386e-06 0.4500000616404133 2.128078177652115e-06 0.4592019891792938 2.128078569851637e-06 0.4675774400278049 2.128078870233395e-06 0.4739448723400065 \
2.128079212045155e-06 0.4811381049525967 2.128079555484969e-06 0.4883107756756314 2.128079816220095e-06 0.4937186470393492 2.128080058250049e-06 0.4987071765458648 \
2.128080324195291e-06 0.5041573145298286 2.128080581464587e-06 0.509394255416739 2.12808077158369e-06 0.5132422368582924 2.128080985109851e-06 0.5175451019736222 \
2.128081124800157e-06 0.5203466115392713 2.128081271000449e-06 0.5232668091041763 2.12808148498835e-06 0.5275186200231483 2.12808169300461e-06 0.5316389396023125 \
2.128081885465879e-06 0.5354321131715788 2.12808207058211e-06 0.5390651926504321 2.128082244955557e-06 0.5424725330931349 2.128082549497633e-06 0.5484058192982523 \
2.128082810056515e-06 0.5534602958276967 2.128083111487544e-06 0.5592859190791987 2.128083365805138e-06 0.5641865993769294 2.128083658661328e-06 0.5698153316805189 \
2.12808391787448e-06 0.5747800306938655 2.128084188950812e-06 0.579963273174682 2.128084430794571e-06 0.5845680738798381 2.128084688299729e-06 0.5894577538325241 \
2.128084915043604e-06 0.5937419314630586 2.128085152044424e-06 0.5982006324572362 2.128085362230986e-06 0.6021379329905048 2.12808557499152e-06 0.6061060319396779 \
2.128085827870286e-06 0.6107954169450593 2.128086031533554e-06 0.6145509252949414 2.128086222250936e-06 0.6180531102377972 2.128086409587374e-06 0.6214768531423983 \
2.128086598465652e-06 0.6249070011644339 2.128086806665448e-06 0.6286671070650327 2.128087050997562e-06 0.6330499453121026 2.128087250564095e-06 0.6366057789565548 \
2.128087454709836e-06 0.6402215701419991 2.12808763934909e-06 0.643474671963314 2.128087908884781e-06 0.6481901084955864 2.128088136591637e-06 0.652149230294136 \
2.128088324263375e-06 0.6553888277830079 2.12808850516352e-06 0.6584949378977958 2.128088664704602e-06 0.661221510907812 2.128088835167002e-06 0.6641177016088209 \
2.128088986918443e-06 0.6666817235716488 2.128089124561455e-06 0.6689905419339194 2.128089273556318e-06 0.6714784915997724 2.128089401298182e-06 0.6736028790357499 \
2.128089544284695e-06 0.675968899142866 2.128089666067751e-06 0.6779749688503388 2.128089802351161e-06 0.6802121872853304 2.128089922180062e-06 0.682172759947357 \
2.128090068775623e-06 0.6845626218370968 2.128090187248565e-06 0.6864845934661837 2.128090283181927e-06 0.6880368302455475 2.128090375701511e-06 0.6895284278106264 \
2.128090480762022e-06 0.6912169000724893 2.128090578843908e-06 0.6927871490736753 2.128090715959225e-06 0.6949707622226827 2.128090835157868e-06 0.6968607547931925 \
2.128090945097838e-06 0.6985951241089645 2.128091082597082e-06 0.7007503743809057 2.128091214026983e-06 0.7027960765825516 2.128091346256499e-06 0.7048392108129343 \
2.128091459433897e-06 0.7065756917706891 2.128091613866751e-06 0.708927873976708 2.128091744646745e-06 0.7109048231498766 2.128091867315455e-06 0.7127465601965561 \
2.128091973583711e-06 0.7143329262278221 2.128092095963735e-06 0.7161490373358268 2.128092197817232e-06 0.7176517022913665 2.128092331955132e-06 0.7196190116794019 \
2.128092452648172e-06 0.7213783352064487 2.12809257178997e-06 0.7231049829175343 2.128092696807984e-06 0.7249059312823601 2.12809282664779e-06 0.7267645120560844 \
2.128092946459962e-06 0.7284691779696002 2.128093075453213e-06 0.730293808329565 2.128093207560277e-06 0.7321507998840678 2.128093325866095e-06 0.7338038328985433 \
2.128093469126786e-06 0.7357927618453034 2.128093571581473e-06 0.7372070005703254 2.128093667788359e-06 0.7385290937783453 2.128093772805981e-06 0.7399656334130889 \
2.128093883577511e-06 0.7414708009413548 2.128093985256052e-06 0.7428439364018735 2.128094088217506e-06 0.7442258341871242 2.128094205143661e-06 0.7457850038572696 \
2.128094333903936e-06 0.747489965072781 2.128094435062908e-06 0.7488201182152049 2.128094583931952e-06 0.7507626302114226 2.128094731611489e-06 0.75267249971878 \
2.128094850976855e-06 0.7542038164026367 2.128094997460699e-06 0.7560679527984652 2.12809512063619e-06 0.7576223900169708 2.128095261439865e-06 0.7593848990234215 \
2.128095398032531e-06 0.7610800595258669 2.128095520190381e-06 0.7625841275516777 2.128095632846779e-06 0.7639610711610054 2.12809577457292e-06 0.7656796138775311 \
2.12809590073942e-06 0.767196844592689 2.128096016156724e-06 0.768574452686535 2.128096146464904e-06 0.7701179991486644 2.128096262177572e-06 0.7714782821591826 \
2.12809638500186e-06 0.7729116492687436 2.128096502846129e-06 0.7742769236963016 2.128096608476118e-06 0.7754922619072108 2.128096723849553e-06 0.7768108638983861 \
2.128096829112716e-06 0.7780056027231214 2.128096940062529e-06 0.7792565499870431 2.128097026467031e-06 0.7802246528436213 2.128097130500851e-06 0.7813823422463088 \
2.128097244396594e-06 0.7826398494046257 2.128097347430013e-06 0.7837684443710583 2.128097455512714e-06 0.7849432998269023 2.128097563764369e-06 0.7861107422109641 \
2.128097699181616e-06 0.7875582910536544 2.128097811855724e-06 0.7887521292973186 2.128097936279784e-06 0.7900592323105087 2.128098054252648e-06 0.7912877959129118 \
2.128098198720603e-06 0.7927781272271259 2.128098316389742e-06 0.7939806363584788 2.128098452269581e-06 0.7953567374150946 2.128098587013954e-06 0.7967081403609936 \
2.128098698084933e-06 0.7978123285366109 2.128098797974273e-06 0.7987978371087655 2.12809889965423e-06 0.7997937268659365 2.128099032867897e-06 0.8010867894381996 \
2.128099151240716e-06 0.8022243628210853 2.128099272781791e-06 0.8033812848148773 2.128099392145442e-06 0.8045065422543012 2.128099513276819e-06 0.80563739819571 \
2.128099644976236e-06 0.8068544426691319 2.128099767984513e-06 0.8079795872959963 2.12809989582812e-06 0.8091371804586788 2.12810002673464e-06 0.8103101881504271 \
2.128100150327798e-06 0.8114062915203997 2.128100257500303e-06 0.8123479140825919 2.128100364929502e-06 0.8132835730547656 2.128100447598621e-06 0.8139979974227743 \
2.128100565310381e-06 0.8150069815425507 2.128100655915986e-06 0.8157770472204025 2.128100786569431e-06 0.8168774959419571 2.128100930959301e-06 0.8180800468042847 \
2.128101064133715e-06 0.8191766687328477 2.128101174025106e-06 0.8200725423139092 2.128101317623991e-06 0.8212302325252553 2.128101471014683e-06 0.8224508494407716 \
2.128101599092908e-06 0.8234574467428303 2.128101738880276e-06 0.8245431382086058 2.128101865129839e-06 0.8255122018650548 2.128102019728391e-06 0.8266841987320058 \
2.128102151939368e-06 0.8276738265999063 2.128102278166151e-06 0.8286078934539939 2.128102395913874e-06 0.8294698388787296 2.128102544986668e-06 0.8305480062617677 \
2.128102712318221e-06 0.8317406852496945 2.128102845539497e-06 0.8326770812274722 2.128103018320819e-06 0.8338744310092966 2.128103186826193e-06 0.8350236380668206 \
2.128103356205492e-06 0.8361608866600232 2.128103537840761e-06 0.8373606451951652 2.128103680174082e-06 0.8382866867625347 2.128103794011069e-06 0.8390185116470331 \
2.128103925192579e-06 0.8398522525089582 2.128104026724794e-06 0.8404903982372576 2.128104143009054e-06 0.8412135669902132 2.128104277643808e-06 0.8420406924792603 \
2.128104474666644e-06 0.8432316292878405 2.128104664772186e-06 0.8443592803112207 2.128104874895499e-06 0.8455816023960827 2.128105055213604e-06 0.8466107566581813 \
2.128105252676705e-06 0.8477171937062282 2.12810542674582e-06 0.8486750118570332 2.12810560906524e-06 0.8496608982186138 2.128105780480376e-06 0.8505716849290491 \
2.128105954593653e-06 0.8514808063694008 2.128106130324621e-06 0.8523822271368225 2.128106306436321e-06 0.8532696099472232 2.128106496054173e-06 0.8542074684498208 \
2.12810668683567e-06 0.8551330189126392 2.128106888431747e-06 0.8560917259710515 2.128107081166005e-06 0.856990088884472 2.128107290037826e-06 0.8579439907476532 \
2.128107520740263e-06 0.8589743400177088 2.128107785183227e-06 0.8601259267840322 2.128108084005915e-06 0.8613896125360476 2.128108363960216e-06 0.8625380186322354 \
2.128108648086081e-06 0.8636694076724545 2.128108922855057e-06 0.8647317823994775 2.128109194712217e-06 0.8657531067718063 2.128109465089334e-06 0.8667403371654003 \
2.128109722167856e-06 0.8676533221001362 2.128109994792687e-06 0.868594905839151 2.128110270759835e-06 0.8695208838709013 2.128110540864093e-06 0.8704012674911344 \
2.128110840740104e-06 0.8713491368600049 2.128111211801162e-06 0.8724801680184872 2.12811150674079e-06 0.8733472453740196 2.128111761036548e-06 0.8740729094291386 \
2.128112059297474e-06 0.8748989982677786 2.128112332904015e-06 0.8756336613858092 2.128112569029958e-06 0.876250392688866 2.128112809374055e-06 0.8768621356511911 \
2.128113031706182e-06 0.8774140071409635 2.128113225712247e-06 0.8778848105679672 2.128113555434997e-06 0.8786625669521169 2.128113710608525e-06 0.8790190643519731 \
2.128114028387606e-06 0.879730644938159 2.128114207248865e-06 0.8801204696806418 2.128114549710761e-06 0.8808457867651537 2.128114733837363e-06 0.8812245477320809 \
2.128115208711942e-06 0.8821665346129511 2.128115376108352e-06 0.8824869809105039 2.128115841951854e-06 0.883348261932613 2.128116022773548e-06 0.8836708855253055 \
2.12811651681265e-06 0.8845204537290557 2.128116658162059e-06 0.8847551796839913 2.128117264500122e-06 0.8857215808967022 2.128117416569336e-06 0.8859539944113424 \
2.128118063256356e-06 0.8869009218298172 2.128118191551238e-06 0.8870812460539503 2.128118839667745e-06 0.8879562712787433 2.128118969467641e-06 0.8881245027440973 \
2.12811974767834e-06 0.8890830197250962 2.128119862725472e-06 0.8892171882189283 2.128120718396314e-06 0.8901564861234483 2.128120863744077e-06 0.8903061494816453 \
2.128121849499649e-06 0.8912466483555094 2.128122070607711e-06 0.8914402669210102 2.128123215727714e-06 0.892367747196105 2.128123346939159e-06 0.8924695935232408 \
2.128124688211624e-06 0.8934615053489913 2.1281248396029e-06 0.8935661991834861 2.12812632105512e-06 0.8944951400107031 2.128126559934816e-06 0.8946288932334222 \
2.128128329356654e-06 0.895502508848118 2.128128718477945e-06 0.895670668133377 2.128131112210654e-06 0.8965556062201232 2.128131587750593e-06 0.8967047758494365 \
2.128135650819817e-06 0.8977025964496719 2.128136142295653e-06 0.8977953148389237 2.128144458892796e-06 0.8987880790885289 2.128145378794248e-06 0.8988514070442593 \
2.128299242370168e-06 0.8998485708192639 2.128302885496457e-06 0.8998628537402877 2.128529614276672e-06 0.8989664306490068 2.128529844616583e-06 0.8988008565867064 \
2.12853145953688e-06 0.897804750401333 2.128531637269166e-06 0.8977103535805105 2.128548403669272e-06 0.8986978311584225 2.128548539768402e-06 0.8987160394686986 \
2.128563710608672e-06 0.8997133888183054 2.128563987713508e-06 0.899719468756186 2.129048028906422e-06 0.9005852143835333 2.129048202241039e-06 0.9007408621809421 \
2.129048862730638e-06 0.9015135064485434 2.12904902879582e-06 0.9017527716291757 2.129049555130528e-06 0.9026184054967997 2.129049746244447e-06 0.9029704910143604 \
2.129050110465499e-06 0.9036902342402512 2.129050289664921e-06 0.9040628043424317 2.129050651551594e-06 0.9048333795345931 2.129050846661164e-06 0.9052442844328937 \
2.129051379059525e-06 0.9062266394381637 2.129051561413164e-06 0.9064623886473868 2.129052553393556e-06 0.905594670761786 2.129052714934123e-06 0.9049318860608667 \
2.129052882926575e-06 0.9040378649110347 2.129053042758061e-06 0.9029782421366458 2.129053180254799e-06 0.9018984154159868 2.129053313162112e-06 0.9007052793196499 \
2.129053439587579e-06 0.8994328447569792 2.129053546986819e-06 0.8982475863895881 2.129053651483477e-06 0.8970047013543965 2.129053765533147e-06 0.8955451342423859 \
2.129053855502734e-06 0.8943225684615312 2.129053960321373e-06 0.8928208677113324 2.129054049769612e-06 0.891473284704788 2.129054132145392e-06 0.8901820884368528 \
2.129054223238392e-06 0.8887006634027688 2.129054360574471e-06 0.8863657732814155 2.129054459067403e-06 0.8846195012157601 2.129054571141153e-06 0.8825649218508906 \
2.129054702024186e-06 0.880080778639088 2.129054838495216e-06 0.8774018563482072 2.129054991949379e-06 0.8742910281085086 2.129055151043747e-06 0.8709679977889497 \
2.129055315327649e-06 0.867445283300377 2.129055471995751e-06 0.8640104344288071 2.129055624086531e-06 0.860615744772629 2.129055777800206e-06 0.857132398554192 \
2.129055937362381e-06 0.853469801378647 2.129056092451083e-06 0.8498714074018293 2.129056266130402e-06 0.8458039138600054 2.129056429161269e-06 0.8419559450883216 \
2.129056590803684e-06 0.8381170660338335 2.129056753450421e-06 0.8342344554797501 2.129056914868927e-06 0.8303657475978833 2.129057083463406e-06 0.8263109424305363 \
2.129057266356504e-06 0.8219002364007665 2.129057434185218e-06 0.8178440888239877 2.129057602471033e-06 0.8137703061148112 2.129057773299084e-06 0.8096302849976138 \
2.129057945473642e-06 0.8054541271740473 2.129058113235561e-06 0.8013830614994394 2.129058296865018e-06 0.7969255463994016 2.129058468271496e-06 0.7927646873948894 \
2.129058653714802e-06 0.7882638003278283 2.129058820385454e-06 0.7842196820467244 2.129058989271585e-06 0.7801233737411432 2.129059173427882e-06 0.7756572567105651 \
2.12905936803791e-06 0.7709405333854473 2.129059515293241e-06 0.7673736106648734 2.129059641923832e-06 0.7643079795643375 2.129059783780644e-06 0.7608754495129878 \
2.129059888184422e-06 0.7583505812556488 2.129060020577074e-06 0.7551502542766809 2.12906013016127e-06 0.7525028097975122 2.129060263325923e-06 0.7492875979647342 \
2.129060419507685e-06 0.7455190770546114 2.129060532737112e-06 0.7427887939149777 2.129060695258476e-06 0.7388718945951063 2.129060867439291e-06 0.7347246296492568 \
2.129061063444044e-06 0.7300078517193382 2.129061227834023e-06 0.7260553905833119 2.129061380230704e-06 0.7223944885043934 2.129061543905858e-06 0.718466402706526 \
2.129061711831558e-06 0.7144406657912139 2.129061891671936e-06 0.7101336212543717 2.129062067965886e-06 0.7059164985576465 2.129062239040521e-06 0.7018286413152719 \
2.129062407358697e-06 0.6978099102718778 2.129062560624828e-06 0.6941537154717222 2.129062722508398e-06 0.6902960245155986 2.129062901459939e-06 0.6860364417190952 \
2.12906303567149e-06 0.6828448068431195 2.129063139177788e-06 0.6803854168085423 2.1290632384622e-06 0.6780286039046017 2.129063339916677e-06 0.6756220912380299 \
2.129063432373276e-06 0.6734303711245889 2.129063516962075e-06 0.6714267031582685 2.129063610539411e-06 0.6692114082407524 2.129063727081631e-06 0.6664546942583044 \
2.129063836559192e-06 0.6638675763958631 2.129063949672203e-06 0.6611971533414394 2.12906407279097e-06 0.6582923426231613 2.129064197017283e-06 0.6553636581362478 \
2.129064367777427e-06 0.6513432847262797 2.129064526226014e-06 0.6476181700514572 2.129064698513837e-06 0.6435738126612673 2.129064844491904e-06 0.6401512360303271 \
2.12906498628512e-06 0.6368325564797357 2.129065117883574e-06 0.6337564355289309 2.129065248046859e-06 0.630718219665797 2.129065373571799e-06 0.6277924818644975 \
2.129065505354707e-06 0.6247239543970449 2.129065635278203e-06 0.6217046839485236 2.129065771586778e-06 0.6185408917806742 2.129065916200345e-06 0.615188962872713 \
2.129066075692536e-06 0.611499189008522 2.129066249152652e-06 0.6074939486938447 2.129066420159954e-06 0.6035554342946753 2.129066651528523e-06 0.5982402936372396 \
2.129066894990528e-06 0.5926661367297537 2.129067069111016e-06 0.5886942528256315 2.129067215383093e-06 0.5853638081576373 2.129067349755312e-06 0.58231230528805 \
2.129067466850207e-06 0.5796585826255305 2.129067562614553e-06 0.5774900935424465 2.129067661461095e-06 0.5752566196463251 2.129067745438414e-06 0.5733628024369305 \
2.129067823052463e-06 0.571614165956722 2.129067884377937e-06 0.5702331258704825 2.129067949058575e-06 0.5687779664863769 2.129068030366711e-06 0.5669528575016536 \
2.129068080436707e-06 0.5658306078972934 2.129068129757269e-06 0.5647256890740617 2.129068191677069e-06 0.5633393552914843 2.129068239508894e-06 0.5622690492396486 \
2.12906829001368e-06 0.5611395143522533 2.129068350075717e-06 0.559799205480933 2.129068409358512e-06 0.5584782058326896 2.129068484415226e-06 0.5568072508052372 \
2.129068554097882e-06 0.5552574373576753 2.129068639686449e-06 0.5533559356568912 2.129068726753821e-06 0.5514265885063823 2.129068810416341e-06 0.5495763264044081 \
2.129068896561366e-06 0.5476734676082877 2.129068992265987e-06 0.5455621222678217 2.129069096550938e-06 0.5432673229847179 2.129069211218113e-06 0.5407497407899529 \
2.129069319936574e-06 0.5383664115638558 2.129069429508814e-06 0.5359693749054023 2.129069541813574e-06 0.5335193270114367 2.129069668589195e-06 0.530759392645703 \
2.129069790866427e-06 0.5281021910076299 2.129069930952405e-06 0.5250685463469849 2.129070067969763e-06 0.5221084647952599 2.129070218271135e-06 0.5188705764247719 \
2.129070377166376e-06 0.5154582091324615 2.129070551500259e-06 0.5117250894133971 2.129070738517481e-06 0.5077378180012799 2.129070943835486e-06 0.5033745272871338 \
2.129071155677679e-06 0.498891131759938 2.129071408479721e-06 0.4935662239713107 2.12907161056737e-06 0.4893264048484654 2.129071845160675e-06 0.4844277613141263 \
2.129072081275272e-06 0.4795194943790256 2.129072334451769e-06 0.474283574581623 2.129072644981731e-06 0.4679020429045382 2.12907286303971e-06 0.4634451779596257 \
2.129073036485344e-06 0.4599153839204358 2.129073212977781e-06 0.4563351808422506 2.129073492459577e-06 0.4506930409909046 2.129073724703484e-06 0.4460279192631412 \
2.129074011797073e-06 0.44029020239849 2.129074229643181e-06 0.435960758243863 2.129074439695769e-06 0.4318042429497612 2.129074640893605e-06 0.4278406951573778 \
2.129074823313765e-06 0.4242617300271556 2.129074997208751e-06 0.4208637793449936 2.129075162072867e-06 0.4176529694331993 2.12907532082684e-06 0.4145718140694327 \
2.129075487073787e-06 0.4113577680628809 2.129075635718993e-06 0.4084923702366076 2.129075788087249e-06 0.4055658186126443 2.129075930150432e-06 0.4028468403491589 \
2.12907609952631e-06 0.3996150665462138 2.12907621990823e-06 0.3973276483660343 2.129076329881494e-06 0.3952449223617059 2.129076444806895e-06 0.3930732253581283 \
2.129076597048475e-06 0.3902080468194818 2.12907670926954e-06 0.3881039677199808 2.129076816462041e-06 0.386098874836553 2.129076968990289e-06 0.383254723448244 \
2.129077097137419e-06 0.380874963946598 2.129077219985412e-06 0.3786015923730871 2.129077399083788e-06 0.375299968600122 2.12907754816842e-06 0.3725653942578417 \
2.129077715875808e-06 0.3695018296724824 2.129077871273443e-06 0.3666748141177644 2.129077995440288e-06 0.3644243980538668 2.129078109332155e-06 0.3623666676050148 \
2.129078230775526e-06 0.3601804966264144 2.129078410927293e-06 0.3569532670533712 2.129078577415114e-06 0.3539878629329621 2.129078767834223e-06 0.3506138544217919 \
2.129078959590819e-06 0.3472380408565978 2.129079142640212e-06 0.344035729794033 2.129079291612277e-06 0.3414435189591631 2.129079411552182e-06 0.3393660536257183 \
2.129079534213665e-06 0.3372483242714233 2.129079657244151e-06 0.3351324902755385 2.129079802148562e-06 0.3326515017845288 2.129079905461337e-06 0.3308907757076019 \
2.129079999190846e-06 0.3292979229163631 2.129080089851148e-06 0.3277620998585528 2.129080200972602e-06 0.3258853746017661 2.129080308145579e-06 0.3240820510456246 \
2.12908040642023e-06 0.3224338250618513 2.129080518824776e-06 0.3205545940512134 2.129080682764676e-06 0.3178277446588927 2.129080844402555e-06 0.3151576097143818 \
2.129080992189301e-06 0.3127316247504084 2.129081154434516e-06 0.3100832165115083 2.129081314465073e-06 0.3074868334344322 2.129081466728372e-06 0.3050304870660137 \
2.129081620100242e-06 0.3025703731928215 2.129081778808771e-06 0.3000411640344692 2.1290819432579e-06 0.297437246442505 2.129082110484977e-06 0.2948063590562646 \
2.129082263596513e-06 0.292412731930112 2.129082446694441e-06 0.2895700146919417 2.129082637002178e-06 0.2866380344427262 2.129082785905237e-06 0.2843603072871506 \
2.129082959842541e-06 0.2817165165722222 2.12908313671993e-06 0.2790484233348025 2.129083284317149e-06 0.2768363681311815 2.129083473948849e-06 0.2740172295061162 \
2.129083623950767e-06 0.2718052906662373 2.129083761060958e-06 0.2697943906627059 2.129083902591401e-06 0.2677397479842996 2.12908401605027e-06 0.2661005451260196 \
2.129084152340596e-06 0.2641384584581135 2.129084282417218e-06 0.2622807416655737 2.12908440067147e-06 0.2606037730704709 2.129084518527066e-06 0.2589348966568543 \
2.129084649420877e-06 0.2570853888657079 2.129084789659635e-06 0.2551145527343576 2.129084905154221e-06 0.2534976852533538 2.129085034005598e-06 0.2516957519945816 \
2.129085149151579e-06 0.2500885525459272 2.129085302462547e-06 0.2479513765689386 2.129085440316308e-06 0.2460367343642474 2.12908557977796e-06 0.2441002375748529 \
2.129085735245815e-06 0.2419427021952501 2.12908586002843e-06 0.2402176526454788 2.129085999893338e-06 0.2382916534360561 2.129086128595514e-06 0.2365220787132559 \
2.129086249554366e-06 0.234860341242685 2.129086366599666e-06 0.2332541163798121 2.12908649260073e-06 0.2315368940272461 2.129086589320323e-06 0.2302195772445239 \
2.129086681409196e-06 0.2289683907689286 2.129086795826667e-06 0.2274152998827935 2.129086894197314e-06 0.2260807986508055 2.129087011344108e-06 0.2244933520241092 \
2.129087114435226e-06 0.2231010305483718 2.129087219949952e-06 0.2216798666278746 2.129087300868012e-06 0.2205933880575098 2.129087374539197e-06 0.2196046443759679 \
2.129087417268434e-06 0.2190314036349237 2.129087460398579e-06 0.2184540235451489 2.129087511196061e-06 0.217774515685755 2.129087548370939e-06 0.217277430841393 \
2.129087589041954e-06 0.2167338127731004 2.129087631833755e-06 0.2161620985357572 2.129087668244897e-06 0.2156758299561118 2.129087710169888e-06 0.2151161507306283 \
2.129087764712098e-06 0.2143884526296278 2.129087803170856e-06 0.2138756926875936 2.129087842797626e-06 0.2133496230586122 2.129087904630128e-06 0.212531488259555 \
2.129087966356579e-06 0.2117156525305126 2.129088022493854e-06 0.210974237875411 2.129088086149084e-06 0.210134110843225 2.129088180240117e-06 0.2088936328424611 \
2.129088267048376e-06 0.2077505933124353 2.12908836100502e-06 0.2065146061917991 2.129088459047254e-06 0.2052266823513323 2.12908856063462e-06 0.2038976009052371 \
2.129088661543568e-06 0.2025832113009377 2.129088758279377e-06 0.2013244528083448 2.129088860404348e-06 0.1999972806373927 2.129088963735906e-06 0.1986583046056677 \
2.129089073618507e-06 0.1972379690671278 2.129089182560765e-06 0.1958337611883887 2.129089302395885e-06 0.1942937175364915 2.129089412679751e-06 0.1928822800638286 \
2.129089520558496e-06 0.191507108810815 2.129089646621254e-06 0.1899051957406391 2.129089736488961e-06 0.1887671190866151 2.1290898469673e-06 0.1873723090993208 \
2.129089924500249e-06 0.1863971337376019 2.129090008823992e-06 0.1853400660204312 2.12909009641205e-06 0.1842452710069853 2.129090184204644e-06 0.18315095174413 \
2.129090265924516e-06 0.1821357652581398 2.129090363486193e-06 0.1809282658474054 2.129090470197344e-06 0.1796118512064394 2.129090570679026e-06 0.178377576484793 \
2.129090694850238e-06 0.1768595317522179 2.129090828741761e-06 0.1752320886156309 2.129090947653953e-06 0.1737937102924047 2.129091098054147e-06 0.1719851742607024 \
2.12909120888924e-06 0.1706594030660365 2.129091348655982e-06 0.168997130456427 2.12909146718129e-06 0.1675953052211382 2.129091572608521e-06 0.1663548750207849 \
2.12909166731838e-06 0.1652455210322802 2.129091760628154e-06 0.1641568522804657 2.12909186153427e-06 0.1629842804551663 2.129091956952102e-06 0.1618800504313296 \
2.129092054143026e-06 0.1607598891027116 2.129092135704507e-06 0.1598237474547246 2.129092241020952e-06 0.1586229753023833 2.129092324500658e-06 0.1576763029943549 \
2.129092426029949e-06 0.1565306813704828 2.129092503260486e-06 0.1556635090415242 2.129092594132523e-06 0.154647919213242 2.129092663483834e-06 0.1538765336840219 \
2.129092748067885e-06 0.1529397840535594 2.129092822461091e-06 0.1521208717489242 2.129092901831293e-06 0.151251902275755 2.129092976418965e-06 0.1504388356812226 \
2.129093045640521e-06 0.1496871728711989 2.129093140321328e-06 0.1486640077242138 2.129093210087093e-06 0.1479134441579097 2.129093294531656e-06 0.147008717574758 \
2.129093356097001e-06 0.1463518850554192 2.129093430139493e-06 0.1455673550676988 2.129093503525017e-06 0.1447940960774066 2.129093584960258e-06 0.1439395015691976 \
2.129093654409405e-06 0.1432139999234875 2.129093729511102e-06 0.1424323701137583 2.129093819423173e-06 0.1415006120834361 2.129093896506793e-06 0.1407052977810757 \
2.129093995617377e-06 0.1396885207473417 2.12909406515744e-06 0.138983077430453 2.129094146475915e-06 0.1381612812129989 2.129094216644325e-06 0.1374549162714094 \
2.129094295612438e-06 0.1366629455350578 2.129094374590721e-06 0.1358740351737466 2.12909444691251e-06 0.1351544405911459 2.129094516277969e-06 0.1344667589602006 \
2.129094564981977e-06 0.1339854049281765 2.129094655744348e-06 0.1330945614011112 2.129094687765876e-06 0.1327823711724506 2.129094775869844e-06 0.131925672678654 \
2.129094808363887e-06 0.1316105445757083 2.129094907031543e-06 0.1306564447580443 2.129094950687519e-06 0.130235859061297 2.129095028669335e-06 0.1294866595045693 \
2.129095066000294e-06 0.1291289430202982 2.129095168151694e-06 0.128153223240932 2.129095235595654e-06 0.1275115375392494 2.129095300748612e-06 0.1268935577290946 \
2.129095366654626e-06 0.1262729746041904 2.129095437806609e-06 0.1256052797936485 2.12909552074397e-06 0.1248293808775363 2.129095606139451e-06 0.1240331657139879 \
2.129095682226845e-06 0.1233259817834828 2.129095762687521e-06 0.1225806238777534 2.129095820771462e-06 0.1220441728027253 2.129095892104936e-06 0.1213870835332726 \
2.129095976893369e-06 0.1206085709991845 2.129096038048402e-06 0.1200487744399507 2.129096108134853e-06 0.1194096117168642 2.129096170640142e-06 0.1188419501154776 \
2.12909623664509e-06 0.1182453094891599 2.129096305417857e-06 0.1176255789053269 2.129096374874481e-06 0.1170017375875525 2.129096458038731e-06 0.1162574953874909 \
2.129096531156255e-06 0.1156056107435251 2.129096601870241e-06 0.1149774116339468 2.129096661221924e-06 0.1144518657417393 2.129096766519135e-06 0.1135239342411639 \
2.12909681238663e-06 0.1131212254602471 2.129096899340683e-06 0.1123603821649216 2.129096942354464e-06 0.1119852310621949 2.129096987221211e-06 0.1115947726395539 \
2.129097076954706e-06 0.1108164664143028 2.129097147839057e-06 0.110204256460374 2.129097226692571e-06 0.109525796983828 2.129097289470346e-06 0.1089876103666232 \
2.129097349464702e-06 0.1084750215669379 2.129097460462474e-06 0.1075310013968523 2.12909754121676e-06 0.1068475792877216 2.129097653680086e-06 0.1059005796323111 \
2.129097704824629e-06 0.1054717782906781 2.129097787809798e-06 0.1047785948356612 2.129097845974503e-06 0.1042945647727652 2.129097960212503e-06 0.1033482075721767 \
2.12909801011597e-06 0.1029366076865433 2.129098095857569e-06 0.1022320954501846 2.12909814488902e-06 0.1018307629303728 2.129098227455441e-06 0.101157455862875 \
2.129098298387777e-06 0.1005815064560546 2.129098366538128e-06 0.1000302812267231 2.129098444148443e-06 0.0994053199805509 2.129098516491814e-06 0.09882546240595018 \
2.129098594067778e-06 0.09820656846618626 2.129098682738439e-06 0.09750287271560702 2.129098756553227e-06 0.09692010793638871 2.129098838144235e-06 0.09627924899616347 \
2.129098916282703e-06 0.09566870926115327 2.129099002032494e-06 0.09500229249765579 2.129099089729402e-06 0.09432453920671229 2.129099183638967e-06 0.09360304191323381 \
2.129099280098285e-06 0.09286661217778783 2.129099358728946e-06 0.09226977907248698 2.129099461452546e-06 0.09149473120661993 2.129099545280196e-06 0.09086620530027881 \
2.129099666032378e-06 0.08996702094116031 2.129099795302029e-06 0.08901247130467421 2.129099951190493e-06 0.08787237469953549 2.129100106290076e-06 0.08675000010972149 \
2.129100263305883e-06 0.08562614142917294 2.129100443326735e-06 0.08435280068725284 2.129100593847601e-06 0.08330035525696428 2.129100742221624e-06 0.08227363395463329 \
2.129100879838855e-06 0.08133079092382095 2.129101019758505e-06 0.08038162993974078 2.129101156365493e-06 0.07946425488810546 2.129101295092791e-06 0.07854214404995859 \
2.129101440403653e-06 0.07758663187171365 2.129101588151466e-06 0.07662571164688473 2.129101746748333e-06 0.07560598447141591 2.129101911000851e-06 0.07456266320243836 \
2.129102080017927e-06 0.07350246718885647 2.129102261906921e-06 0.07237646636762114 2.129102462529019e-06 0.07115268999588262 2.129102676406562e-06 0.0698691158856425 \
2.129102904040694e-06 0.0685263410462881 2.129103145626236e-06 0.06712722147996912 2.129103427215414e-06 0.06552977831071743 2.129103724369535e-06 0.06388229915275011 \
2.129104047802612e-06 0.06213267023812474 2.129104438962031e-06 0.0600758559534558 2.129104840456333e-06 0.05803293250078725 2.129105217397059e-06 0.05617754872181892 \
2.129105584510791e-06 0.05442503025024555 2.129105934627471e-06 0.05280240270907886 2.129106253933125e-06 0.05136309724710254 2.129106558257407e-06 0.05002640192327024 \
2.129106855163313e-06 0.04875503464657577 2.129107137163638e-06 0.04757867888787161 2.129107417596943e-06 0.04643900623749339 2.129107682320567e-06 0.04538777697325767 \
2.129107958218279e-06 0.04431704973151576 2.129108232683143e-06 0.04327654260273706 2.129108531102423e-06 0.04217254828989973 2.12910875761848e-06 0.04135316230013186 \
2.129109069531317e-06 0.04025053053625379 2.129109289786109e-06 0.03948972371590862 2.129109507050863e-06 0.03875470657060948 2.129109716773512e-06 0.03806113111453101 \
2.1291100269559e-06 0.03705828856757609 2.129110249553778e-06 0.03635538859683734 2.129110496919279e-06 0.03559019656168042 2.129110769325655e-06 0.03476651972027592 \
2.129110989958209e-06 0.03411384091885184 2.12911127423846e-06 0.03329124852897781 2.129111512151752e-06 0.0326183788879464 2.129111750241164e-06 0.03195887699386461 \
2.129111985496492e-06 0.03132132139405813 2.129112214275199e-06 0.03071728735992773 2.129112447005948e-06 0.03011490821398154 2.129112666308989e-06 0.02955843195412813 \
2.12911287025206e-06 0.02905055018162466 2.129113269161795e-06 0.02808303002558106 2.129113456316051e-06 0.02764052191221165 2.129113828521772e-06 0.0267814187683372 \
2.129114015473295e-06 0.02635997027055515 2.129114384827242e-06 0.02554620807076183 2.12911453848041e-06 0.02521471147941385 2.129114954694564e-06 0.02434161493068329 \
2.129115160182381e-06 0.02392065165079968 2.129115499190341e-06 0.02323955384462723 2.129115681885069e-06 0.02287916718068597 2.129116138978978e-06 0.02199597290476789 \
2.129116268719714e-06 0.02174967209293581 2.129116722140138e-06 0.02089828923199067 2.12911686451243e-06 0.0206336680476187 2.129117394079191e-06 0.01967289368906444 \
2.129117520286197e-06 0.01945139161001456 2.129118082520635e-06 0.01850749734048266 2.129118245259022e-06 0.01824627541187189 2.129118809439087e-06 0.01738327200207762 \
2.129118961183154e-06 0.01716165742474803 2.129119662862638e-06 0.01618760396393164 2.129119832951728e-06 0.01596324388168 2.129120488009604e-06 0.01513221026437959 \
2.129120654523916e-06 0.01492874613340729 2.129121387637676e-06 0.01406966818047924 2.129121520900854e-06 0.01391906482409888 2.129122372558029e-06 0.01299647369571925 \
2.129122510500477e-06 0.01285324185793544 2.129123450559967e-06 0.0119198170026788 2.129123614321604e-06 0.01176347583728811 2.129124601555039e-06 0.01085909507266535 \
2.129124736144115e-06 0.0107410715025141 2.129125877583545e-06 0.009819907073012045 2.129125985822443e-06 0.009738548299709823 2.129127309069827e-06 0.00880579379490502 \
2.129127441815525e-06 0.008718202093769473 2.12912896431665e-06 0.007760835273143199 2.129129076858719e-06 0.007690148685505111 2.129130769150306e-06 0.00669558715138598 \
2.129130909416891e-06 0.00662113250846694 2.129132982426194e-06 0.005629132576249021 2.129133174987711e-06 0.005545002188831318 2.129135385197559e-06 0.004656096148610405 \
2.129135791984232e-06 0.004507219767123045 2.129138613724208e-06 0.003590578528330178 2.129139135019958e-06 0.00344214578404881 2.129143347121009e-06 0.002447529662748036 \
2.129143899683877e-06 0.002340875287107731 2.129149782973417e-06 0.001359168649576994 2.129150032246415e-06 0.001311490127959886 2.129163182367465e-06 0.0003136950974005476 \
2.129163299150435e-06 0.0003112730584132499 2.158990000000011e-06 3.042397160644726e-06 2.202746667027013e-06 -0.0009024818035526668 2.202746739442629e-06 -0.001022682652537627 \
2.202747175467347e-06 -0.001858525046639076 2.20274726236173e-06 -0.002046124893065343 2.202747617065043e-06 -0.00288168582347465 2.202747716611644e-06 -0.003135075204051477 \
2.202747976881348e-06 -0.003828199033013717 2.20274811720375e-06 -0.004216406518003108 2.202748344689832e-06 -0.004856871791621592 2.202748481897271e-06 -0.005239031028659006 \
2.20274886679612e-06 -0.006187559915121 2.202748998893307e-06 -0.006423332025500122 2.202749687336335e-06 -0.005917035979538006 2.202749844265069e-06 -0.005202654566481615 \
2.202749971914231e-06 -0.004414133290428114 2.202750099456021e-06 -0.003433350487145549 2.202750217130233e-06 -0.002355902309038119 2.20275031626992e-06 -0.001320627313728655 \
2.20275042165263e-06 -9.507383675133965e-05 2.202750535559933e-06 0.001369964538583592 2.202750666615328e-06 0.003229572948258866 2.202750791978547e-06 0.005172303930030842 \
2.202750983820411e-06 0.008432154569684791 2.202751127490204e-06 0.01107975669588844 2.202751285472017e-06 0.01417105828876112 2.202751434071664e-06 0.01723098336859398 \
2.202751587122593e-06 0.02051714008521248 2.202751746187569e-06 0.02405720796424875 2.202751899257778e-06 0.02756764950178633 2.202752047604842e-06 0.03105219347129199 \
2.202752196711284e-06 0.03462388853332505 2.202752351275713e-06 0.03838854885099419 2.202752511961676e-06 0.04235886888523473 2.202752676640863e-06 0.04647718198980624 \
2.202752853163806e-06 0.05093664320808645 2.202753032175606e-06 0.05549818742091989 2.202753222948448e-06 0.0603932190016783 2.2027534277958e-06 0.06567927942044927 \
2.202753648293053e-06 0.07139554989571946 2.202753881211021e-06 0.07745499876455469 2.202754130458799e-06 0.08395499695136356 2.202754403380326e-06 0.09108394918256098 \
2.202754700173383e-06 0.09884095133633181 2.202755027609895e-06 0.1073964775374675 2.202755397423695e-06 0.1170487607486894 2.202755792369975e-06 0.1273407304921971 \
2.202756250458528e-06 0.1392499850125259 2.202756782558388e-06 0.1530377249371455 2.202757408110396e-06 0.169180864038255 2.202758094102462e-06 0.1867931863309214 \
2.202758896945878e-06 0.2072766958045763 2.202759796258209e-06 0.2300508264895909 2.202760696698322e-06 0.2526618731709107 2.202761498589855e-06 0.2726215666318766 \
2.202762194096996e-06 0.2897857674353052 2.202762826931282e-06 0.3052728323588638 2.202763422339773e-06 0.3197161646377594 2.202763969382815e-06 0.3328722959176427 \
2.202764503143162e-06 0.3455929446372428 2.202765022382586e-06 0.3578476146335662 2.202765529774048e-06 0.3697097539883151 2.202766033395218e-06 0.3813674725871593 \
2.202766545138114e-06 0.3930934709428262 2.202767052299123e-06 0.404595334768291 2.202767582595137e-06 0.4164962117964878 2.202768068708625e-06 0.4272847049163567 \
2.202768546816947e-06 0.437781779057129 2.202768986249071e-06 0.4473362978389137 2.202769109408535e-06 0.4500002106608159 2.202769355727463e-06 0.4553046876287923 \
2.202769698999458e-06 0.4626558934952216 2.202770010436459e-06 0.4692815017887791 2.202770261147724e-06 0.4745855323881177 2.202770531976868e-06 0.480281321066213 \
2.202770868458777e-06 0.4873122872019196 2.202771224467388e-06 0.4946959640027882 2.202771541737556e-06 0.5012322602315481 2.202771780618105e-06 0.506122906570856 \
2.202772021646287e-06 0.5110269393752048 2.202772273577991e-06 0.5161276795544476 2.202772513731834e-06 0.5209621749612534 2.202772736483296e-06 0.5254248476203834 \
2.202772925040943e-06 0.5291850880529715 2.202773139790986e-06 0.5334523706207774 2.202773354339378e-06 0.5376948565446859 2.20277361310367e-06 0.5427871977552768 \
2.202773863931242e-06 0.5477009885064807 2.202774119350104e-06 0.5526782776843104 2.202774470392629e-06 0.5594898819265107 2.202774735000954e-06 0.5645984056527484 \
2.202775001417509e-06 0.569709962982798 2.20277526193182e-06 0.5746801970751495 2.202775529021882e-06 0.5797469183389945 2.202775772159962e-06 0.5843213438768613 \
2.202776027852189e-06 0.5890994944692448 2.202776255671159e-06 0.5933243819692556 2.202776493215979e-06 0.5976999800355528 2.202776704606465e-06 0.6015679915939678 \
2.202776916747225e-06 0.6054277082074113 2.202777105936602e-06 0.6088479815213901 2.20277723709492e-06 0.6112112531841202 2.202777369391478e-06 0.6135871094428261 \
2.202777554614204e-06 0.6169015645304802 2.202777716636591e-06 0.6197943209800671 2.202777875055755e-06 0.6226100751126036 2.202778009167621e-06 0.6249846001944386 \
2.202778181488729e-06 0.6280247049765127 2.202778310427531e-06 0.6302937061188456 2.202778430805044e-06 0.6324061607157294 2.202778571333915e-06 0.634864734791624 \
2.202778764419407e-06 0.6382321981637986 2.202778914230185e-06 0.6408363654380513 2.202779081537779e-06 0.6437327988167145 2.202779262592003e-06 0.6468572757970242 \
2.202779465918433e-06 0.6503523798695617 2.202779648771588e-06 0.6534819287355287 2.202779819395834e-06 0.6563879501053153 2.202779996860074e-06 0.6594029650344411 \
2.202780162839024e-06 0.6622113135173925 2.202780320075814e-06 0.6648594636266301 2.202780460561866e-06 0.6672075432495704 2.202780604291994e-06 0.6695987751186935 \
2.202780737338985e-06 0.6718055529208897 2.202780879311128e-06 0.6741523780906628 2.202780999371661e-06 0.6761293215200647 2.202781144309748e-06 0.6785098354674278 \
2.202781260306798e-06 0.6804095298668216 2.202781379886685e-06 0.6823647593763783 2.20278147884666e-06 0.68397755359623 2.202781597355078e-06 0.6859039329668146 \
2.20278168439936e-06 0.6873150904607619 2.202781806410179e-06 0.6892866586554622 2.202781905332791e-06 0.6908817703737582 2.202781997228166e-06 0.6923536807698466 \
2.202782097196705e-06 0.6939486118486815 2.202782195442366e-06 0.6955126686751646 2.202782287156128e-06 0.6969676095571918 2.20278239128907e-06 0.698613189139943 \
2.202782527015812e-06 0.7007470979739818 2.202782681624274e-06 0.7031613517373301 2.202782816731986e-06 0.7052558942641604 2.202782963068532e-06 0.7075085519458914 \
2.202783091536073e-06 0.7094732734147607 2.202783215720207e-06 0.7113609898537658 2.202783325624507e-06 0.7130225953369277 2.202783442207576e-06 0.7147759898693785 \
2.202783542385406e-06 0.7162749667021007 2.202783679474215e-06 0.7183149847558421 2.202783799463242e-06 0.7200901405411056 2.20278391857669e-06 0.7218426783097279 \
2.202784045072077e-06 0.723693513465353 2.202784170939449e-06 0.7255245570057045 2.202784293560467e-06 0.7272980597885179 2.202784421177991e-06 0.7291334326655684 \
2.202784551426783e-06 0.7309957624152177 2.202784673019733e-06 0.73272442801297 2.202784811788425e-06 0.7346853525547948 2.202784912196869e-06 0.7360963845229137 \
2.202785015584257e-06 0.7375412410987998 2.202785109244699e-06 0.7388443755773992 2.202785220866297e-06 0.7403895158541485 2.2027853073349e-06 0.7415798421827293 \
2.20278540819801e-06 0.7429609798983192 2.202785540294732e-06 0.7447573558536402 2.202785649496033e-06 0.7462323422761349 2.202785754027664e-06 0.747635567415085 \
2.202785877674144e-06 0.7492836897664436 2.20278602637058e-06 0.7512497161812216 2.202786148251239e-06 0.7528480713857697 2.202786261855803e-06 0.7543274008692354 \
2.202786402375488e-06 0.7561429069656862 2.20278654356493e-06 0.7579511824827749 2.202786661311106e-06 0.7594470562859095 2.202786790000765e-06 0.7610693809796742 \
2.202786932555413e-06 0.7628512182523866 2.202787048411964e-06 0.7642872416835913 2.202787194175229e-06 0.7660789429779771 2.202787316007677e-06 0.7675637574673733 \
2.202787434476374e-06 0.7689965471136999 2.202787557264006e-06 0.7704700089613156 2.202787683416888e-06 0.7719718272910862 2.202787793785939e-06 0.7732757954107932 \
2.202787919217035e-06 0.7747465774777432 2.202788024698746e-06 0.775974259539018 2.202788157865176e-06 0.7775122819577122 2.202788280546631e-06 0.7789173428708996 \
2.202788415309674e-06 0.7804473432620218 2.202788525980963e-06 0.7816923373676121 2.202788635302591e-06 0.7829118427552927 2.202788770435026e-06 0.7844048889494442 \
2.20278892121405e-06 0.7860523747618094 2.202789061582958e-06 0.7875692293014268 2.202789181294483e-06 0.7888502570533434 2.202789319548823e-06 0.7903153082715967 \
2.202789442919159e-06 0.7916096503654788 2.202789588017784e-06 0.7931164937536124 2.202789727758043e-06 0.7945521172774316 2.202789854939466e-06 0.7958455533278409 \
2.20278997397922e-06 0.7970449251022731 2.202790086337411e-06 0.7981670522831598 2.20279019056619e-06 0.79919939674296 2.202790285905002e-06 0.8001364844871954 \
2.202790422193112e-06 0.8014634245741865 2.202790539085655e-06 0.8025894467082511 2.202790658725145e-06 0.8037305025474466 2.202790780606716e-06 0.8048811831579785 \
2.202790902985053e-06 0.8060245537852575 2.202791031013733e-06 0.8072081965553952 2.202791155658531e-06 0.8083483262222385 2.202791286157279e-06 0.8095291977395493 \
2.202791412617706e-06 0.8106611567088965 2.202791539743674e-06 0.8117869190804841 2.202791644861151e-06 0.8127087429624065 2.20279175011134e-06 0.8136235164943317 \
2.20279184125159e-06 0.8144090748259969 2.202791964669625e-06 0.8154632009865571 2.202792051748274e-06 0.8162003374872545 2.202792151070959e-06 0.8170344894488412 \
2.202792295992702e-06 0.8182390501293432 2.202792432261206e-06 0.8193582434421302 2.202792541723485e-06 0.8202477434185359 2.202792687843586e-06 0.8214214001843773 \
2.202792839202198e-06 0.8226208465286928 2.20279296500612e-06 0.8236052915965452 2.202793109416779e-06 0.824721541823094 2.202793234017729e-06 0.8256729463037898 \
2.202793384729791e-06 0.8268094083523665 2.20279352010105e-06 0.8278169867326588 2.202793645303979e-06 0.8287379047458127 2.202793762973361e-06 0.829593908450195 \
2.202793908801338e-06 0.8306418458276996 2.20279407529732e-06 0.8318207857986918 2.202794206154408e-06 0.8327345044534114 2.202794379603848e-06 0.833928356718921 \
2.202794547722322e-06 0.8350667646575466 2.202794717596125e-06 0.8361988603660855 2.202794898450753e-06 0.8373843006762304 2.202795041633135e-06 0.8383085120571983 \
2.202795155746478e-06 0.8390361588138326 2.202795285812469e-06 0.8398559950134801 2.202795387687705e-06 0.8404909448220066 2.202795504566998e-06 0.8412116130393378 \
2.202795641678928e-06 0.8420465258793415 2.202795839559572e-06 0.843231707656198 2.202796031345765e-06 0.8443585547012582 2.202796240708828e-06 0.8455646258450146 \
2.202796422822406e-06 0.846593677725298 2.202796619917178e-06 0.8476867969181797 2.202796793185875e-06 0.8486305714188691 2.202796976264561e-06 0.8496104335327738 \
2.202797147401587e-06 0.8505103231661706 2.202797322080438e-06 0.8514128411730317 2.202797497318728e-06 0.8523022053693007 2.202797673458367e-06 0.8531802340241421 \
2.202797863809624e-06 0.8541115036082744 2.20279805438677e-06 0.855025905954957 2.202798254818193e-06 0.8559685891497206 2.202798447410669e-06 0.8568563992305701 \
2.202798658273806e-06 0.8578086227668252 2.202798886187182e-06 0.8588150784816577 2.202799152217719e-06 0.8599606428795262 2.202799450738801e-06 0.8612090806949765 \
2.202799726692482e-06 0.8623286542354505 2.202800010954596e-06 0.8634483918036945 2.202800285103046e-06 0.8644969441068078 2.202800557392313e-06 0.8655088801415273 \
2.202800827558088e-06 0.8664846790737442 2.202801084736186e-06 0.8673881555543895 2.202801357299353e-06 0.868319368003445 2.202801633304697e-06 0.8692355072818493 \
2.202801903418628e-06 0.870106770567397 2.202802203245002e-06 0.8710447971670072 2.202802574222291e-06 0.8721640818024149 2.202802869154012e-06 0.8730224021943973 \
2.202803123432376e-06 0.873740732376842 2.202803421677207e-06 0.8745584461000401 2.202803695285219e-06 0.8752856917963749 2.202803931415444e-06 0.8758961959341748 \
2.202804171760979e-06 0.8765017794770257 2.202804394097167e-06 0.8770481951318053 2.20280458810245e-06 0.8775144010549708 2.202804917823794e-06 0.8782846129827527 \
2.202805072996819e-06 0.8786376896881318 2.202805390752407e-06 0.8793424631377607 2.202805569616983e-06 0.8797286397841958 2.202805912078462e-06 0.8804474051285093 \
2.202806096217817e-06 0.880822800830328 2.202806571118475e-06 0.881756283451624 2.202806738513154e-06 0.8820737784441692 2.2028072043462e-06 0.8829272622221894 \
2.202807385170493e-06 0.8832470363605239 2.202807879204793e-06 0.8840891816604841 2.202808020548668e-06 0.8843218944112644 2.202808626940586e-06 0.8852805359894154 \
2.202808779011766e-06 0.8855111592597558 2.202809425691436e-06 0.8864506941541785 2.202809553987642e-06 0.8866295550025313 2.202810202164815e-06 0.8874976172723908 \
2.202810331923675e-06 0.8876644392549727 2.202811100144497e-06 0.8886037370453904 2.202811229881009e-06 0.8887539063021698 2.202812083306654e-06 0.8896836309705964 \
2.202812226565087e-06 0.8898301468060963 2.202813212785821e-06 0.890764641901611 2.202813434267227e-06 0.8909571971396437 2.202814577308628e-06 0.8918770673440963 \
2.202814707298117e-06 0.8919774876506176 2.202816058923388e-06 0.8929731820841386 2.20281620928357e-06 0.89307657739048 2.202817689916169e-06 0.8939986636922405 \
2.202817928817934e-06 0.8941315911431026 2.202819693311632e-06 0.894999985510941 2.202820000994978e-06 0.8951330875684044 2.202822522266181e-06 0.8960612226716312 \
2.202822959317422e-06 0.8961978289811912 2.202826862729643e-06 0.8971619289239613 2.20282710951145e-06 0.8972094058147089 2.202834686001284e-06 0.8981998139535015 \
2.202834801913031e-06 0.8982099955090975 2.202853900445735e-06 0.8992062631372056 2.202854297888509e-06 0.8992194728667773 2.20300471332359e-06 0.9002121614362558 \
2.203004979381947e-06 0.9002436812458944 2.203010247532015e-06 0.8993470931706574 2.203010453902932e-06 0.899191170936528 2.203011932015742e-06 0.8982046351054961 \
2.203012112466398e-06 0.8981003355419954 2.203014334948061e-06 0.8971299612768925 2.203014541040575e-06 0.897079983173831 2.203024949306681e-06 0.8980580240048047 \
2.203025087164257e-06 0.8980839755683444 2.203031884513298e-06 0.8990685088718567 2.203032070084766e-06 0.8990874390200084 2.203528299258968e-06 0.9000706848616691 \
2.203528359054814e-06 0.9000975977971888 2.203529612605432e-06 0.9010828413531861 2.203529718298035e-06 0.9012097231395001 2.203530376428752e-06 0.9021613947651476 \
2.203530513611021e-06 0.9023918767045529 2.203531036637641e-06 0.9033649777562528 2.203531099501233e-06 0.9034908765919824 2.203531572096782e-06 0.904476514442582 \
2.203531623410595e-06 0.9045863669199017 2.203532089373931e-06 0.9055619780118375 2.203532121578392e-06 0.9056252631670594 2.203532838677129e-06 0.9066212416280413 \
2.203532923113402e-06 0.9066528951765993 2.203533523179781e-06 0.9059679814895146 2.203533643037393e-06 0.9055903401525059 2.203533774200172e-06 0.9050640446667092 \
2.203533909019925e-06 0.9043926011431642 2.203534057154984e-06 0.9034897747335404 2.203534194714335e-06 0.902493211317788 2.203534334926095e-06 0.9013135799985507 \
2.203534433588205e-06 0.9003872218501816 2.203534519272014e-06 0.8995148096066522 2.203534601836213e-06 0.8986166894493001 2.203534716618842e-06 0.8972773101170661 \
2.203534797717086e-06 0.8962642459447687 2.203534877134364e-06 0.8952218112132616 2.203534982588891e-06 0.8937633947192651 2.203535105230195e-06 0.8919606744930825 \
2.203535204954274e-06 0.890414036797163 2.203535375148685e-06 0.8876203405523397 2.203535521333776e-06 0.8850727273800474 2.203535689551925e-06 0.8819879035815887 \
2.203535861713021e-06 0.8786780617039783 2.203536046099114e-06 0.8749807502679057 2.203536230665458e-06 0.8711418063496947 2.203536414912943e-06 0.8671917613865908 \
2.203536600248607e-06 0.8631174608718694 2.203536774636335e-06 0.8592060069639053 2.203536957340272e-06 0.8550405244181323 2.203537132687366e-06 0.8509893565349284 \
2.203537315016877e-06 0.8467313026054767 2.203537505330306e-06 0.8422468264612591 2.203537675660435e-06 0.838204894125699 2.203537842184073e-06 0.8342320488410089 \
2.203538004754937e-06 0.830337741667393 2.20353815461616e-06 0.8267359097041467 2.203538305792179e-06 0.8230937075736249 2.203538494937653e-06 0.8185270080344306 \
2.203538640655707e-06 0.8150026134285653 2.203538815646674e-06 0.8107652770601156 2.203538964118217e-06 0.807166938184282 2.203539136005683e-06 0.8029987283123258 \
2.203539305073922e-06 0.7988973224349885 2.203539469252631e-06 0.7949140139776875 2.203539628580168e-06 0.7910485911592836 2.203539789029776e-06 0.7871568543472617 \
2.203539990849157e-06 0.7822630953020117 2.203540139296892e-06 0.7786646206504594 2.203540293464276e-06 0.77492821376164 2.203540430547636e-06 0.7716074476660475 \
2.203540539933082e-06 0.7689587163513494 2.203540645866538e-06 0.7663946531324515 2.203540772880885e-06 0.7633217481666642 2.203540887243854e-06 0.7605561828888391 \
2.203540990091676e-06 0.7580702160470256 2.203541111681992e-06 0.7551325442760125 2.203541222459267e-06 0.7524575925939972 2.203541339308092e-06 0.7496376180588871 \
2.203541450092817e-06 0.7469652567786068 2.203541568458919e-06 0.7441116745915923 2.203541693286014e-06 0.7411038668912771 2.20354184584781e-06 0.7374292753756717 \
2.203541979744798e-06 0.7342062928952946 2.203542100776237e-06 0.7312947572377408 2.203542264973752e-06 0.7273475399259534 2.203542442334698e-06 0.7230877912371642 \
2.203542624545107e-06 0.7187161681757385 2.203542805542372e-06 0.7143786395952922 2.203542986206316e-06 0.7100537072471783 2.203543176357883e-06 0.7055071781827296 \
2.203543364117777e-06 0.7010230964996226 2.203543564650882e-06 0.696237807975249 2.203543773336343e-06 0.6912646166759551 2.203543980979907e-06 0.6863227581165517 \
2.203544208547776e-06 0.6809140411171237 2.20354440082261e-06 0.6763521085712711 2.203544638087858e-06 0.6707310800019505 2.203544831366122e-06 0.6661595641347996 \
2.203545064098868e-06 0.6606646229758047 2.203545269656336e-06 0.6558174602470968 2.203545502009757e-06 0.6503484594495911 2.203545697011727e-06 0.6457674053103037 \
2.203545900240336e-06 0.6410004262200759 2.203546080092881e-06 0.6367906205544323 2.203546259199312e-06 0.6326052789263827 2.203546422576526e-06 0.628795088826817 \
2.20354659462593e-06 0.6247880828503264 2.203546758118769e-06 0.6209892715878097 2.203546933908587e-06 0.6169100951581823 2.203547115847573e-06 0.6126978430086294 \
2.203547304331305e-06 0.6083422542008314 2.203547510763727e-06 0.6035858951323969 2.20354769007839e-06 0.5994633272559844 2.203547887257257e-06 0.5949432360761027 \
2.203548096345397e-06 0.5901646611556908 2.20354830209466e-06 0.5854760387944159 2.203548542605348e-06 0.5800160304866983 2.20354871573345e-06 0.5760958285528379 \
2.203548880627452e-06 0.5723746772837877 2.203549061488027e-06 0.5683014035092815 2.203549218774123e-06 0.5647722902613652 2.203549387756918e-06 0.5609879409349005 \
2.203549567863379e-06 0.5569709657351898 2.203549720846506e-06 0.5535669615732179 2.203549852560951e-06 0.5506462283231492 2.203549999948651e-06 0.5473865746199473 \
2.203550087374242e-06 0.5454560063082221 2.203550172245481e-06 0.5435860258811447 2.203550270874694e-06 0.5414171943998213 2.203550342966855e-06 0.5398340751058975 \
2.203550440057874e-06 0.5377039800781129 2.203550525648258e-06 0.5358302678688993 2.203550590729134e-06 0.5344081412607664 2.203550714329502e-06 0.5317121235594142 \
2.203550808753772e-06 0.52965475734789 2.203550906276994e-06 0.5275349985745696 2.203551079137645e-06 0.5237893654184622 2.203551214133166e-06 0.5208709659121862 \
2.203551368316627e-06 0.5175498113398643 2.203551542781984e-06 0.5138002600288881 2.20355169458797e-06 0.510550000123414 2.203551840818953e-06 0.5074290310664136 \
2.203551984717826e-06 0.5043644611166801 2.203552127739669e-06 0.5013276181140283 2.203552223349517e-06 0.499301733014788 2.203552317793473e-06 0.4973032961550828 \
2.203552438849414e-06 0.4947494705229025 2.20355253372771e-06 0.4927525559781179 2.203552649558553e-06 0.4903172469328811 2.203552736822402e-06 0.4884854516151125 \
2.203552819252848e-06 0.4867593351188191 2.203552914660801e-06 0.484765406725184 2.203553015371081e-06 0.4826639978995959 2.203553112231473e-06 0.4806459052877932 \
2.203553250961224e-06 0.4777646955734051 2.203553386666086e-06 0.4749532752442271 2.203553587150809e-06 0.4708139964547478 2.203553802464962e-06 0.4663911383470885 \
2.203553984040267e-06 0.462674698484628 2.203554183012236e-06 0.4586189944293299 2.203554353577757e-06 0.455154096457448 2.203554527931444e-06 0.4516251957269069 \
2.203554696864699e-06 0.4482170126441485 2.20355486946186e-06 0.4447467276163349 2.20355505206819e-06 0.4410867902598327 2.203555240617055e-06 0.4373240875354826 \
2.203555434084593e-06 0.4334777823509549 2.203555642405232e-06 0.4293535036700135 2.203555856750462e-06 0.4251286740881063 2.203556082455792e-06 0.4207018662297695 \
2.20355630899916e-06 0.4162771402745992 2.203556571175911e-06 0.4111844468197049 2.203556820209735e-06 0.4063709766754009 2.203557121308432e-06 0.4005865607947761 \
2.20355741072925e-06 0.3950673729298416 2.203557718243529e-06 0.3892455819062323 2.203558040439924e-06 0.3831936848847286 2.203558368170407e-06 0.3770882112794804 \
2.203558700600163e-06 0.3709500980558715 2.20355903032917e-06 0.3649083177186754 2.203559351558758e-06 0.3590729273462687 2.203559682375082e-06 0.3531219177045733 \
2.203560024730645e-06 0.3470224718704957 2.203560324371677e-06 0.3417374346434491 2.203560654159242e-06 0.3359723367088904 2.203560981053185e-06 0.3303128110141857 \
2.203561319032532e-06 0.3245206193888226 2.203561628003695e-06 0.3192755432624759 2.203561952801668e-06 0.31382336954194 2.203562268431866e-06 0.3085864885517507 \
2.203562573419032e-06 0.3035810258414895 2.203562828757678e-06 0.2994330834535801 2.203563093620834e-06 0.295170851203172 2.203563380703519e-06 0.2905978071194348 \
2.203563603673297e-06 0.2870801635277143 2.203563803212566e-06 0.2839591363066187 2.20356401286858e-06 0.2807045410859125 2.203564193125121e-06 0.2779290029372279 \
2.203564355469841e-06 0.2754463208250681 2.203564505904815e-06 0.2731629026725527 2.203564656910124e-06 0.2708866524077067 2.203564853800714e-06 0.2679392949564011 \
2.203564984945478e-06 0.2659970646012914 2.203565109682017e-06 0.2641561221543183 2.20356526127406e-06 0.2619266655689588 2.203565357242231e-06 0.2605306204207966 \
2.203565453793599e-06 0.2591282589302421 2.203565578413388e-06 0.2573209601776467 2.203565720989923e-06 0.255257422470362 2.203565879923458e-06 0.25296979123958 \
2.203566012589525e-06 0.251062957019046 2.203566196158294e-06 0.2484301322588876 2.203566377393459e-06 0.2458327969660818 2.203566588907564e-06 0.2428051031600066 \
2.203566791497399e-06 0.2399069804317323 2.203566958053846e-06 0.2375282895552967 2.203567168273059e-06 0.2345337828133105 2.203567341690945e-06 0.2320692345528927 \
2.203567570533673e-06 0.2288260787734411 2.203567791168424e-06 0.2257162440502939 2.203567966830138e-06 0.2232503232699662 2.203568147290643e-06 0.2207258962977968 \
2.203568318047021e-06 0.2183528725291195 2.203568498243287e-06 0.2158619697278009 2.203568664973904e-06 0.2135675266585953 2.203568814095326e-06 0.2115251542210239 \
2.203568969905344e-06 0.2094125291275523 2.203569105085769e-06 0.2075875692769576 2.203569255167197e-06 0.2055694209972212 2.203569387612823e-06 0.2037957203154137 \
2.203569528157359e-06 0.2019220745191926 2.203569645226124e-06 0.2003748851744883 2.20356977493373e-06 0.1986681706274326 2.203569896991199e-06 0.1970700654731777 \
2.203570019534635e-06 0.1954731161836187 2.203570137553958e-06 0.1939418157697267 2.203570272576731e-06 0.1921981789937757 2.203570417201182e-06 0.1903420634523806 \
2.203570545551681e-06 0.1887049708672087 2.203570669186156e-06 0.1871351133418249 2.203570766736279e-06 0.1859021016257166 2.203570881809208e-06 0.1844539912642748 \
2.203570975507888e-06 0.1832809848801438 2.203571074292011e-06 0.1820493959460708 2.203571197226552e-06 0.1805230483556907 2.203571292980556e-06 0.1793400249325384 \
2.203571422068107e-06 0.177753298391591 2.203571524533477e-06 0.1764993061988986 2.203571622786974e-06 0.1753029542432101 2.203571742874186e-06 0.1738483570896001 \
2.203571845423405e-06 0.1726127298531683 2.203571955881064e-06 0.1712877101305652 2.203572084370928e-06 0.1697552709290656 2.203572175855769e-06 0.1686698090598139 \
2.203572280340358e-06 0.1674358120019214 2.203572355277094e-06 0.1665544493622226 2.203572444845591e-06 0.1655049734124585 2.2035724954106e-06 0.164914347906921 \
2.203572545388976e-06 0.1643318187475747 2.203572610358061e-06 0.163576534137217 2.203572645872029e-06 0.1631646263336159 2.203572718071202e-06 0.162329174921529 \
2.203572785200297e-06 0.1615546732967998 2.203572844430032e-06 0.160873195114598 2.20357288817563e-06 0.1603710314414745 2.203572935822459e-06 0.1598254649913795 \
2.203573006202993e-06 0.1590230739426561 2.203573088541159e-06 0.1580883269013631 2.203573166712759e-06 0.1572048664554128 2.203573248765708e-06 0.1562816770844126 \
2.203573341469331e-06 0.1552436243401225 2.203573464249494e-06 0.153877370231325 2.203573563395588e-06 0.1527810927807017 2.203573664895935e-06 0.1516651170047695 \
2.203573766171126e-06 0.1505582666538253 2.203573862662911e-06 0.1495093242781697 2.203573962080945e-06 0.1484346886615803 2.203574046381569e-06 0.1475281828465028 \
2.203574139320259e-06 0.1465342051547719 2.2035742219212e-06 0.1456551508734999 2.203574330687285e-06 0.1445034822456445 2.203574436330265e-06 0.1433917535370727 \
2.203574517989854e-06 0.1425365900703354 2.203574611735024e-06 0.1415598856352903 2.203574705302971e-06 0.1405903867550886 2.203574788187462e-06 0.139735765814107 \
2.203574876346636e-06 0.1388313836440244 2.203574956132722e-06 0.1380170907865772 2.203575049728121e-06 0.1370669869522621 2.203575139660646e-06 0.1361590166429519 \
2.203575210211042e-06 0.1354501541392388 2.203575279971219e-06 0.1347521119166949 2.203575394120126e-06 0.1336164586193709 2.20357547609874e-06 0.1328058651355588 \
2.203575563704042e-06 0.1319440719770354 2.203575663205238e-06 0.1309710196939938 2.203575772385241e-06 0.1299110174488692 2.203575874550573e-06 0.1289256009328031 \
2.203575982010779e-06 0.1278959836800649 2.203576102045057e-06 0.1267549558890445 2.203576196253091e-06 0.1258657925752028 2.203576327232195e-06 0.1246390638240933 \
2.203576426659896e-06 0.1237164070883829 2.203576535781582e-06 0.1227104370444639 2.20357664463475e-06 0.1217138859540913 2.203576736944154e-06 0.120874257454373 \
2.203576849784484e-06 0.1198547128626846 2.203576946796524e-06 0.118986084968971 2.203577051062872e-06 0.1180628196869088 2.203577160029803e-06 0.1171053395831002 \
2.203577259569368e-06 0.1162371554254778 2.203577376562078e-06 0.1152245300989246 2.203577463662869e-06 0.1144761644999183 2.20357757295452e-06 0.1135478691973115 \
2.203577654479582e-06 0.1128618460838699 2.203577754254576e-06 0.1120273350449922 2.203577871679726e-06 0.1110526766231405 2.203577973464844e-06 0.1102143708571793 \
2.203578061203792e-06 0.1094962336869811 2.2035781420033e-06 0.1088432886892514 2.203578228954319e-06 0.1081456845520918 2.203578309740945e-06 0.1075007757815706 \
2.203578399947511e-06 0.1067842832273628 2.203578490898266e-06 0.1060655611559195 2.20357857956879e-06 0.1053685613006139 2.203578678583611e-06 0.1045946508745568 \
2.203578772289787e-06 0.1038723470842792 2.203578866149062e-06 0.1031520741219857 2.203578966976511e-06 0.1023817709659086 2.203579071607409e-06 0.1015861061604995 \
2.203579195570165e-06 0.1006484085638475 2.203579292969478e-06 0.09991551135558702 2.203579413227425e-06 0.09901872452754552 2.2035795240953e-06 0.09819831936474602 \
2.203579628568336e-06 0.09742874659471555 2.203579745805045e-06 0.09656937225591002 2.203579847599366e-06 0.09582695326576983 2.203579945574917e-06 0.09511577589263259 \
2.203580086079406e-06 0.09410164141823299 2.203580191157202e-06 0.09334832721827611 2.203580289770019e-06 0.09264549593674179 2.203580382484827e-06 0.09198739948435641 \
2.203580468683212e-06 0.09137785861853052 2.203580562596187e-06 0.09071637432184691 2.203580659696933e-06 0.09003559055802626 2.203580769117988e-06 0.08927317549644689 \
2.203580870101537e-06 0.08857281843916648 2.203580963759483e-06 0.08792605868920525 2.203581037934155e-06 0.08741581771673042 2.203581175834007e-06 0.08647193599618339 \
2.203581248191011e-06 0.08597917321277694 2.203581383512214e-06 0.08506274029062395 2.203581469423819e-06 0.08448410751389913 2.203581614152054e-06 0.08351486081643937 \
2.203581710382619e-06 0.0828744112740944 2.203581798218398e-06 0.08229260392026354 2.203581914017306e-06 0.08152964121883956 2.203582029145757e-06 0.08077575264951149 \
2.20358214291219e-06 0.08003553900012179 2.203582283169682e-06 0.0791300282244784 2.203582424545716e-06 0.07822490276368012 2.203582574181758e-06 0.07727536491519127 \
2.203582718670613e-06 0.07636690312463701 2.203582869844724e-06 0.07542565384097814 2.203583019215544e-06 0.07450459906593411 2.203583168562251e-06 0.0735926433331697 \
2.203583328517767e-06 0.07262574717347114 2.203583484664678e-06 0.07169171823582712 2.203583659153112e-06 0.07065947636250877 2.203583828862219e-06 0.0696671357044583 \
2.203584014041303e-06 0.0685979885997255 2.20358421076238e-06 0.06747763456279594 2.203584421280199e-06 0.06629631776014881 2.203584643312255e-06 0.06507007089066431 \
2.203584873524276e-06 0.0638195278444372 2.203585116035382e-06 0.06252626147401 2.203585376689467e-06 0.06116236403900636 2.203585656588531e-06 0.05972739422233359 \
2.203585950172255e-06 0.05825544847408989 2.203586265108239e-06 0.05671370145268265 2.203586607914164e-06 0.05507846134953124 2.203586957380758e-06 0.0534565727116736 \
2.203587366284915e-06 0.05161746230842366 2.203587712949942e-06 0.05010669351290297 2.203588100364995e-06 0.04846839895323611 2.203588444582787e-06 0.04705645202362623 \
2.203588768009047e-06 0.04576625679949029 2.203589073054809e-06 0.04458093278443617 2.203589365916806e-06 0.04347099288378908 2.203589650057723e-06 0.04242242262004604 \
2.203589926078015e-06 0.04142902112907627 2.203590192930566e-06 0.04049015932812138 2.203590461822789e-06 0.03956531631184226 2.203590737883211e-06 0.03863769040165695 \
2.203591025478782e-06 0.03769451689421055 2.203591265044408e-06 0.03692662498323904 2.203591554211835e-06 0.03602084344675294 2.203591770003438e-06 0.03535960341037672 \
2.203591957720476e-06 0.03479599077274986 2.203592155849582e-06 0.03421285035004928 2.203592518724446e-06 0.03317032497347058 2.203592776866276e-06 0.03244834222605905 \
2.20359308657919e-06 0.0316030971185694 2.203593352049328e-06 0.03089664771451467 2.203593620168408e-06 0.03019941363307669 2.203593899042439e-06 0.02949128999862272 \
2.203594145228875e-06 0.02888043298519722 2.203594375860285e-06 0.02832033800396738 2.203594614150204e-06 0.02775711540944564 2.203594849157568e-06 0.02721270742060762 \
2.203595076940031e-06 0.02669509678424227 2.203595485552303e-06 0.02579039168486155 2.203595661854632e-06 0.02540904040268441 2.203596016332316e-06 0.02465798827491217 \
2.203596200203288e-06 0.02427641469830137 2.20359653515201e-06 0.02359448510613503 2.203596699060727e-06 0.02326678168937357 2.203597091331303e-06 0.02249905491676728 \
2.203597247322069e-06 0.02220010404946675 2.203597678925426e-06 0.02138321689778962 2.203597816314806e-06 0.0211255367654138 2.203598333123589e-06 0.02017559010600388 \
2.203598458659483e-06 0.01995091418019728 2.203598915901008e-06 0.01915998482559782 2.203599075046989e-06 0.01889493739859509 2.203599682285467e-06 0.01793263500095189 \
2.203599816822955e-06 0.01772934138481063 2.203600480086948e-06 0.01678091027541291 2.203600673410379e-06 0.01651856846389665 2.203601341067039e-06 0.01565087920017967 \
2.203601502655887e-06 0.01544858341705342 2.20360225789114e-06 0.01454101846553843 2.203602407452107e-06 0.01436800730673201 2.203603297789931e-06 0.01338293844200974 \
2.203603396447817e-06 0.01327873262558703 2.203604353121314e-06 0.01230993787860994 2.203604474231021e-06 0.01219243157195396 2.20360546572373e-06 0.01126376273051215 \
2.20360562925246e-06 0.01111855113153209 2.203606759174535e-06 0.01018247077230436 2.203606871621774e-06 0.01009565848301377 2.203608249445262e-06 0.009103273453806031 \
2.203608388390533e-06 0.009009747578659758 2.203609942788868e-06 0.008018073335410726 2.20361005485534e-06 0.00794673960805117 2.20361169983817e-06 0.006958154532207958 \
2.203611807090664e-06 0.006899512253112593 2.203613751584152e-06 0.005937533026687714 2.20361395848211e-06 0.005843834961138424 2.203616297369852e-06 0.00487227039639981 \
2.203616721356264e-06 0.004712306502041247 2.20361949358946e-06 0.003780857497341114 2.203619941898552e-06 0.003647790772321777 2.203623582397237e-06 0.00272553831825111 \
2.203624079053071e-06 0.002619503085887757 2.203629830173496e-06 0.001650572925599863 2.203630116955382e-06 0.001609446887446839 2.203635471944066e-06 0.0006353228983793809 \
2.203635677300692e-06 0.0005920420449145349 2.206282712074507e-06 -0.0002718533828215428 2.206282867950111e-06 -0.0004579010352009555 2.206283416265203e-06 -0.001326296959495401 \
2.206283529048879e-06 -0.001543805653187533 2.206283963541018e-06 -0.002491429791030493 2.206284039366175e-06 -0.002673591589873599 2.206284396016773e-06 -0.003590195133438418 \
2.206284523065853e-06 -0.003936807634339821 2.206284801566247e-06 -0.004716444651655622 2.20628490965073e-06 -0.005020876868076652 2.206285253249855e-06 -0.00592430224391268 \
2.20628536024372e-06 -0.006162325733041658 2.206286259614116e-06 -0.005653094509861465 2.206286438047545e-06 -0.004687598829536962 2.20628654377096e-06 -0.003940993102967527 \
2.206286668833738e-06 -0.002883597584075996 2.206286762417833e-06 -0.001971418478057775 2.206286840257396e-06 -0.001132968824455395 2.206286920329394e-06 -0.0001977429743171 \
2.206287042702204e-06 0.001370578777960296 2.206287160958077e-06 0.003041212838230153 2.206287279607187e-06 0.004860750887681821 2.206287393089626e-06 0.006730904986417607 \
2.206287496532764e-06 0.008536402178002854 2.206287611192018e-06 0.01064190690353853 2.206287801775811e-06 0.0143607330143792 2.206287935565949e-06 0.01711819191720031 \
2.206288085819515e-06 0.02033933849841947 2.206288240988762e-06 0.02378599874269359 2.206288396380811e-06 0.0273434151175349 2.206288544088042e-06 0.03080849965087477 \
2.206288693077668e-06 0.03437359286003162 2.206288848068751e-06 0.03814545786868043 2.206289007439364e-06 0.04208062121327779 2.206289172372775e-06 0.04620305710844342 \
2.206289347319104e-06 0.0506208066052034 2.206289526449176e-06 0.05518387280380205 2.206289716238431e-06 0.06005265756871143 2.2062899199354e-06 0.06530840376289772 \
2.206290139745932e-06 0.07100650943730057 2.206290371497376e-06 0.07703584544314998 2.206290619322673e-06 0.08349927754587044 2.206290890643603e-06 0.09058756662233436 \
2.206291185356381e-06 0.09829181712822582 2.206291510614029e-06 0.106792896697727 2.206291876859735e-06 0.1163551101154179 2.206292270156447e-06 0.1266079356677421 \
2.206292722809343e-06 0.1383809089651769 2.206293248524511e-06 0.1520098384503803 2.206293867738049e-06 0.1679979965193872 2.206294548482365e-06 0.1854865650013753 \
2.20629534215732e-06 0.2057488551561759 2.206296230922953e-06 0.2282732214494322 2.206297044312215e-06 0.2487218262351868 2.206297766061792e-06 0.2667261628598245 \
2.2062984017258e-06 0.282460740414376 2.206298973442562e-06 0.2965101025186013 2.206299508996845e-06 0.3095696210007924 2.206300012355259e-06 0.3217495654069301 \
2.206300488682701e-06 0.3331878525640654 2.206300962606306e-06 0.3444754071334732 2.206301420078024e-06 0.3552759747331513 2.206301886058294e-06 0.3661792384270033 \
2.206302335046104e-06 0.376592601923634 2.206302831152646e-06 0.3879857357798637 2.206303350914508e-06 0.3998002499051578 2.206303730319152e-06 0.4083447473225827 \
2.206304170327875e-06 0.4181679450526055 2.206304640096814e-06 0.4285466970600206 2.206305125617752e-06 0.4391589006481625 2.206305565065858e-06 0.4486701556983262 \
2.206305626818807e-06 0.4500002248264944 2.206305750324704e-06 0.4526540461147197 2.206305997336497e-06 0.4579447795386873 2.206306249931409e-06 0.463325462421476 \
2.206306447502524e-06 0.467511453725808 2.206306673074271e-06 0.4722681264242033 2.206306994642268e-06 0.4790073975813253 2.206307263421496e-06 0.4846013351959894 \
2.20630748207297e-06 0.4891262574467725 2.206307692176936e-06 0.4934547887280634 2.206307918582461e-06 0.4980921872304203 2.206308127687652e-06 0.5023516957637455 \
2.20630831708991e-06 0.5061927337048852 2.206308441251129e-06 0.5086969563931187 2.206308568006226e-06 0.5112441466129884 2.206308728004704e-06 0.5144514110933732 \
2.206308975647656e-06 0.5193914248715521 2.206309154234115e-06 0.5229351592435862 2.206309325187692e-06 0.5263079149198099 2.206309586537288e-06 0.5314455197962068 \
2.20630981260887e-06 0.5358634945234868 2.206310015740537e-06 0.5398188128751134 2.206310180971267e-06 0.5430252218652345 2.206310337758288e-06 0.5460612552756139 \
2.206310526914905e-06 0.5497137532216215 2.206310728782658e-06 0.5535976061995346 2.206310952933981e-06 0.5578986282275192 2.206311191316346e-06 0.5624617013850463 \
2.206311426077985e-06 0.566941985223824 2.20631165634869e-06 0.5713275351537204 2.206311862141324e-06 0.5752375533958141 2.206312067125538e-06 0.5791255875933676 \
2.20631230994078e-06 0.5837094709690289 2.206312564698362e-06 0.588493349632063 2.206312792926793e-06 0.5927514274590796 2.206313030765665e-06 0.5971656109489694 \
2.206313243043101e-06 0.6010807441713891 2.206313454836505e-06 0.6049674646600495 2.206313708720774e-06 0.6095919957414236 2.206313913314301e-06 0.6132953190650409 \
2.206314165037654e-06 0.6178178328453598 2.206314352827174e-06 0.6211736970442716 2.206314605700251e-06 0.6256587164710262 2.206314804109613e-06 0.6291560967673944 \
2.206314983842284e-06 0.6323071487074056 2.206315254113091e-06 0.6370161336915187 2.206315471396856e-06 0.6407803561788556 2.206315651923236e-06 0.6438916924996977 \
2.20631585308413e-06 0.6473460740030906 2.206316021667512e-06 0.650231451944099 2.206316226025719e-06 0.6537144072723954 2.206316371688778e-06 0.6561873372238678 \
2.206316536247377e-06 0.6589728476742622 2.206316705716593e-06 0.6618316558839334 2.206316859256675e-06 0.664412775690417 2.206317000490202e-06 0.6667750288922751 \
2.206317144066013e-06 0.6691685747430841 2.206317277296139e-06 0.6713840140331436 2.206317419196459e-06 0.6737368819239464 2.206317539430086e-06 0.6757233098298149 \
2.206317684081138e-06 0.6781085120392751 2.206317800299843e-06 0.6800197521569988 2.206317919382163e-06 0.6819757159594566 2.206318017960476e-06 0.6835903813535821 \
2.206318135558183e-06 0.6855122399681081 2.206318222994146e-06 0.6869376986921233 2.206318347740232e-06 0.6889650632873403 2.206318447547296e-06 0.6905825000046129 \
2.206318540037092e-06 0.6920753042469043 2.206318641321177e-06 0.6937043390836264 2.206318739114283e-06 0.695273833970533 2.206318830385075e-06 0.6967333967490603 \
2.206318932842905e-06 0.6983656370917724 2.206319065752136e-06 0.7004728611232253 2.206319220767541e-06 0.7029137789397926 2.206319355649227e-06 0.7050222373350452 \
2.206319501145018e-06 0.7072806469370021 2.206319628999685e-06 0.709252249158637 2.20631975345798e-06 0.7111597484283609 2.206319864783685e-06 0.7128563623504806 \
2.206319978813713e-06 0.7145852226468989 2.20632007932493e-06 0.7161013069709498 2.206320216526077e-06 0.7181590832501857 2.206320336471979e-06 0.7199473375636642 \
2.206320455641778e-06 0.7217141075019444 2.206320582586792e-06 0.7235855504531626 2.206320707354209e-06 0.7254141264975077 2.206320830849597e-06 0.7272133847865295 \
2.20632095763087e-06 0.7290498056238117 2.206321088220355e-06 0.730930225429108 2.206321210432258e-06 0.7326797786847141 2.206321347490272e-06 0.7346298644824388 \
2.206321448705626e-06 0.7360619656663578 2.206321553674562e-06 0.7375401619041119 2.206321645165995e-06 0.7388229997694907 2.206321758241356e-06 0.7404001534680551 \
2.20632184554224e-06 0.7416107338190071 2.20632195000557e-06 0.7430512000342341 2.206322080768703e-06 0.7448411286358657 2.2063221906822e-06 0.7463352048609909 \
2.206322295341958e-06 0.7477488743938407 2.20632241917362e-06 0.7494094725133206 2.206322567926971e-06 0.751387874302702 2.206322689842132e-06 0.7529958494242643 \
2.206322803696392e-06 0.7544867042370438 2.20632294419585e-06 0.7563117925204224 2.206323085519364e-06 0.7581313010100689 2.206323203298971e-06 0.7596352654099263 \
2.206323331697459e-06 0.7612620174900669 2.206323474021161e-06 0.7630496612437514 2.206323590410316e-06 0.7644991888858087 2.206323736133977e-06 0.7662987831554334 \
2.206323857913867e-06 0.7677897310961733 2.206323976478797e-06 0.7692300520321635 2.206324099092246e-06 0.7707078417740018 2.206324225543629e-06 0.77221964326554 \
2.206324335666584e-06 0.7735261258099556 2.206324461188726e-06 0.7750039859681491 2.206324566849672e-06 0.7762386743660952 2.206324702026829e-06 0.7778058706872942 \
2.206324825637345e-06 0.7792267957652825 2.206324955634725e-06 0.7807078764205345 2.206325068606223e-06 0.7819831642610904 2.206325176500111e-06 0.7831908181350914 \
2.206325313030793e-06 0.7847046126527283 2.206325463151702e-06 0.7863508260127218 2.206325605416005e-06 0.7878933964149381 2.206325724997519e-06 0.7891771019825847 \
2.206325861808649e-06 0.7906313890246753 2.206325984312413e-06 0.7919206245676671 2.206326128984341e-06 0.7934276941869095 2.206326269769414e-06 0.794878360380241 \
2.206326396585209e-06 0.796171745508174 2.206326515632602e-06 0.7973744708066829 2.206326627895563e-06 0.7984986270115709 2.206326732283333e-06 0.7995352562746869 \
2.206326827560395e-06 0.8004739840425704 2.206326963902891e-06 0.8018044219089175 2.206327080767959e-06 0.8029326473252685 2.206327200364489e-06 0.8040757482679398 \
2.206327322250299e-06 0.8052288531124292 2.206327444838559e-06 0.8063765489401953 2.206327572579618e-06 0.8075599074701925 2.206327697362526e-06 0.8087035441861687 \
2.2063278278629e-06 0.8098867241643505 2.206327954229597e-06 0.8110199871086299 2.206328081578389e-06 0.8121498004723215 2.206328186791179e-06 0.8130740322933268 \
2.206328291495184e-06 0.8139855427426806 2.20632838302539e-06 0.8147757515715357 2.20632850639836e-06 0.8158311616195392 2.206328593352408e-06 0.8165684017534872 \
2.206328692208245e-06 0.8173999442793862 2.206328836710884e-06 0.8186029267949408 2.206328973036572e-06 0.8197243345631372 2.206329082445008e-06 0.8206145128367788 \
2.206329228461948e-06 0.821788834531623 2.206329380203007e-06 0.8229927727264784 2.206329506119585e-06 0.8239792970156907 2.206329650568649e-06 0.8250971468990039 \
2.206329775264817e-06 0.8260503472050121 2.206329925878834e-06 0.8271873005969326 2.206330061249302e-06 0.8281959289694237 2.206330186472937e-06 0.8291179217777711 \
2.206330304128897e-06 0.8299746468143927 2.20633044991051e-06 0.8310230722388168 2.20633061639426e-06 0.8322027532553667 2.206330747215023e-06 0.8331167337813133 \
2.206330920675045e-06 0.834311196379941 2.206331088787841e-06 0.8354501125721271 2.206331258668969e-06 0.8365827385393307 2.206331439512627e-06 0.8377685497174457 \
2.206331582704692e-06 0.8386931238161603 2.206331696822189e-06 0.8394210074154138 2.206331826873799e-06 0.8402408682651782 2.206331928753516e-06 0.8408758513273116 \
2.206332045641139e-06 0.841596551294542 2.206332182786859e-06 0.8424315815669623 2.206332380696072e-06 0.8436167827761205 2.206332572515411e-06 0.8447436440637145 \
2.206332781866157e-06 0.8459494874145237 2.206332964017768e-06 0.8469786287449077 2.206333161103991e-06 0.8480715276019779 2.206333334356719e-06 0.8490148531186206 \
2.206333517450963e-06 0.8499943787178993 2.20633368858243e-06 0.8508936588199895 2.206333863270272e-06 0.8517955326875627 2.206334038504287e-06 0.8526841769874772 \
2.206334214641154e-06 0.8535614892404448 2.206334405008494e-06 0.8544920815553035 2.206334595580845e-06 0.8554057038167108 2.206334795976837e-06 0.8563474066245403 \
2.206334988566463e-06 0.8572344253714166 2.206335199466375e-06 0.858185963363946 2.206335427341861e-06 0.8591913103610016 2.206335693424718e-06 0.8603357477151101 \
2.206335991926854e-06 0.8615822374427254 2.206336267816323e-06 0.8627000332972231 2.206336552083492e-06 0.8638181192989086 2.206336826221443e-06 0.8648650323418529 \
2.206337098522366e-06 0.8658754039994767 2.206337368678562e-06 0.8668495780678541 2.206337625862699e-06 0.8677515347235455 2.206337898421613e-06 0.8686810999091764 \
2.206338174469331e-06 0.8695957110915412 2.206338444589598e-06 0.8704649939918846 2.206338744449489e-06 0.8714007440816277 2.206339115430114e-06 0.8725171209518352 \
2.206339410352536e-06 0.8733732402027278 2.206339664628271e-06 0.8740897163373675 2.206339962841735e-06 0.8749052413925265 2.206340236411347e-06 0.8756305047096297 \
2.206340472534748e-06 0.8762394088953867 2.206340712859886e-06 0.8768433401198644 2.206340935193821e-06 0.8773882060838187 2.206341129200254e-06 0.8778530214284207 \
2.206341458909681e-06 0.8786208714695904 2.20634161408109e-06 0.87897283049042 2.20634193172349e-06 0.8796750328643211 2.206342110604035e-06 0.8800599154915705 \
2.206342453064798e-06 0.8807759898408113 2.20634263726721e-06 0.8811501695110489 2.206343112296513e-06 0.8820806183873429 2.206343279683462e-06 0.8823969901232691 \
2.206343745459843e-06 0.8832471741583867 2.206343926299187e-06 0.8835657112976044 2.206344420308805e-06 0.8844044135654346 2.206344561623711e-06 0.8846360992458032 \
2.206345167867327e-06 0.8855901496945974 2.206345319942525e-06 0.8858196526512701 2.206345966662599e-06 0.8867549368993356 2.206346094949267e-06 0.8869330782847171 \
2.206346743158686e-06 0.8877977435561634 2.206346872882985e-06 0.8879638504720397 2.206347641302053e-06 0.8888993076310558 2.206347771073903e-06 0.8890488273083775 \
2.206348624736508e-06 0.8899738047157748 2.206348767761561e-06 0.8901192131187072 2.206349754067048e-06 0.8910487927319016 2.2063499755536e-06 0.8912403904783051 \
2.206351118378138e-06 0.8921548233216382 2.206351248258076e-06 0.8922544308366913 2.206352600758498e-06 0.8932425879319322 2.206352751041431e-06 0.8933452769452155 \
2.206354231575698e-06 0.8942627870546499 2.206354470485492e-06 0.8943950258099049 2.206356252518432e-06 0.8952625983306248 2.20635663826586e-06 0.895426813549116 \
2.206359040424079e-06 0.8963023915260389 2.206359515360049e-06 0.8964490046842035 2.206363433287164e-06 0.8974035634625627 2.206363903247409e-06 0.8974927205890085 \
2.206372272035386e-06 0.8984807567386782 2.206372492545714e-06 0.8984960697096243 2.206417072074293e-06 0.8994905034760702 2.206418273460192e-06 0.8995076493514624 \
2.206554083268694e-06 0.9004821828323031 2.206554262245419e-06 0.9005421539807538 2.206557707120337e-06 0.8996085030263692 2.206557879904192e-06 0.8994755022453073 \
2.206559206223899e-06 0.8985168769831137 2.206559392989208e-06 0.8983970610744239 2.206561177194233e-06 0.8974304740967198 2.206561389324515e-06 0.8973403978332656 \
2.206574730020299e-06 0.8983331062395279 2.206574843308144e-06 0.8983517458922662 2.206583546661241e-06 0.8993273409280406 2.20658409447182e-06 0.8993637478389299 \
2.207076621843714e-06 0.9003542216796759 2.207076717582567e-06 0.9004233209197793 2.207077660131942e-06 0.9014023545001312 2.207077822585253e-06 0.9016297223302431 \
2.2070783892915e-06 0.9025464066367429 2.207078496462212e-06 0.9027401250447874 2.207078889770564e-06 0.9035002370985188 2.207079022567928e-06 0.9037710185404622 \
2.207079402169034e-06 0.9045728679206633 2.20707953238378e-06 0.9048512534150681 2.207079993790073e-06 0.9057878278182891 2.207080113037131e-06 0.9060008176934132 \
2.207081542646165e-06 0.9050557440230738 2.207081626316292e-06 0.9046580283931719 2.207081751622122e-06 0.9039622140338933 2.207081859436291e-06 0.9032622438705011 \
2.207081978430637e-06 0.9023800387125585 2.207082093802854e-06 0.9014106868475621 2.207082183899751e-06 0.900578017289966 2.207082295347455e-06 0.8994526603282017 \
2.207082381426603e-06 0.8985125975436928 2.207082487392251e-06 0.8972736935213672 2.207082587160617e-06 0.8960214106762436 2.207082668156227e-06 0.8949470092681954 \
2.207082777804195e-06 0.8934133399212493 2.207082863391606e-06 0.8921520042367302 2.207082955514215e-06 0.8907345325087322 2.207083043733598e-06 0.8893220116766375 \
2.207083152508351e-06 0.8875100775672261 2.207083235401385e-06 0.8860780350921965 2.207083343975057e-06 0.8841400608632336 2.207083436201252e-06 0.8824412727986957 \
2.20708352082175e-06 0.8808423775446282 2.20708360666218e-06 0.8791839877465467 2.20708368587706e-06 0.8776224824828824 2.20708376196503e-06 0.8760960492665846 \
2.207083854301399e-06 0.874210837196514 2.207083914177735e-06 0.8729702140710593 2.207083971566019e-06 0.8717685933706794 2.207084033561192e-06 0.8704574090763495 \
2.207084096840043e-06 0.8691057216070059 2.207084146911381e-06 0.8680269866686803 2.207084196353533e-06 0.8669542389500936 2.20708426002324e-06 0.8655623656543436 \
2.207084335970659e-06 0.8638877358586781 2.207084384801671e-06 0.8628032002737418 2.207084433325624e-06 0.8617197496806845 2.207084509037347e-06 0.8600184098866027 \
2.207084576246124e-06 0.8584975010852487 2.207084618952631e-06 0.8575263577286506 2.207084662855204e-06 0.8565244243916033 2.207084750660351e-06 0.8545103166059256 \
2.20708481351352e-06 0.8530605771626394 2.207084872183177e-06 0.8517018597088126 2.207084908361778e-06 0.8508614974547222 2.207084943180258e-06 0.8500510151036469 \
2.207084978206243e-06 0.8492340038666518 2.207085048258213e-06 0.8475953578585981 2.207085096728698e-06 0.8464581214772323 2.207085140673499e-06 0.8454248116355969 \
2.207085186191255e-06 0.8443523575543517 2.207085250092166e-06 0.8428433081697474 2.207085316218539e-06 0.8412777165526386 2.207085421348608e-06 0.8387809254526315 \
2.207085509283283e-06 0.8366857089760468 2.207085588228565e-06 0.834800137446173 2.207085676393602e-06 0.8326899670047023 2.207085763209599e-06 0.8306078985741704 \
2.207085851101283e-06 0.8284959280419055 2.207085942350373e-06 0.8262996967350639 2.207086045112241e-06 0.8238226494465998 2.207086143615716e-06 0.8214450402687625 \
2.207086255948631e-06 0.8187302447322098 2.207086368922768e-06 0.8159967029774419 2.207086490210663e-06 0.8130591602364435 2.207086620717817e-06 0.8098958628758253 \
2.207086749763719e-06 0.8067658935936169 2.20708690323932e-06 0.8030416153605923 2.20708706852354e-06 0.799029304640783 2.207087236264745e-06 0.7949567682299736 \
2.207087432788334e-06 0.7901857478752816 2.207087637550659e-06 0.7852160332972318 2.207087850227715e-06 0.7800563994093253 2.207088050847662e-06 0.7751902022758907 \
2.207088251706389e-06 0.7703212856706637 2.207088401728407e-06 0.766686939713112 2.207088532263574e-06 0.7635264252913375 2.207088666681014e-06 0.7602735436595947 \
2.207088772876544e-06 0.7577048602246427 2.207088906182877e-06 0.754482067181252 2.207089013215803e-06 0.7518959494812111 2.207089156291704e-06 0.7484409822837247 \
2.207089320797846e-06 0.7444713482725677 2.207089441615092e-06 0.74155777711076 2.207089612721756e-06 0.7374334100931738 2.207089773612309e-06 0.733558046396253 \
2.207089990204929e-06 0.7283457217000903 2.207090183460631e-06 0.7236999380850822 2.207090362395765e-06 0.7194029726762079 2.207090529212387e-06 0.7154015770462002 \
2.207090715418352e-06 0.7109395231330657 2.207090903351593e-06 0.7064416825495208 2.207091069273698e-06 0.7024749886985119 2.207091261631787e-06 0.6978803202016938 \
2.207091402988682e-06 0.6945068232011449 2.207091559996444e-06 0.6907636199298515 2.207091755976089e-06 0.6860965106368763 2.207091918410194e-06 0.6822325558671515 \
2.207092079586376e-06 0.6784034260021697 2.207092271894574e-06 0.6738409413562468 2.207092489556453e-06 0.6686845685784016 2.207092737577755e-06 0.6628199086538362 \
2.207092915635219e-06 0.6586162961343578 2.207093164179028e-06 0.6527567611811057 2.20709336678627e-06 0.6479896840619462 2.207093536596938e-06 0.6440011601507294 \
2.207093695213124e-06 0.6402799599229552 2.207093833743559e-06 0.637035894415233 2.207093969951321e-06 0.6338503464729111 2.207094096262698e-06 0.6309003762865483 \
2.207094225721933e-06 0.6278810604265532 2.207094354053672e-06 0.6248911458464299 2.207094485383602e-06 0.6218374290191309 2.207094617410215e-06 0.6187713222160208 \
2.207094761570095e-06 0.6154276788919771 2.207094905778687e-06 0.6120888358645944 2.207095053433791e-06 0.6086753592300279 2.207095200490149e-06 0.6052842859263143 \
2.207095358304175e-06 0.6016504852589418 2.207095490909828e-06 0.5986039825107707 2.207095622374794e-06 0.5955897059985247 2.207095741804593e-06 0.5928552647156846 \
2.207095877873286e-06 0.5897484304797134 2.207095992801548e-06 0.5871283594046445 2.207096143912269e-06 0.5836892419704927 2.207096258561337e-06 0.5810871834776226 \
2.207096376499006e-06 0.5784138884735546 2.207096466280294e-06 0.576381560286313 2.207096556599689e-06 0.5743415774978985 2.207096623290559e-06 0.5728373329037385 \
2.207096688852372e-06 0.5713590910263378 2.207096739894495e-06 0.5702089751121119 2.207096801596215e-06 0.5688198806440578 2.20709686468607e-06 0.5674025889664359 \
2.207096929044425e-06 0.5659586381304559 2.207096982438223e-06 0.5647616504486359 2.207097075080806e-06 0.5626864159088959 2.207097151688078e-06 0.5609719030357503 \
2.20709720751314e-06 0.5597256439368602 2.207097276567266e-06 0.5581857825097393 2.207097383455392e-06 0.5558054549196561 2.207097461199018e-06 0.5540764009223496 \
2.207097562049117e-06 0.5518382286767042 2.207097687729971e-06 0.5490568313009737 2.207097787971657e-06 0.5468419758621708 2.20709789988934e-06 0.5443739014182352 \
2.207098003155247e-06 0.5421024366463116 2.207098122904589e-06 0.5394737463112931 2.207098224637469e-06 0.5372436950013484 2.207098340157213e-06 0.5347185748314579 \
2.207098455192299e-06 0.5322102907975605 2.207098581673211e-06 0.529456475824718 2.207098707047008e-06 0.5267350629320526 2.207098853862932e-06 0.5235577714138258 \
2.20709898942638e-06 0.5206304261698983 2.207099147124634e-06 0.5172373565578411 2.207099309443689e-06 0.5137528589513558 2.207099490267585e-06 0.5098871206809381 \
2.207099682715905e-06 0.5057874350093188 2.207099895621209e-06 0.5012700264709963 2.207100127802608e-06 0.4963634062180514 2.207100385093186e-06 0.4909555076455908 \
2.20710062471901e-06 0.4859407514401474 2.207100926434446e-06 0.479662588092526 2.2071012143538e-06 0.4737079198104491 2.207101527242619e-06 0.4672821326282255 \
2.207101846980824e-06 0.4607585360408045 2.207102186575985e-06 0.4538766993710576 2.207102513478483e-06 0.4472977926730654 2.207102849036864e-06 0.4405887635920606 \
2.207103166132787e-06 0.4342949501181722 2.207103500370541e-06 0.4277061431972559 2.207103851801663e-06 0.4208322784122511 2.207104166327818e-06 0.4147233751108969 \
2.207104489505308e-06 0.4084912998479469 2.207104930620065e-06 0.400057814108821 2.207105272736103e-06 0.3935812134363078 2.207105572680633e-06 0.3879522399691127 \
2.207105947811638e-06 0.3809760137481454 2.207106277555877e-06 0.3749002425561211 2.207106560798803e-06 0.3697269896098562 2.207106860945059e-06 0.3642865787664632 \
2.207107140547253e-06 0.3592589179584539 2.207107364323365e-06 0.3552676761685443 2.207107576103695e-06 0.3515151294490645 2.207107778537159e-06 0.3479514629380864 \
2.207107979628427e-06 0.3444362246481504 2.207108185342845e-06 0.3408632458568372 2.207108452965717e-06 0.3362478643926977 2.207108691897011e-06 0.3321601360780691 \
2.207108925403074e-06 0.3281974319442653 2.207109138868473e-06 0.3246000376975314 2.207109360246046e-06 0.3208952602338652 2.207109560209693e-06 0.3175728982722026 \
2.207109764482006e-06 0.3142073831356898 2.207109961828878e-06 0.3109812293225088 2.207110147201405e-06 0.3079732989686547 2.207110343307796e-06 0.3048147723336881 \
2.207110545584936e-06 0.3015820927993307 2.207110721243233e-06 0.2988007390096292 2.20711090711339e-06 0.295878328903569 2.207111114092782e-06 0.2926488196724605 \
2.207111299414374e-06 0.2897857719971084 2.207111494641181e-06 0.2867989994419413 2.207111650415531e-06 0.28443329608414 2.207111829172313e-06 0.2817356906084737 \
2.207112010203233e-06 0.2790344478478936 2.207112160100346e-06 0.2768142575519123 2.207112361143774e-06 0.273859574769726 2.207112510258904e-06 0.2716833853889438 \
2.207112648798333e-06 0.2696726034832688 2.207112800673409e-06 0.2674956304896134 2.207112915147537e-06 0.2658586287383957 2.207113046677468e-06 0.2639823142040156 \
2.207113172435956e-06 0.2622048582339201 2.207113276776362e-06 0.2607341604582348 2.207113389755722e-06 0.2591418073851619 2.207113506084246e-06 0.2575033437579446 \
2.207113649011667e-06 0.2554974228347739 2.207113762273172e-06 0.2539102348881249 2.207113896429905e-06 0.2520298733123076 2.207114006902709e-06 0.2504818583075984 \
2.207114162335284e-06 0.2483006006477398 2.207114303220383e-06 0.2463217957442577 2.207114454612954e-06 0.2441928603691365 2.207114609775034e-06 0.2420086586735095 \
2.207114739184283e-06 0.2401849910837116 2.207114873896376e-06 0.2382868210192302 2.207115011594201e-06 0.2363478190565156 2.207115129346217e-06 0.2346905900295477 \
2.20711528867041e-06 0.2324499447852502 2.207115425932636e-06 0.2305210708572645 2.207115566678993e-06 0.2285488733964877 2.207115672470166e-06 0.2270688194984586 \
2.207115802411564e-06 0.2252532503786337 2.207115902948028e-06 0.2238506847401111 2.207116005281735e-06 0.2224250970611539 2.207116079010317e-06 0.2214012665004395 \
2.20711615824426e-06 0.2203047212273054 2.207116229215507e-06 0.2193236206014474 2.207116280678535e-06 0.218612902325451 2.207116333626988e-06 0.2178825126218075 \
2.20711641278199e-06 0.2167921001391954 2.207116455054626e-06 0.2162104926182252 2.207116494899171e-06 0.2156628374086678 2.20711653812282e-06 0.2150692779925967 \
2.207116579029822e-06 0.2145080585354088 2.207116649152284e-06 0.2135474129702876 2.207116682837255e-06 0.2130867492099046 2.207116727666638e-06 0.212477723463 \
2.2071167865238e-06 0.2116792343136102 2.20711685130926e-06 0.2108017053965978 2.207116908790024e-06 0.2100241135398916 2.207116969219033e-06 0.209207737948094 \
2.207117066255463e-06 0.2078991976528634 2.207117150945123e-06 0.2067595417901527 2.207117259855885e-06 0.2052972881712416 2.207117356256692e-06 0.2040065614180294 \
2.207117451273329e-06 0.2027428333585779 2.207117554705127e-06 0.2013717100485363 2.207117649634473e-06 0.2001158751783069 2.207117752654899e-06 0.198757993281026 \
2.207117857737332e-06 0.1973779917312911 2.207117967046146e-06 0.1959482000350934 2.207118077489628e-06 0.1945091075764383 2.207118193779903e-06 0.1929996650696684 \
2.207118303709896e-06 0.1915811184357085 2.20711841337232e-06 0.1901717999899754 2.207118515088965e-06 0.1888694322720079 2.207118608043679e-06 0.1876837490531375 \
2.207118700772569e-06 0.1865049219968967 2.207118774458125e-06 0.1855719169757668 2.20711885729934e-06 0.1845269810791141 2.207118931885336e-06 0.1835895008849975 \
2.207119001608678e-06 0.1827150226754214 2.207119068327085e-06 0.1818808699270075 2.207119164170411e-06 0.1806871657728035 2.207119246877184e-06 0.1796611249561687 \
2.207119340441008e-06 0.1785035608809835 2.207119435337095e-06 0.1773351434884491 2.207119546707405e-06 0.1759704596301353 2.207119688349759e-06 0.1742450478777388 \
2.207119803596612e-06 0.1728486436789435 2.207119948144251e-06 0.1711076225712051 2.207120059739928e-06 0.1697708811114609 2.207120200958902e-06 0.1680898955975501 \
2.207120316696175e-06 0.1667201145354908 2.207120422656861e-06 0.1654722325850081 2.207120521416477e-06 0.164314417410061 2.20712061775965e-06 0.1631901152369615 \
2.207120706417402e-06 0.1621596955203892 2.207120831751673e-06 0.1607099933926625 2.207120926277088e-06 0.1596224416957933 2.20712102401604e-06 0.1585042187118262 \
2.207121132110917e-06 0.1572745454417887 2.207121226778605e-06 0.1562036643369483 2.207121334226451e-06 0.1549951394274829 2.207121425315495e-06 0.1539767092330788 \
2.207121532087206e-06 0.1527896463435911 2.207121635480472e-06 0.1516469620792683 2.207121746560958e-06 0.1504267727114754 2.207121835786939e-06 0.1494522115900035 \
2.207121921266868e-06 0.1485231035185812 2.207122005192055e-06 0.1476157397758405 2.207122074898619e-06 0.1468658175993407 2.207122153536697e-06 0.1460232248551682 \
2.207122231847954e-06 0.1451880611912267 2.207122302483827e-06 0.1444378248611795 2.207122387974695e-06 0.1435337156153706 2.207122475363672e-06 0.1426139614481139 \
2.207122556951185e-06 0.1417594571206545 2.207122654270137e-06 0.1407454482154784 2.207122734959659e-06 0.139910090776864 2.20712282574469e-06 0.1389752404035735 \
2.207122947088963e-06 0.1377336220260025 2.207123036138604e-06 0.13682812281983 2.207123134655454e-06 0.1358318692385875 2.207123221741723e-06 0.1349560640726983 \
2.207123332152611e-06 0.1338550874529322 2.207123420611433e-06 0.1329791517134813 2.207123521340026e-06 0.1319874611681985 2.20712362612958e-06 0.1309622419763913 \
2.207123720519813e-06 0.1300442429014473 2.207123817024605e-06 0.1291112112475518 2.207123916511258e-06 0.1281591654439075 2.207124002912429e-06 0.1273384721630967 \
2.20712409789256e-06 0.1264411177628728 2.207124202081388e-06 0.1254629331099751 2.207124311200138e-06 0.124445178694 2.207124405550594e-06 0.1235704029653004 \
2.207124517846343e-06 0.1225411084520107 2.207124613309697e-06 0.1216733466577494 2.207124717520587e-06 0.1207311846737792 2.207124806865944e-06 0.1199276649878674 \
2.207124877253217e-06 0.1192980345746366 2.207124952639251e-06 0.1186268760051257 2.207125028771421e-06 0.1179522201461119 2.207125097748918e-06 0.1173458504859956 \
2.207125180268091e-06 0.1166263596898966 2.207125252211578e-06 0.1160015972854393 2.207125334290304e-06 0.1152916772467617 2.20712541862478e-06 0.1145654108773922 \
2.207125496418619e-06 0.113898375935255 2.207125589183521e-06 0.1131065723182637 2.207125704787342e-06 0.1121254933399327 2.207125810692911e-06 0.1112341778178403 \
2.207125888349831e-06 0.1105854195321705 2.207125976646302e-06 0.1098504899494786 2.207126056703354e-06 0.1091866403929743 2.207126153629479e-06 0.1083861389179563 \
2.207126248864964e-06 0.1076031391441806 2.207126337436159e-06 0.1068780200140514 2.20712643874426e-06 0.1060523297458165 2.207126544289947e-06 0.1051963702337609 \
2.207126653484312e-06 0.1043160928234657 2.207126761601933e-06 0.1034503663302994 2.207126881519694e-06 0.1024949450012773 2.207126982881521e-06 0.1016914181115986 \
2.207127088891151e-06 0.100855068690839 2.20712721468278e-06 0.09986840123414902 2.207127344240086e-06 0.09885896724496235 2.20712747991544e-06 0.09780904711780367 \
2.207127655987303e-06 0.09645781830037269 2.207127819787823e-06 0.09521257997344186 2.207127982612565e-06 0.09398642071914091 2.2071280677512e-06 0.09334985726464029 \
2.207128137589223e-06 0.09282999162688726 2.207128207084828e-06 0.09231474740697931 2.207128281043488e-06 0.09176875214326782 2.207128377198375e-06 0.09106241641841166 \
2.207128451613741e-06 0.09051841344162129 2.207128529603309e-06 0.08995079828656057 2.207128606052139e-06 0.08939693755534793 2.207128693546224e-06 0.08876614459792892 \
2.207128795722934e-06 0.08803382885421264 2.207128884287322e-06 0.08740269463919083 2.20712899395281e-06 0.08662585268124241 2.207129110009217e-06 0.08580942306245626 \
2.207129251558034e-06 0.0848216759818637 2.207129384427018e-06 0.08390253510334872 2.207129525187328e-06 0.08293727564630923 2.207129674896948e-06 0.08192024575105315 \
2.207129810608835e-06 0.08100683753927941 2.207129952125717e-06 0.08006309454860433 2.207130087247591e-06 0.07917070961097784 2.207130228520028e-06 0.07824718349428782 \
2.20713037561292e-06 0.07729532867436953 2.207130527122786e-06 0.07632524417621221 2.2071306924985e-06 0.07527819040792309 2.20713085625969e-06 0.07425356708383206 \
2.207131032389632e-06 0.07316505371836476 2.20713122152861e-06 0.07201151367936541 2.207131432202233e-06 0.07074528708793332 2.207131651768855e-06 0.06944624562626683 \
2.207131886535262e-06 0.06808094281860989 2.2071321449277e-06 0.06660616301228137 2.20713243959236e-06 0.06496103773121734 2.207132743671683e-06 0.06330286177969326 \
2.207133104582163e-06 0.06138472526627536 2.207133440499035e-06 0.05964719353945821 2.207133880676406e-06 0.05743991201668189 2.207134259043809e-06 0.05560437501227136 \
2.207134701502771e-06 0.05352996728430704 2.207135055522916e-06 0.05192508193542229 2.207135442039672e-06 0.05022502935509546 2.207135786643729e-06 0.04875485597254389 \
2.207136108618665e-06 0.04741934964807833 2.207136412152492e-06 0.04619304551845941 2.207136707073488e-06 0.04503122626702559 2.207136989555767e-06 0.04394770877170886 \
2.207137266636177e-06 0.04291147062934708 2.207137532363668e-06 0.04194013461971725 2.207137803594355e-06 0.0409708748276704 2.207138079853372e-06 0.04000619535229137 \
2.207138369752594e-06 0.03901828782233653 2.207138598128987e-06 0.03825741181922668 2.207138903013054e-06 0.03726495139513845 2.20713911968491e-06 0.03657573971894532 \
2.207139311041637e-06 0.03597943984071691 2.207139509636156e-06 0.03537298232318693 2.207139839551497e-06 0.03438820140908775 2.20714008149717e-06 0.03368375433354889 \
2.207140396809222e-06 0.03278771666975258 2.207140666929207e-06 0.03203957074185158 2.20714092330088e-06 0.03134567005659093 2.20714120331288e-06 0.03060515313352298 \
2.207141448968656e-06 0.02997014710356035 2.207141681704301e-06 0.02938120249260199 2.207141924434299e-06 0.02878348292867495 2.207142161161563e-06 0.02821317433052753 \
2.207142389807974e-06 0.0276732289298247 2.207142807093634e-06 0.02671456010533928 2.207143002274328e-06 0.02627749693639509 2.207143383441411e-06 0.02544369227895442 \
2.207143560694232e-06 0.02506446942885681 2.207143903145688e-06 0.02434654114125227 2.20714405641412e-06 0.02403127656358269 2.207144431432584e-06 0.02327616399748992 \
2.207144569066725e-06 0.02300530455388665 2.207145053333359e-06 0.02207084195640928 2.20714517295276e-06 0.02184403312078184 2.207145589991564e-06 0.02106026682208277 \
2.207145733393791e-06 0.02079332360769017 2.207146254605172e-06 0.01984598817089831 2.207146382379042e-06 0.0196205814374062 2.207146966791417e-06 0.01863359713481367 \
2.207147139226823e-06 0.01835589372257288 2.207147743323573e-06 0.01743644241612937 2.207147904755214e-06 0.01720262545858322 2.207148544701433e-06 0.01631831686205014 \
2.2071487230176e-06 0.016083210242981 2.207149371001648e-06 0.01526127675881721 2.20714953625524e-06 0.01505930898173208 2.207150272557175e-06 0.01419381259610907 \
2.207150406833225e-06 0.01404154276213586 2.207151203932743e-06 0.01317592498067951 2.207151344530354e-06 0.01302934089458718 2.207152309873577e-06 0.0120661300044765 \
2.207152474212382e-06 0.01190857475316222 2.207153474943511e-06 0.01099048917119646 2.207153612213369e-06 0.01087009009405628 2.207154750907886e-06 0.009949273443646761 \
2.207154865085787e-06 0.009863136028526375 2.207156245730622e-06 0.008889755784408603 2.207156400087833e-06 0.00878832203975914 2.207157946582061e-06 0.00781340401000951 \
2.207158030943764e-06 0.007760176032106158 2.207159716371082e-06 0.006770348169342283 2.207159839899572e-06 0.00670487246831437 2.207161889714139e-06 0.005720970231232756 \
2.207162086114296e-06 0.005634691917282852 2.207164404793654e-06 0.004698942116576918 2.207164865407988e-06 0.004530544077955615 2.20716760550353e-06 0.003639937533647344 \
2.207168123648567e-06 0.00349159181499799 2.207172274289875e-06 0.002502201117031859 2.207172812139882e-06 0.002396807933581942 2.20717889437533e-06 0.001421603691354927 \
2.20717915335574e-06 0.001378272220758726 2.20718447611909e-06 0.0003814093765652445 2.207184589276134e-06 0.0003711807182531981 2.20983070639237e-06 -0.0004615907568095335 \
2.209830868831338e-06 -0.0006852153244161934 2.209831369832807e-06 -0.001554404032531494 2.209831454015369e-06 -0.001725199767551738 2.209831855538194e-06 -0.002626792336557519 \
2.20983194487316e-06 -0.002845673237760077 2.20983223146497e-06 -0.0035898660494722 2.209832359033499e-06 -0.003937855927128601 2.209832677745161e-06 -0.004830400105952924 \
2.209832791946313e-06 -0.00515011308870196 2.209833074346638e-06 -0.005887653497963378 2.209833204572857e-06 -0.006177415671381139 2.209834182925754e-06 -0.005220113099403402 \
2.209834370233287e-06 -0.004004368716724641 2.209834501677689e-06 -0.002901539130564616 2.209834607105242e-06 -0.001869327786897239 2.209834692822726e-06 -0.0009323217369615201 \
2.209834774749213e-06 4.151965372454519e-05 2.209834895786036e-06 0.001618129410352471 2.209834994714683e-06 0.003024565667809575 2.209835153111356e-06 0.005482561958548801 \
2.209835370558587e-06 0.00923691162542661 2.209835551780809e-06 0.0126653356758144 2.209835763874906e-06 0.01697021734206094 2.209835926898563e-06 0.02046388365739064 \
2.209836087520978e-06 0.02403759527126768 2.209836241061221e-06 0.02755862871109176 2.209836389117902e-06 0.031036270750196 2.209836538198811e-06 0.03460722192241437 \
2.209836692728722e-06 0.03837091703902212 2.209836853379538e-06 0.04234026030123839 2.209837018034218e-06 0.04645786783841532 2.209837194575117e-06 0.05091770581196236 \
2.209837373537969e-06 0.05547793877747508 2.209837564281134e-06 0.0603721650098247 2.209837769062163e-06 0.06565647483694508 2.209837989534449e-06 0.07137203566208646 \
2.209838222394174e-06 0.0774299331224613 2.20983847158165e-06 0.08392829098722057 2.209838744423777e-06 0.09105513637423955 2.209839041127578e-06 0.09880974921055499 \
2.209839368453968e-06 0.1073623706929605 2.209839738105355e-06 0.11701033799881 2.209840132977169e-06 0.1273002725707723 2.209840590815409e-06 0.1392030195235975 \
2.209841122622249e-06 0.1529832553757746 2.209841747860046e-06 0.1691182447448397 2.209842433607517e-06 0.1867241161332086 2.209843236003391e-06 0.2071957342970069 \
2.209844134802183e-06 0.2299563735557614 2.209844940415632e-06 0.2501946571168963 2.209845654166966e-06 0.2679877251922811 2.209846283728848e-06 0.2835633151515627 \
2.209846854092298e-06 0.2975737963344939 2.20984738504768e-06 0.3105173405876944 2.20984788683513e-06 0.3226580892822354 2.209848366129684e-06 0.3341673054699896 \
2.209848831685103e-06 0.3452566901045974 2.209849295481511e-06 0.3562094254686541 2.209849751229541e-06 0.3668794056881832 2.209850211449675e-06 0.3775613305945491 \
2.209850749733646e-06 0.3899285626759094 2.209851250584179e-06 0.4013172511919189 2.209851650806863e-06 0.4103337945930838 2.209852157667644e-06 0.421642452039157 \
2.209852643633856e-06 0.4323669409017459 2.209853043148568e-06 0.4410997362599856 2.209853453760627e-06 0.4500002277813482 2.20985388268706e-06 0.4592207708982954 \
2.209854284201442e-06 0.4677760623951868 2.209854591591888e-06 0.4742753916877908 2.209854941833647e-06 0.4816249679276425 2.20985529507385e-06 0.4889795533930016 \
2.20985554824443e-06 0.4942125642332652 2.20985578118832e-06 0.4989990073547648 2.209856022831611e-06 0.5039392821429431 2.209856247822229e-06 0.5085102868389438 \
2.209856439858337e-06 0.5123881070394828 2.209856624670034e-06 0.5161059569497825 2.20985684696035e-06 0.5205538992744256 2.209857013671757e-06 0.5238726938135662 \
2.209857230888352e-06 0.5281726418673847 2.209857433967244e-06 0.5321820613122353 2.209857611378699e-06 0.5356681922482178 2.209857799451086e-06 0.5393528234657015 \
2.209858035483265e-06 0.5439555888699217 2.209858301365289e-06 0.5491186112539347 2.209858523127178e-06 0.5534070305875756 2.209858803185033e-06 0.5588091140818973 \
2.209859046184818e-06 0.5634839438879177 2.209859321538161e-06 0.5687575845994758 2.209859566533501e-06 0.5734440561015828 2.20985980682772e-06 0.5780305526007354 \
2.209860047867023e-06 0.5826153106864888 2.209860305457841e-06 0.5874946531182738 2.209860540824618e-06 0.5919209497705462 2.209860772126727e-06 0.5962518282209535 \
2.209860994653448e-06 0.6003950532231523 2.209861203013056e-06 0.6042587207462122 2.20986144085487e-06 0.6086392006348278 2.209861651715085e-06 0.612499186772883 \
2.209861907322267e-06 0.617151767543529 2.209862106050032e-06 0.620751700070918 2.209862381682677e-06 0.6257066023742009 2.209862604438798e-06 0.6296824120643636 \
2.209862897809921e-06 0.6348814180513288 2.209863130579923e-06 0.6389753720667986 2.209863350781309e-06 0.6428252659334456 2.209863552051921e-06 0.6463216644290061 \
2.209863769340794e-06 0.6500784077528632 2.209863944056703e-06 0.6530842133917786 2.209864130321333e-06 0.6562672470877895 2.209864309060386e-06 0.6593113758161715 \
2.209864471764399e-06 0.6620700940033843 2.20986463703341e-06 0.6648583661366954 2.209864780301223e-06 0.6672607123132118 2.209864919531648e-06 0.669583864918244 \
2.209865059332215e-06 0.6719085596965743 2.209865194107422e-06 0.6741424479378803 2.209865321601663e-06 0.6762463034350935 2.209865454555774e-06 0.6784344250006583 \
2.209865576160125e-06 0.680430207161383 2.209865704573366e-06 0.6825336955632141 2.209865820340421e-06 0.6844241240890321 2.209865918381593e-06 0.686020684362688 \
2.209866019077699e-06 0.687656981754083 2.209866128831463e-06 0.689434454762776 2.209866245599418e-06 0.6913211166705923 2.209866336826191e-06 0.6927889453402305 \
2.209866446031605e-06 0.6945396927028351 2.209866547140326e-06 0.6961566646470493 2.209866642540618e-06 0.6976767415743361 2.209866752022642e-06 0.6994136821864276 \
2.209866886474277e-06 0.7015344809028976 2.209867035493213e-06 0.7038694457768003 2.209867164423232e-06 0.7058755144243859 2.209867311083691e-06 0.7081418729260142 \
2.209867437868072e-06 0.7100885084081828 2.209867562465961e-06 0.7119899232102255 2.209867674319728e-06 0.7136874821928206 2.209867787275692e-06 0.7153928249203609 \
2.209867887829089e-06 0.716903336497302 2.209868025110592e-06 0.7189542886859326 2.209868144979452e-06 0.7207346491296758 2.209868264162204e-06 0.7224952472954583 \
2.209868391164313e-06 0.7243608783177121 2.209868515712665e-06 0.726179956024653 2.209868639383675e-06 0.7279757435764195 2.209868765971953e-06 0.7298035010246171 \
2.209868896541188e-06 0.7316777339938921 2.209869019056222e-06 0.7334262671520465 2.209869155299713e-06 0.7353588786631546 2.209869256742486e-06 0.7367901064855561 \
2.209869362765969e-06 0.7382789144707947 2.209869453297152e-06 0.7395446819117977 2.209869567123378e-06 0.7411267287627761 2.20986965478496e-06 0.742338113895605 \
2.209869760680238e-06 0.7437932991468792 2.209869891033532e-06 0.7455718205320391 2.20987000160114e-06 0.7470699275523445 2.209870106271611e-06 0.7484790865773925 \
2.209870230233143e-06 0.7501360792234356 2.209870378790597e-06 0.752105598322839 2.209870500473193e-06 0.7537054667443914 2.209870614584882e-06 0.7551949470168074 \
2.209870755005483e-06 0.7570132059451244 2.209870896533544e-06 0.7588296197226846 2.209871014322813e-06 0.7603289862386273 2.209871142522635e-06 0.7619481626911874 \
2.209871284590468e-06 0.7637269294216019 2.209871401465576e-06 0.7651780119234867 2.209871547139362e-06 0.7669714049983392 2.209871668877809e-06 0.7684572223066155 \
2.209871787518301e-06 0.7698939375992205 2.209871909984594e-06 0.7713653733660819 2.209872036701684e-06 0.7728756341192486 2.209872146603678e-06 0.7741754302862822 \
2.209872272219022e-06 0.7756497674172792 2.20987237802943e-06 0.7768823528242577 2.209872514199553e-06 0.7784559787239111 2.209872638546601e-06 0.7798807766277074 \
2.209872765971877e-06 0.7813271999647126 2.209872880527956e-06 0.7826155184370988 2.209872987208226e-06 0.7838050786084815 2.209873125150823e-06 0.785328674235108 \
2.209873274600319e-06 0.7869612315653352 2.209873419452536e-06 0.7885256944569791 2.209873538888287e-06 0.7898026796320731 2.20987367431316e-06 0.7912364721526877 \
2.209873795807481e-06 0.7925100718437531 2.209873939166555e-06 0.7939977458315933 2.209874082600237e-06 0.7954699260458764 2.209874208411247e-06 0.7967479640295563 \
2.209874327457928e-06 0.7979459892863545 2.209874439471573e-06 0.7990632136113104 2.209874544263454e-06 0.8000996927221937 2.209874639456303e-06 0.8010335634530776 \
2.209874775866828e-06 0.8023587211299719 2.209874892679005e-06 0.8034813603122919 2.209875012140248e-06 0.8046180202255495 2.2098751341806e-06 0.8057672874017472 \
2.209875257080697e-06 0.8069126780167393 2.209875384200053e-06 0.8080849010520604 2.209875509341915e-06 0.8092265787736463 2.209875639893142e-06 0.8104047139317369 \
2.209875765969389e-06 0.811530109085512 2.209875893966049e-06 0.8126603425876329 2.209875999427297e-06 0.8135823118114501 2.209876102696597e-06 0.814477091043954 \
2.209876195349946e-06 0.8152732203909091 2.209876319044181e-06 0.8163262937528154 2.209876406664095e-06 0.8170655553659417 2.209876505330151e-06 0.8178914289762149 \
2.209876648877154e-06 0.819080619224994 2.209876784463307e-06 0.8201904093102529 2.209876893653288e-06 0.8210742465492874 2.209877041102747e-06 0.8222539401850584 \
2.209877191506449e-06 0.8234410273756358 2.209877316975411e-06 0.8244188977545531 2.209877461141395e-06 0.8255287290252299 2.20987758542996e-06 0.8264738611628292 \
2.209877735900256e-06 0.8276038147969816 2.209877871506614e-06 0.8286089145501508 2.209877996601616e-06 0.8295251220930787 2.209878114317453e-06 0.8303776282987162 \
2.209878260203052e-06 0.8314210189912619 2.209878426696148e-06 0.8325942517713072 2.209878557562851e-06 0.833503494447128 2.209878731007461e-06 0.8346911703335461 \
2.209878899140202e-06 0.8358239212093587 2.209879068993949e-06 0.8369500705213252 2.209879249886955e-06 0.838129582835239 2.209879393021216e-06 0.8390486258646698 \
2.209879507119162e-06 0.8397723391454259 2.209879637246322e-06 0.8405879656882547 2.209879739102179e-06 0.8412191375388212 2.209879855947599e-06 0.8419354178465567 \
2.209879992919396e-06 0.84276453896487 2.209880190759142e-06 0.843942473808897 2.20988038244463e-06 0.8450620046306492 2.209880591850993e-06 0.8462610422160779 \
2.209880773861877e-06 0.8472832413425977 2.209880970977333e-06 0.8483697584184032 2.209881144290447e-06 0.8493077402131245 2.209881327325656e-06 0.8502809338042043 \
2.209881498478783e-06 0.8511747489972419 2.209881673131736e-06 0.8520708361396651 2.209881848382891e-06 0.8529540285731302 2.209882024530391e-06 0.8538259128238825 \
2.209882214836779e-06 0.8547503816925358 2.209882405427748e-06 0.8556583881771193 2.209882605979791e-06 0.8565949481971697 2.209882798582588e-06 0.8574764650234362 \
2.209883009331288e-06 0.8584213553684483 2.209883237362186e-06 0.8594210644592908 2.209883503241952e-06 0.8605573106989262 2.209883801820094e-06 0.8617960322792503 \
2.209884077983729e-06 0.8629075153790151 2.209884362230229e-06 0.8640180616030438 2.20988463641423e-06 0.8650581816846495 2.20988490866944e-06 0.8660616517296992 \
2.209885178858914e-06 0.8670295451208139 2.209885436023238e-06 0.8679256252637404 2.209885708596972e-06 0.8688492356117473 2.209885984602435e-06 0.8697577927663542 \
2.209886254710518e-06 0.8706213441784563 2.209886554568938e-06 0.8715508809746347 2.209886925582816e-06 0.8726599440782473 2.209887220515529e-06 0.873510245983525 \
2.209887474800895e-06 0.8742218447789023 2.20988777304417e-06 0.8750318897722944 2.209888046640928e-06 0.8757523113099853 2.209888282767907e-06 0.8763571312809064 \
2.209888523107205e-06 0.876957042728428 2.209888745440861e-06 0.8774982514557473 2.209888939446793e-06 0.8779599514934209 2.209889269165228e-06 0.8787226653583874 \
2.209889424338019e-06 0.8790722725343518 2.209889742071409e-06 0.8797700114458387 2.20988992093906e-06 0.880152324917399 2.209890263400534e-06 0.8808637455080008 \
2.209890447552368e-06 0.8812353200296749 2.209890922478418e-06 0.8821594045029107 2.209891089871654e-06 0.8824737723885729 2.20989155569296e-06 0.8833186808430151 \
2.209891736520447e-06 0.883635209600208 2.209892230549786e-06 0.8844687288968743 2.209892371887773e-06 0.8846990198924604 2.209892978249103e-06 0.8856473543416146 \
2.209893130320955e-06 0.8858754372639542 2.209893777008948e-06 0.8868048391838264 2.209893905303109e-06 0.8869818633102416 2.209894553496582e-06 0.8878410756373726 \
2.209894683245133e-06 0.8880061989117775 2.209895451498601e-06 0.8889361126992519 2.209895581240625e-06 0.8890847997417872 2.209896434697557e-06 0.8900046759307325 \
2.209896577924673e-06 0.8901495209380393 2.209897564158077e-06 0.8910738355210844 2.209897785636141e-06 0.8912643084423501 2.209898928653689e-06 0.8921737958641509 \
2.209899058631989e-06 0.8922730011388891 2.209900410338988e-06 0.8932565980587214 2.209900560692342e-06 0.8933589605607284 2.209902041315768e-06 0.8942730372387374 \
2.20990228021907e-06 0.8944047337041336 2.209904061344227e-06 0.8952702388217941 2.209904447325594e-06 0.8954343910560414 2.209906848871634e-06 0.896309305076933 \
2.20990732380842e-06 0.8964562995603377 2.209911141970139e-06 0.8973944547681553 2.209911624459336e-06 0.897487269196476 2.209919510474849e-06 0.898471373493449 \
2.209920126637539e-06 0.8985180228791175 2.210015282612379e-06 0.899508178894561 2.210016773214557e-06 0.8995204306067698 2.210128061288741e-06 0.9005118233983579 \
2.210128237625743e-06 0.9005706457326812 2.210131860757067e-06 0.8996048713171836 2.210132041955093e-06 0.8994654179496379 2.21013335307657e-06 0.8985275682722235 \
2.210133534953976e-06 0.8984123497545736 2.21013535794417e-06 0.8974436520388238 2.210135517857424e-06 0.8973766233009967 2.210148668688723e-06 0.8983720910457982 \
2.210148779670276e-06 0.8983905835035384 2.210157601254383e-06 0.8993863063850064 2.210158148023846e-06 0.8994226481040219 2.21065071997668e-06 0.9003987622903815 \
2.210650789769166e-06 0.9004496773542636 2.210651622421929e-06 0.9012853800543292 2.210651748468094e-06 0.9014513953152168 2.210652328988957e-06 0.9023435091985418 \
2.210652469953212e-06 0.9025895326188698 2.210652869091291e-06 0.9033428289365844 2.210653019240832e-06 0.9036449200440446 2.210653462322153e-06 0.9045762589490434 \
2.210653619494256e-06 0.9049121924877023 2.210654065120987e-06 0.9058152254958243 2.210654163577326e-06 0.9059929146639856 2.21065558025872e-06 0.9052304871087643 \
2.210655711415865e-06 0.904616184869324 2.210655880423041e-06 0.9036290332250884 2.210656045714917e-06 0.9024406226812831 2.210656151980697e-06 0.9015554774641358 \
2.210656255417528e-06 0.9006052096506509 2.210656341184247e-06 0.8997486040545581 2.210656430678233e-06 0.8987887485205278 2.210656554922632e-06 0.8973492764100613 \
2.21065667300358e-06 0.8958624931586439 2.210656760219672e-06 0.8946938835082598 2.210656884526716e-06 0.8929289312882503 2.210656991510644e-06 0.8913158670103165 \
2.210657091342348e-06 0.8897378501708729 2.210657217633174e-06 0.8876466417139378 2.210657385821785e-06 0.884705368138502 2.210657541521538e-06 0.8818365157686672 \
2.210657738126367e-06 0.8780362649814708 2.210657921747617e-06 0.8743271923380105 2.21065813325501e-06 0.8698916163736473 2.21065831406481e-06 0.8659808238081558 \
2.210658498645858e-06 0.8618945354625286 2.210658671649853e-06 0.8579913311618118 2.210658857050503e-06 0.8537436868396935 2.210659036133651e-06 0.8495884889292737 \
2.210659219722713e-06 0.8452850234109005 2.210659386484418e-06 0.8413449312544377 2.210659554574996e-06 0.8373487193315756 2.210659717684167e-06 0.8334514816705533 \
2.210659872870403e-06 0.829729402178684 2.210660045969282e-06 0.8255639501984255 2.210660231959738e-06 0.8210763864673301 2.210660396580222e-06 0.8170961425007568 \
2.210660561450132e-06 0.8131038678717658 2.210660736782164e-06 0.8088537582860886 2.210660901208668e-06 0.8048648186953292 2.210661069844278e-06 0.8007719922541914 \
2.210661260647645e-06 0.7961398815555145 2.210661446171818e-06 0.7916360074082958 2.210661655100628e-06 0.7865651471012967 2.210661879917618e-06 0.7811107659751856 \
2.210662069732705e-06 0.77650678233121 2.210662271590188e-06 0.7716133355283564 2.210662415860827e-06 0.76811790639139 2.210662557504392e-06 0.7646880872338248 \
2.210662685202102e-06 0.7615975116975136 2.210662796247943e-06 0.7589113686396982 2.210662924810579e-06 0.7558028559024855 2.210663057376087e-06 0.7525995467138866 \
2.210663170697783e-06 0.7498629233610832 2.210663307032409e-06 0.7465723252212872 2.210663413431661e-06 0.7440058350410135 2.210663572650447e-06 0.7401674766516904 \
2.210663745028142e-06 0.7360137588823189 2.210663907275386e-06 0.7321074183421575 2.210664079624343e-06 0.7279612819449855 2.210664239010527e-06 0.7241302920521341 \
2.210664446815714e-06 0.7191408067115369 2.210664607355379e-06 0.7152908836069264 2.210664799844715e-06 0.7106793324906435 2.210664985361064e-06 0.7062404417184839 \
2.210665155237109e-06 0.7021802791355866 2.210665347106947e-06 0.6975984806629684 2.210665493330962e-06 0.6941099299715526 2.210665653617309e-06 0.6902897983225644 \
2.210665856006145e-06 0.6854719661536142 2.210666037294609e-06 0.681161582477689 2.210666206116035e-06 0.6771536053116509 2.210666391961911e-06 0.6727470762459599 \
2.210666597892751e-06 0.6678715161770782 2.210666765819558e-06 0.6639016226084196 2.210666926081261e-06 0.6601182542089066 2.210667164933735e-06 0.65448589698252 \
2.210667332694849e-06 0.6505369020837752 2.210667513768288e-06 0.6462813620835641 2.210667674923199e-06 0.642499550819208 2.21066782119046e-06 0.6390715923276049 \
2.210667959878569e-06 0.6358268652274862 2.210668089235615e-06 0.6328040340451749 2.21066821862017e-06 0.6297855584526113 2.21066834694149e-06 0.6267952385336898 \
2.210668477143629e-06 0.6237652412672913 2.210668606160073e-06 0.6207683673242944 2.210668744735633e-06 0.6175525629501428 2.21066889281122e-06 0.6141227553162802 \
2.210669079138505e-06 0.60981438109949 2.210669226822204e-06 0.6064079319686639 2.21066946198641e-06 0.600995965122186 2.21066965443414e-06 0.5965821560879089 \
2.210669895003954e-06 0.5910808370261941 2.210670064051325e-06 0.587228367631822 2.21067020171775e-06 0.5840969866928536 2.210670329822726e-06 0.581191110277254 \
2.210670443409422e-06 0.5786182870235701 2.210670534774225e-06 0.5765512826027382 2.210670624196113e-06 0.5745328691003393 2.210670691457846e-06 0.573016830490748 \
2.210670757478049e-06 0.5715297341779608 2.210670809531724e-06 0.5703577032508095 2.210670873770593e-06 0.5689124506700958 2.210670935307115e-06 0.5675311492520995 \
2.21067099958866e-06 0.5660899724818867 2.210671052779755e-06 0.5648985048860162 2.21067114512554e-06 0.5628316153148989 2.210671221701441e-06 0.5611191615154557 \
2.210671277545091e-06 0.5598732849310241 2.210671346888199e-06 0.5583285932816697 2.210671452739475e-06 0.5559733466166974 2.21067153043128e-06 0.5542469170533902 \
2.210671631029867e-06 0.5520159549745236 2.210671759063078e-06 0.5491849411292137 2.21067185856046e-06 0.5469885705929382 2.210671971125811e-06 0.544508366501287 \
2.210672074170131e-06 0.5422442603473754 2.210672194219017e-06 0.5396115972585003 2.210672295833426e-06 0.5373863339265779 2.210672411457693e-06 0.5348611538529422 \
2.210672526573874e-06 0.5323536236546169 2.210672653010918e-06 0.529604142030661 2.210672778525185e-06 0.5268822104345234 2.210672925204861e-06 0.5237112381511962 \
2.210673060875569e-06 0.5207845659358002 2.210673218641408e-06 0.5173942078023266 2.210673381063349e-06 0.5139116507621072 2.210673561971817e-06 0.5100482739823553 \
2.210673754563972e-06 0.5059503908118104 2.210673967555743e-06 0.5014368974673542 2.210674199988459e-06 0.4965308659362653 2.210674457509373e-06 0.49112491222925 \
2.210674697473551e-06 0.4861095397820235 2.210674998677905e-06 0.4798501326413723 2.210675286975534e-06 0.4738957353990632 2.210675600061861e-06 0.4674739717793394 \
2.210675919588141e-06 0.4609631488871989 2.210676259085406e-06 0.4540919149088484 2.210676585275518e-06 0.4475353831519197 2.21067692175678e-06 0.4408159131180407 \
2.210677238467587e-06 0.4345373385230166 2.21067757255266e-06 0.4279587671099637 2.210677924261528e-06 0.4210864038135054 2.210678238746378e-06 0.4149846225409808 \
2.210678562192835e-06 0.4087533091618546 2.210679003120948e-06 0.400331870031168 2.210679344916025e-06 0.3938679283557566 2.210679644350068e-06 0.3882534014213259 \
2.210680018872672e-06 0.3812944595528024 2.210680348250389e-06 0.375233915169682 2.210680631354694e-06 0.3700684563936956 2.210680931099704e-06 0.3646408765157301 \
2.210681210595549e-06 0.3596219010422631 2.210681434267487e-06 0.3556377385586224 2.210681645979194e-06 0.3518907610576284 2.210681848481927e-06 0.3483292724130969 \
2.210682049543475e-06 0.3448190020587957 2.210682255221383e-06 0.3412518188287665 2.21068247359686e-06 0.3374887625241871 2.210682717359256e-06 0.3333167726275162 \
2.210682944115829e-06 0.3294678078423895 2.2106831640268e-06 0.3257615367192951 2.210683382451408e-06 0.3221060038181086 2.210683586476418e-06 0.318715141566024 \
2.210683788334207e-06 0.3153870758963987 2.210683988657595e-06 0.3121102802474151 2.210684175271502e-06 0.309079115007194 2.210684372573108e-06 0.3058982938882217 \
2.210684581156335e-06 0.3025606704206737 2.210684786791057e-06 0.2992974534031506 2.210685011523137e-06 0.2957609785165763 2.210685228418979e-06 0.2923771984023277 \
2.21068543609833e-06 0.2891642611511841 2.210685667149177e-06 0.2856239464683982 2.210685841949429e-06 0.2829684481899911 2.210686021147604e-06 0.2802647299798244 \
2.21068619002212e-06 0.2777348429135014 2.210686418345393e-06 0.274348458173166 2.210686595082661e-06 0.2717528218126659 2.210686763365392e-06 0.2693020894036587 \
2.210686935832162e-06 0.2668230333489093 2.210687069934441e-06 0.264903804409765 2.210687215894446e-06 0.2628277003548514 2.210687354589946e-06 0.2608803500812688 \
2.210687476871551e-06 0.2591684246570544 2.210687610990381e-06 0.2572942758553639 2.210687740091486e-06 0.2554978336754472 2.21068785952522e-06 0.2538430842138498 \
2.210687986360419e-06 0.2520939183506197 2.210688106001441e-06 0.2504447954274527 2.210688255617635e-06 0.2483797066042054 2.210688390481146e-06 0.2465170278296022 \
2.21068852003856e-06 0.2447289494531232 2.210688677103379e-06 0.2425624627506451 2.210688801099014e-06 0.2408491463446025 2.210688941247149e-06 0.2389135279283614 \
2.21068907114005e-06 0.2371200701944942 2.21068919175767e-06 0.2354534357320198 2.2106893542306e-06 0.2332087289724075 2.2106895002847e-06 0.2311905595759856 \
2.210689638605484e-06 0.2292825126447264 2.210689746532702e-06 0.2277949627009887 2.210689877317609e-06 0.225993474229161 2.210689975823625e-06 0.22463752857886 \
2.210690079906972e-06 0.2232056532573264 2.210690152783836e-06 0.2222046546567725 2.210690234937313e-06 0.2210804129356655 2.210690302346398e-06 0.2201585377209549 \
2.210690349050661e-06 0.2195201149856669 2.21069039846802e-06 0.2188449488487562 2.210690489422163e-06 0.2176035744446363 2.210690555816576e-06 0.2166983392055156 \
2.210690602779869e-06 0.2160586379972232 2.210690653091075e-06 0.2153737902794619 2.210690712240424e-06 0.2145693142997165 2.210690755086328e-06 0.2139870779821451 \
2.210690798893629e-06 0.2133941263688522 2.210690868423894e-06 0.2124566309962414 2.210690955340708e-06 0.2112864027023158 2.210691036529563e-06 0.2101949018929156 \
2.210691122429026e-06 0.2090416531541652 2.210691216575207e-06 0.2077796428137634 2.210691308329081e-06 0.2065517647617813 2.210691403625517e-06 0.2052788208685862 \
2.210691500104208e-06 0.2039945431316728 2.21069160092949e-06 0.2026602783061639 2.210691696885502e-06 0.2013924147365721 2.210691799571213e-06 0.2000377255165624 \
2.210691902607566e-06 0.1986831378210229 2.210692012697906e-06 0.1972405340748948 2.210692121449794e-06 0.1958206085628783 2.210692241171749e-06 0.1942631948714586 \
2.210692351614651e-06 0.1928328887741874 2.210692459617459e-06 0.1914411844406488 2.210692584973803e-06 0.1898318066870429 2.210692677907979e-06 0.1886434908940876 \
2.210692756278755e-06 0.1876443873000938 2.210692832918829e-06 0.1866698667869858 2.210692915430143e-06 0.1856249297118943 2.210692984939759e-06 0.1847473639743596 \
2.210693050895387e-06 0.1839166514106665 2.210693115162722e-06 0.1831089953192083 2.210693227146207e-06 0.1817072258029639 2.210693321200173e-06 0.1805353135896268 \
2.210693428841935e-06 0.1791985758407087 2.210693535314993e-06 0.1778827552324552 2.21069365530692e-06 0.1764073736674057 2.210693793359545e-06 0.174720142305475 \
2.2106939095201e-06 0.1733081217455876 2.210694071616903e-06 0.1713503924599185 2.210694186705419e-06 0.1699688234017716 2.210694326691019e-06 0.1682987764548305 \
2.210694443897094e-06 0.1669083002780509 2.210694554816447e-06 0.1655990025649634 2.210694652444933e-06 0.1644521190704843 2.210694747295481e-06 0.1633427224865242 \
2.210694863349893e-06 0.161991523106341 2.210694954898444e-06 0.1609305136382055 2.21069505100742e-06 0.1598214181625073 2.210695145225553e-06 0.1587403933520305 \
2.210695238726156e-06 0.1576732160104884 2.210695332323478e-06 0.1566104070550305 2.210695428005016e-06 0.1555300824433628 2.210695518592921e-06 0.1545132165873678 \
2.210695609606078e-06 0.1534969984004868 2.210695705154555e-06 0.1524358767948732 2.210695795820268e-06 0.1514342506187442 2.21069589889263e-06 0.1503020548964867 \
2.210695971344079e-06 0.1495100717445464 2.210696050444872e-06 0.148649146151682 2.210696124993091e-06 0.1478424742503694 2.2106961960245e-06 0.1470770917224498 \
2.210696268788981e-06 0.1462962409077327 2.210696343406156e-06 0.1454990959398698 2.210696413389118e-06 0.1447543557055888 2.210696487550038e-06 0.143968261688537 \
2.210696541295377e-06 0.1434005634796054 2.210696594578932e-06 0.1428396203849428 2.21069665977469e-06 0.1421555039833398 2.210696731080731e-06 0.141411576573238 \
2.210696795450793e-06 0.1407432786314442 2.210696868802753e-06 0.1399847409254479 2.210696929420321e-06 0.1393607073002494 2.210697015453804e-06 0.1384787080092832 \
2.21069709140482e-06 0.1377037134581418 2.210697181372726e-06 0.1367902106004182 2.210697263099683e-06 0.1359645165492482 2.210697345789661e-06 0.1351360437760365 \
2.210697428345969e-06 0.1343145513298757 2.210697533908124e-06 0.1332698421778018 2.210697615775408e-06 0.1324642397250402 2.210697713142868e-06 0.1315110876582503 \
2.210697803143728e-06 0.130634908321232 2.210697891113987e-06 0.1297829978838479 2.210697974043842e-06 0.1289892226181523 2.210698048280934e-06 0.1282822873521282 \
2.210698147931992e-06 0.1273377645104763 2.210698243687052e-06 0.1264350619688987 2.210698330534457e-06 0.1256206895242312 2.210698420535994e-06 0.1247808744623497 \
2.210698500868674e-06 0.1240346855852102 2.210698587562703e-06 0.1232365419604467 2.210698686393032e-06 0.1223331159004786 2.210698776475169e-06 0.1215131568528167 \
2.210698886718427e-06 0.1205141992263624 2.210698973949866e-06 0.1197275966302077 2.210699042523e-06 0.1191120727131645 2.210699127185392e-06 0.1183553887582162 \
2.210699193692874e-06 0.1177634990399222 2.210699265148799e-06 0.1171309945267847 2.210699334822604e-06 0.1165184920865242 2.210699412159692e-06 0.1158409171037389 \
2.210699507902974e-06 0.1150054407698888 2.210699579157887e-06 0.1143861389207103 2.21069964652742e-06 0.1138025718558601 2.210699714964191e-06 0.113211685696446 \
2.210699790554542e-06 0.1125613765304429 2.210699881296388e-06 0.1117840233035959 2.210699964000116e-06 0.1110788257213999 2.210700077599187e-06 0.1101151050704521 \
2.210700187474899e-06 0.1091895325357105 2.210700279674213e-06 0.1084169374841771 2.210700403623544e-06 0.1073835127717347 2.210700491987867e-06 0.1066505015902263 \
2.210700631446837e-06 0.1055001025916527 2.210700730743538e-06 0.1046863788921388 2.21070082339359e-06 0.1039306459201802 2.210700933598102e-06 0.1030359883605075 \
2.210701018892542e-06 0.1023467905686673 2.210701103793345e-06 0.101663637589173 2.210701186744308e-06 0.1009989740617136 2.21070130925421e-06 0.1000225794851696 \
2.210701431196062e-06 0.09905761200121259 2.210701557818349e-06 0.09806258992746317 2.210701670630471e-06 0.09718220909187772 2.210701815205956e-06 0.09606278874246346 \
2.210701952919884e-06 0.09500564015228773 2.210702069610674e-06 0.09411672853020667 2.210702197354242e-06 0.0931507147971556 2.210702297018758e-06 0.09240236948627445 \
2.210702376452637e-06 0.09180921593916676 2.210702475187935e-06 0.09107599640376031 2.210702553063239e-06 0.09050081472416407 2.210702634529154e-06 0.08990210528957472 \
2.210702709246463e-06 0.0893557072655629 2.2107027897762e-06 0.08876971652456604 2.210702908608526e-06 0.08791061481419053 2.210702998269062e-06 0.08726673116015753 \
2.210703103183109e-06 0.08651800316437093 2.210703234657666e-06 0.08558693768262025 2.210703395765802e-06 0.08445695903909305 2.210703535947497e-06 0.08348350561263763 \
2.210703684450103e-06 0.08246223579158835 2.210703821170292e-06 0.08153124812726546 2.210703961182002e-06 0.08058696725890066 2.210704098179202e-06 0.07967195061625794 \
2.210704236789813e-06 0.07875532825288725 2.2107043812627e-06 0.07780967510081127 2.210704528808937e-06 0.07685421131041187 2.210704686312648e-06 0.07584560580436887 \
2.210704850707884e-06 0.07480523464991846 2.210705018799982e-06 0.07375451744755303 2.210705199799341e-06 0.07263751640721161 2.210705398512623e-06 0.07142823309373261 \
2.210705611921415e-06 0.07014922396308329 2.2107058380853e-06 0.06881630383186611 2.210706078645623e-06 0.06742468841361035 2.210706356206535e-06 0.06585179211508728 \
2.210706653410938e-06 0.06420523370201831 2.210706971711662e-06 0.06248365192299224 2.210707361695962e-06 0.06043183534616462 2.210707760522748e-06 0.05839861031494715 \
2.210708202994687e-06 0.05621846258761681 2.210708587975589e-06 0.05438828987170503 2.210709000022182e-06 0.05249218901100536 2.210709351759698e-06 0.05092353490091287 \
2.21070968726435e-06 0.04946969867921969 2.210709997763244e-06 0.04816021644386199 2.210710291700064e-06 0.04695194805701195 2.210710584430997e-06 0.04577883625507727 \
2.210710859274204e-06 0.04470700909733757 2.210711133117927e-06 0.04366353526031765 2.210711398807687e-06 0.04267398813878486 2.210711674116703e-06 0.04167180388267511 \
2.210711958673621e-06 0.04066026046469497 2.210712254971736e-06 0.03963283340811159 2.210712513847121e-06 0.03875659098599576 2.210712741803527e-06 0.03800131046948733 \
2.210712960528722e-06 0.03729095380188759 2.210713180383449e-06 0.03659437723507575 2.210713521249514e-06 0.03554043311314246 2.210713797290394e-06 0.03470953269536187 \
2.210714090721169e-06 0.03384790442147732 2.210714373289092e-06 0.03303898052111545 2.210714628198528e-06 0.03232625790162248 2.210714908882988e-06 0.03155947796597136 \
2.210715154716381e-06 0.03090318379665042 2.21071538687767e-06 0.03029616297556957 2.210715627215008e-06 0.02968398395812225 2.210715862851843e-06 0.02909722707395018 \
2.21071609106302e-06 0.0285403787496557 2.210716507835749e-06 0.02755138287878544 2.210716702361127e-06 0.02710176794309662 2.210717088601532e-06 0.02623051698020805 \
2.210717267770925e-06 0.0258356865503758 2.210717618998109e-06 0.02507792837274256 2.210717786904156e-06 0.0247229612172224 2.210718171166812e-06 0.02392944198669211 \
2.21071828644854e-06 0.02369675911063252 2.210718728496378e-06 0.02282172072611499 2.210718950311652e-06 0.02239223679446916 2.210719473931311e-06 0.02139838041889957 \
2.210719629293819e-06 0.02110714647916685 2.210720146999888e-06 0.02015295207761772 2.210720272033152e-06 0.01992792118872039 2.210720796234659e-06 0.01901759738223179 \
2.210720932454034e-06 0.01879045572456909 2.21072153873049e-06 0.01783210191617334 2.210721705739623e-06 0.01758082406519646 2.210722348947266e-06 0.01666064795441237 \
2.210722528091535e-06 0.0164167113061686 2.210723218250269e-06 0.01551958953683085 2.210723381870153e-06 0.01531511209162885 2.21072414235084e-06 0.01440332854054019 \
2.210724289392962e-06 0.01423371673427115 2.210725107264621e-06 0.01333087949608782 2.210725226813134e-06 0.01320411419549955 2.210726142674655e-06 0.01227329163592313 \
2.210726284027572e-06 0.01213544173166964 2.210727232503148e-06 0.01124488043697059 2.210727391142586e-06 0.01110230805801717 2.21072857354363e-06 0.01011356759191894 \
2.21072867164402e-06 0.01003725601038859 2.21072993325548e-06 0.009120360285939955 2.21073006766933e-06 0.009028655389366201 2.210731608240655e-06 0.008043892937307966 \
2.210731689273999e-06 0.007992925041580451 2.210733277867931e-06 0.007023242357651564 2.210733410759078e-06 0.006948518507451114 2.21073538746242e-06 0.005952856104192286 \
2.210735569200568e-06 0.005869662958407677 2.210737671554228e-06 0.004980929874643355 2.210738112345996e-06 0.004810448874467742 2.210740767560855e-06 0.003892108290451164 \
2.210741244140394e-06 0.003745909362026665 2.210744882222614e-06 0.00279447349697209 2.21074540774606e-06 0.002678838783887205 2.210751013810845e-06 0.001700248310874221 \
2.210751324898547e-06 0.001653333728976835 2.210756459226246e-06 0.0006858192122199529 2.210756653206019e-06 0.0006440832883579712 2.213404576914862e-06 -0.0002037173203380238 \
2.213404741115283e-06 -0.0003889174928863678 2.213405314458091e-06 -0.001270938904608877 2.213405389392278e-06 -0.001411855863724778 2.213405849976055e-06 -0.002393592696522268 \
2.213405961916807e-06 -0.002660411672198376 2.213406215188795e-06 -0.003300974950034667 2.213406381572099e-06 -0.003745951779090856 2.213406676567869e-06 -0.004566571567208835 \
2.213406788055442e-06 -0.00488071790655901 2.213407067428216e-06 -0.005641221413069743 2.213407188386555e-06 -0.005938820066262044 2.213408282339388e-06 -0.005180465225493313 \
2.213408406471631e-06 -0.004410796826645887 2.213408530879049e-06 -0.003456122327429311 2.213408650435428e-06 -0.002364170815481491 2.213408748579805e-06 -0.001341064316055312 \
2.213408855004127e-06 -0.0001052154991983786 2.213408967239972e-06 0.001336046702817826 2.213409102195821e-06 0.003249882807978809 2.21340922478233e-06 0.005149402351921401 \
2.213409413644246e-06 0.008353592055059769 2.213409554826578e-06 0.01094873860302964 2.213409708187922e-06 0.01393943619118621 2.213409851561427e-06 0.01687898420971235 \
2.213410005752867e-06 0.02017576688295359 2.213410161892825e-06 0.02363796584892512 2.213410317618878e-06 0.02719811802828209 2.213410465112557e-06 0.03065407560139007 \
2.213410613784323e-06 0.03420778369279751 2.213410769114407e-06 0.03798436241030867 2.213410927740287e-06 0.04189786275883118 2.213411092673448e-06 0.0460171220807938 \
2.213411267096336e-06 0.05041857973200652 2.213411446085736e-06 0.05497510627343041 2.213411635385597e-06 0.05982852266675163 2.213411838393602e-06 0.06506368941101938 \
2.213412057870669e-06 0.07075025585284363 2.21341228893533e-06 0.07675903373893865 2.213412535995649e-06 0.08319974270080552 2.213412806420637e-06 0.0902619122132732 \
2.213413099984324e-06 0.09793335781011638 2.213413424033306e-06 0.1064001814721126 2.213413788254856e-06 0.1159066558703892 2.213414180806325e-06 0.1261372395632307 \
2.213414630304251e-06 0.1378252442462487 2.213415153096483e-06 0.1513754922073403 2.213415766694219e-06 0.1672157090591849 2.213416444455093e-06 0.184625848284817 \
2.213417232720212e-06 0.2047487967247964 2.213418115553071e-06 0.22712469896725 2.213418933839029e-06 0.2476994923478653 2.213419661268608e-06 0.2658503723959502 \
2.213420301381635e-06 0.2817009601644404 2.21342087568535e-06 0.2958213763442377 2.213421413251317e-06 0.3089396094373287 2.213421917248776e-06 0.3211464104224903 \
2.21342239337143e-06 0.3325930942309646 2.213422871259445e-06 0.3439912352478621 2.213423324592551e-06 0.3547121966731367 2.213423795885259e-06 0.3657614311162562 \
2.213424238561085e-06 0.3760518588326446 2.213424757059872e-06 0.3879885572071845 2.213425284221992e-06 0.3999987293386327 2.213425663131623e-06 0.4085537955782026 \
2.213426193047166e-06 0.4204060347738258 2.213426622963746e-06 0.429919877745455 2.213427076664521e-06 0.4398653393542544 2.213427543378037e-06 0.4500002271552926 \
2.213427981059267e-06 0.4594210430579985 2.213428389021531e-06 0.468120704286539 2.213428708454564e-06 0.4748816926501604 2.213429080589836e-06 0.4826992142337162 \
2.213429315571977e-06 0.4876010339127531 2.213429549178225e-06 0.4924491904621348 2.213429797190648e-06 0.4975647713404599 2.213430095592078e-06 0.5036796627825791 \
2.213430351948479e-06 0.5088948470128004 2.21343056424179e-06 0.5131878547336713 2.213430758259861e-06 0.5170959594548015 2.213430905246394e-06 0.5200432695146362 \
2.213431059224404e-06 0.523118600542271 2.213431277106154e-06 0.5274469616807909 2.21343153021048e-06 0.5324525256580425 2.213431740049324e-06 0.5365797337241586 \
2.213431951502633e-06 0.5407247601751553 2.213432233709533e-06 0.5462280430697679 2.213432463254817e-06 0.5506821559930507 2.213432679151023e-06 0.5548604062613707 \
2.213432961372541e-06 0.560308769190463 2.213433212680268e-06 0.5651538146135803 2.21343351034116e-06 0.5708625224168123 2.21343376056806e-06 0.5756519166658941 \
2.213434016931555e-06 0.5805516059354519 2.21343425734157e-06 0.585116682128892 2.213434515521386e-06 0.5900038400537884 2.213434739113592e-06 0.5942175703762435 \
2.213434977623163e-06 0.5986919452581434 2.213435185207861e-06 0.6025689278491061 2.213435401730487e-06 0.6065904171332736 2.213435651033092e-06 0.6111939272561876 \
2.213435856106535e-06 0.6149609706257601 2.213436107378861e-06 0.6195555361399968 2.213436310600886e-06 0.6232455818254186 2.213436507472791e-06 0.6267987644955494 \
2.213436700764307e-06 0.630267737067843 2.213436955542762e-06 0.6348113783570861 2.213437185753374e-06 0.638887973644319 2.213437403107185e-06 0.6427143472883045 \
2.213437701512907e-06 0.6479268061885751 2.213437916915757e-06 0.6516657345437264 2.213438118139476e-06 0.6551344108237934 2.213438293060983e-06 0.6581323437428509 \
2.213438458126254e-06 0.6609495238976936 2.213438627594775e-06 0.6638251431769452 2.213438779731612e-06 0.666392827642013 2.213438917642298e-06 0.6687037209181631 \
2.213439066478412e-06 0.6711867545200138 2.213439194593014e-06 0.6733159837320549 2.213439337815828e-06 0.6756849429836936 2.213439459090077e-06 0.6776819274526149 \
2.213439596688761e-06 0.6799401191146522 2.213439716069216e-06 0.6818929034138137 2.213439863176962e-06 0.6842914131385206 2.213439980378628e-06 0.6861933934268433 \
2.213440073884205e-06 0.6877071857403232 2.213440164873897e-06 0.6891752279197846 2.213440267615961e-06 0.6908280855439021 2.213440369133525e-06 0.6924555900607121 \
2.213440487516631e-06 0.6943444167618776 2.213440599637217e-06 0.6961264383846065 2.213440717192718e-06 0.6979868779962457 2.213440902343004e-06 0.7008959348649784 \
2.213441033535213e-06 0.7029413755586562 2.213441169703753e-06 0.7050491462541959 2.213441291222456e-06 0.7069171228306749 2.213441431145468e-06 0.7090538254196674 \
2.213441535088117e-06 0.7106315721465845 2.2134416462491e-06 0.712309798010818 2.213441750508965e-06 0.7138759052437967 2.213441880147056e-06 0.7158124745844324 \
2.213441977077769e-06 0.7172526339884565 2.213442116000004e-06 0.7193052800722975 2.213442235549293e-06 0.7210612846995991 2.213442355121865e-06 0.7228080613301419 \
2.213442480897243e-06 0.7246353354365959 2.213442607615585e-06 0.7264656873164689 2.213442729655437e-06 0.728218443613998 2.21344285780388e-06 0.7300486655261287 \
2.213442987872205e-06 0.7318956587421809 2.213443108863227e-06 0.7336041830685722 2.213443249633811e-06 0.7355801168346318 2.21344335060338e-06 0.7369898206659778 \
2.213443452204237e-06 0.7384020079314992 2.213443548224548e-06 0.7397310783624924 2.213443659137403e-06 0.7412570822736337 2.21344374678503e-06 0.7424563811251772 \
2.2134438466394e-06 0.7438154404043728 2.213443981404538e-06 0.7456370856934184 2.213444097699018e-06 0.747198032089633 2.213444201190815e-06 0.7485782798032956 \
2.213444325446263e-06 0.7502239458264747 2.213444470359203e-06 0.7521280942578691 2.213444588339771e-06 0.753666143975803 2.213444707270879e-06 0.7552056331692281 \
2.213444846850418e-06 0.7569980918234445 2.213444991202808e-06 0.7588357421297242 2.213445109263616e-06 0.7603265096672839 2.213445234085335e-06 0.7618908200857619 \
2.213445373916531e-06 0.7636286950759973 2.213445498679428e-06 0.7651662633748356 2.213445642192899e-06 0.7669199865864609 2.213445762878376e-06 0.7683824344671055 \
2.213445883722124e-06 0.7698356273746885 2.213446003367048e-06 0.7712633747646481 2.213446133074687e-06 0.7727989859455529 2.21344624181849e-06 0.7740766298596218 \
2.213446364466226e-06 0.7755070372682662 2.213446474242911e-06 0.7767778749889983 2.213446603267025e-06 0.7782599816788072 2.213446735043344e-06 0.7797610257751375 \
2.213446848355919e-06 0.7810403609326458 2.213446969441861e-06 0.7823954393038701 2.213447073314495e-06 0.7835479431998941 2.213447215597517e-06 0.785111775748914 \
2.213447363800666e-06 0.7867227488076519 2.213447522694201e-06 0.7884297907063792 2.213447642887223e-06 0.7897074707829422 2.21344779245393e-06 0.7912811323018302 \
2.213447916569146e-06 0.7925734175081853 2.213448042273444e-06 0.7938699048627912 2.213448145219011e-06 0.7949224966762399 2.213448259590165e-06 0.7960823495211882 \
2.213448372064409e-06 0.7972131756542409 2.213448462336983e-06 0.7981137961420948 2.213448551677879e-06 0.7989989930139054 2.213448676903817e-06 0.800229513878344 \
2.213448784675179e-06 0.8012785338618679 2.213448914342978e-06 0.8025281307685926 2.213449035722257e-06 0.8036855380110038 2.213449152278057e-06 0.8047859282369955 \
2.213449273083452e-06 0.80591497746663 2.213449405708758e-06 0.8071413435168892 2.213449527502378e-06 0.8082555056211007 2.213449654106103e-06 0.8094015704683005 \
2.213449779719621e-06 0.8105266036187198 2.213449899211046e-06 0.8115857443778658 2.213450037409299e-06 0.8127973981963581 2.213450146908547e-06 0.8137473213416323 \
2.213450231056662e-06 0.8144713378799666 2.21345035186072e-06 0.8155017394983226 2.213450447369557e-06 0.8163089346032877 2.21345058366036e-06 0.8174496006492775 \
2.213450726424414e-06 0.8186303638797883 2.213450860857535e-06 0.8197292014569521 2.213450970729519e-06 0.8206175763825388 2.213451114629137e-06 0.8217677661037901 \
2.21345126795672e-06 0.8229768690765377 2.213451395805574e-06 0.8239722812379519 2.213451536202905e-06 0.8250521595273246 2.213451662107844e-06 0.8260088941474263 \
2.21345181672401e-06 0.8271688948348412 2.213451949079339e-06 0.8281489842609937 2.213452075346168e-06 0.8290730392392056 2.213452193006695e-06 0.8299245984162376 \
2.213452341409092e-06 0.8309852945996649 2.21345250860326e-06 0.8321626230293395 2.213452641380572e-06 0.8330844501529713 2.213452814281769e-06 0.8342675727345584 \
2.213452982699063e-06 0.8354015168591284 2.213453152193536e-06 0.8365246342267009 2.213453333630418e-06 0.8377070668209077 2.213453476186559e-06 0.8386219603417975 \
2.21345359009745e-06 0.8393441765511721 2.213453720973658e-06 0.8401643924869071 2.213453822596633e-06 0.8407940582489307 2.213453939036871e-06 0.8415078269750864 \
2.213454074330058e-06 0.8423269142909066 2.213454271595159e-06 0.8435017451489455 2.213454462114483e-06 0.844614933042255 2.213454672039296e-06 0.8458175693076773 \
2.213454852817827e-06 0.8468334846981137 2.213455050185846e-06 0.8479221976595614 2.21345522404434e-06 0.8488638701886076 2.213455406558583e-06 0.8498353939890455 \
2.213455577902693e-06 0.8507314120859523 2.213455752248258e-06 0.8516272398309612 2.213455927651258e-06 0.8525125793730954 2.213456103896448e-06 0.8533864315694911 \
2.213456293665326e-06 0.8543099749208749 2.213456484423344e-06 0.8552205033559714 2.21345668621255e-06 0.8561646193034282 2.213456878916116e-06 0.8570482883232282 \
2.213457088356793e-06 0.8579892478796384 2.213457318098559e-06 0.8589986827500428 2.213457583567511e-06 0.8601360945383778 2.213457882213855e-06 0.8613786760148464 \
2.213458160601222e-06 0.8625023989005415 2.213458444791177e-06 0.8636161469557806 2.213458719285784e-06 0.8646608622318305 2.21345899137728e-06 0.8656672252055042 \
2.213459261593726e-06 0.8666387059277968 2.213459518761915e-06 0.8675381145236246 2.213459791320979e-06 0.8684653318325959 2.21346006734232e-06 0.8693777905953765 \
2.213460337484171e-06 0.8702455402709716 2.213460637231954e-06 0.8711796653984102 2.213461008105812e-06 0.872294745819888 2.213461303028797e-06 0.8731503023941 \
2.213461557284845e-06 0.8738665406311316 2.213461855515577e-06 0.8746822274488602 2.213462129133901e-06 0.8754080260278182 2.213462365269549e-06 0.8760175227551726 \
2.213462605621406e-06 0.876622281264788 2.213462827963785e-06 0.8771680781109068 2.213463021968128e-06 0.8776338860468618 2.213463351691207e-06 0.8784037109613512 \
2.21346350686397e-06 0.8787567114621292 2.213463824616497e-06 0.879461652496718 2.213464003481858e-06 0.8798480920375044 2.213464345943323e-06 0.8805675499479563 \
2.213464530084847e-06 0.8809434933546246 2.213465004990284e-06 0.8818790560183651 2.213465172384703e-06 0.8821975058309585 2.213465638216128e-06 0.8830540251881659 \
2.213465819040967e-06 0.8833751042472839 2.213466313074347e-06 0.8842212008576973 2.213466454417055e-06 0.884455124402366 2.213467060806836e-06 0.8854193259359495 \
2.213467212878983e-06 0.8856514227360587 2.21346785955747e-06 0.8865980751852495 2.213467987853825e-06 0.8867785329419297 2.213468635979926e-06 0.8876550049536978 \
2.213468765772447e-06 0.8878236738033012 2.213469544034094e-06 0.8887860366092379 2.213469659025973e-06 0.8889208282599539 2.213470514758392e-06 0.8898661633196656 \
2.213470660021537e-06 0.8900169066926564 2.213471645777722e-06 0.8909664261264102 2.213471866882862e-06 0.8911622482549515 2.213473011997306e-06 0.8921020388386462 \
2.213473143207264e-06 0.8922053928944147 2.213474330865799e-06 0.8931033243919096 2.213474484486091e-06 0.8932130731307282 2.213475894522803e-06 0.8941348173026452 \
2.213476117329622e-06 0.8942660193790342 2.21347779802033e-06 0.8951452796684343 2.21347812564151e-06 0.8952966652167414 2.213480355582631e-06 0.8961896554712738 \
2.213480908496592e-06 0.8963788593752812 2.213484476711123e-06 0.8973573335043913 2.213484800223538e-06 0.8974284307984646 2.213491156631826e-06 0.8984120886469452 \
2.213491705534673e-06 0.8984686671268907 2.213544207609024e-06 0.8994658645395698 2.213544850637886e-06 0.8994692460188505 2.213736989308519e-06 0.9004073346715066 \
2.21373719072249e-06 0.9004708280105613 2.213741150500432e-06 0.8995366825576255 2.21374133452723e-06 0.8993953949813248 2.213742651124504e-06 0.8984641879157507 \
2.213742823168358e-06 0.8983566564859006 2.213744719544653e-06 0.8973720929359315 2.213744893250842e-06 0.897304621671452 2.213757467177875e-06 0.8982933655523699 \
2.213757552368112e-06 0.8983081509245614 2.213765819241151e-06 0.8993078551592517 2.213766293960572e-06 0.8993433667976791 2.214259794870011e-06 0.9002974142054325 \
2.214259914349735e-06 0.9003767372269074 2.214260807172786e-06 0.9012336455299185 2.214260953429422e-06 0.901423267690772 2.214261548322101e-06 0.9023325668564308 \
2.214261683292917e-06 0.9025673929107925 2.214262187968707e-06 0.9035294259428087 2.214262320579608e-06 0.9038000271808221 2.214262721206972e-06 0.9046475051114249 \
2.214262865572371e-06 0.9049556543240072 2.21426328869358e-06 0.9058123566484279 2.214263384150638e-06 0.9059850892484415 2.214264808709454e-06 0.9052205906349737 \
2.214264933747309e-06 0.9046352442223391 2.214265060157898e-06 0.9039223775493039 2.214265162806642e-06 0.9032486771507763 2.214265290021932e-06 0.9022944222362175 \
2.214265408867758e-06 0.9012801950564071 2.214265506520237e-06 0.9003603330664713 2.214265588522258e-06 0.8995243596151602 2.214265668185821e-06 0.8986589236008835 \
2.214265778963989e-06 0.8973708307079206 2.214265880140004e-06 0.8961049472956977 2.214265963084475e-06 0.8950067229086057 2.214266071529892e-06 0.8934921260891034 \
2.21426617999385e-06 0.8918872687155874 2.214266275049989e-06 0.8904106867557802 2.214266395922642e-06 0.8884444419111864 2.214266516699262e-06 0.8863849482818795 \
2.214266629744432e-06 0.8843763393508186 2.214266732915182e-06 0.8824794505619851 2.214266818515338e-06 0.8808620855018965 2.214266892989399e-06 0.8794251273161163 \
2.214266987312941e-06 0.8775673968166831 2.214267075773858e-06 0.8757888800524039 2.214267154846869e-06 0.8741711975775893 2.214267248834224e-06 0.872216793437976 \
2.214267330179529e-06 0.8704993514258973 2.214267425093555e-06 0.8684673705816817 2.214267518136275e-06 0.8664480751909672 2.214267614922069e-06 0.8643215060814092 \
2.214267738217441e-06 0.8615778533848952 2.214267851664452e-06 0.859022019682563 2.214267977516491e-06 0.8561558571929792 2.214268100844635e-06 0.8533196845306243 \
2.214268230022926e-06 0.850323637950593 2.214268370619783e-06 0.8470370034914 2.214268479399504e-06 0.8444782910716596 2.214268614459257e-06 0.8412850455921466 \
2.214268724119566e-06 0.8386804253780991 2.214268853299345e-06 0.8356002443501571 2.214268979483175e-06 0.8325812421138936 2.21426910657353e-06 0.8295317031556502 \
2.214269235595804e-06 0.826427745883674 2.214269344676044e-06 0.8237985689995477 2.214269484526701e-06 0.8204223029647078 2.214269623954893e-06 0.8170507778356514 \
2.214269756708524e-06 0.8138366863616762 2.214269886777199e-06 0.8106848159989707 2.214270010472646e-06 0.8076853837479523 2.214270147427035e-06 0.8043627031572629 \
2.214270261138882e-06 0.8016030849198694 2.214270388615922e-06 0.7985086235398901 2.214270499416994e-06 0.7958187897651571 2.214270618603452e-06 0.7929254985494992 \
2.214270731982508e-06 0.7901733724735396 2.214270866292901e-06 0.7869138859547327 2.214270973387168e-06 0.7843152933129034 2.214271089404311e-06 0.7815009627552112 \
2.214271218595275e-06 0.778367508739124 2.214271316207711e-06 0.7760002683782802 2.214271421787151e-06 0.773440790716327 2.21427153046932e-06 0.7708069008430674 \
2.214271632885583e-06 0.7683258101021144 2.214271726279241e-06 0.7660641808432364 2.214271845835017e-06 0.7631702213567544 2.214271938307379e-06 0.7609327305817616 \
2.214272030945494e-06 0.7586922094322426 2.214272129370309e-06 0.7563124992069843 2.214272237347962e-06 0.7537030947613649 2.214272333616474e-06 0.7513778334636231 \
2.214272419872876e-06 0.7492952979736797 2.214272522736666e-06 0.7468128004450286 2.214272601580994e-06 0.744910856519283 2.214272702387036e-06 0.7424801602439853 \
2.214272836915276e-06 0.7392377693660663 2.214272974140135e-06 0.7359316755186537 2.214273117619987e-06 0.7324773442723981 2.214273266044177e-06 0.7289066083419234 \
2.214273409305472e-06 0.7254625447335662 2.214273549382451e-06 0.7220977259655398 2.214273705808317e-06 0.7183435968963056 2.214273830210067e-06 0.715360858370426 \
2.214273951271848e-06 0.7124600029613375 2.21427410478411e-06 0.7087850045121084 2.214274239566055e-06 0.7055614325718365 2.214274365665088e-06 0.7025479112911024 \
2.214274508839371e-06 0.6991289103945657 2.214274628921163e-06 0.6962626602560111 2.214274758155491e-06 0.6931807499479741 2.214274864640539e-06 0.6906432840523983 \
2.214274976916361e-06 0.6879696524977363 2.214275073251647e-06 0.6856773754336868 2.21427517606134e-06 0.683232326200841 2.214275270865193e-06 0.6809792012818872 \
2.214275376187123e-06 0.6784784437814733 2.214275484625777e-06 0.6759058899658261 2.214275583635057e-06 0.673558569590366 2.21427570039165e-06 0.6707929011939652 \
2.214275808476927e-06 0.6682347329991606 2.214275918483136e-06 0.6656332609774134 2.214276004570978e-06 0.6635992664604092 2.214276134166118e-06 0.6605400273835189 \
2.214276226767366e-06 0.6583552307294462 2.214276322555092e-06 0.6560965362104854 2.214276407507078e-06 0.6540950852804182 2.214276526801602e-06 0.6512869789851043 \
2.21427661407154e-06 0.6492343850333612 2.214276704778561e-06 0.6471030993779646 2.214276805943536e-06 0.6447280068361273 2.214276885774359e-06 0.6428551652550211 \
2.214276974560194e-06 0.6407732405330839 2.21427705225042e-06 0.6389536101386547 2.214277114019368e-06 0.6375081226244841 2.214277177784013e-06 0.6360167668935747 \
2.214277241018233e-06 0.634538653569437 2.214277280258806e-06 0.6336218002627473 2.214277320897828e-06 0.6326726453797233 2.214277400982362e-06 0.6308039353694699 \
2.214277470886542e-06 0.6291742390428672 2.214277521523257e-06 0.6279942052995945 2.214277560272899e-06 0.6270914175114127 2.214277599267879e-06 0.6261832343283663 \
2.214277643882627e-06 0.6251445623164014 2.214277686739083e-06 0.6241478292286105 2.214277737053686e-06 0.6229782634938205 2.214277788990864e-06 0.6217719122409077 \
2.214277874058448e-06 0.6197972300178722 2.214277934038866e-06 0.6184052992407258 2.214278023826075e-06 0.61632338076978 2.214278100290156e-06 0.6145529519516876 \
2.214278179854447e-06 0.6127119801362371 2.214278260891059e-06 0.6108383709630588 2.214278350105382e-06 0.6087775861620425 2.214278440965394e-06 0.6066826282541496 \
2.214278528184102e-06 0.6046739453334793 2.214278621957293e-06 0.6025158549334848 2.214278723642756e-06 0.6001788642681311 2.214278823240848e-06 0.5978941858483342 \
2.214278935095888e-06 0.5953317151711254 2.214279051129026e-06 0.5926772450523136 2.214279172750131e-06 0.5899020947998995 2.214279277133946e-06 0.5875236635596754 \
2.214279421924166e-06 0.5842296531729801 2.214279534584126e-06 0.5816734289694181 2.214279643596094e-06 0.5792035939892568 2.214279736075537e-06 0.5771100174076607 \
2.214279829526177e-06 0.5749994714793375 2.21427992185204e-06 0.5729181236728181 2.214279994438741e-06 0.571283073141143 2.214280050392967e-06 0.5700232888304386 \
2.214280111461248e-06 0.5686498830286455 2.214280209950764e-06 0.5664400707212188 2.214280273162208e-06 0.5650238531380825 2.214280333588177e-06 0.5636708824310654 \
2.21428041053656e-06 0.5619492451093103 2.214280473695101e-06 0.5605380106414651 2.21428056200871e-06 0.558569506627369 2.214280633210033e-06 0.5569845302974165 \
2.214280719745787e-06 0.555060151797141 2.21428084109856e-06 0.5523665438352664 2.214280969027808e-06 0.5495364947125975 2.214281067158439e-06 0.5473694328713704 \
2.214281180282434e-06 0.5448752016832871 2.214281282350254e-06 0.5426314425864434 2.214281401299124e-06 0.5400217272291628 2.214281504386832e-06 0.5377630705755105 \
2.214281618593986e-06 0.5352670017334624 2.214281732009658e-06 0.532794946211756 2.214281859080713e-06 0.5300302694710822 2.214281982900802e-06 0.5273426867079006 \
2.214282127689607e-06 0.5242103332418484 2.21428226351311e-06 0.5212782585303676 2.214282418567968e-06 0.5179428401013338 2.214282579419853e-06 0.5144913885072363 \
2.2142827581493e-06 0.5106699876709851 2.21428294832834e-06 0.5066200804011861 2.214283158230362e-06 0.5021665212646098 2.214283386936346e-06 0.4973332357952056 \
2.214283640864285e-06 0.4919960258408594 2.21428388179775e-06 0.4869529241725989 2.214284177960236e-06 0.4807889695952298 2.214284467957623e-06 0.4747910561470179 \
2.214284774200956e-06 0.4684976697011882 2.214285094876887e-06 0.4619520863481486 2.214285422744054e-06 0.4553041925245184 2.214285762989109e-06 0.4484521981997251 \
2.214286088414654e-06 0.4419418052309769 2.214286410321802e-06 0.4355465312739703 2.214286740535907e-06 0.4290298934287748 2.214287096528499e-06 0.4220583188787752 \
2.214287415406929e-06 0.4158579595363656 2.214287752858691e-06 0.4093433989943853 2.214288180725408e-06 0.4011531841887147 2.214288529437355e-06 0.3945419525178304 \
2.214288837073319e-06 0.388759214407489 2.21428921689981e-06 0.3816861832573664 2.214289548089372e-06 0.3755780492082042 2.214289831697452e-06 0.370391509977049 \
2.214290142516396e-06 0.3647512908748707 2.214290421833004e-06 0.3597258263082204 2.214290648329152e-06 0.3556836811642302 2.214290864011538e-06 0.3518598964090484 \
2.214291061295543e-06 0.3483842179544538 2.214291266280002e-06 0.3447988491770444 2.214291478501966e-06 0.3411119200457455 2.214291733807154e-06 0.33670771290924 \
2.214291975329403e-06 0.3325734463267218 2.214292206706731e-06 0.3286464933807047 2.214292421559231e-06 0.3250253651850565 2.214292642118388e-06 0.3213332986541765 \
2.214292843544355e-06 0.3179852906236645 2.214293046612606e-06 0.3146379646143546 2.214293244508215e-06 0.3114011111455273 2.214293431469302e-06 0.3083651674074345 \
2.214293625269521e-06 0.3052406640298299 2.214293829186134e-06 0.3019773030815858 2.214294008255468e-06 0.2991336297844484 2.214294243846324e-06 0.2954229173226265 \
2.214294444650423e-06 0.2922868215109002 2.214294645829314e-06 0.2891696385850206 2.214294869639057e-06 0.2857334090862961 2.214295034201803e-06 0.2832271910241367 \
2.214295211129189e-06 0.2805503385691353 2.214295396922194e-06 0.2777610713150803 2.21429557873767e-06 0.2750538970423583 2.214295757762463e-06 0.2724132377985424 \
2.214295925107616e-06 0.2699606650006489 2.214296085536533e-06 0.2676371805838822 2.214296208110285e-06 0.2658719571410424 2.214296357874814e-06 0.2637236906090554 \
2.21429648557194e-06 0.2619099339733745 2.214296592880312e-06 0.2603957336038235 2.214296708880974e-06 0.2587625259947361 2.21429681918957e-06 0.2572125806747212 \
2.214296945068767e-06 0.2554509781935611 2.214297060550618e-06 0.2538402638894013 2.214297195131521e-06 0.2519757335310172 2.214297307194775e-06 0.2504255755821768 \
2.214297457534134e-06 0.2483447107137444 2.214297597159989e-06 0.2464124269747185 2.214297743051809e-06 0.2444035064209518 2.214297876012447e-06 0.2425734862730615 \
2.214297999574161e-06 0.2408709992523319 2.214298146783853e-06 0.2388417729476062 2.214298263370682e-06 0.2372355665500016 2.214298402825831e-06 0.23532008003217 \
2.214298537000301e-06 0.2334768281602104 2.214298662976757e-06 0.2317465561243653 2.21429878237616e-06 0.2301094434087779 2.214298877230585e-06 0.2288105340759602 \
2.214298990368184e-06 0.2272617792622066 2.214299070684642e-06 0.2261626001158484 2.214299158249698e-06 0.2249657246820506 2.214299283786835e-06 0.2232507767215072 \
2.214299389480542e-06 0.2218101326756785 2.214299479135054e-06 0.2205921574607158 2.214299549986253e-06 0.2196300825522397 2.214299593014783e-06 0.2190460135436258 \
2.214299635305326e-06 0.2184724035808872 2.214299677647042e-06 0.2178984240735344 2.214299749842461e-06 0.2169203674089526 2.214299792235817e-06 0.2163464205126744 \
2.214299827490656e-06 0.2158693585303403 2.214299871682239e-06 0.2152716287340076 2.214299941290466e-06 0.2143309212991285 2.214299975633796e-06 0.2138672544767182 \
2.214300020093325e-06 0.2132698436071631 2.214300087771806e-06 0.2123628126304402 2.214300174199065e-06 0.2112058698236149 2.214300248835667e-06 0.2102078598594563 \
2.214300330137675e-06 0.2091219706754807 2.214300427015059e-06 0.2078300362310651 2.214300552998548e-06 0.2061528795789772 2.214300655533384e-06 0.2047906894256944 \
2.214300757016901e-06 0.2034500128132261 2.214300858082597e-06 0.202119416354989 2.214300954696816e-06 0.2008491615811921 2.214301056661239e-06 0.1995112314821507 \
2.214301163383483e-06 0.1981153840927639 2.214301271788623e-06 0.1967018790395962 2.214301383782779e-06 0.1952465002768531 2.214301496249907e-06 0.1937897263683151 \
2.214301608323246e-06 0.1923454332378671 2.21430171621572e-06 0.1909603537828802 2.214301817598649e-06 0.1896629368444172 2.214301909236098e-06 0.1884941330679491 \
2.214302003211707e-06 0.1872990757663449 2.214302074478072e-06 0.1863957871745983 2.21430215115336e-06 0.1854271890400033 2.214302254812475e-06 0.184122202819407 \
2.214302328479595e-06 0.1831974022686171 2.214302401825495e-06 0.1822796569444652 2.214302515215845e-06 0.1808667181969195 2.214302603074485e-06 0.1797760932362061 \
2.214302686923162e-06 0.1787387947787487 2.214302815885589e-06 0.1771515524267008 2.214302917772084e-06 0.1759040172436072 2.214303023472791e-06 0.1746156056808686 \
2.214303125120866e-06 0.1733818993219825 2.214303255982584e-06 0.1718019019596718 2.214303363179221e-06 0.1705140034701537 2.214303492508118e-06 0.168969083715685 \
2.21430360420461e-06 0.167642098072289 2.214303704535188e-06 0.1664555496840579 2.214303800335743e-06 0.1653276075899142 2.214303911148015e-06 0.1640289617085985 \
2.214303998548296e-06 0.1630090521997956 2.214304109869413e-06 0.1617156184952586 2.214304202821272e-06 0.1606409001560029 2.21430429039415e-06 0.1596330843918451 \
2.214304392025023e-06 0.1584700928658864 2.214304476479078e-06 0.1575086241734052 2.214304551583457e-06 0.1566573095634876 2.2143046294057e-06 0.1557789554714152 \
2.214304709763569e-06 0.1548759612316424 2.214304810818399e-06 0.1537464547857493 2.214304893251962e-06 0.1528311848879565 2.214304985556514e-06 0.1518114053368895 \
2.214305062490987e-06 0.150965812476358 2.214305145413558e-06 0.1500585909391909 2.214305216944298e-06 0.1492793026301012 2.214305313327797e-06 0.1482344968214558 \
2.214305383556283e-06 0.1474766665551334 2.214305466536561e-06 0.1465853655470201 2.214305527978824e-06 0.1459298106834085 2.214305599661209e-06 0.1451677491870439 \
2.214305668289752e-06 0.1444408762699853 2.214305718558261e-06 0.1439102090153988 2.214305766138067e-06 0.143409423336876 2.214305820187418e-06 0.1428423132663369 \
2.214305879529515e-06 0.1422216078256897 2.214305947564922e-06 0.1415124633834424 2.214306023828345e-06 0.1407207186008814 2.214306092108144e-06 0.1400161356079559 \
2.214306186894323e-06 0.1390460813732662 2.214306276448135e-06 0.1381341561933974 2.214306348133609e-06 0.1374075731330657 2.214306432085017e-06 0.1365606113096345 \
2.214306497397473e-06 0.1359045398875483 2.214306558840598e-06 0.1352895588344758 2.214306633117096e-06 0.1345490408254265 2.214306695327357e-06 0.1339328028964004 \
2.214306763298365e-06 0.133265236037424 2.214306822505405e-06 0.1326856657519672 2.214306895177878e-06 0.1319767402814105 2.214306970197987e-06 0.1312477270463112 \
2.214307055651411e-06 0.1304208267333309 2.21430714175175e-06 0.1295914604616623 2.214307241877205e-06 0.1286317929389105 2.214307323166875e-06 0.127857435971709 \
2.214307424934223e-06 0.1268981149578782 2.214307509182182e-06 0.1261072369695883 2.214307607998911e-06 0.1251836587365037 2.214307680839455e-06 0.1245055382686853 \
2.214307760865543e-06 0.1237631876254407 2.214307831351338e-06 0.1231117958237987 2.214307903881761e-06 0.1224439308288319 2.214307981350756e-06 0.1217331219782777 \
2.214308088702104e-06 0.1207554316575004 2.214308189340119e-06 0.1198442997624752 2.214308261927673e-06 0.1191899427853172 2.214308330759514e-06 0.1185715582611356 \
2.214308396546334e-06 0.1179824683205609 2.214308466175131e-06 0.1173610347366148 2.214308536558877e-06 0.1167350538439435 2.21430861173725e-06 0.1160688810594495 \
2.214308715991484e-06 0.1151493019715505 2.214308791126138e-06 0.114489769343061 2.214308860041223e-06 0.1138870655592168 2.214308923246094e-06 0.1133369146236164 \
2.21430899278746e-06 0.1127339156958381 2.214309050088964e-06 0.1122385190692166 2.214309121730019e-06 0.1116210355509516 2.214309179565092e-06 0.1111240709857579 \
2.214309251686527e-06 0.1105063809580559 2.21430931410261e-06 0.1099736279351742 2.214309398424132e-06 0.1092565349771765 2.2143094660201e-06 0.1086842173446869 \
2.214309574816032e-06 0.1077671916889585 2.214309679126564e-06 0.1068924975608609 2.214309758614772e-06 0.1062289053282379 2.214309846183182e-06 0.1055008617114655 \
2.214309909639535e-06 0.1049752776433979 2.214309971350651e-06 0.10446579874651 2.214310075190416e-06 0.103612238268202 2.214310157871118e-06 0.1029362225408096 \
2.214310256339144e-06 0.1021348761715451 2.214310340785582e-06 0.101450818648051 2.214310457263062e-06 0.1005121841703865 2.214310591996508e-06 0.09943411943161744 \
2.214310728066044e-06 0.0983541971400249 2.214310842385451e-06 0.09745369041838402 2.214310927852596e-06 0.09678457778867394 2.214311038134268e-06 0.09592640631053104 \
2.214311118922622e-06 0.09530159220710262 2.214311218473493e-06 0.09453592511176086 2.214311308421543e-06 0.09384821103094763 2.214311380924943e-06 0.09329669945188329 \
2.214311462667009e-06 0.09267796846073476 2.214311590787244e-06 0.09171467366828615 2.214311672199308e-06 0.09110674702409056 2.214311746631215e-06 0.09055373306570065 \
2.214311821605099e-06 0.08999936228352182 2.214311901024074e-06 0.08941505746347288 2.214312009684932e-06 0.08862052380504259 2.214312104044903e-06 0.08793517800096999 \
2.214312193440026e-06 0.08728987318634121 2.214312300205742e-06 0.086524181682867 2.214312418708182e-06 0.08568073755029131 2.214312560233252e-06 0.08468224831562859 \
2.214312693371676e-06 0.08375174214918565 2.214312834217007e-06 0.08277682112810406 2.214312983268988e-06 0.08175525972387458 2.214313119066717e-06 0.08083369778093191 \
2.214313260523232e-06 0.0798830809748103 2.214313395783147e-06 0.07898330517332906 2.214313537164988e-06 0.07805242629322809 2.214313684232761e-06 0.07709434677344783 \
2.214313835960902e-06 0.07611680364043326 2.214314001309203e-06 0.07506403321855706 2.214314165176721e-06 0.07403332863189842 2.214314341490648e-06 0.07293832728335037 \
2.21431453092575e-06 0.07177777688466977 2.214314741692455e-06 0.07050569389938771 2.214314961464952e-06 0.06920150027616521 2.214315196433104e-06 0.06783224552442871 \
2.214315455333654e-06 0.06635227408830123 2.214315750264117e-06 0.06470266364809808 2.214316054610178e-06 0.06304001691994518 2.214316416556457e-06 0.06111393619706453 \
2.214316732684212e-06 0.05947639552636011 2.214317174006677e-06 0.0572596911373907 2.214317487572719e-06 0.05573556853365672 2.214317911072189e-06 0.0537382660685313 \
2.214318255024043e-06 0.05216649213267931 2.21431859526531e-06 0.05065508790922631 2.2143189061029e-06 0.04931137323461653 2.214319200574802e-06 0.04807062469528345 \
2.214319494274299e-06 0.04686392507224969 2.214319769145535e-06 0.04576537019482012 2.214320044685701e-06 0.04468949010490332 2.214320309776229e-06 0.04367785045825667 \
2.214320586533311e-06 0.04264571401740119 2.214320869801435e-06 0.04161414314527601 2.214321167794735e-06 0.04055545327485047 2.214321427280131e-06 0.03965542606183669 \
2.214321657303569e-06 0.03887446236327848 2.214321876995156e-06 0.03814321686473518 2.214322101935296e-06 0.0374128399305801 2.21432242218897e-06 0.0363978329183388 \
2.21432270998682e-06 0.03550963653148703 2.214322986382154e-06 0.03467738358988744 2.214323270201283e-06 0.03384352473043348 2.214323508310587e-06 0.03315996078327022 \
2.214323792621371e-06 0.03236211345273886 2.214324034533221e-06 0.03169864947531036 2.214324269673394e-06 0.03106710921041438 2.214324511380923e-06 0.03043352335444016 \
2.214324748333856e-06 0.02982731501219571 2.214324978676274e-06 0.02925002048968134 2.214325192426852e-06 0.02872465224286764 2.214325398273815e-06 0.02822791768061097 \
2.214325790610838e-06 0.02730524204782691 2.214325979002849e-06 0.02687312495148303 2.214326354614307e-06 0.02603163971789 2.214326529081081e-06 0.02564950258131362 \
2.214326953015541e-06 0.02474274850847508 2.214327073769958e-06 0.02449086781212801 2.214327544020721e-06 0.02353384026002922 2.214327693235786e-06 0.02323677291035493 \
2.214328086867998e-06 0.02246740853134286 2.214328257894342e-06 0.02213909006726131 2.214328745173274e-06 0.02121869533024997 2.214328887220983e-06 0.02095326544309953 \
2.214329420237252e-06 0.01997576278857772 2.214329542401289e-06 0.01975737097014436 2.214330064559033e-06 0.01885981776906158 2.214330235137336e-06 0.01857989792133653 \
2.214330722450399e-06 0.01781360777737795 2.214330893973322e-06 0.01755501440977742 2.21433151376008e-06 0.01666567753024489 2.214331684684406e-06 0.0164316648397145 \
2.214332390235396e-06 0.01551160061118263 2.214332552852409e-06 0.01530799450170666 2.214333309745899e-06 0.01439879525764199 2.214333450662544e-06 0.01423641007536438 \
2.214334350661384e-06 0.01324361033368418 2.214334438010634e-06 0.01315122959105692 2.214335342363989e-06 0.01223321097894121 2.214335479555938e-06 0.01209984223734439 \
2.214336450212214e-06 0.01118944790767422 2.214336578130092e-06 0.01107451071402888 2.214337728540038e-06 0.01011008206277823 2.214337822342075e-06 0.01003687265682024 \
2.214339078387887e-06 0.009120584045805383 2.2143392159292e-06 0.009026502753623255 2.214340774683602e-06 0.008029670037698805 2.214340858486287e-06 0.007977066150721189 \
2.214342463865106e-06 0.00699828665725172 2.21434257476345e-06 0.006935886594503895 2.214344507009824e-06 0.005959177461785255 2.214344686714759e-06 0.005876661013304485 \
2.214346798505876e-06 0.004981749118765498 2.214347141291011e-06 0.004848482978762325 2.214349654457045e-06 0.003966891390423618 2.214350124178715e-06 0.003819799497680527 \
2.214353764494989e-06 0.002847564273158896 2.214354280232175e-06 0.002731633924241866 2.214359622062014e-06 0.001773027297371861 2.214359907382299e-06 0.001729522787584184 \
2.214365136030129e-06 0.0007540451492352357 2.214365310176695e-06 0.0007162692714263865 2.217013698769002e-06 -0.0001123232525192561 2.21701387179429e-06 -0.0002901710972538241 \
2.217014491546044e-06 -0.001202022686018724 2.217014580115222e-06 -0.001365806793032466 2.217014941086355e-06 -0.002110727959526865 2.21701506578065e-06 -0.002395793696299351 \
2.217015429622531e-06 -0.003299857180474864 2.217015600898199e-06 -0.003758114451912169 2.217015894896038e-06 -0.004576312838821549 2.217016005104443e-06 -0.004886880824040592 \
2.217016283358441e-06 -0.005643955697619643 2.21701640463225e-06 -0.00594200199557267 2.217017498254348e-06 -0.00517389603226481 2.217017621358228e-06 -0.004409713243767066 \
2.217017744826303e-06 -0.003462788751204457 2.2170178649921e-06 -0.002366010162083454 2.217017962853768e-06 -0.001346276287748183 2.217018069556104e-06 -0.0001076498664581183 \
2.217018181397488e-06 0.001328007358939307 2.217018317371855e-06 0.003256083960376262 2.217018439401011e-06 0.00514709866632534 2.217018627817289e-06 0.008343062029134115 \
2.217018768805819e-06 0.01093380316938193 2.217018921577522e-06 0.01391176330477175 2.21701906428015e-06 0.01683596409946878 2.217019218632387e-06 0.02013443377634912 \
2.217019374426043e-06 0.02358734537610087 2.21701953048334e-06 0.02715365164079262 2.21701967788774e-06 0.03060642997674319 2.217019826504485e-06 0.03415780069914553 \
2.217019981925702e-06 0.03793559522944389 2.217020140311532e-06 0.04184227512730877 2.217020305251154e-06 0.04596085539464361 2.217020479500423e-06 0.05035714787605008 \
2.217020658443539e-06 0.05491177248689325 2.217020847583032e-06 0.0597604232635115 2.21702105036361e-06 0.06498910043066243 2.217021269735637e-06 0.07067233091134768 \
2.217021500572133e-06 0.07667464705993039 2.217021747383969e-06 0.0831083675499642 2.21702201751608e-06 0.09016243555275107 2.217022310704188e-06 0.0978236474935409 \
2.217022634359625e-06 0.1062798466079799 2.217022997926912e-06 0.1157689210849182 2.21702339022043e-06 0.1259925151671456 2.217023838699915e-06 0.1376538644086695 \
2.2170243603994e-06 0.1511757390224034 2.217024972772043e-06 0.1669844191341421 2.217025649417359e-06 0.1843663871188266 2.21702643632765e-06 0.2044554566749352 \
2.217027317548744e-06 0.2267919980918504 2.217028137292384e-06 0.2474048556006221 2.217028865745328e-06 0.2655829647002126 2.217029507221317e-06 0.2814688958417333 \
2.217030083144485e-06 0.2956305456066151 2.217030620401302e-06 0.3087428400511723 2.217031124292597e-06 0.3209487846516751 2.217031601896145e-06 0.3324328152479784 \
2.217032080019379e-06 0.343838772307344 2.217032532118228e-06 0.3545331600964184 2.217033003884519e-06 0.365596737404158 2.21703344758136e-06 0.3759140547845509 \
2.217033969549898e-06 0.3879344734281669 2.21703449708783e-06 0.399956933836353 2.217034876602574e-06 0.4085271910771138 2.217035405564174e-06 0.4203606102508351 \
2.217035874883255e-06 0.4307444005277802 2.217036310038791e-06 0.4402814026247405 2.217036757516117e-06 0.4500002273945978 2.217037197539592e-06 0.4594737646471725 \
2.217037600841335e-06 0.4680814138276727 2.217037919241101e-06 0.4748254127722248 2.217038289219015e-06 0.4826007100982719 2.217038525472097e-06 0.4875314737878706 \
2.217038760543493e-06 0.4924129045770672 2.217039011882831e-06 0.4975994385012801 2.217039318269865e-06 0.5038799449729535 2.217039575228319e-06 0.5091120301871851 \
2.217039783702615e-06 0.5133309170973237 2.217039984084905e-06 0.5173683849445317 2.217040126478606e-06 0.5202244049244739 2.217040275403071e-06 0.5231993726577677 \
2.217040486949329e-06 0.5274019882470222 2.217040713006951e-06 0.5318780389403845 2.217040907549333e-06 0.5357103559602913 2.217041096681229e-06 0.539423417888626 \
2.217041326128277e-06 0.5439012399750046 2.217041508634082e-06 0.5474563135343053 2.217041745996952e-06 0.5520623276458133 2.21704201499126e-06 0.5572695987004129 \
2.21704226390171e-06 0.5620706638085723 2.217042507918531e-06 0.5667633705755619 2.217042780273744e-06 0.5719926523718327 2.217043041669873e-06 0.5769928369418796 \
2.217043299301279e-06 0.5819084237686675 2.217043546144628e-06 0.586601202059797 2.217043791890354e-06 0.5912552023551558 2.217044018467874e-06 0.5955288021520931 \
2.217044249620064e-06 0.5998646534936181 2.217044455900444e-06 0.6037202012184053 2.217044684021204e-06 0.6079592993751251 2.217044906401185e-06 0.6120725203834017 \
2.217045133377667e-06 0.6162454422471376 2.217045348430617e-06 0.6201823359462864 2.21704557780019e-06 0.6243500782103125 2.217045846823065e-06 0.6292041961704016 \
2.217046069836712e-06 0.6331993632081415 2.217046282091289e-06 0.6369772451758789 2.217046493488879e-06 0.6407176358819484 2.217046693558109e-06 0.644236566349866 \
2.217046923151958e-06 0.6482486956559365 2.217047163988886e-06 0.6524328529570182 2.217047345738273e-06 0.6555667906748446 2.2170475342865e-06 0.6588018260593631 \
2.217047687366139e-06 0.6614154033769962 2.217047859374421e-06 0.6643352515471471 2.217048009547239e-06 0.6668697017322168 2.217048146064529e-06 0.6691578850264722 \
2.217048295693716e-06 0.6716547631652277 2.217048423434085e-06 0.673777752640997 2.217048563020222e-06 0.6760856948620949 2.21704868725891e-06 0.6781310478824312 \
2.217048818408749e-06 0.6802827752320969 2.217048942850093e-06 0.6823179209931315 2.217049080080916e-06 0.6845542421253382 2.217049200329086e-06 0.6865048414796368 \
2.217049341660529e-06 0.6887891282595083 2.21704944199164e-06 0.6904033553735033 2.217049563109343e-06 0.6923460943304175 2.217049653886878e-06 0.6937948943079848 \
2.217049751145344e-06 0.6953408241330762 2.217049847353224e-06 0.6968660703265798 2.217049935967068e-06 0.6982647859968389 2.217050033255091e-06 0.6997938110311075 \
2.217050165723729e-06 0.7018622871835729 2.217050320913928e-06 0.7042674555997347 2.217050458791879e-06 0.7063866855441746 2.217050603646153e-06 0.7085960165693863 \
2.21705073070791e-06 0.7105202221428537 2.21705085539347e-06 0.7123960184768648 2.217050968098846e-06 0.7140814553427599 2.217051079889191e-06 0.7157437310299281 \
2.21705118066784e-06 0.7172341607972841 2.217051317946295e-06 0.7192525454101454 2.217051437630367e-06 0.7210013704967912 2.217051557059838e-06 0.7227365757678518 \
2.21705168394306e-06 0.7245692610776365 2.217051808360712e-06 0.7263556789600311 2.217051932093536e-06 0.728121726658988 2.217052058689063e-06 0.7299181396522603 \
2.217052189074464e-06 0.7317573312219798 2.217052311884284e-06 0.7334798522758219 2.217052447320059e-06 0.7353678990088863 2.217052548609838e-06 0.7367723836293941 \
2.217052656232334e-06 0.7382576460517265 2.217052745760416e-06 0.7394878879617913 2.217052860308785e-06 0.7410528648863303 2.217052948337041e-06 0.7422487366778059 \
2.217053055415107e-06 0.7436953530868765 2.2170531854801e-06 0.7454403311053276 2.217053296759795e-06 0.7469230742113165 2.217053401378355e-06 0.7483084058091373 \
2.21705352546134e-06 0.7499400420429273 2.217053673762168e-06 0.7518749696944975 2.217053795162032e-06 0.7534462209622173 2.21705390960278e-06 0.7549170836379747 \
2.217054049940097e-06 0.7567069362027918 2.217054191702981e-06 0.7584995177563068 2.217054309503919e-06 0.759977341175643 2.217054437480785e-06 0.761570846386187 \
2.217054579183209e-06 0.7633205808366864 2.217054696694522e-06 0.7647599110190483 2.217054842299791e-06 0.7665289162262866 2.217054963994099e-06 0.7679951561698679 \
2.217055082724709e-06 0.7694149786178283 2.217055205011304e-06 0.7708662727382939 2.21705533205582e-06 0.77236234268503 2.217055441699792e-06 0.7736439866494906 \
2.217055567386705e-06 0.7751025186690397 2.217055673401805e-06 0.776323977486031 2.217055808987771e-06 0.7778743028704433 2.217055933950768e-06 0.7792913979962601 \
2.217056059856921e-06 0.7807070123991936 2.217056175124167e-06 0.7819915514687489 2.21705628142864e-06 0.7831664991275713 2.217056419833432e-06 0.7846822315516878 \
2.217056569129882e-06 0.7862997378875561 2.217056714637327e-06 0.7878588534534761 2.217056834041839e-06 0.7891257303126159 2.217056969134663e-06 0.7905455128963393 \
2.217057090387826e-06 0.7918076974797237 2.217057233381105e-06 0.7932816011184505 2.21705737758541e-06 0.7947523458802197 2.217057503122239e-06 0.7960199014141693 \
2.217057622168612e-06 0.7972110037065316 2.217057734104495e-06 0.7983213107123885 2.217057838976047e-06 0.7993531099923881 2.217057934226459e-06 0.8002831901653534 \
2.217058070569705e-06 0.8016020813281191 2.217058187393835e-06 0.8027203407102198 2.217058306798445e-06 0.803852171037294 2.217058428905249e-06 0.8049980820693966 \
2.21705855186025e-06 0.8061401395390313 2.217058678828951e-06 0.8073073595000361 2.21705880406856e-06 0.8084467645495962 2.217058934640955e-06 0.8096220968518901 \
2.217059060631473e-06 0.8107441738369082 2.217059188817386e-06 0.8118738099374113 2.217059294347114e-06 0.8127947795787664 2.217059397218887e-06 0.8136847278655364 \
2.217059490214057e-06 0.8144826950388273 2.217059614010659e-06 0.8155354283166244 2.217059701978917e-06 0.8162769513478326 2.217059800709988e-06 0.8171027376706747 \
2.217059943975142e-06 0.8182889948057973 2.217060079253827e-06 0.8193962136425846 2.21706018836845e-06 0.8202800249700468 2.217060336451758e-06 0.8214657808291811 \
2.217060486222685e-06 0.8226492530953341 2.217060611457285e-06 0.8236267526687548 2.217060755448703e-06 0.8247372275730155 2.217060879504774e-06 0.8256825756473101 \
2.217061029968032e-06 0.8268152483647575 2.217061165678884e-06 0.8278240064655301 2.217061290697392e-06 0.828742521381556 2.217061408452322e-06 0.8295983347934622 \
2.217061554429135e-06 0.8306466023667578 2.217061720938452e-06 0.8318251482734692 2.217061851861028e-06 0.8327390940956469 2.217062025288466e-06 0.8339327615268647 \
2.217062193435348e-06 0.8350717495747054 2.217062363270277e-06 0.8362042975620877 2.217062544195048e-06 0.8373912937861997 2.217062687293307e-06 0.8383160748488641 \
2.217062801379198e-06 0.8390446117604563 2.217062931553184e-06 0.8398665237782376 2.217063033394266e-06 0.8405024977857931 2.217063150213615e-06 0.8412243379523001 \
2.217063287078045e-06 0.8420597162999857 2.217063484876669e-06 0.8432475311273343 2.21706367648074e-06 0.8443767279905872 2.217063885921221e-06 0.8455874169714939 \
2.217064067846852e-06 0.8466193100105236 2.217064264979957e-06 0.8477171434207121 2.217064438329848e-06 0.8486653666163242 2.217064621329232e-06 0.8496493024239481 \
2.217064792495495e-06 0.8505537352954988 2.217064967127282e-06 0.8514606693963016 2.217065142389669e-06 0.8523550102558151 2.217065318541784e-06 0.8532381479010797 \
2.217065508812824e-06 0.8541746551565574 2.217065699414774e-06 0.85509499218684 2.217065900062401e-06 0.8560449689899254 2.217066092672966e-06 0.8569390259424264 \
2.217066303330652e-06 0.8578972157030333 2.217066531456051e-06 0.8589122247267402 2.217066797213369e-06 0.8600655879592763 2.217067095837813e-06 0.8613244245924475 \
2.217067372169332e-06 0.862454900702886 2.21706765640239e-06 0.8635842083919951 2.217067930614306e-06 0.8646423892283146 2.217068202842372e-06 0.8656634505877856 \
2.217068473051191e-06 0.8666487272755322 2.217068730204067e-06 0.8675609437488442 2.217069002786335e-06 0.868501515423508 2.217069278771335e-06 0.8694269133137555 \
2.217069548872911e-06 0.8703069289141475 2.217069848734863e-06 0.8712546000783432 2.217070219768993e-06 0.8723856543073821 2.217070514706754e-06 0.8732530157608677 \
2.217070768997536e-06 0.8739790309043101 2.217071067254951e-06 0.8748056771600844 2.217071340863485e-06 0.8755409825400007 2.217071576991549e-06 0.8761583495732972 \
2.21707181733693e-06 0.876770807053994 2.217072039670212e-06 0.8773233906735478 2.21707223367596e-06 0.8777948466981503 2.217072563398506e-06 0.8785737911727464 \
2.217072718571944e-06 0.8789308835864816 2.217073036347473e-06 0.8796437246174529 2.21707321520917e-06 0.8800342982281311 2.217073557671047e-06 0.8807611334253193 \
2.217073741799519e-06 0.8811407335605206 2.217074216677856e-06 0.8820849466541889 2.217074384074052e-06 0.8824061830950772 2.217074849915456e-06 0.8832696475595492 \
2.217075030737665e-06 0.8835931319180218 2.217075524775914e-06 0.8844450822729043 2.217075666124327e-06 0.8846804878101884 2.217076272457385e-06 0.8856498028150036 \
2.217076424526724e-06 0.8858829444029697 2.2170770712152e-06 0.8868329272509302 2.217077199509723e-06 0.8870138524519416 2.217077847626928e-06 0.8878919388991984 \
2.217077977425792e-06 0.8880607713689423 2.217078755627481e-06 0.8890227771434612 2.217078870684414e-06 0.8891574578072456 2.217079726342848e-06 0.8901003239091128 \
2.217079871707615e-06 0.8902505899439886 2.21708085746403e-06 0.8911948786459364 2.21708107856904e-06 0.8913892999646706 2.217082223696019e-06 0.8923206810037944 \
2.217082354912618e-06 0.892422953350996 2.217083696124267e-06 0.8934189515818408 2.21708384752321e-06 0.8935240845833778 2.217085328961459e-06 0.8944568913393511 \
2.217085567840892e-06 0.8945912088657246 2.217087337161074e-06 0.8954685138428928 2.21708772631084e-06 0.895637400736999 2.217090119976627e-06 0.896526474291006 \
2.21709059568945e-06 0.8966764365754722 2.217094011699057e-06 0.8975478548673914 2.217094658849072e-06 0.8976786076740833 2.217102137013678e-06 0.8986646932675814 \
2.217102809590796e-06 0.8987192862546014 2.217195253995366e-06 0.8997188196574962 2.217195917228051e-06 0.8997241906476866 2.217385126389945e-06 0.900686595210158 \
2.217385288462789e-06 0.9007292695325627 2.217387933983676e-06 0.8998161167154269 2.217388102533154e-06 0.8996881690130656 2.217389379285545e-06 0.8987393243250013 \
2.217389581451881e-06 0.8986030018074492 2.217391189561267e-06 0.8976721249252815 2.217391381667192e-06 0.8975774045828077 2.217406495049839e-06 0.8985726115129884 \
2.217406683108756e-06 0.8986004060702872 2.217417988037768e-06 0.8995874924221801 2.217418361423516e-06 0.8996034751727418 2.217907373786698e-06 0.9005892719715856 \
2.217907484554897e-06 0.9006868984798269 2.217908237227259e-06 0.9015617873136611 2.217908339021945e-06 0.9017086238768567 2.21790887442049e-06 0.9025814930725723 \
2.217908976929663e-06 0.9027670217776843 2.217909369148481e-06 0.9035254014384071 2.217909509991429e-06 0.9038129158713877 2.217909951028881e-06 0.9047472953155866 \
2.217910136514484e-06 0.9051402477015744 2.217910652827601e-06 0.9061269394579334 2.217910737502694e-06 0.9062564181617988 2.217911972174744e-06 0.9053011091537977 \
2.217912129388156e-06 0.9045688862145235 2.217912321204817e-06 0.9034162411061901 2.217912488045348e-06 0.9021712267446264 2.217912635003746e-06 0.9008824031243315 \
2.217912749119942e-06 0.8997575350477262 2.217912878992032e-06 0.8983446880789033 2.21791299010955e-06 0.8970273815442567 2.217913082914029e-06 0.8958483937359277 \
2.217913171236719e-06 0.8946639786015808 2.217913274417478e-06 0.8932058048613533 2.217913366625413e-06 0.8918333298588224 2.21791345419561e-06 0.8904732289418564 \
2.217913568189076e-06 0.8886245408236838 2.2179137299935e-06 0.8858564722885236 2.217913914992117e-06 0.8825005184224666 2.217914107151785e-06 0.8788219124347386 \
2.217914308599138e-06 0.874780227084481 2.217914515009728e-06 0.8704697801294994 2.21791470018168e-06 0.8664790122147591 2.217914884689405e-06 0.862405115500708 \
2.217915057841296e-06 0.8585071391690239 2.217915242887321e-06 0.8542751393552932 2.217915420261524e-06 0.8501657390392787 2.217915597007955e-06 0.8460284987362284 \
2.217915763166606e-06 0.8421077870518131 2.217915925211044e-06 0.8382599993991456 2.217916091783925e-06 0.8342839555277276 2.217916250437662e-06 0.8304816347052207 \
2.217916441313687e-06 0.8258903812682129 2.217916616297258e-06 0.8216694867670907 2.217916786243392e-06 0.8175615830390965 2.217916951419567e-06 0.8135626411663678 \
2.217917124611674e-06 0.8093650119631921 2.217917295673877e-06 0.8052155696745213 2.217917463774913e-06 0.801136095357175 2.217917654109863e-06 0.7965156511928794 \
2.217917837691806e-06 0.7920591698039 2.217918045682732e-06 0.7870113041480956 2.217918268259242e-06 0.7816114142545842 2.217918457674258e-06 0.7770174196885687 \
2.217918650984654e-06 0.7723312127316435 2.21791879443024e-06 0.7688556734481145 2.21791894385359e-06 0.7652374066097742 2.217919063006063e-06 0.7623536300085233 \
2.217919175722544e-06 0.7596269484184472 2.217919284997451e-06 0.7569846861296079 2.217919421027209e-06 0.753697254849378 2.217919533823024e-06 0.750972995067179 \
2.21791965602098e-06 0.7480232093637929 2.217919767605752e-06 0.7453311011793381 2.217919892312215e-06 0.7423241425761796 2.217920046694167e-06 0.7386034578119585 \
2.217920213478233e-06 0.7345862494782525 2.217920430642921e-06 0.7293605768817599 2.21792062520351e-06 0.7246835946359503 2.217920785534396e-06 0.7208333202545074 \
2.217920960959998e-06 0.7166251500492028 2.217921150723573e-06 0.7120779400724765 2.217921339451897e-06 0.7075610435995559 2.217921521273264e-06 0.7032145396962334 \
2.217921705870676e-06 0.6988062725207448 2.217921842953811e-06 0.6955348514212173 2.217921996242049e-06 0.6918805091472418 2.217922191613795e-06 0.6872279990818534 \
2.217922347770547e-06 0.6835136309588888 2.217922505722766e-06 0.6797605476340507 2.21792270397403e-06 0.6750570282453686 2.217922897319928e-06 0.6704763548785364 \
2.217923133825274e-06 0.6648822204491218 2.217923320030377e-06 0.6604858901039825 2.217923557652698e-06 0.6548824851665868 2.217923744451452e-06 0.6504854738275335 \
2.217923925009211e-06 0.6462424706993735 2.217924088085156e-06 0.6424159959781919 2.21792423269672e-06 0.6390271817202816 2.217924373299071e-06 0.6357379642635244 \
2.217924500108657e-06 0.632774906490579 2.217924632245193e-06 0.6296924762754078 2.217924758489144e-06 0.6267508340255646 2.217924889752774e-06 0.6236963630311418 \
2.217925018850514e-06 0.6206978048938425 2.217925158276178e-06 0.6174624210713571 2.217925306646171e-06 0.6140261568477932 2.21792550120306e-06 0.6095278574984737 \
2.217925644648937e-06 0.6062198040692683 2.217925879109182e-06 0.6008245134060309 2.217926051007495e-06 0.5968818013610552 2.217926263928033e-06 0.5920102583789468 \
2.217926436394651e-06 0.5880775912131976 2.217926566719197e-06 0.5851108450968721 2.217926698275517e-06 0.5821241897920357 2.217926808505599e-06 0.5796262478458715 \
2.217926904159846e-06 0.5774603558442819 2.217927003393806e-06 0.5752182923213994 2.217927086311907e-06 0.5733484809858778 2.217927165227534e-06 0.5715706040143225 \
2.217927228156309e-06 0.5701535626562365 2.217927293664786e-06 0.5686800671140783 2.217927374150838e-06 0.5668736364148982 2.217927424016846e-06 0.5657560592102344 \
2.217927473205615e-06 0.5646541775062763 2.2179275346754e-06 0.5632780399140616 2.217927582596929e-06 0.5622058085646952 2.217927633441648e-06 0.5610687758404553 \
2.217927692541903e-06 0.5597501790023616 2.21792775115623e-06 0.5584442118409422 2.217927826782323e-06 0.5567607189607793 2.217927897341035e-06 0.5551915720267918 \
2.217927986471042e-06 0.5532116467156011 2.21792807569462e-06 0.5512351177508077 2.217928160998231e-06 0.5493490637975145 2.217928248625197e-06 0.5474138635528197 \
2.21792834562712e-06 0.545274424894262 2.217928449972891e-06 0.5429792414815097 2.217928566264315e-06 0.5404269323775457 2.217928672601932e-06 0.5380963700835184 \
2.217928784310815e-06 0.5356536306660374 2.217928896605295e-06 0.5332047801427824 2.217929023802854e-06 0.5304364255197962 2.217929146572528e-06 0.5277698476303582 \
2.217929288796925e-06 0.5246912237717902 2.217929425160056e-06 0.5217463069543907 2.217929577381123e-06 0.5184691491721333 2.217929737017329e-06 0.5150420887864461 \
2.217929912992522e-06 0.5112761258030903 2.217930101501108e-06 0.5072591542828934 2.21793030856769e-06 0.5028616940969075 2.217930533509662e-06 0.4981043078903621 \
2.217930784905619e-06 0.4928144328841237 2.217931021331185e-06 0.4878598554762091 2.217931318494919e-06 0.4816683149127979 2.217931609172211e-06 0.4756487143466775 \
2.217931917027196e-06 0.469313240945046 2.217932230852953e-06 0.4628991126846517 2.217932559994313e-06 0.4562163541974347 2.217932893372419e-06 0.4494927613461197 \
2.217933224999028e-06 0.4428490490857003 2.217933546548425e-06 0.4364504708187015 2.217933874224237e-06 0.4299742838549845 2.21793422184386e-06 0.4231546934710667 \
2.217934555065174e-06 0.4166645133789623 2.217934900974402e-06 0.4099771621835854 2.217935346388222e-06 0.4014400148089548 2.217935704178092e-06 0.3946500490499754 \
2.217936018334911e-06 0.3887397205534429 2.217936402745391e-06 0.3815756289527631 2.217936732720036e-06 0.3754830843203271 2.217937017930125e-06 0.3702633801070484 \
2.217937326220382e-06 0.3646649204592909 2.217937606017443e-06 0.3596257204303125 2.217937832011793e-06 0.3555880084110294 2.217938046849747e-06 0.3517755993421203 \
2.21793824528482e-06 0.3482769933469286 2.217938449224337e-06 0.3447071465415313 2.217938659760396e-06 0.3410461989361561 2.217938916734521e-06 0.3366091000429626 \
2.217939157995129e-06 0.3324763702393667 2.217939389568845e-06 0.3285420159269506 2.217939604222291e-06 0.3249208057821749 2.217939825046275e-06 0.3212218866489027 \
2.217940026292867e-06 0.3178749657716667 2.21794022938212e-06 0.3145250552959265 2.217940427226991e-06 0.3112865758726304 2.217940614079936e-06 0.3082497660855442 \
2.217940808016662e-06 0.3051208532403978 2.217941011761317e-06 0.30185834615803 2.217941190488583e-06 0.2990186060348319 2.217941428134378e-06 0.2952727068736475 \
2.217941627896611e-06 0.2921508861588616 2.217941829525427e-06 0.2890253490052915 2.217942054991886e-06 0.285561995332 2.217942221086285e-06 0.2830312764183137 \
2.217942399705387e-06 0.2803277612349699 2.217942581409588e-06 0.2775983111934518 2.217942770043305e-06 0.2747882307029562 2.217942947466508e-06 0.2721695222189568 \
2.217943124659645e-06 0.2695724116247911 2.21794328473156e-06 0.2672552081803913 2.217943405132239e-06 0.2655193337608355 2.217943552958303e-06 0.2633957862580221 \
2.217943681588075e-06 0.2615692882062232 2.217943783793658e-06 0.2601227034409412 2.217943902028939e-06 0.2584516051170885 2.217944022482299e-06 0.2567534139348401 \
2.217944146190617e-06 0.2550183706610066 2.217944264442643e-06 0.2533694204037282 2.217944392295773e-06 0.2515887492000971 2.217944512581604e-06 0.249915736161692 \
2.21794466526121e-06 0.2477917697339537 2.217944800173988e-06 0.2459264316518071 2.21794492881341e-06 0.2441493177932957 2.217945086528788e-06 0.2419705448111171 \
2.21794521321009e-06 0.2402201997919771 2.217945348536158e-06 0.2383592392624043 2.217945487448727e-06 0.2364550510890953 2.217945605221031e-06 0.2348405558720491 \
2.21794576449185e-06 0.2326580599570062 2.217945901013704e-06 0.2307878375452989 2.21794604224565e-06 0.2288626996658652 2.217946148058693e-06 0.2274220928889542 \
2.21794627840164e-06 0.2256484734765637 2.217946378112453e-06 0.2242944442559471 2.217946480933888e-06 0.2228991027388591 2.217946554349542e-06 0.2219046249368765 \
2.217946634181104e-06 0.2208265149641777 2.217946704228335e-06 0.2198809561195558 2.217946754631426e-06 0.2192009305305119 2.217946806883225e-06 0.2184966408607167 \
2.217946886120743e-06 0.2174292050927151 2.217946927964696e-06 0.2168658036437602 2.217946967304648e-06 0.216336351877609 2.217947010340057e-06 0.2157575332679269 \
2.217947054507483e-06 0.2151638767852215 2.217947128273223e-06 0.2141731338947761 2.21794716378522e-06 0.2136967174286463 2.217947211500021e-06 0.2130606706933813 \
2.217947272229561e-06 0.2122518321687151 2.217947340486787e-06 0.2113438957752176 2.217947413008566e-06 0.2103801801047663 2.217947485683193e-06 0.2094152724966429 \
2.217947593999181e-06 0.2079788886429202 2.217947691670323e-06 0.20668564243436 2.217947803221819e-06 0.2052110974836689 2.217947901757253e-06 0.2039136008387587 \
2.217948005250393e-06 0.2025572972554956 2.217948101152127e-06 0.2013021587886929 2.217948203780057e-06 0.1999606878451601 2.21794830660317e-06 0.1986207062101238 \
2.217948416722797e-06 0.1971897063011611 2.217948525418353e-06 0.1957815523781236 2.217948645095581e-06 0.1942360962608612 2.21794875537326e-06 0.192818053470401 \
2.217948863436481e-06 0.1914343471929882 2.217948988535148e-06 0.1898375077741012 2.217949078504981e-06 0.1886931806549971 2.217949157191935e-06 0.1876950225942949 \
2.217949234476806e-06 0.1867173468865102 2.217949320985382e-06 0.1856271834369256 2.217949419934593e-06 0.1843848109964498 2.217949490443458e-06 0.1835017733581451 \
2.217949561894511e-06 0.1826096997732476 2.217949667039846e-06 0.1813018727451555 2.217949746279475e-06 0.1803200401832796 2.217949827363369e-06 0.1793174195483187 \
2.21794992085531e-06 0.1781663090788374 2.217950021631284e-06 0.1769308188703378 2.217950171343388e-06 0.175105380089017 2.217950287132703e-06 0.1737009932372819 \
2.217950438138081e-06 0.1718807311127691 2.2179505492465e-06 0.1705485445502526 2.217950691372958e-06 0.168854666407182 2.217950809031379e-06 0.167460358327668 \
2.217950913935975e-06 0.1662230887079887 2.217951008998573e-06 0.1651069099307241 2.217951102429828e-06 0.1640147999883682 2.21795120347649e-06 0.1628388413495604 \
2.217951299823398e-06 0.1617223204899406 2.217951396975644e-06 0.1606011553546776 2.217951480024216e-06 0.1596469772300165 2.21795159006187e-06 0.1583897228513109 \
2.217951672364431e-06 0.1574542248873526 2.217951777364141e-06 0.156267858580057 2.21795185506021e-06 0.1553950893374849 2.217951937879688e-06 0.1544690878994293 \
2.217952019541594e-06 0.1535604570452941 2.217952108890884e-06 0.152571060794856 2.21795218460332e-06 0.1517364980793458 2.217952267165934e-06 0.1508307726525361 \
2.217952343747367e-06 0.1499942554682341 2.217952412035253e-06 0.1492531084507001 2.217952505402265e-06 0.1482449401818621 2.217952574555677e-06 0.1475015570698688 \
2.217952650180008e-06 0.1466917482325688 2.217952711729128e-06 0.1460354497178591 2.217952778977892e-06 0.1453208357145237 2.217952850039891e-06 0.1445684785944268 \
2.21795292553732e-06 0.143772322008306 2.21795298444886e-06 0.1431546944759192 2.21795306112247e-06 0.1423563022825049 2.217953141443211e-06 0.1415233898163201 \
2.217953214594519e-06 0.1407682091691316 2.217953308750941e-06 0.139800669784813 2.217953380355125e-06 0.1390684367429364 2.2179534538159e-06 0.1383201464810226 \
2.217953537327651e-06 0.1374732033664194 2.217953626806795e-06 0.1365744208092838 2.2179536918717e-06 0.1359252211013016 2.217953803997723e-06 0.1348115665849295 \
2.217953869183863e-06 0.1341670699454539 2.217953939222108e-06 0.1334770515823289 2.217953999527163e-06 0.1328849371768329 2.217954054537987e-06 0.1323464455745446 \
2.217954142654965e-06 0.1314871014507438 2.217954183441259e-06 0.131090685705856 2.21795428714401e-06 0.1300923774523848 2.21795433045658e-06 0.1296773144713907 \
2.217954391675178e-06 0.1290920262082728 2.217954436511897e-06 0.1286643765206081 2.217954524107923e-06 0.127831527987147 2.217954565661879e-06 0.1274377589706847 \
2.217954625523389e-06 0.1268718307679372 2.217954697367115e-06 0.1261946708524367 2.217954753579841e-06 0.1256664967939027 2.21795481606734e-06 0.125081039250218 \
2.217954890295323e-06 0.1243877959456236 2.217954964976328e-06 0.1236954937854857 2.217955052159541e-06 0.1228905551604285 2.217955120558091e-06 0.1222610287411191 \
2.217955201128775e-06 0.1215216597888775 2.217955282424256e-06 0.120778012781285 2.217955349340781e-06 0.1201677797529914 2.217955432157725e-06 0.1194156054679852 \
2.217955491346448e-06 0.1188799972037829 2.217955557267447e-06 0.1182853617472536 2.217955637141491e-06 0.1175675408705869 2.21795571363729e-06 0.1168828806096336 \
2.2179557950994e-06 0.1161574242846086 2.217955893570281e-06 0.1152852106851665 2.21795596868063e-06 0.114622623867465 2.21795607166842e-06 0.1137180076826871 \
2.217956145852371e-06 0.1130691786503039 2.217956243471825e-06 0.1122190343868764 2.21795633928278e-06 0.1113890351962442 2.217956435131205e-06 0.110562946039519 \
2.217956516069412e-06 0.1098685209805978 2.217956604452683e-06 0.1091134439098378 2.217956703052661e-06 0.108274944429282 2.217956775836865e-06 0.1076586405352824 \
2.217956865109775e-06 0.1069058608836731 2.217956927091788e-06 0.1063852406583179 2.217956989684956e-06 0.1058613310701875 2.217957074907104e-06 0.105150777260444 \
2.217957180369478e-06 0.1042758147594986 2.217957260199961e-06 0.1036167065755082 2.217957340914214e-06 0.1029530974056021 2.217957423527949e-06 0.1022768941101355 \
2.217957493972562e-06 0.1017026162492672 2.217957597231928e-06 0.1008648142128753 2.217957670072053e-06 0.1002767039768694 2.217957755712335e-06 0.09958839426015198 \
2.217957874514072e-06 0.09863954321822334 2.217957942151898e-06 0.09810250133474645 2.21795801190202e-06 0.09755100310752296 2.217958089237e-06 0.09694230106952094 \
2.217958181657254e-06 0.09621870517595056 2.217958253354782e-06 0.09566033062548993 2.217958339171941e-06 0.09499542738017568 2.217958441597192e-06 0.09420660575030523 \
2.217958534892083e-06 0.09349264652734962 2.217958631208556e-06 0.09276005482712441 2.217958708110817e-06 0.09217843893134048 2.217958801590805e-06 0.09147541043939374 \
2.217958880833232e-06 0.09088281005358793 2.217958995455426e-06 0.0900310686188453 2.217959125063685e-06 0.08907580221142102 2.217959258320876e-06 0.08810234090122065 \
2.217959402350765e-06 0.08705990691030199 2.217959559518909e-06 0.08593388720602639 2.217959709295387e-06 0.08487214151476249 2.217959871762978e-06 0.08373303262435308 \
2.217960014942984e-06 0.08273971668837025 2.217960167622107e-06 0.0816913199659166 2.217960301891877e-06 0.08077856892457436 2.217960443644155e-06 0.07982444400446118 \
2.217960578643816e-06 0.07892500874648442 2.217960720601213e-06 0.07798882638923543 2.217960867448644e-06 0.07703088995320664 2.217961019894053e-06 0.07604750978240994 \
2.217961185112776e-06 0.07499422991502351 2.217961349250621e-06 0.07396067809208305 2.217961526112024e-06 0.07286119333145537 2.21796171645358e-06 0.07169407515132428 \
2.217961927410093e-06 0.07042030845332216 2.217962147819231e-06 0.0691121699798517 2.217962383344393e-06 0.06773900533435212 2.217962643793767e-06 0.0662496528900723 \
2.217962939459177e-06 0.06459579389282195 2.217963244581463e-06 0.06292902455725519 2.217963609576024e-06 0.06098725515092194 2.217964004456839e-06 0.05894944116461652 \
2.217964410847493e-06 0.05692211719668253 2.217964826573035e-06 0.05491854459141238 2.217965189379358e-06 0.0532251207245777 2.217965533980647e-06 0.05166301626031383 \
2.21796584916051e-06 0.05027284652491828 2.217966144689875e-06 0.04900240867073854 2.217966442670382e-06 0.04775344010203557 2.217966718469172e-06 0.04662857640242725 \
2.217966997243768e-06 0.04551884372531381 2.217967261178638e-06 0.04449205559535935 2.217967537201376e-06 0.04344260531795661 2.21796781615763e-06 0.04240676967887352 \
2.217968129850963e-06 0.04127097799875453 2.21796836585125e-06 0.04043636567030678 2.217968621645987e-06 0.03955075129286261 2.217968881769487e-06 0.03867033103466553 \
2.217969151904759e-06 0.03778142289416799 2.217969431124746e-06 0.03688501536902895 2.217969712963396e-06 0.03600226561751176 2.217969989839066e-06 0.03515600409566183 \
2.217970268932665e-06 0.03432349610146775 2.217970501810272e-06 0.03364444121149882 2.217970785646989e-06 0.03283527291840588 2.217971025751923e-06 0.03216626441466421 \
2.217971265550746e-06 0.0315119836023277 2.21797150482792e-06 0.03087436846876356 2.217971740084942e-06 0.03026290129608995 2.217971971011964e-06 0.02967475842909434 \
2.217972186001007e-06 0.02913788335257221 2.217972588155459e-06 0.02816043724496065 2.217972786878278e-06 0.02768988489927659 2.217973160561294e-06 0.0268265706552881 \
2.217973347359617e-06 0.02640514011949098 2.217973694919304e-06 0.02563810810034544 2.217973816848767e-06 0.0253740445387235 2.217974199320207e-06 0.02456430406701914 \
2.217974370028236e-06 0.02421180751242828 2.217974827125621e-06 0.02328894863848502 2.217975012758007e-06 0.0229225623309489 2.21797537621526e-06 0.02221803970155307 \
2.217975596582612e-06 0.02179832126591805 2.217976054308969e-06 0.02093867417890744 2.217976189728599e-06 0.02068687731869814 2.217976719624047e-06 0.01972418011126781 \
2.217976838945017e-06 0.01951377505543128 2.217977404730696e-06 0.01856069823426573 2.217977569110437e-06 0.0182962226476828 2.217978187655734e-06 0.01735107502432094 \
2.217978357709933e-06 0.01710418363667701 2.217978889842166e-06 0.01636278834442301 2.217979086926142e-06 0.01610013864443424 2.217979810045215e-06 0.01517806887136661 \
2.217979974675381e-06 0.01497647803580381 2.217980723800767e-06 0.01409711804523418 2.21798085710012e-06 0.01394643716836554 2.217981717353758e-06 0.01301449210748497 \
2.217981852457379e-06 0.01287422877142914 2.21798279503482e-06 0.01193816285908547 2.217982958630574e-06 0.01178202925388569 2.217983959987201e-06 0.0108653384673985 \
2.217984097529988e-06 0.01074500730514941 2.217985319636371e-06 0.009765086624518643 2.217985426589084e-06 0.00968516078425012 2.217986830780577e-06 0.008707372520026449 \
2.217986935611284e-06 0.008639312158696611 2.217988470448246e-06 0.00767719340797631 2.217988565731547e-06 0.007617466071856052 2.217990174528868e-06 0.006680264535635283 \
2.217990308605608e-06 0.006609506832171614 2.217992405618559e-06 0.005610918814474722 2.217992636163191e-06 0.005510783990371394 2.217994959158434e-06 0.004586584533412417 \
2.217995440488638e-06 0.004413562233393853 2.217998278050269e-06 0.003511943147855551 2.217998822969955e-06 0.003360532104877318 2.218002947178351e-06 0.002408309874554541 \
2.218003490902011e-06 0.002305347543005144 2.218009362191237e-06 0.001333291345955189 2.218009605056421e-06 0.001286469439319215 2.218023932948772e-06 0.0002880570268237783 \
2.218024077507414e-06 0.0002853642807229123 2.220661356428512e-06 -0.0006859155495331031 2.22066149598365e-06 -0.000901903561740745 2.220662005077582e-06 -0.001859438188174024 \
2.220662094565085e-06 -0.002052812934985279 2.220662457959945e-06 -0.00291126965001638 2.220662548982015e-06 -0.003143482006111167 2.220662914420052e-06 -0.004127275145644371 \
2.220663024680619e-06 -0.004436819103926468 2.220663336727774e-06 -0.005309594399865315 2.220663439442621e-06 -0.005584800160857357 2.220663803290477e-06 -0.006384516484886619 \
2.220663968081208e-06 -0.006586298968823262 2.220664547677408e-06 -0.005791490933239759 2.220664722787551e-06 -0.004914057272375438 2.220664839479485e-06 -0.004132845175365214 \
2.22066496606409e-06 -0.003100877896798674 2.220665067873012e-06 -0.002132773363901063 2.220665188361723e-06 -0.0008283127610571584 2.220665278808799e-06 0.0002599396317828252 \
2.22066537669893e-06 0.001541559978017447 2.220665475763239e-06 0.002943971508909197 2.220665646570516e-06 0.005594911825788154 2.220665868338539e-06 0.00944046646559993 \
2.220666064242384e-06 0.01317281463966807 2.220666223123766e-06 0.01639870563256729 2.220666387552263e-06 0.01989779506365397 2.220666541918293e-06 0.02331070396473752 \
2.220666700690818e-06 0.02693200463312963 2.220666847428777e-06 0.03036422445567413 2.220666996052748e-06 0.0339113704936035 2.220667151667245e-06 0.03768995713197771 \
2.220667308909259e-06 0.04156499463828727 2.220667473802057e-06 0.04567927910670353 2.220667647221578e-06 0.05005184210758699 2.220667825915293e-06 0.05459761989277153 \
2.22066801453113e-06 0.05943075613080645 2.220668215431273e-06 0.06460909294799391 2.220668434888064e-06 0.0702927970720964 2.220668664434351e-06 0.07626037976612585 \
2.220668910133291e-06 0.08266408948881369 2.22066917869823e-06 0.08967663153997742 2.220669470040144e-06 0.09728936802005522 2.220669791708172e-06 0.1056939239977524 \
2.220670152022263e-06 0.1150987971742611 2.220670543001701e-06 0.1252892839303718 2.220670986416517e-06 0.1368209045172546 2.220671502729604e-06 0.1502062239570841 \
2.220672108934821e-06 0.16586000516691 2.220672780191848e-06 0.1831102247110778 2.220673559691505e-06 0.20301830483439 2.220674432001388e-06 0.2251413938832897 \
2.220675262336713e-06 0.2460320778586349 2.220675993667063e-06 0.264292249712138 2.220676641612843e-06 0.280346965484095 2.220677224923317e-06 0.29469740877147 \
2.220677760655584e-06 0.3077798509628869 2.220678263914169e-06 0.3199778888071559 2.22067874911767e-06 0.3316516836183861 2.220679228040375e-06 0.3430829066939081 \
2.220679674471008e-06 0.3536501814456421 2.220680148800718e-06 0.3647819492304352 2.220680597991712e-06 0.3752331958288908 2.220681088463969e-06 0.3865396207984229 \
2.220681617036723e-06 0.3985997842463301 2.220681988181062e-06 0.4069920784971888 2.220682515935418e-06 0.4188173133762567 2.220682978292178e-06 0.4290642331729484 \
2.220683450624318e-06 0.4394285229343968 2.220683932409041e-06 0.4498981261869666 2.220683965448159e-06 0.4506126593745911 2.220684003207152e-06 0.45142837879914 \
2.220684078725137e-06 0.4530572051633331 2.220684229761107e-06 0.4563088938659436 2.220684437280373e-06 0.460764549126051 2.220684625319184e-06 0.4647825567212808 \
2.220684844328398e-06 0.469441659996985 2.220685087159409e-06 0.4745824626509371 2.220685386935037e-06 0.4808894567257585 2.220685624728187e-06 0.4858624696070272 \
2.220685887949588e-06 0.4913374535260851 2.220686148847132e-06 0.4967277906005185 2.220686378401219e-06 0.5014431429135263 2.220686601461413e-06 0.506003872007333 \
2.220686803037404e-06 0.5100983586086808 2.220686951867463e-06 0.51310967141356 2.220687196178515e-06 0.5180317772556589 2.220687328783749e-06 0.5206893064287169 \
2.220687468140331e-06 0.5234717264876519 2.220687679105724e-06 0.5276623644271943 2.220687853979606e-06 0.5311266030493931 2.220688122027852e-06 0.5364094032095129 \
2.22068831705351e-06 0.5402319029111832 2.220688496615017e-06 0.5437361368949839 2.220688747571146e-06 0.5486228351952749 2.220689024979257e-06 0.5540035987981641 \
2.220689308928559e-06 0.5594901708581531 2.22068956456585e-06 0.5644152233389156 2.220689855548069e-06 0.570006772487656 2.220690115853754e-06 0.5749917787111524 \
2.220690384297874e-06 0.5801232573974072 2.220690627063004e-06 0.5847450403362237 2.220690883594205e-06 0.5896146675871002 2.220691109757648e-06 0.59388771440121 \
2.220691347099142e-06 0.5983512154742827 2.22069155648786e-06 0.6022720321566808 2.220691770260628e-06 0.6062574570422776 2.220692023713469e-06 0.6109557890491497 \
2.220692226567816e-06 0.6146943332140289 2.220692419372338e-06 0.6182333111593361 2.220692609677365e-06 0.6217090173923294 2.220692800335854e-06 0.6251694921350958 \
2.22069300291378e-06 0.6288260100903066 2.220693265662542e-06 0.6335359534764116 2.220693494630232e-06 0.6376100987349322 2.220693714577867e-06 0.6414991146358265 \
2.22069394026254e-06 0.6454625140719233 2.220694149149966e-06 0.6491091855837361 2.220694370803585e-06 0.652957810138281 2.220694555693011e-06 0.6561429680377227 \
2.220694745707564e-06 0.6594017273991298 2.220694895862686e-06 0.6619630641908443 2.220695070740593e-06 0.6649292185271485 2.220695216461309e-06 0.6673855496832628 \
2.220695352493842e-06 0.6696641287411549 2.220695500856121e-06 0.672138295335571 2.220695630303833e-06 0.6742883907026684 2.22069576416953e-06 0.6764996355878535 \
2.22069589251393e-06 0.6786115243545502 2.220696017902058e-06 0.6806677490053815 2.220696147367755e-06 0.6827843190971332 2.22069627834897e-06 0.6849171426143115 \
2.220696426722072e-06 0.6873221141612875 2.220696534784827e-06 0.6890667486235877 2.220696663316499e-06 0.6911333958680312 2.220696798756283e-06 0.6933004139195943 \
2.220696923690607e-06 0.6952876996714908 2.220697049447875e-06 0.6972799977491608 2.220697155963766e-06 0.6989584331773744 2.220697273081655e-06 0.7007929859467624 \
2.2206973916214e-06 0.7026383448210159 2.220697514924797e-06 0.704545102273978 2.220697618097695e-06 0.7061304255463237 2.220697769068859e-06 0.7084341141567283 \
2.220697885323065e-06 0.7101955266062138 2.220698015883454e-06 0.7121605601685687 2.220698134445982e-06 0.7139335830373704 2.220698240519851e-06 0.7155108922888329 \
2.220698340544791e-06 0.716990346352101 2.220698477870006e-06 0.719009255813789 2.220698596531362e-06 0.7207429633399333 2.220698718230586e-06 0.7225107522614664 \
2.220698843413151e-06 0.7243181860083944 2.220698965432965e-06 0.7260693242762759 2.220699093464718e-06 0.7278954552757622 2.220699217946458e-06 0.7296603419865877 \
2.22069934624578e-06 0.7314685590147565 2.220699473339584e-06 0.7332489547570846 2.220699599364423e-06 0.7350034830462163 2.22069970210311e-06 0.7364262918236342 \
2.220699816775855e-06 0.7380063527755659 2.220699898181918e-06 0.7391232259175492 2.220700017381438e-06 0.7407496908814458 2.220700110023778e-06 0.7420059782745783 \
2.220700248182834e-06 0.7438668850244906 2.220700379238334e-06 0.7456179978167152 2.220700509370502e-06 0.7473439783685625 2.220700614344577e-06 0.7487266533969134 \
2.220700753484419e-06 0.7505456565005918 2.220700907428719e-06 0.7525407731682957 2.220701029372999e-06 0.7541080835708853 2.220701176919359e-06 0.7559892974429111 \
2.220701298924537e-06 0.7575320275232224 2.220701447624466e-06 0.7593968175435225 2.220701581671092e-06 0.7610632318338031 2.220701703924347e-06 0.7625711443351471 \
2.220701816790256e-06 0.763953046884334 2.220701959641224e-06 0.7656882893306027 2.220702086364119e-06 0.7672149413549471 2.220702202168994e-06 0.7685995877768005 \
2.220702331910822e-06 0.7701390587657672 2.22070244764921e-06 0.7715019052061673 2.220702570601637e-06 0.7729391548276606 2.220702688317297e-06 0.7743051053122872 \
2.220702794287273e-06 0.7755262985206828 2.220702910698467e-06 0.7768586864857919 2.2207030173164e-06 0.7780703956921795 2.220703129515121e-06 0.7793369495935717 \
2.22070321618369e-06 0.7803089322889447 2.220703319569181e-06 0.7814603789665585 2.220703432733432e-06 0.7827108149434853 2.220703538380716e-06 0.783868819044773 \
2.220703647720273e-06 0.7850578567336689 2.220703754897287e-06 0.786214126597127 2.220703884303365e-06 0.7875981444497275 2.22070399672075e-06 0.7887899291890393 \
2.22070412010849e-06 0.7900869036018625 2.220704237558825e-06 0.7913106402786101 2.220704381085743e-06 0.7927918312347375 2.220704496005322e-06 0.7939667362870242 \
2.220704634727735e-06 0.7953719780830618 2.220704772759876e-06 0.7967562205547866 2.220704882253029e-06 0.7978444364842524 2.220704983271459e-06 0.7988406866985471 \
2.22070508435942e-06 0.7998302780396641 2.220705216746616e-06 0.8011146558616069 2.220705335472037e-06 0.8022550163876687 2.220705457256542e-06 0.8034134048507504 \
2.220705576346336e-06 0.8045351524060473 2.220705697550853e-06 0.8056657048884367 2.220705829194664e-06 0.8068811249615274 2.220705952212703e-06 0.8080052413861453 \
2.220706079823023e-06 0.8091594649786741 2.220706210891683e-06 0.8103325925767672 2.220706334212046e-06 0.8114249716726942 2.220706442136311e-06 0.8123719892944993 \
2.220706549931703e-06 0.8133095350680949 2.220706631652631e-06 0.8140147772069938 2.220706748520247e-06 0.815015186305849 2.220706839581256e-06 0.8157880755829442 \
2.220706973749888e-06 0.8169164295805346 2.22070711832076e-06 0.8181184617099191 2.220707251823126e-06 0.8192158725965917 2.220707361789038e-06 0.8201107352847025 \
2.220707505654697e-06 0.8212684563313245 2.220707658960262e-06 0.8224861772268215 2.220707786698555e-06 0.8234883060891934 2.220707927340891e-06 0.8245786478120171 \
2.220708053124455e-06 0.8255423809867173 2.220708207742427e-06 0.8267124309768116 2.220708340154193e-06 0.8277017767197102 2.220708466433798e-06 0.8286345641820314 \
2.220708584064113e-06 0.8294941055817234 2.220708732230975e-06 0.8305638349826423 2.22070889937522e-06 0.8317531470681401 2.220709031993881e-06 0.832683775428688 \
2.220709204938569e-06 0.8338803479528284 2.220709373325224e-06 0.8350269493631071 2.220709542859754e-06 0.8361634673386688 2.220709724228909e-06 0.8373596561587384 \
2.220709866861491e-06 0.8382862741713709 2.220709980797339e-06 0.8390176620397163 2.220710111571134e-06 0.8398476357987267 2.220710213225074e-06 0.8404856735008092 \
2.220710329718803e-06 0.8412091703399448 2.220710465236349e-06 0.8420405885319162 2.220710662580143e-06 0.8432318270427018 2.220710853245141e-06 0.8443612543037786 \
2.22071106310198e-06 0.8455804035625291 2.220711244039104e-06 0.8466117334714958 2.220711441374591e-06 0.8477160230260256 2.220711615161427e-06 0.8486711109012058 \
2.220711797742881e-06 0.8496572451898022 2.220711969062461e-06 0.850566499179887 2.220712143447507e-06 0.8514760798656241 2.220712318831052e-06 0.8523748177975867 \
2.220712495063209e-06 0.8532619682996843 2.220712684901451e-06 0.8542000584728613 2.220712875637665e-06 0.8551245802328369 2.220713077434399e-06 0.856083442102113 \
2.220713270127775e-06 0.8569809170305027 2.220713479756076e-06 0.857937542729613 2.22071370919384e-06 0.8589615588718806 2.22071397499048e-06 0.8601183337444025 \
2.220714273565707e-06 0.8613802063570262 2.220714551467221e-06 0.8625196921548358 2.220714835677695e-06 0.8636511027355716 2.220715110089482e-06 0.8647118800460076 \
2.220715382252364e-06 0.8657341977214618 2.220715652421455e-06 0.8667205537246333 2.220715909616139e-06 0.8676338760342862 2.22071618215581e-06 0.868575115807136 \
2.220716458190291e-06 0.8695013130444248 2.220716728342986e-06 0.8703818891200001 2.220717028049787e-06 0.8713292845176382 2.220717398867258e-06 0.8724597217497643 \
2.220717693785921e-06 0.8733269024855727 2.220717948030199e-06 0.8740525764960509 2.220718246254198e-06 0.8748787854419284 2.220718519878969e-06 0.8756137195941651 \
2.220718756017958e-06 0.8762307200963571 2.220718996373686e-06 0.8768427579093606 2.220719218719338e-06 0.8773949085683344 2.220719412723072e-06 0.877865919014753 \
2.220719742447196e-06 0.878644045115768 2.220719897619855e-06 0.8790007149587372 2.220720215373248e-06 0.879712598742095 2.220720394238605e-06 0.8801026384247937 \
2.220720736700094e-06 0.8808283583858193 2.220720920841292e-06 0.8812073588304842 2.220721395746114e-06 0.8821499412898334 2.220721563140601e-06 0.8824705695712217 \
2.220722028971889e-06 0.8833323038036038 2.220722209796771e-06 0.8836551183393088 2.220722703830028e-06 0.8845051821644966 2.220722845172603e-06 0.8847400410050358 \
2.220723451563118e-06 0.8857071861637142 2.220723603635685e-06 0.8859397703602404 2.220724250313757e-06 0.8868873789663725 2.220724378610246e-06 0.8870678433440622 \
2.220725026723245e-06 0.8879435266410994 2.220725156528523e-06 0.8881118897635528 2.220725934785608e-06 0.8890711781604964 2.220726049780422e-06 0.8892053868933587 \
2.220726905511062e-06 0.8901454611437621 2.220727050777629e-06 0.8902951528450479 2.220728036533732e-06 0.8912364417375994 2.220728257640946e-06 0.8914302300078862 \
2.220729402752027e-06 0.892358484239638 2.220729533960174e-06 0.8924604119362172 2.220730875263369e-06 0.8934531785430913 2.22073102665103e-06 0.8935579568409697 \
2.220732508109867e-06 0.8944876667405802 2.220732746990229e-06 0.894621531696939 2.220734516461986e-06 0.8954958910368339 2.220734905568823e-06 0.8956641700186337 \
2.220737299334232e-06 0.8965498195158238 2.220737774894223e-06 0.8966991754584082 2.220741837950387e-06 0.8976977719002629 2.220742329424408e-06 0.8977905759376156 \
2.220750645951487e-06 0.8987839664765119 2.220751565805377e-06 0.8988472044554419 2.220877770945903e-06 0.8998441026240215 2.220878784754255e-06 0.8998514601858095 \
2.221070497347411e-06 0.8990059056521554 2.221070727348974e-06 0.8988405173838494 2.221072342221535e-06 0.8978439928078279 2.221072519935388e-06 0.8977495532019018 \
2.221089285710428e-06 0.8987316330193963 2.221089421698825e-06 0.8987497732072308 2.221104884427938e-06 0.8997471920221268 2.22110515229253e-06 0.8997526389354535 \
2.221588977619798e-06 0.9006560548284696 2.221589098408998e-06 0.9007687033315858 2.221589886180037e-06 0.9017381658104292 2.221590020318756e-06 0.901943163319478 \
2.22159051393353e-06 0.9027850367016239 2.221590658833145e-06 0.9030569221572713 2.22159105464053e-06 0.9038490360455199 2.221591174436184e-06 0.9041001886668685 \
2.221591558609717e-06 0.9049189780371781 2.221591670731364e-06 0.9051556495331843 2.221592178052335e-06 0.9061253139956988 2.221592272051191e-06 0.90626859229291 \
2.221593430700898e-06 0.9055667778886739 2.221593533663831e-06 0.9051589876696525 2.221593617506701e-06 0.9047707260375384 2.221593751246752e-06 0.9040404158978201 \
2.221593851964133e-06 0.9033957423200318 2.221593959579919e-06 0.9026166239542108 2.221594077153173e-06 0.9016533104038295 2.221594165418223e-06 0.90085556431878 \
2.221594285051691e-06 0.8996698288011099 2.221594382373389e-06 0.8986166602050341 2.221594493390828e-06 0.8973222354192386 2.221594595500415e-06 0.8960407982554908 \
2.221594678931815e-06 0.8949326975987755 2.221594783112883e-06 0.8934749428758865 2.221594874199646e-06 0.8921321265381427 2.221594966740432e-06 0.8907058396397178 \
2.22159506189443e-06 0.8891776325191247 2.221595176449407e-06 0.88725933118288 2.221595265292509e-06 0.8857137884271823 2.22159536353169e-06 0.8839502506198179 \
2.221595448901864e-06 0.8823735982707064 2.221595529802107e-06 0.8808434949738935 2.221595602763399e-06 0.8794355441897157 2.221595669782045e-06 0.8781198554636557 \
2.221595738393124e-06 0.8767515715160701 2.221595821888035e-06 0.8750591081124355 2.221595884015366e-06 0.8737811510706814 2.221595946997964e-06 0.8724704924326797 \
2.221596042153715e-06 0.8704632161180945 2.221596142764353e-06 0.8683077530860182 2.221596222643544e-06 0.8665738309361769 2.221596306905814e-06 0.8647250601592834 \
2.221596386016074e-06 0.8629723295901451 2.221596448831519e-06 0.8615696597604833 2.221596536288553e-06 0.8596016864744445 2.221596602182084e-06 0.8581079708060287 \
2.221596670243626e-06 0.856556281928966 2.221596719556134e-06 0.8554267461646872 2.221596774792923e-06 0.85415654045335 2.221596815532529e-06 0.8532164928603474 \
2.221596861834283e-06 0.8521450198670055 2.221596892048343e-06 0.8514441160591502 2.221596921089625e-06 0.8507691938976955 2.22159695172822e-06 0.8500558939662993 \
2.22159701300541e-06 0.8486254874746039 2.221597066077972e-06 0.8473828229799116 2.221597119733165e-06 0.8461232012188223 2.221597182390447e-06 0.8446482873934593 \
2.221597245673395e-06 0.8431545995644786 2.221597336171269e-06 0.8410121009440262 2.22159743316905e-06 0.8387078554355326 2.22159751614655e-06 0.8367307351423475 \
2.221597598150905e-06 0.8347721678896715 2.221597687219306e-06 0.8326403548070889 2.221597771732643e-06 0.8306135893189693 2.221597862591523e-06 0.8284303722590877 \
2.221597954526378e-06 0.8262176456275642 2.221598056957308e-06 0.8237486178045141 2.22159815707534e-06 0.8213320995840899 2.221598271896223e-06 0.8185572053828121 \
2.22159838410276e-06 0.8158423448209959 2.221598509096305e-06 0.8128151787794674 2.221598640356713e-06 0.8096337870015397 2.221598785627755e-06 0.8061104108175116 \
2.221598940135368e-06 0.8023613213197434 2.221599111575989e-06 0.7981999722344618 2.221599275625781e-06 0.794217661721315 2.221599460041203e-06 0.7897413884478564 \
2.221599666533576e-06 0.7847307375046715 2.22159985602742e-06 0.7801344622909899 2.221600049421183e-06 0.775444374634302 2.221600249988037e-06 0.7705834242206392 \
2.221600397552439e-06 0.7670092004965298 2.221600527563889e-06 0.7638619034739171 2.221600662428303e-06 0.7605987503374771 2.221600768918754e-06 0.7580234999254772 \
2.221600900608547e-06 0.7548403390839162 2.221601007032976e-06 0.7522693550468039 2.221601150211605e-06 0.7488125398635642 2.221601311338716e-06 0.7449250928176189 \
2.221601429565533e-06 0.7420746008290786 2.221601599798354e-06 0.7379721584775248 2.221601765724623e-06 0.7339761998059781 2.221601985266953e-06 0.7286940862104242 \
2.221602178454078e-06 0.724050920820232 2.221602353368041e-06 0.719851304223293 2.221602520315139e-06 0.7158476177432674 2.2216027078061e-06 0.711355754450834 \
2.221602895234537e-06 0.7068709122373377 2.221603063571096e-06 0.7028473835914892 2.22160325640163e-06 0.6982428782038785 2.221603396451377e-06 0.694901318858167 \
2.221603552708666e-06 0.6911769338170629 2.221603746878113e-06 0.6865540563080536 2.221603905984601e-06 0.6827702245679255 2.221604064344631e-06 0.679008548037742 \
2.22160425966174e-06 0.6743756772263459 2.221604470090519e-06 0.6693917663527935 2.221604722792664e-06 0.6634173774538097 2.221604902460615e-06 0.6591769455535931 \
2.221605154037489e-06 0.6532475027332399 2.221605354410306e-06 0.6485340174553987 2.221605526064158e-06 0.6445032789616798 2.221605684756275e-06 0.6407814961122935 \
2.221605823964202e-06 0.637522316374186 2.221605960288252e-06 0.6343349641335875 2.221606087501276e-06 0.6313646237382058 2.221606216993833e-06 0.6283457899522861 \
2.221606344985121e-06 0.6253646753452949 2.22160647605963e-06 0.6223174651643489 2.221606606771705e-06 0.6192830747181834 2.221606749379757e-06 0.6159760732208495 \
2.221606892103236e-06 0.612672916206165 2.221607044651036e-06 0.6091471600588 2.221607189155024e-06 0.6058158037532523 2.221607353173272e-06 0.6020406322262999 \
2.221607490637933e-06 0.5988837056407329 2.221607625454949e-06 0.5957940466067043 2.221607746953592e-06 0.5930134750293682 2.221607885803896e-06 0.5898448108574432 \
2.221607999450713e-06 0.5872554148224447 2.221608150860885e-06 0.5838116422847746 2.22160826457956e-06 0.5812320812748947 2.221608383992651e-06 0.5785269636915771 \
2.221608472673178e-06 0.5765205397309219 2.221608563818269e-06 0.5744630259469776 2.221608629157144e-06 0.5729901393713442 2.221608693626846e-06 0.5715377831648228 \
2.221608744447459e-06 0.5703933076453638 2.221608803422398e-06 0.569066051987989 2.221608870867106e-06 0.5675516747474645 2.221608937959298e-06 0.5660472084764079 \
2.221608990879742e-06 0.5648615894615425 2.221609086527225e-06 0.5627204246953637 2.221609143708361e-06 0.5614413394337 2.221609197510977e-06 0.5602399192081799 \
2.221609259253082e-06 0.5588634520375642 2.221609345086214e-06 0.5569525037715509 2.221609427781861e-06 0.5551133137453282 2.221609553910589e-06 0.552313430559463 \
2.221609689009665e-06 0.5493247407981657 2.221609787329828e-06 0.5471534914294828 2.22160989990789e-06 0.5446716589975775 2.221610002452305e-06 0.5424173856211837 \
2.221610122561131e-06 0.5397821662853191 2.221610224248782e-06 0.5375541863492928 2.221610339752745e-06 0.5350300289250629 2.221610454643861e-06 0.5325260225312031 \
2.221610581121134e-06 0.5297740207092871 2.22161070633833e-06 0.5270565158317848 2.221610853184312e-06 0.5238798967507053 2.221610988642446e-06 0.5209557060405445 \
2.221611146203055e-06 0.5175672114705414 2.221611308357229e-06 0.5140875588169389 2.221611489068307e-06 0.5102248342695275 2.22161168131606e-06 0.5061308236654174 \
2.221611894038323e-06 0.5016182665703952 2.221612125943484e-06 0.4967183500883584 2.221612383137187e-06 0.4913135654247419 2.221612622690498e-06 0.4863004534671564 \
2.221612924620373e-06 0.4800178499336004 2.221613212386814e-06 0.4740665530855001 2.221613525189057e-06 0.4676409412178996 2.221613845020806e-06 0.4611139840073785 \
2.221614184657409e-06 0.4542292677834274 2.221614511873228e-06 0.4476411633207955 2.221614847034797e-06 0.4409363684817221 2.221615164291457e-06 0.4346351592989786 \
2.221615498111436e-06 0.4280489847791872 2.22161584979678e-06 0.4211625252737479 2.221616163864498e-06 0.4150547397555842 2.221616486893702e-06 0.4088175946446666 \
2.221616927873099e-06 0.4003732788922496 2.221617270275942e-06 0.3938810608698495 2.22161757072383e-06 0.3882325136127223 2.221617946053401e-06 0.3812375944419973 \
2.22161827612863e-06 0.3751439175705365 2.221618559406411e-06 0.3699597784791666 2.221618859913772e-06 0.3645020109013299 2.221619139561233e-06 0.3594637112692664 \
2.221619363423523e-06 0.3554634414471464 2.221619575274513e-06 0.35170280677964 2.221619777623113e-06 0.3481338771034005 2.221619978758139e-06 0.3446120049995081 \
2.221620184535656e-06 0.3410324794262659 2.22162044551437e-06 0.3365252478245505 2.221620685004553e-06 0.3324209773202946 2.221620917679624e-06 0.3284665339262754 \
2.221621131761216e-06 0.3248537323113044 2.221621352906983e-06 0.3211475567840967 2.221621553789873e-06 0.3178053707831449 2.221621757181075e-06 0.3144500223650613 \
2.221621954849487e-06 0.3112139453100684 2.221622141093175e-06 0.3081862077816076 2.221622336074257e-06 0.3050391973134606 2.221622539536502e-06 0.3017803754370622 \
2.221622717477407e-06 0.2989521325826759 2.221622953201112e-06 0.2952356640875101 2.221623151333965e-06 0.2921385263640672 2.221623352678033e-06 0.2890160050544278 \
2.221623576967229e-06 0.2855690750291008 2.221623741897129e-06 0.2830551950838826 2.221623919525814e-06 0.2803657404651576 2.221624103924961e-06 0.2775946687427531 \
2.221624287746306e-06 0.2748547260732712 2.221624466202978e-06 0.2722194282383935 2.221624638103246e-06 0.2696976713509589 2.221624798643653e-06 0.2673699088296289 \
2.221624920125711e-06 0.265617282026588 2.221625073047238e-06 0.2634201198254058 2.221625200480934e-06 0.2616085083773952 2.221625304654604e-06 0.2601317890528609 \
2.221625421559081e-06 0.2584775571399547 2.221625536570573e-06 0.2568557450124987 2.221625660932803e-06 0.2551103168403305 2.221625776507086e-06 0.2534925198640895 \
2.221625910614607e-06 0.2516172680784447 2.221626025601848e-06 0.2500177396912131 2.221626179351445e-06 0.2478798443778067 2.221626316154646e-06 0.2459790966208961 \
2.221626450740453e-06 0.2441094379339017 2.221626606604589e-06 0.2419575875351012 2.221626731253411e-06 0.2402378086535915 2.221626870468935e-06 0.2383186229544463 \
2.22162700069296e-06 0.236525770455347 2.2216271210458e-06 0.2348769158236033 2.221627256439084e-06 0.233027137746051 2.221627407644063e-06 0.2309620730808924 \
2.221627542400533e-06 0.2291249940296414 2.22162764708672e-06 0.2277003186426776 2.221627769622861e-06 0.2260366668203369 2.22162790456742e-06 0.2242086518061946 \
2.221627999683167e-06 0.2229209267876512 2.221628114943222e-06 0.2213657311907907 2.221628197476202e-06 0.2202562617028589 2.221628268681533e-06 0.2192992955643472 \
2.221628317389017e-06 0.2186449771734718 2.221628364583973e-06 0.2180112263680214 2.221628411132791e-06 0.2173864029843717 2.221628464521355e-06 0.2166701476649976 \
2.221628501898025e-06 0.2161690444847812 2.221628539283138e-06 0.2156680710113931 2.221628579604508e-06 0.2151283464800275 2.221628650854647e-06 0.2141753141901174 \
2.221628685068904e-06 0.2137180869447317 2.221628731463534e-06 0.2131018213873352 2.221628791907201e-06 0.2122998083652294 2.22162886091012e-06 0.2113853596849882 \
2.221628926205071e-06 0.210520730631805 2.221628994183195e-06 0.2096212333552783 2.221629110629525e-06 0.2080823984153433 2.221629200551713e-06 0.2068957989735914 \
2.221629308217619e-06 0.2054771097790837 2.221629404278935e-06 0.2042146625011118 2.221629507657509e-06 0.2028641889872041 2.221629604342543e-06 0.2016026287683381 \
2.221629707152396e-06 0.2002625524503448 2.221629807912368e-06 0.1989526210414513 2.221629919058034e-06 0.1975116692735505 2.221630026097529e-06 0.1961279675313261 \
2.221630144004064e-06 0.1946083430154048 2.221630252114387e-06 0.1932197128021231 2.221630361412987e-06 0.1918224631760269 2.221630482044739e-06 0.1902849927564414 \
2.221630576945331e-06 0.1890796997295432 2.22163070550625e-06 0.18745262875399 2.221630798541038e-06 0.1862801166370808 2.221630900937594e-06 0.1849947785893032 \
2.221630988904886e-06 0.1838942174288659 2.221631087175557e-06 0.182668828510528 2.221631183776179e-06 0.1814691026470878 2.221631270414692e-06 0.1803971466393716 \
2.221631356823704e-06 0.1793305247657973 2.221631452660814e-06 0.1781527189679156 2.221631557387688e-06 0.1768710765218302 2.221631703199975e-06 0.1750963017969037 \
2.221631819167907e-06 0.1736923427161618 2.221631975631711e-06 0.1718092975148396 2.22163208681163e-06 0.1704786474822015 2.22163222706163e-06 0.1688098560703619 \
2.221632350073035e-06 0.1673544160765056 2.221632456564033e-06 0.1661007559767333 2.221632552889491e-06 0.1649724583647661 2.221632650322959e-06 0.1638357962207703 \
2.221632754176237e-06 0.1626293386330815 2.22163284597681e-06 0.1615673458739011 2.221632944364525e-06 0.1604337426303964 2.22163302728317e-06 0.1594828374885931 \
2.221633122651503e-06 0.1583950132920943 2.221633205213851e-06 0.1574587876231885 2.221633307798537e-06 0.1563016192679324 2.221633384076854e-06 0.1554454316211293 \
2.221633472662479e-06 0.1544557264474612 2.221633544831984e-06 0.1536532700165102 2.221633626541473e-06 0.1527486200895024 2.221633700220281e-06 0.1519363404455653 \
2.221633780440409e-06 0.1510573496788611 2.221633852168484e-06 0.1502755532525617 2.221633920425463e-06 0.149534520573691 2.221634018141422e-06 0.1484788062294206 \
2.221634087591606e-06 0.147731872792437 2.221634170343085e-06 0.1468455801890639 2.221634230379995e-06 0.1462052652532956 2.221634300618658e-06 0.1454587420502366 \
2.221634372046193e-06 0.1447037411390827 2.221634452559694e-06 0.1438588888651768 2.221634515822599e-06 0.1431977449412327 2.221634593496578e-06 0.1423892845091393 \
2.221634682806343e-06 0.141463758692191 2.221634752169929e-06 0.1407479403162204 2.221634850118149e-06 0.1397418416088305 2.221634940462669e-06 0.1388188591118084 \
2.221635026242994e-06 0.1379520826379384 2.221635093896779e-06 0.1372719511642241 2.221635160204629e-06 0.1366075914250998 2.221635238824321e-06 0.1358227655030745 \
2.22163531951923e-06 0.135020537018139 2.221635377921894e-06 0.1344419857224206 2.221635438674417e-06 0.1338420332148588 2.221635532580729e-06 0.1329184183639811 \
2.221635574978232e-06 0.1325029080242558 2.221635654222426e-06 0.1317336600863391 2.221635694592584e-06 0.1313430593815061 2.221635784293463e-06 0.130477658168832 \
2.22163582324155e-06 0.1301029732927899 2.221635918857236e-06 0.1291862249441596 2.221635957741065e-06 0.1288146335111444 2.221636050975841e-06 0.1279263274670414 \
2.22163611931843e-06 0.1272775968534341 2.221636171639285e-06 0.1267823325594629 2.221636253739999e-06 0.1260075984242486 2.221636324903378e-06 0.1253406747583812 \
2.221636402856366e-06 0.1246136378429537 2.221636481976102e-06 0.1238779526756392 2.221636560619333e-06 0.1231489004754178 2.221636640654241e-06 0.122409328367501 \
2.221636702388658e-06 0.1218405706457005 2.22163677598364e-06 0.1211645344030958 2.221636859363458e-06 0.120401093559758 2.221636923460189e-06 0.1198161795466899 \
2.221636992898777e-06 0.119184869057559 2.221637065921716e-06 0.1185234239195788 2.221637150796627e-06 0.1177582144838446 2.221637230159478e-06 0.117046673033812 \
2.221637314893136e-06 0.1162898833629492 2.221637405604425e-06 0.1154830714735263 2.221637481187503e-06 0.1148135241260771 2.221637546915428e-06 0.1142333070693714 \
2.221637606975201e-06 0.1137047561823949 2.221637676580917e-06 0.1130943456353956 2.221637742999968e-06 0.1125141752866663 2.221637822411231e-06 0.1118230150855203 \
2.221637912674161e-06 0.1110406875128299 2.221637981718461e-06 0.1104447270551955 2.22163805627358e-06 0.1098035355921305 2.221638144757501e-06 0.1090456469739195 \
2.221638223865648e-06 0.1083709350695736 2.221638293734029e-06 0.1077773127978274 2.221638374743399e-06 0.1070920034756896 2.221638430948213e-06 0.106618206733547 \
2.221638493607492e-06 0.1060916009495399 2.221638558754097e-06 0.105545887371837 2.221638630089726e-06 0.1049504956797945 2.221638750386101e-06 0.1039516085561449 \
2.221638801939673e-06 0.103525508500865 2.221638857088741e-06 0.1030709598036589 2.221638947785925e-06 0.1023262935955709 2.221639030175778e-06 0.1016530765296615 \
2.221639125755586e-06 0.1008759670630478 2.221639232965152e-06 0.1000092507657299 2.221639336624558e-06 0.09917656019160864 2.221639422832161e-06 0.09848810438956324 \
2.221639509074386e-06 0.09780303991321163 2.22163958861546e-06 0.09717448010577609 2.221639668628333e-06 0.09654538840876434 2.221639759916661e-06 0.09583163072761708 \
2.22163984166208e-06 0.09519620281310773 2.221639930588917e-06 0.09450872319168514 2.221640020366224e-06 0.09381864801001834 2.221640097328872e-06 0.09323024625953365 \
2.221640187653689e-06 0.0925435244861572 2.221640251462415e-06 0.09206084550525626 2.221640323925983e-06 0.09151514907748673 2.221640388054635e-06 0.09103438864950099 \
2.221640466302011e-06 0.09045054736970405 2.221640566003292e-06 0.08971110930136832 2.221640640056443e-06 0.08916512281998501 2.221640726664979e-06 0.08852997392441805 \
2.221640872964685e-06 0.08746544055362569 2.221640983676948e-06 0.08666684197409438 2.221641093986626e-06 0.08587717033461532 2.221641236182269e-06 0.08486839672072237 \
2.22164137623472e-06 0.08388450488753585 2.221641518880534e-06 0.08289222299161547 2.221641667651249e-06 0.08186778387581196 2.221641804363935e-06 0.08093569403044946 \
2.221641946484565e-06 0.07997640434545976 2.221642081061545e-06 0.07907728405019222 2.221642221281423e-06 0.07814997945867638 2.221642369028229e-06 0.07718353387841098 \
2.221642518982415e-06 0.07621348085094087 2.221642683698246e-06 0.07516037195605636 2.221642847284363e-06 0.07412732798506308 2.221643021932716e-06 0.07303837372665309 \
2.221643208986408e-06 0.07188781219077654 2.221643418972926e-06 0.0706159374129187 2.221643637046174e-06 0.06931715807027321 2.221643870366327e-06 0.06795188046253516 \
2.221644124845881e-06 0.0664909822812602 2.22164441780254e-06 0.06484528303377844 2.221644719953089e-06 0.06318745987130532 2.221645057674791e-06 0.06138078634948794 \
2.221645452783393e-06 0.05932807220464856 2.221645820234636e-06 0.05747953410674719 2.221646237842402e-06 0.05544691527644593 2.221646582838376e-06 0.0538196438399016 \
2.221646933380665e-06 0.05221302159193914 2.221647248341029e-06 0.0508087490907442 2.221647547582396e-06 0.049508488261462 2.221647846948248e-06 0.04824029756235761 \
2.221648122190958e-06 0.04710512226277328 2.221648405654525e-06 0.04596497870754415 2.221648667254946e-06 0.04493681260994405 2.221648944707071e-06 0.04387103439794762 \
2.221649220766506e-06 0.04283531238677037 2.221649529036243e-06 0.04170718945545093 2.221649751468863e-06 0.0409114719535993 2.221650039009947e-06 0.03990505631995635 \
2.221650275242879e-06 0.0390969788355163 2.221650593704554e-06 0.03803800466874574 2.221650844115589e-06 0.03722710566490722 2.221651167100391e-06 0.03620720400565681 \
2.221651425436406e-06 0.03541203096995557 2.221651715410285e-06 0.03454066075983582 2.221651945205102e-06 0.0338658635512188 2.221652230100444e-06 0.03304787219836024 \
2.221652469846563e-06 0.03237513696606491 2.221652710481132e-06 0.03171392889024889 2.221652949599619e-06 0.03107212555077287 2.22165318553853e-06 0.03045460689686571 \
2.221653416367391e-06 0.02986254663395104 2.221653631393918e-06 0.02932175456294728 2.221654033559759e-06 0.0283374222946415 2.22165423211788e-06 0.02786401170979088 \
2.221654605819066e-06 0.02699470773596776 2.221654792632261e-06 0.02657042318767052 2.221655138633508e-06 0.02580176906824739 2.221655260576947e-06 0.02553595448027303 \
2.221655643429963e-06 0.02472011952872977 2.221655803864149e-06 0.02438657631284594 2.221656246865303e-06 0.02348572425118655 2.221656417479344e-06 0.02314627247835563 \
2.22165673805594e-06 0.02251902970747987 2.221656938340868e-06 0.0221336684630111 2.221657385278801e-06 0.02128811173678137 2.221657513222916e-06 0.02104854104185888 \
2.221658001100276e-06 0.02014826272243131 2.221658136077553e-06 0.01990454278080647 2.221658618329071e-06 0.0190640092473091 2.221658780655186e-06 0.01879235028057063 \
2.221659267049527e-06 0.01801148170254873 2.221659430077186e-06 0.01776103207540622 2.221660110298876e-06 0.01676849304257711 2.221660249382614e-06 0.01657541006259178 \
2.221660981877148e-06 0.01560782569993242 2.22166114077078e-06 0.01540693214221847 2.221661923851867e-06 0.01445869962397344 2.221662069644422e-06 0.01428952172302696 \
2.221662920425781e-06 0.01334248985256295 2.221663031529053e-06 0.01322388191882306 2.221663964823416e-06 0.0122699293983148 2.221664098661466e-06 0.01213902814618388 \
2.221665057199482e-06 0.01123495036716388 2.221665178316551e-06 0.01112486091825863 2.221666300400348e-06 0.01017270671243764 2.221666405901602e-06 0.01008921053061839 \
2.221667734976014e-06 0.009112307258623473 2.221667855180288e-06 0.009029744095492466 2.221669403542048e-06 0.008036808760534916 2.221669484329818e-06 0.007986285493236449 \
2.221671055209352e-06 0.007024564730313319 2.221671122625551e-06 0.006986095570813155 2.221673043392229e-06 0.006001386377072119 2.221673230194113e-06 0.005914747648762168 \
2.22167554560806e-06 0.0049318160947762 2.221675945134908e-06 0.004777795182599986 2.221678508944408e-06 0.003889929704329555 2.221679007815328e-06 0.003736330440833864 \
2.221682637539317e-06 0.002784984367379526 2.221683188233292e-06 0.002663729254427667 2.221688586673671e-06 0.001711392372544448 2.221688899941243e-06 0.001662511220227468 \
2.221693892233791e-06 0.0006970413096974805 2.221694076252826e-06 0.0006571176749162138 2.224342555395609e-06 -0.0002691198397987355 2.224342711454572e-06 -0.0004551674219448388 \
2.224343259438427e-06 -0.001322174727784445 2.22434337237642e-06 -0.001539785040943742 2.22434380163135e-06 -0.002474302920374066 2.224343907888515e-06 -0.002730173903076456 \
2.224344190690666e-06 -0.003454402452283872 2.22434430428521e-06 -0.003760966378165151 2.224344642839789e-06 -0.004705104513819927 2.22434475526375e-06 -0.005021586953003071 \
2.224345083541651e-06 -0.005887841248467669 2.224345191080171e-06 -0.006130875888161453 2.224346071006203e-06 -0.005789627805322099 2.22434624621225e-06 -0.004910736584223327 \
2.224346363043013e-06 -0.004127745010746014 2.224346489910137e-06 -0.00309221842859156 2.224346591442863e-06 -0.002125750314016509 2.224346712864133e-06 -0.0008095618968406578 \
2.224346803029046e-06 0.0002767910803854594 2.224346900212695e-06 0.001550247908954045 2.22434699828696e-06 0.002938803805678211 2.224347165508045e-06 0.005530627736217106 \
2.224347387813323e-06 0.009378371294171852 2.224347573551714e-06 0.01290572951649239 2.224347797633049e-06 0.01747895571448658 2.224347957277781e-06 0.02091945933227325 \
2.224348121767111e-06 0.02459614091902196 2.224348271591569e-06 0.0280452875125503 2.224348420991461e-06 0.03156498790849799 2.224348570522767e-06 0.03515592969144176 \
2.224348724602661e-06 0.03891669635189081 2.224348886786809e-06 0.0429309674228065 2.224349053210035e-06 0.0470989728378523 2.224349229143508e-06 0.05154884981278444 \
2.224349410271779e-06 0.05616867911875007 2.224349602402705e-06 0.06110225049351239 2.224349810098117e-06 0.0664648391313285 2.224350032018198e-06 0.07222051812179281 \
2.22435026721968e-06 0.07834079218654426 2.224350519405989e-06 0.08491829088081257 2.224350795545224e-06 0.09213111703448683 2.224351096666701e-06 0.1000001933597138 \
2.224351428586562e-06 0.1086702418150647 2.22435180590533e-06 0.1185147411083515 2.224352204195386e-06 0.1288888856248832 2.224352673503706e-06 0.1410822143415975 \
2.22435321952923e-06 0.1552200475789812 2.224353854489538e-06 0.1715918832733369 2.224354553890129e-06 0.1895291194622146 2.224355372129055e-06 0.2103807608661494 \
2.224356277823022e-06 0.2332840710921665 2.224357067334088e-06 0.253091928008631 2.224357771092906e-06 0.2706124241987875 2.224358388943719e-06 0.2858796548825839 \
2.224358954567131e-06 0.2997575097153312 2.224359476302405e-06 0.3124620269501652 2.224359974086121e-06 0.3244932238414255 2.224360457724081e-06 0.3360954048923613 \
2.224360914598215e-06 0.3469667650518959 2.224361387439109e-06 0.3581213589834248 2.224361827052466e-06 0.3684065070151987 2.224362314929562e-06 0.379719432411247 \
2.224362845729984e-06 0.3919028193132517 2.224363343625359e-06 0.4032143644097119 2.224363775002613e-06 0.41292177789323 2.224364261889801e-06 0.4237731225600331 \
2.224364761989243e-06 0.4348012155672935 2.224365106609934e-06 0.4423321287141763 2.224365460003778e-06 0.4500000647748709 2.224365887773617e-06 0.4592134948422093 \
2.224366279634688e-06 0.4675816212925634 2.224366579929044e-06 0.4739471552041949 2.224366921860125e-06 0.4811428413521782 2.22436726519457e-06 0.4883132334011818 \
2.224367525955058e-06 0.4937215836208605 2.224367768011587e-06 0.4987106167174703 2.224368034010056e-06 0.5041617362307154 2.22436829349824e-06 0.5094435946950286 \
2.22436848341454e-06 0.5132872703533161 2.224368698649141e-06 0.5176241792560061 2.2243688371999e-06 0.5204025546691405 2.224368982080679e-06 0.5232962183003332 \
2.224369195494746e-06 0.5275364624051522 2.22436939751936e-06 0.5315382148201082 2.224369590248024e-06 0.5353370730264509 2.224369775503404e-06 0.5389735557287745 \
2.224369952500927e-06 0.5424323215059959 2.224370261764263e-06 0.5484573594957171 2.22437052291231e-06 0.5535233414883098 2.224370824731481e-06 0.5593562770234363 \
2.224371080160122e-06 0.5642781701956761 2.224371372515619e-06 0.5698968483756405 2.224371631969813e-06 0.5748654731717864 2.22437190208979e-06 0.5800301911327002 \
2.224372144100348e-06 0.5846380733684551 2.224372401610146e-06 0.5895273573494454 2.224372628054483e-06 0.5938057549890672 2.224372864942965e-06 0.5982619499065401 \
2.224373074987873e-06 0.6021962733001386 2.224373287918584e-06 0.6061670177072124 2.224373541397282e-06 0.6108668889270118 2.224373744692931e-06 0.6146150465592417 \
2.224373936381114e-06 0.6181346807088086 2.224374125007478e-06 0.6215812235468744 2.224374312325416e-06 0.6249823889551316 2.224374517937406e-06 0.6286953279350977 \
2.224374767760625e-06 0.6331759959753138 2.224374971572403e-06 0.6368063379741715 2.224375179211121e-06 0.6404826298163093 2.224375371862737e-06 0.6438748386876914 \
2.22437561647481e-06 0.6481531432733096 2.224375864373314e-06 0.6524620620600715 2.224376044208219e-06 0.6555644139995785 2.224376234982255e-06 0.6588391718544121 \
2.224376388158437e-06 0.6614554104590837 2.224376559827147e-06 0.6643705886591137 2.224376710293968e-06 0.6669108747194671 2.224376846897971e-06 0.6692010654183506 \
2.224376996338373e-06 0.6716954191563786 2.224377124072523e-06 0.6738189269502312 2.22437726394477e-06 0.6761323074508511 2.224377388021905e-06 0.6781756764962316 \
2.22437751938327e-06 0.6803315871556701 2.224377643554731e-06 0.6823627547057004 2.224377781331592e-06 0.6846081866267727 2.224377901575812e-06 0.6865586181592046 \
2.224378043628417e-06 0.6888545186016138 2.224378143856122e-06 0.6904668682779994 2.224378265160113e-06 0.6924123325129877 2.224378356135388e-06 0.6938641504265992 \
2.224378453518671e-06 0.695411869780077 2.224378550601538e-06 0.6969507228893711 2.224378639884158e-06 0.6983595753378042 2.224378737855943e-06 0.699898781449533 \
2.22437886813103e-06 0.7019319515314388 2.224379021543255e-06 0.7043083163565919 2.224379157109067e-06 0.7063909659299702 2.224379301449562e-06 0.708591461371511 \
2.224379427320445e-06 0.710496752775434 2.224379552347831e-06 0.712376488910674 2.224379666630191e-06 0.7140841686551523 2.224379777613335e-06 0.7157331888171029 \
2.224379877308404e-06 0.7172065512867005 2.224380014352622e-06 0.7192196995505324 2.224380133379835e-06 0.7209572005600779 2.224380253677943e-06 0.7227029412191364 \
2.224380380176863e-06 0.7245276185835638 2.224380504108467e-06 0.7263044524160376 2.2243806283948e-06 0.7280754330070212 2.224380754759953e-06 0.7298652243312684 \
2.224380884571694e-06 0.7316925631262517 2.224381008410214e-06 0.7334254795816325 2.2243811411911e-06 0.735272086289578 2.224381242042306e-06 0.7366670415914529 \
2.224381355233975e-06 0.738224777043618 2.224381442019956e-06 0.7394137384482823 2.224381558645253e-06 0.7410021813026957 2.22438164793451e-06 0.7422110784210975 \
2.224381759111394e-06 0.7437075443329063 2.224381888370157e-06 0.7454347509364776 2.224382002229194e-06 0.7469455276109591 2.224382106633406e-06 0.74832188588007 \
2.224382231000437e-06 0.7499498655229884 2.224382378240616e-06 0.7518616907275563 2.224382498520907e-06 0.753411006437983 2.224382614425446e-06 0.7548933175676444 \
2.22438275450129e-06 0.7566706674475765 2.22438289711296e-06 0.7584645678799224 2.224383015067203e-06 0.7599365027959469 2.224383141883712e-06 0.7615071445339606 \
2.224383282766856e-06 0.7632375905494565 2.224383402560353e-06 0.7646969139886852 2.22438354751921e-06 0.7664484133613445 2.224383669077996e-06 0.7679052725436226 \
2.22438378811749e-06 0.7693214142140735 2.224383909748853e-06 0.7707575700077021 2.224384037717831e-06 0.772256936813787 2.224384146933014e-06 0.7735272422640712 \
2.224384271823892e-06 0.774969549136603 2.224384378939953e-06 0.7761978171588899 2.224384512193147e-06 0.7777146071439789 2.224384639296593e-06 0.7791497354387434 \
2.224384761047568e-06 0.7805132846941326 2.224384877632151e-06 0.7818078758210534 2.224384983459753e-06 0.7829735233300771 2.224385122825895e-06 0.7844949153190801 \
2.224385271897694e-06 0.786105286864636 2.224385419626362e-06 0.7876841235632186 2.224385538932239e-06 0.7889471147195867 2.224385672939052e-06 0.7903527806482344 \
2.224385793365226e-06 0.791604423795974 2.224385934910404e-06 0.7930616786923709 2.224386082336416e-06 0.7945638089648995 2.224386206810925e-06 0.7958198087139573 \
2.224386325854918e-06 0.7970105506108808 2.224386437445201e-06 0.7981174590942314 2.22438654267449e-06 0.7991530841216606 2.224386638185594e-06 0.8000862307887144 \
2.224386774247547e-06 0.8014036057482816 2.224386891123681e-06 0.8025237700417888 2.224387010277354e-06 0.8036549841722296 2.224387132589548e-06 0.8048050501807249 \
2.224387255861622e-06 0.8059526272620129 2.224387382358398e-06 0.8071184350969989 2.224387507861062e-06 0.8082633544790385 2.224387638586967e-06 0.8094437311890262 \
2.224387764154938e-06 0.8105658358439867 2.224387893209804e-06 0.8117072367686948 2.224387999065961e-06 0.8126345588578442 2.224388100234836e-06 0.8135133322873783 \
2.224388194854656e-06 0.8143286754242188 2.22438831913574e-06 0.8153900871385379 2.224388408847426e-06 0.816149614585347 2.22438850788495e-06 0.8169816577628611 \
2.224388645662827e-06 0.8181280288377792 2.224388780198677e-06 0.81923501721715 2.224388888604943e-06 0.8201180631035904 2.224389038518447e-06 0.8213254631869725 \
2.224389189097025e-06 0.8225223201378843 2.22438931459218e-06 0.8235077122548546 2.224389458438707e-06 0.8246238332260477 2.224389583021971e-06 0.8255790649890803 \
2.224389731875191e-06 0.8267066458678887 2.224389868023775e-06 0.827725029289517 2.224389993047602e-06 0.8286494160599757 2.224390110754582e-06 0.8295103773055483 \
2.22439025639358e-06 0.8305630309532103 2.224390422774875e-06 0.8317484146982921 2.224390553358564e-06 0.8326660250626342 2.224390726880675e-06 0.8338683097812621 \
2.224390895002577e-06 0.8350147136930499 2.22439106486518e-06 0.8361549927788252 2.224391245766883e-06 0.8373497079260466 2.224391388876165e-06 0.8382806519784776 \
2.224391502965127e-06 0.839013953006387 2.224391633127603e-06 0.8398410866028793 2.224391734972734e-06 0.8404811280669765 2.22439185179894e-06 0.8412075886390841 \
2.22439198869038e-06 0.8420483852080155 2.224392186497604e-06 0.843243620449199 2.22439237812275e-06 0.8443797466267589 2.224392587554618e-06 0.8455974227529048 \
2.2243927695013e-06 0.8466352798309468 2.224392966630154e-06 0.8477391449715804 2.224393139971014e-06 0.8486924050423899 2.224393322979321e-06 0.8496814535024207 \
2.224393494142355e-06 0.8505903669473519 2.22439366877945e-06 0.851501688465695 2.224393844039281e-06 0.8524001683007644 2.22439402018973e-06 0.8532872510191711 \
2.224394210470029e-06 0.8542278331088334 2.22439440106916e-06 0.8551519386507073 2.224394601692395e-06 0.8561055033533737 2.22439479430095e-06 0.8570028516027762 \
2.224395004981641e-06 0.8579644845832216 2.224395233083109e-06 0.8589827023971403 2.224395498871091e-06 0.860139640227508 2.224395797483852e-06 0.8614018215255795 \
2.224396073772491e-06 0.8625348754565382 2.22439635800901e-06 0.8636666213345715 2.22439663221378e-06 0.8647267940813509 2.224396904448638e-06 0.8657495569722869 \
2.22439717465278e-06 0.8667361702337206 2.22439743180839e-06 0.867649441901348 2.224397704388604e-06 0.8685908808535525 2.22439798037489e-06 0.8695169452638583 \
2.224398250477721e-06 0.870397355937691 2.224398550334798e-06 0.8713451925332844 2.224398921362456e-06 0.8724761722512941 2.224399216299767e-06 0.8733433185969293 \
2.224399470589207e-06 0.8740690226522811 2.224399768845991e-06 0.874895168896023 2.224400042455427e-06 0.8756299040683481 2.224400278583913e-06 0.8762466977562872 \
2.224400518929827e-06 0.8768585021646264 2.224400741263492e-06 0.8774104263690854 2.224400935269169e-06 0.8778812671168952 2.224401264991885e-06 0.8786590883967833 \
2.224401420165319e-06 0.8790156160651978 2.224401737941389e-06 0.8797272612331356 2.224401916803031e-06 0.8801171459162566 2.224402259264861e-06 0.8808425821290963 \
2.224402443393021e-06 0.881221400612852 2.224402918270754e-06 0.8821634994206867 2.224403085666965e-06 0.8824839765989225 2.224403551508906e-06 0.8833452998114757 \
2.224403732330958e-06 0.8836679564577563 2.224404226369383e-06 0.8845176198113115 2.224404367718007e-06 0.8847523712107549 2.224404974052072e-06 0.8857188576377059 \
2.224405126121395e-06 0.8859512996759633 2.224405772809558e-06 0.8868983431897121 2.22440590110417e-06 0.8870786909355212 2.224406549221232e-06 0.8879538337624689 \
2.224406679020295e-06 0.8881220828502663 2.224407457223772e-06 0.8890807033877333 2.224407572278734e-06 0.8892148977954012 2.224408427940206e-06 0.8901543051721961 \
2.224408573301076e-06 0.8903040038307473 2.224409559057127e-06 0.8912446482480114 2.224409780162495e-06 0.8914382978987679 2.224410925289423e-06 0.8923659558950503 \
2.224411056506439e-06 0.8924678262926897 2.224412397715013e-06 0.8934599079028542 2.224412549114272e-06 0.8935646301988298 2.224414030551995e-06 0.8944937559627255 \
2.224414269431373e-06 0.8946275407274444 2.224416038746979e-06 0.8955013787854181 2.224416427898191e-06 0.8956696032899972 2.224418821561142e-06 0.8965547188539188 \
2.224419297270139e-06 0.8967039926079825 2.22442336043021e-06 0.8977020505850396 2.224423851854269e-06 0.8977948037134476 2.224432168453822e-06 0.898787348739254 \
2.22443308835295e-06 0.8988506593152591 2.22457657358348e-06 0.8998476076348748 2.224577692016456e-06 0.8998537475785264 2.224782783635955e-06 0.898985773748599 \
2.224783010725457e-06 0.8988224379910277 2.224784620332255e-06 0.8978282360369357 2.224784797740799e-06 0.8977338482811539 2.224801704889099e-06 0.8987315468430059 \
2.224801814328198e-06 0.8987460089186867 2.224817595049444e-06 0.8997418097871094 2.224817891375339e-06 0.8997476966799167 2.225301325027745e-06 0.9007060148833608 \
2.225301454078085e-06 0.9008313386292994 2.22530210422793e-06 0.9016292186224167 2.225302293723661e-06 0.9019133038041363 2.22530279694564e-06 0.9027675859898705 \
2.225302932418299e-06 0.9030208676018907 2.225303332877016e-06 0.9038195223753869 2.225303464814953e-06 0.9040958310886574 2.225303866030017e-06 0.9049509627747726 \
2.225303964290194e-06 0.9051582028152527 2.225304430164004e-06 0.9060587574877488 2.225304591662727e-06 0.9063060456044927 2.22530573567525e-06 0.9055153668657776 \
2.225305880654596e-06 0.9049059606760256 2.225306059207353e-06 0.9039396653125833 2.225306239402631e-06 0.9027054491383806 2.22530638209356e-06 0.9015369228101149 \
2.225306499253164e-06 0.9004524619440171 2.225306588234525e-06 0.8995505656965809 2.225306679878177e-06 0.8985529714258781 2.22530681299011e-06 0.8969831049011855 \
2.225306906711193e-06 0.8957895978311226 2.225306997850002e-06 0.8945634483845346 2.225307111142313e-06 0.8929516940777753 2.225307214251226e-06 0.8913998138690341 \
2.225307310518406e-06 0.8898830246517148 2.225307429655523e-06 0.8879200664089764 2.225307598240772e-06 0.8849885378698126 2.225307760012273e-06 0.8820195265790133 \
2.225307953231332e-06 0.8782956415026882 2.225308138794443e-06 0.8745571577041361 2.225308349060748e-06 0.8701566079887386 2.225308531309789e-06 0.8662213066841463 \
2.225308716173183e-06 0.8621339172744639 2.22530888885833e-06 0.8582419637438897 2.225309074966403e-06 0.8539816046497358 2.225309252782491e-06 0.849858603441091 \
2.225309433499072e-06 0.8456251963850057 2.225309598637331e-06 0.8417258760277182 2.225309763911433e-06 0.837798995916667 2.225309927159096e-06 0.8339004324287677 \
2.225310085749369e-06 0.8300982805770993 2.225310262673771e-06 0.8258418712800655 2.225310459187584e-06 0.8211009660847696 2.225310626744125e-06 0.8170498602679914 \
2.225310793484544e-06 0.8130123908857781 2.225310967908061e-06 0.8087844286215062 2.225311137277684e-06 0.8046757316210446 2.225311305476778e-06 0.8005936994537799 \
2.225311494325046e-06 0.7960093488074458 2.225311685140882e-06 0.7913773844868103 2.225311893523091e-06 0.7863203192056716 2.225312119942597e-06 0.7808277108969495 \
2.225312309142794e-06 0.7762391340290878 2.225312519289483e-06 0.7711455503222944 2.225312668057987e-06 0.7675418410361046 2.225312799050976e-06 0.7643705172588006 \
2.225312936616212e-06 0.7610417440783073 2.225313042367441e-06 0.7584842184275663 2.225313177141075e-06 0.7552262509102785 2.2253132889738e-06 0.7525244432456109 \
2.225313418408964e-06 0.7493992292091655 2.225313573597688e-06 0.7456545577979357 2.225313685233441e-06 0.7429626190147979 2.225313844808055e-06 0.7391166470929011 \
2.225314020129688e-06 0.7348935218456193 2.225314232505151e-06 0.7297828120356423 2.225314425387679e-06 0.7251458607116523 2.225314582088971e-06 0.7213823872711312 \
2.225314768763662e-06 0.716903961299824 2.225314957650011e-06 0.7123775767926828 2.225315148534203e-06 0.70780884692282 2.225315335282138e-06 0.7033444557767304 \
2.225315518366954e-06 0.698972331957095 2.225315655685935e-06 0.6956951921588121 2.225315808928892e-06 0.6920418367118417 2.225316004057543e-06 0.6873949992893974 \
2.225316161351872e-06 0.6836535194673684 2.225316320746467e-06 0.6798660670227984 2.22531651649026e-06 0.6752219404489795 2.225316708689394e-06 0.6706682621108646 \
2.225316943641022e-06 0.6651105611269369 2.22531713111727e-06 0.6606839627962382 2.225317368354404e-06 0.6550894036851447 2.225317557534366e-06 0.6506361170423679 \
2.225317738150178e-06 0.6463915264929231 2.225317901844741e-06 0.6425504277539856 2.22531804639615e-06 0.6391628119244788 2.22531818686792e-06 0.6358764726647652 \
2.225318313968707e-06 0.6329064225879303 2.225318446276183e-06 0.6298198307262635 2.22531857286323e-06 0.626870110582017 2.225318703443497e-06 0.62383130535404 \
2.225318832712896e-06 0.6208285625908692 2.225318971819793e-06 0.6176004736356133 2.225319120330103e-06 0.6141606483517721 2.225319309878658e-06 0.6097777958748198 \
2.225319455581914e-06 0.6064170107178907 2.225319690632478e-06 0.601007464699683 2.225319873631749e-06 0.5968099615921 2.225320097973422e-06 0.5916778694808832 \
2.225320269146672e-06 0.5877753019413697 2.225320401480491e-06 0.5847634284691802 2.22532053327703e-06 0.5817721407249107 2.225320639820933e-06 0.5793579518205488 \
2.225320735711292e-06 0.5771868999037388 2.225320828211542e-06 0.5750974572268882 2.225320920638905e-06 0.5730134868920421 2.225320993067212e-06 0.5713818265150021 \
2.225321048796317e-06 0.5701269325864891 2.225321109905404e-06 0.5687522410723198 2.22532120667008e-06 0.5665806864277688 2.225321268161595e-06 0.5652027770813386 \
2.225321327214216e-06 0.5638802801505602 2.225321402840882e-06 0.5621878686488651 2.22532146986366e-06 0.5606896577364279 2.225321543460769e-06 0.5590483558003441 \
2.225321611066772e-06 0.5575429304381756 2.225321727135829e-06 0.5549610936632026 2.225321827342234e-06 0.5527359403974305 2.225321939349424e-06 0.5502565947066531 \
2.225322033841475e-06 0.5481686943853854 2.225322154996172e-06 0.5454955387196141 2.225322255183939e-06 0.5432910220514219 2.225322371174451e-06 0.5407443765731218 \
2.225322478878288e-06 0.5383833065966291 2.225322588456977e-06 0.5359861028148916 2.22532270057842e-06 0.5335400310751951 2.225322827515605e-06 0.5307765704644959 \
2.225322949665123e-06 0.5281221248815906 2.225323089426038e-06 0.525095489155881 2.225323226564154e-06 0.522132778766487 2.225323376529244e-06 0.5189020692106626 \
2.225323535302247e-06 0.5154923220538846 2.225323709327904e-06 0.511765695450105 2.225323896158028e-06 0.5077823379664483 2.225324101125993e-06 0.5034264211640872 \
2.225324323834942e-06 0.4987133299464507 2.225324576739139e-06 0.4933874474923696 2.225324811693046e-06 0.4884604410272814 2.225325107961308e-06 0.4822828691822955 \
2.225325397751266e-06 0.4762763831984252 2.225325704087084e-06 0.4699660956099861 2.225326016405612e-06 0.4635767846525711 2.225326354971068e-06 0.4566963260653934 \
2.225326678082485e-06 0.4501741115777416 2.225327016477787e-06 0.4433881855507311 2.225327340309053e-06 0.4369378830387565 2.225327664703474e-06 0.4305204627449936 \
2.22532800763776e-06 0.4237851826852676 2.225328346918578e-06 0.4171698123421442 2.225328686393212e-06 0.4105997181257849 2.225329129505058e-06 0.4020958655332711 \
2.225329491573227e-06 0.3952155038183801 2.225329812124964e-06 0.3891775711374149 2.225330199059534e-06 0.3819561902961204 2.225330526929795e-06 0.3758957719299574 \
2.225330812088851e-06 0.3706704968427373 2.225331130457646e-06 0.3648820026298218 2.225331413288573e-06 0.3597820188690578 2.225331641977337e-06 0.3556924369094372 \
2.225331859870141e-06 0.3518226517641353 2.225332055119486e-06 0.3483769517668343 2.225332262027585e-06 0.344751588202948 2.225332476824342e-06 0.3410137651016431 \
2.225332729050892e-06 0.3366564674340092 2.225332971046205e-06 0.3325077909124976 2.225333201898484e-06 0.3285822460490526 2.225333416746675e-06 0.3249550452085373 \
2.225333637103364e-06 0.3212604562488142 2.225333838674264e-06 0.3179050685021769 2.22533404175821e-06 0.3145531374773136 2.225334239655597e-06 0.3113121771742085 \
2.225334426754836e-06 0.3082694484595072 2.225334620655179e-06 0.3051385396431291 2.225334825703514e-06 0.3018527636900292 2.225335005938266e-06 0.2989872106339772 \
2.225335241836277e-06 0.2952669081535775 2.225335443123827e-06 0.2921198200609627 2.225335644514631e-06 0.2889965001417216 2.225335869163794e-06 0.2855437159941698 \
2.225336034543768e-06 0.2830223598911593 2.225336212348105e-06 0.280330186126118 2.225336396004319e-06 0.277570343839212 2.225336581246076e-06 0.2748090658167894 \
2.225336759391454e-06 0.2721781298892599 2.225336932983517e-06 0.2696316866093095 2.22533709334837e-06 0.267306655456324 2.225337214459552e-06 0.2655585721882695 \
2.22533736765434e-06 0.2633570345323199 2.225337494985789e-06 0.2615475749425888 2.225337598313628e-06 0.2600830587034867 2.225337715638424e-06 0.2584225376281647 \
2.225337833445381e-06 0.2567591557214636 2.225337957409147e-06 0.2550199666844239 2.225338074393314e-06 0.2533821414201824 2.225338205189442e-06 0.2515535495016885 \
2.225338322399552e-06 0.2499173892700276 2.225338475652677e-06 0.2477853623028658 2.225338611183197e-06 0.2459029165157107 2.225338742864405e-06 0.244074199323236 \
2.225338899457317e-06 0.2419017673596028 2.225339024653874e-06 0.2401755227310949 2.225339160371501e-06 0.2383060149301216 2.225339292798663e-06 0.2364844144139329 \
2.225339412772324e-06 0.2348355337769661 2.225339575820161e-06 0.232606585912384 2.225339714627252e-06 0.230713852557009 2.225339853100972e-06 0.2288300961780371 \
2.225339958645721e-06 0.2273962817971701 2.225340087007401e-06 0.2256537837490921 2.225340191135024e-06 0.2242444877898851 2.225340291651026e-06 0.222886569499566 \
2.225340366695402e-06 0.2218745444235658 2.225340444028457e-06 0.2208349692306942 2.225340518791636e-06 0.2198305887827458 2.225340596755314e-06 0.218785487158918 \
2.225340651621824e-06 0.2180503923904892 2.225340708118599e-06 0.2172938400168352 2.225340751572119e-06 0.2167123195211523 2.225340791613165e-06 0.2161767335077376 \
2.225340830852113e-06 0.2156521099473339 2.22534087172635e-06 0.2151058606261434 2.22534092587884e-06 0.2143825797409383 2.225340964295972e-06 0.2138698309421548 \
2.225341003584678e-06 0.2133480458229882 2.225341065121386e-06 0.2125332203444249 2.225341127098915e-06 0.2117131287842428 2.225341183575664e-06 0.2109664019951111 \
2.225341248207254e-06 0.2101124842966758 2.225341343715876e-06 0.2088522205996687 2.225341431031607e-06 0.207701294711168 2.225341527641208e-06 0.2064291756790013 \
2.225341624870762e-06 0.2051510266126755 2.225341725717823e-06 0.2038307158897115 2.225341826317594e-06 0.2025192706911573 2.225341922808891e-06 0.2012627769767186 \
2.225342024991065e-06 0.1999338657614989 2.225342128630721e-06 0.1985898465970496 2.225342238404734e-06 0.1971698847140261 2.225342347579759e-06 0.1957617939809042 \
2.225342467677851e-06 0.1942174441246506 2.225342577697376e-06 0.1928086337505992 2.225342685809285e-06 0.1914295694688549 2.225342808837984e-06 0.1898652723262108 \
2.225342898948553e-06 0.1887234630454603 2.225343006314044e-06 0.1873671680421656 2.225343083125352e-06 0.1864004060894758 2.22534316657062e-06 0.1853535952511875 \
2.225343256102432e-06 0.1842338297700716 2.225343340667898e-06 0.1831790839553313 2.225343420384038e-06 0.1821880912968773 2.225343521709242e-06 0.1809331989518758 \
2.225343630056471e-06 0.1795959386230563 2.225343726532169e-06 0.1784102562612937 2.225343851909986e-06 0.1768766438339704 2.225343984693456e-06 0.1752616821119887 \
2.225344102464279e-06 0.1738362801839788 2.225344248115856e-06 0.1720835746408261 2.225344358713008e-06 0.1707596463148658 2.225344500843447e-06 0.1690680578777541 \
2.22534461655307e-06 0.1676985735146403 2.225344722027083e-06 0.166456424915798 2.225344816543742e-06 0.1653485352650968 2.225344912181114e-06 0.1642320043563913 \
2.225345009252958e-06 0.1631032360400927 2.225345108304212e-06 0.161956192050434 2.225345202227769e-06 0.1608730077890209 2.225345287503444e-06 0.1598934595213354 \
2.225345387883236e-06 0.1587475631033795 2.225345472186073e-06 0.1577906478848196 2.225345574585582e-06 0.1566342854655733 2.225345651979844e-06 0.1557646215197878 \
2.225345744324758e-06 0.154731814591042 2.22534581457623e-06 0.1539498814072817 2.225345910750659e-06 0.1528844393027091 2.225345987575322e-06 0.152038051282755 \
2.225346066345474e-06 0.1511758489440315 2.225346140238394e-06 0.150370438825067 2.225346207936138e-06 0.1496353997608715 2.225346304000026e-06 0.1485973848112393 \
2.225346373572453e-06 0.1478489919002561 2.225346457461625e-06 0.1469503328160803 2.225346518593461e-06 0.146298213254472 2.225346590861543e-06 0.1455309799806117 \
2.225346663300106e-06 0.1447677488542132 2.225346744281147e-06 0.1439178685120187 2.225346810355616e-06 0.1432275520600639 2.225346887756113e-06 0.1424219220725307 \
2.22534697713157e-06 0.1414956876531561 2.225347047992216e-06 0.1407644282175171 2.225347146879283e-06 0.1397487730030469 2.225347224198192e-06 0.1389620820751095 \
2.225347306243418e-06 0.1381330876879582 2.22534739435453e-06 0.1372467208126059 2.225347461981677e-06 0.1365690714953818 2.225347542278859e-06 0.1357674830239305 \
2.225347617062888e-06 0.1350239185327315 2.225347685064065e-06 0.1343502586094245 2.225347731746974e-06 0.1338891847862563 2.225347820998567e-06 0.1330118383700247 \
2.225347859221617e-06 0.1326395291833771 2.225347928213527e-06 0.1319690872918072 2.225347980961596e-06 0.1314578750898332 2.225348063954378e-06 0.1306559489775353 \
2.225348104132828e-06 0.1302688434457458 2.225348196650202e-06 0.1293805059784019 2.22534823536857e-06 0.1290098403727171 2.225348309129285e-06 0.1283055160094505 \
2.225348370757286e-06 0.1277188748199021 2.225348442784976e-06 0.1270353589407805 2.225348510952008e-06 0.1263909833196726 2.225348585574169e-06 0.1256908956540175 \
2.225348667426635e-06 0.1249253613889138 2.225348750880797e-06 0.124147338931438 2.225348823832511e-06 0.1234692772477456 2.225348896559441e-06 0.122795332839617 \
2.225348956549435e-06 0.1222410931008323 2.225349042917447e-06 0.121445549533078 2.225349103886164e-06 0.1208856452315438 2.225349162271955e-06 0.1203507897957366 \
2.22534922790662e-06 0.119751336354628 2.225349287260861e-06 0.1192111367930785 2.225349355292642e-06 0.1185941868697126 2.225349452587012e-06 0.11771710490035 \
2.225349531078992e-06 0.1170124163111649 2.225349621315123e-06 0.1162055395685231 2.225349717161808e-06 0.1153523005684616 2.225349792119504e-06 0.1146878351828532 \
2.225349896478921e-06 0.1137670532163148 2.225349983267518e-06 0.1130053589403202 2.225350092924934e-06 0.1120476726212376 2.225350174478996e-06 0.1113387926087848 \
2.225350270092629e-06 0.1105114393564785 2.225350346804822e-06 0.10985058581598 2.225350441723287e-06 0.1090364400125625 2.225350517546392e-06 0.1083889268999046 \
2.225350595246049e-06 0.1077282965354292 2.2253506775775e-06 0.1070311517075373 2.225350737142763e-06 0.1065286079538068 2.225350800900501e-06 0.1059924133642201 \
2.225350861995109e-06 0.1054803128126646 2.225350957858847e-06 0.1046801683739134 2.225351002721941e-06 0.1043071445723913 2.225351085962687e-06 0.1036173314376927 \
2.225351135082509e-06 0.1032117000904133 2.225351244131271e-06 0.1023149933518279 2.225351288967353e-06 0.1019479364619093 2.225351379228585e-06 0.1012117400678687 \
2.225351420105203e-06 0.1008795969612472 2.225351490563617e-06 0.1003088525914566 2.225351576851038e-06 0.09961307626065434 2.225351668628597e-06 0.09887705578174606 \
2.22535173815669e-06 0.09832225024344161 2.225351816683849e-06 0.09769854072774181 2.225351907412525e-06 0.09698178745350861 2.225351983228664e-06 0.09638605854785212 \
2.225352065241407e-06 0.09574500473888557 2.225352146994443e-06 0.09510943278387665 2.225352237502267e-06 0.09440967388330095 2.225352327061564e-06 0.09372126988887708 \
2.225352412671398e-06 0.09306698857649189 2.225352505450896e-06 0.09236212353634379 2.225352586338857e-06 0.0917510971760913 2.225352687467827e-06 0.09099177263830999 \
2.225352767961352e-06 0.09039108594384238 2.225352852204218e-06 0.08976589684797046 2.225352926049265e-06 0.08922077348043934 2.225353002898743e-06 0.08865632925481931 \
2.225353091039112e-06 0.08801255002475737 2.225353171103482e-06 0.08743108261130086 2.225353264139672e-06 0.08675939571108145 2.225353382140385e-06 0.08591369538214398 \
2.225353524513612e-06 0.08490278100234279 2.225353668761962e-06 0.08388867104764453 2.225353811089671e-06 0.08289807427203813 2.225353960667414e-06 0.08186746790234835 \
2.22535409698116e-06 0.08093761126893445 2.225354239101592e-06 0.0799778356000513 2.225354373655019e-06 0.07907840240745091 2.225354514007729e-06 0.07814980287393705 \
2.225354661689802e-06 0.0771833418413561 2.225354811805299e-06 0.07621180464723754 2.225354976525776e-06 0.07515824360926991 2.225355140155128e-06 0.07412455432658185 \
2.225355314933688e-06 0.07303438636984133 2.225355502186304e-06 0.07188220095900363 2.225355712231308e-06 0.07060976590783831 2.225355930441531e-06 0.06930979572898451 \
2.225356163898619e-06 0.06794333957253913 2.225356418744638e-06 0.06648001693367038 2.225356711839195e-06 0.06483321328442151 2.225357014178957e-06 0.06317411115207273 \
2.225357328765832e-06 0.06148945259513613 2.225357725026526e-06 0.05942677493938087 2.225358058743672e-06 0.05774249301432461 2.225358466054501e-06 0.05574994498853819 \
2.22535879393926e-06 0.05419380357502902 2.225359150629899e-06 0.05254809000207299 2.22535946386806e-06 0.05114243792209583 2.225359766835193e-06 0.04981740498512215 \
2.225360064375718e-06 0.04854875663330436 2.225360343155274e-06 0.04739109061078805 2.225360626155169e-06 0.04624570307560639 2.225360887895477e-06 0.04521055793698023 \
2.22536116713437e-06 0.04413130357485813 2.22536143924029e-06 0.0431040186124033 2.225361746607047e-06 0.04197194005652995 2.225361968409948e-06 0.04117329707315532 \
2.225362274870428e-06 0.04009446155587663 2.225362501059881e-06 0.03931650950691581 2.225362739977206e-06 0.03851359500741255 2.225362964401039e-06 0.03777663690506906 \
2.22536316666332e-06 0.03712468825868943 2.225363367705949e-06 0.03648814235703791 2.225363719479983e-06 0.03540095449820539 2.225363969725821e-06 0.03464776841732944 \
2.2253642160441e-06 0.03392252499723709 2.225364497376965e-06 0.03311308780599518 2.22536474046795e-06 0.03242954897046491 2.2253649759417e-06 0.03178112583711486 \
2.225365217601206e-06 0.03113119522156456 2.225365454483483e-06 0.03050988948014832 2.225365685016041e-06 0.02991733361391674 2.225365898984568e-06 0.02937801894285819 \
2.225366104927115e-06 0.02886851641492237 2.225366497651603e-06 0.02792196059063811 2.225366685729283e-06 0.02747992420741849 2.225367061168249e-06 0.02661861215736662 \
2.225367236042477e-06 0.02622659266649364 2.225367659365491e-06 0.02530049759795254 2.225367780614876e-06 0.02504150687334681 2.225368221176528e-06 0.02412433837770948 \
2.225368363674647e-06 0.02383402682615681 2.225368695728157e-06 0.02316883068419595 2.225368878693682e-06 0.02280879143785283 2.225369267997886e-06 0.02205689891561978 \
2.225369436343594e-06 0.02173705378531499 2.225369908457993e-06 0.02085107653961301 2.225370048202727e-06 0.0205916297664938 2.225370543782804e-06 0.01969297428531048 \
2.225370671008237e-06 0.01946923320191776 2.225371238917342e-06 0.01851512288677271 2.22537140317129e-06 0.0182513999453204 2.225372013043028e-06 0.0173209960017622 \
2.225372172728257e-06 0.01708922829277545 2.225372699639798e-06 0.01635462467776483 2.225372904157091e-06 0.01608193551804103 2.225373627634478e-06 0.01515939662837778 \
2.22537379307661e-06 0.01495683325581705 2.225374539636356e-06 0.01408081084911163 2.225374672939569e-06 0.01393008075245666 2.225375533124155e-06 0.01299799962960837 \
2.22537566920557e-06 0.01285670227674402 2.225376609799459e-06 0.01192267652923807 2.225376773572533e-06 0.01176632439256516 2.225377774751464e-06 0.01084959205883911 \
2.225377912229187e-06 0.01072929995296418 2.225379082926798e-06 0.009787962024485789 2.225379175323166e-06 0.009718668544398181 2.225380593399014e-06 0.008725931027897449 \
2.225380680375162e-06 0.00866912727384293 2.225382221370793e-06 0.00770199130002063 2.225382330686806e-06 0.007633428668288294 2.225383973934629e-06 0.006673746291950173 \
2.225384106791908e-06 0.006603544020797993 2.225386201172206e-06 0.005605323336654431 2.225386409576941e-06 0.00551468736035817 2.225388763913366e-06 0.004577307911602986 \
2.225389237472123e-06 0.004407121484391641 2.225392122908979e-06 0.003492041675788492 2.225392652573326e-06 0.00334538389506189 2.225396860800552e-06 0.00237996320858989 \
2.225397374234803e-06 0.002283557532494709 2.225403133485495e-06 0.001325291758975802 2.225403368066713e-06 0.001279502680325907 2.225418035894088e-06 0.0002809017338477542 \
2.22541814896418e-06 0.0002788534805396912 2.22805516904393e-06 -0.0006849217749926401 2.228055335205606e-06 -0.0009443270389602415 2.228055814074993e-06 -0.001850320037528519 \
2.22805590679462e-06 -0.002050462221988249 2.228056272019697e-06 -0.002913187630468476 2.228056363676813e-06 -0.00314709230904735 2.228056729783165e-06 -0.004133001189868674 \
2.22805683993029e-06 -0.004442309109773816 2.228057150668543e-06 -0.005311341427314526 2.228057252407188e-06 -0.005583925258601597 2.228057616111313e-06 -0.00638370916272213 \
2.228057780957636e-06 -0.006585924750287024 2.228058360754956e-06 -0.005792290386912202 2.228058535589415e-06 -0.004916934050781314 2.228058652279015e-06 -0.00413641027497409 \
2.228058778708707e-06 -0.00310656561120747 2.22805888073091e-06 -0.002137079422087956 2.228059000577393e-06 -0.0008406209844352954 2.228059091214629e-06 0.0002489246187367611 \
2.228059189634679e-06 0.001536790859923857 2.228059289358323e-06 0.002948496343048522 2.228059456842332e-06 0.005545701385567424 2.228059675420934e-06 0.009327395936412004 \
2.228059861491256e-06 0.0128572688386996 2.228060082873864e-06 0.01737012273305725 2.228060243533997e-06 0.02082840415615294 2.228060406999647e-06 0.02447866954313523 \
2.228060557635164e-06 0.02794359528291388 2.228060706690917e-06 0.03145289236167962 2.228060856153671e-06 0.03504014479003619 2.228061010184683e-06 0.03879791952579481 \
2.228061172300943e-06 0.04280891157365373 2.228061338330408e-06 0.04696567134311741 2.228061514283228e-06 0.05141478668696391 2.228061694953865e-06 0.05602187592747932 \
2.228061886774811e-06 0.06094655248807559 2.228062093880316e-06 0.06629309753158302 2.228062315452046e-06 0.07203901748582854 2.228062550186215e-06 0.07814662931008168 \
2.228062801725783e-06 0.08470684589377442 2.228063077167849e-06 0.09190125212984442 2.228063377363668e-06 0.09974607960254324 2.228063708295878e-06 0.108390578238945 \
2.228064083962612e-06 0.1181923833971668 2.22806448154548e-06 0.1285487285136021 2.228064948370082e-06 0.1406786766767902 2.228065491362617e-06 0.1547396794802719 \
2.22806612478764e-06 0.1710742296429572 2.22806682072769e-06 0.1889259607126788 2.2280676362848e-06 0.2097135943149445 2.228068546312904e-06 0.2327316641523666 \
2.228069339569124e-06 0.2526372689279454 2.2280700450442e-06 0.2702038474981599 2.228070663988467e-06 0.2855008995781749 2.228071231094408e-06 0.2994177966724069 \
2.228071754174414e-06 0.3121574438576628 2.228072253153207e-06 0.3242197130846058 2.228072737193214e-06 0.3358335658028451 2.228073192420047e-06 0.3466679577370423 \
2.228073666932009e-06 0.3578644504627745 2.228074106840717e-06 0.368158604789619 2.228074592685345e-06 0.3794271463718566 2.228075124288118e-06 0.3916316501999784 \
2.228075626951416e-06 0.4030538969706937 2.228076056023669e-06 0.4127111343288326 2.228076547040338e-06 0.4236561147984291 2.228077048470418e-06 0.434714731975362 \
2.228077395015009e-06 0.442288187401736 2.228077750424385e-06 0.4500000616404133 2.228078177652114e-06 0.4592019891792938 2.228078569851637e-06 0.4675774400278049 \
2.228078870233395e-06 0.4739448723400065 2.228079212045155e-06 0.4811381049525967 2.228079555484969e-06 0.4883107756756314 2.228079816220095e-06 0.4937186470393492 \
2.228080058250049e-06 0.4987071765458648 2.228080324195291e-06 0.5041573145298286 2.228080581464587e-06 0.509394255416739 2.22808077158369e-06 0.5132422368582924 \
2.228080985109851e-06 0.5175451019736222 2.228081124800157e-06 0.5203466115392713 2.228081271000449e-06 0.5232668091041763 2.22808148498835e-06 0.5275186200231483 \
2.228081693004609e-06 0.5316389396023125 2.228081885465879e-06 0.5354321131715788 2.22808207058211e-06 0.5390651926504321 2.228082244955557e-06 0.5424725330931349 \
2.228082549497633e-06 0.5484058192982523 2.228082810056515e-06 0.5534602958276967 2.228083111487544e-06 0.5592859190791987 2.228083365805138e-06 0.5641865993769294 \
2.228083658661327e-06 0.5698153316805189 2.22808391787448e-06 0.5747800306938655 2.228084188950812e-06 0.579963273174682 2.228084430794571e-06 0.5845680738798381 \
2.228084688299729e-06 0.5894577538325241 2.228084915043604e-06 0.5937419314630586 2.228085152044424e-06 0.5982006324572362 2.228085362230986e-06 0.6021379329905048 \
2.22808557499152e-06 0.6061060319396779 2.228085827870286e-06 0.6107954169450593 2.228086031533554e-06 0.6145509252949414 2.228086222250936e-06 0.6180531102377972 \
2.228086409587374e-06 0.6214768531423983 2.228086598465652e-06 0.6249070011644339 2.228086806665447e-06 0.6286671070650327 2.228087050997562e-06 0.6330499453121026 \
2.228087250564095e-06 0.6366057789565548 2.228087454709836e-06 0.6402215701419991 2.22808763934909e-06 0.643474671963314 2.228087908884781e-06 0.6481901084955864 \
2.228088136591637e-06 0.652149230294136 2.228088324263375e-06 0.6553888277830079 2.22808850516352e-06 0.6584949378977958 2.228088664704602e-06 0.661221510907812 \
2.228088835167002e-06 0.6641177016088209 2.228088986918443e-06 0.6666817235716488 2.228089124561455e-06 0.6689905419339194 2.228089273556318e-06 0.6714784915997724 \
2.228089401298182e-06 0.6736028790357499 2.228089544284695e-06 0.675968899142866 2.228089666067751e-06 0.6779749688503388 2.228089802351161e-06 0.6802121872853304 \
2.228089922180062e-06 0.682172759947357 2.228090068775623e-06 0.6845626218370968 2.228090187248565e-06 0.6864845934661837 2.228090283181926e-06 0.6880368302455475 \
2.228090375701511e-06 0.6895284278106264 2.228090480762022e-06 0.6912169000724893 2.228090578843908e-06 0.6927871490736753 2.228090715959225e-06 0.6949707622226827 \
2.228090835157868e-06 0.6968607547931925 2.228090945097838e-06 0.6985951241089645 2.228091082597082e-06 0.7007503743809057 2.228091214026983e-06 0.7027960765825516 \
2.228091346256499e-06 0.7048392108129343 2.228091459433897e-06 0.7065756917706891 2.228091613866751e-06 0.708927873976708 2.228091744646745e-06 0.7109048231498766 \
2.228091867315455e-06 0.7127465601965561 2.228091973583711e-06 0.7143329262278221 2.228092095963735e-06 0.7161490373358268 2.228092197817232e-06 0.7176517022913665 \
2.228092331955131e-06 0.7196190116794019 2.228092452648172e-06 0.7213783352064487 2.22809257178997e-06 0.7231049829175343 2.228092696807984e-06 0.7249059312823601 \
2.22809282664779e-06 0.7267645120560844 2.228092946459962e-06 0.7284691779696002 2.228093075453213e-06 0.730293808329565 2.228093207560277e-06 0.7321507998840678 \
2.228093325866095e-06 0.7338038328985433 2.228093469126786e-06 0.7357927618453034 2.228093571581473e-06 0.7372070005703254 2.228093667788358e-06 0.7385290937783453 \
2.22809377280598e-06 0.7399656334130889 2.228093883577511e-06 0.7414708009413548 2.228093985256052e-06 0.7428439364018735 2.228094088217506e-06 0.7442258341871242 \
2.228094205143661e-06 0.7457850038572696 2.228094333903936e-06 0.747489965072781 2.228094435062908e-06 0.7488201182152049 2.228094583931952e-06 0.7507626302114226 \
2.228094731611489e-06 0.75267249971878 2.228094850976855e-06 0.7542038164026367 2.228094997460699e-06 0.7560679527984652 2.22809512063619e-06 0.7576223900169708 \
2.228095261439865e-06 0.7593848990234215 2.228095398032531e-06 0.7610800595258669 2.228095520190381e-06 0.7625841275516777 2.228095632846779e-06 0.7639610711610054 \
2.22809577457292e-06 0.7656796138775311 2.22809590073942e-06 0.767196844592689 2.228096016156724e-06 0.768574452686535 2.228096146464904e-06 0.7701179991486644 \
2.228096262177572e-06 0.7714782821591826 2.22809638500186e-06 0.7729116492687436 2.228096502846128e-06 0.7742769236963016 2.228096608476118e-06 0.7754922619072108 \
2.228096723849553e-06 0.7768108638983861 2.228096829112716e-06 0.7780056027231214 2.228096940062529e-06 0.7792565499870431 2.228097026467031e-06 0.7802246528436213 \
2.22809713050085e-06 0.7813823422463088 2.228097244396594e-06 0.7826398494046257 2.228097347430013e-06 0.7837684443710583 2.228097455512714e-06 0.7849432998269023 \
2.228097563764369e-06 0.7861107422109641 2.228097699181616e-06 0.7875582910536544 2.228097811855724e-06 0.7887521292973186 2.228097936279784e-06 0.7900592323105087 \
2.228098054252648e-06 0.7912877959129118 2.228098198720603e-06 0.7927781272271259 2.228098316389742e-06 0.7939806363584788 2.228098452269581e-06 0.7953567374150946 \
2.228098587013954e-06 0.7967081403609936 2.228098698084933e-06 0.7978123285366109 2.228098797974273e-06 0.7987978371087655 2.22809889965423e-06 0.7997937268659365 \
2.228099032867897e-06 0.8010867894381996 2.228099151240716e-06 0.8022243628210853 2.22809927278179e-06 0.8033812848148773 2.228099392145442e-06 0.8045065422543012 \
2.228099513276819e-06 0.80563739819571 2.228099644976236e-06 0.8068544426691319 2.228099767984513e-06 0.8079795872959963 2.22809989582812e-06 0.8091371804586788 \
2.228100026734639e-06 0.8103101881504271 2.228100150327798e-06 0.8114062915203997 2.228100257500303e-06 0.8123479140825919 2.228100364929502e-06 0.8132835730547656 \
2.228100447598621e-06 0.8139979974227743 2.228100565310381e-06 0.8150069815425507 2.228100655915985e-06 0.8157770472204025 2.228100786569431e-06 0.8168774959419571 \
2.228100930959301e-06 0.8180800468042847 2.228101064133715e-06 0.8191766687328477 2.228101174025106e-06 0.8200725423139092 2.228101317623991e-06 0.8212302325252553 \
2.228101471014683e-06 0.8224508494407716 2.228101599092908e-06 0.8234574467428303 2.228101738880276e-06 0.8245431382086058 2.228101865129839e-06 0.8255122018650548 \
2.228102019728391e-06 0.8266841987320058 2.228102151939368e-06 0.8276738265999063 2.22810227816615e-06 0.8286078934539939 2.228102395913874e-06 0.8294698388787296 \
2.228102544986667e-06 0.8305480062617677 2.228102712318221e-06 0.8317406852496945 2.228102845539496e-06 0.8326770812274722 2.228103018320819e-06 0.8338744310092966 \
2.228103186826193e-06 0.8350236380668206 2.228103356205492e-06 0.8361608866600232 2.228103537840761e-06 0.8373606451951652 2.228103680174082e-06 0.8382866867625347 \
2.228103794011069e-06 0.8390185116470331 2.228103925192579e-06 0.8398522525089582 2.228104026724794e-06 0.8404903982372576 2.228104143009054e-06 0.8412135669902132 \
2.228104277643808e-06 0.8420406924792603 2.228104474666644e-06 0.8432316292878405 2.228104664772186e-06 0.8443592803112207 2.228104874895498e-06 0.8455816023960827 \
2.228105055213604e-06 0.8466107566581813 2.228105252676705e-06 0.8477171937062282 2.22810542674582e-06 0.8486750118570332 2.22810560906524e-06 0.8496608982186138 \
2.228105780480376e-06 0.8505716849290491 2.228105954593653e-06 0.8514808063694008 2.228106130324621e-06 0.8523822271368225 2.228106306436321e-06 0.8532696099472232 \
2.228106496054173e-06 0.8542074684498208 2.22810668683567e-06 0.8551330189126392 2.228106888431747e-06 0.8560917259710515 2.228107081166005e-06 0.856990088884472 \
2.228107290037825e-06 0.8579439907476532 2.228107520740263e-06 0.8589743400177088 2.228107785183227e-06 0.8601259267840322 2.228108084005915e-06 0.8613896125360476 \
2.228108363960216e-06 0.8625380186322354 2.228108648086081e-06 0.8636694076724545 2.228108922855057e-06 0.8647317823994775 2.228109194712217e-06 0.8657531067718063 \
2.228109465089334e-06 0.8667403371654003 2.228109722167855e-06 0.8676533221001362 2.228109994792686e-06 0.868594905839151 2.228110270759835e-06 0.8695208838709013 \
2.228110540864093e-06 0.8704012674911344 2.228110840740104e-06 0.8713491368600049 2.228111211801162e-06 0.8724801680184872 2.22811150674079e-06 0.8733472453740196 \
2.228111761036548e-06 0.8740729094291386 2.228112059297473e-06 0.8748989982677786 2.228112332904015e-06 0.8756336613858092 2.228112569029958e-06 0.876250392688866 \
2.228112809374055e-06 0.8768621356511911 2.228113031706182e-06 0.8774140071409635 2.228113225712247e-06 0.8778848105679672 2.228113555434997e-06 0.8786625669521169 \
2.228113710608525e-06 0.8790190643519731 2.228114028387606e-06 0.879730644938159 2.228114207248864e-06 0.8801204696806418 2.228114549710761e-06 0.8808457867651537 \
2.228114733837363e-06 0.8812245477320809 2.228115208711942e-06 0.8821665346129511 2.228115376108352e-06 0.8824869809105039 2.228115841951854e-06 0.883348261932613 \
2.228116022773548e-06 0.8836708855253055 2.22811651681265e-06 0.8845204537290557 2.228116658162059e-06 0.8847551796839913 2.228117264500122e-06 0.8857215808967022 \
2.228117416569336e-06 0.8859539944113424 2.228118063256356e-06 0.8869009218298172 2.228118191551238e-06 0.8870812460539503 2.228118839667745e-06 0.8879562712787433 \
2.228118969467641e-06 0.8881245027440973 2.22811974767834e-06 0.8890830197250962 2.228119862725472e-06 0.8892171882189283 2.228120718396314e-06 0.8901564861234483 \
2.228120863744077e-06 0.8903061494816453 2.228121849499648e-06 0.8912466483555094 2.228122070607711e-06 0.8914402669210102 2.228123215727714e-06 0.892367747196105 \
2.228123346939158e-06 0.8924695935232408 2.228124688211624e-06 0.8934615053489913 2.2281248396029e-06 0.8935661991834861 2.22812632105512e-06 0.8944951400107031 \
2.228126559934816e-06 0.8946288932334222 2.228128329356654e-06 0.895502508848118 2.228128718477945e-06 0.895670668133377 2.228131112210654e-06 0.8965556062201232 \
2.228131587750593e-06 0.8967047758494365 2.228135650819817e-06 0.8977025964496719 2.228136142295653e-06 0.8977953148389237 2.228144458892796e-06 0.8987880790885289 \
2.228145378794248e-06 0.8988514070442593 2.228299242370168e-06 0.8998485708192639 2.228302885496457e-06 0.8998628537402877 2.228529614276671e-06 0.8989664306490068 \
2.228529844616583e-06 0.8988008565867064 2.22853145953688e-06 0.897804750401333 2.228531637269166e-06 0.8977103535805105 2.228548403669272e-06 0.8986978311584225 \
2.228548539768402e-06 0.8987160394686986 2.228563710608672e-06 0.8997133888183054 2.228563987713508e-06 0.899719468756186 2.229048028906422e-06 0.9005852143835333 \
2.229048202241039e-06 0.9007408621809421 2.229048862730638e-06 0.9015135064485434 2.22904902879582e-06 0.9017527716291757 2.229049555130528e-06 0.9026184054967997 \
2.229049746244447e-06 0.9029704910143604 2.229050110465499e-06 0.9036902342402512 2.229050289664921e-06 0.9040628043424317 2.229050651551594e-06 0.9048333795345931 \
2.229050846661164e-06 0.9052442844328937 2.229051379059525e-06 0.9062266394381637 2.229051561413164e-06 0.9064623886473868 2.229052553393556e-06 0.905594670761786 \
2.229052714934123e-06 0.9049318860608667 2.229052882926575e-06 0.9040378649110347 2.229053042758061e-06 0.9029782421366458 2.229053180254799e-06 0.9018984154159868 \
2.229053313162111e-06 0.9007052793196499 2.229053439587578e-06 0.8994328447569792 2.229053546986819e-06 0.8982475863895881 2.229053651483477e-06 0.8970047013543965 \
2.229053765533147e-06 0.8955451342423859 2.229053855502734e-06 0.8943225684615312 2.229053960321373e-06 0.8928208677113324 2.229054049769612e-06 0.891473284704788 \
2.229054132145392e-06 0.8901820884368528 2.229054223238392e-06 0.8887006634027688 2.22905436057447e-06 0.8863657732814155 2.229054459067403e-06 0.8846195012157601 \
2.229054571141153e-06 0.8825649218508906 2.229054702024186e-06 0.880080778639088 2.229054838495216e-06 0.8774018563482072 2.229054991949379e-06 0.8742910281085086 \
2.229055151043747e-06 0.8709679977889497 2.229055315327649e-06 0.867445283300377 2.229055471995751e-06 0.8640104344288071 2.229055624086531e-06 0.860615744772629 \
2.229055777800206e-06 0.857132398554192 2.229055937362381e-06 0.853469801378647 2.229056092451083e-06 0.8498714074018293 2.229056266130402e-06 0.8458039138600054 \
2.229056429161269e-06 0.8419559450883216 2.229056590803684e-06 0.8381170660338335 2.22905675345042e-06 0.8342344554797501 2.229056914868927e-06 0.8303657475978833 \
2.229057083463406e-06 0.8263109424305363 2.229057266356504e-06 0.8219002364007665 2.229057434185218e-06 0.8178440888239877 2.229057602471033e-06 0.8137703061148112 \
2.229057773299084e-06 0.8096302849976138 2.229057945473642e-06 0.8054541271740473 2.229058113235561e-06 0.8013830614994394 2.229058296865018e-06 0.7969255463994016 \
2.229058468271496e-06 0.7927646873948894 2.229058653714802e-06 0.7882638003278283 2.229058820385453e-06 0.7842196820467244 2.229058989271585e-06 0.7801233737411432 \
2.229059173427882e-06 0.7756572567105651 2.22905936803791e-06 0.7709405333854473 2.229059515293241e-06 0.7673736106648734 2.229059641923832e-06 0.7643079795643375 \
2.229059783780644e-06 0.7608754495129878 2.229059888184422e-06 0.7583505812556488 2.229060020577074e-06 0.7551502542766809 2.22906013016127e-06 0.7525028097975122 \
2.229060263325923e-06 0.7492875979647342 2.229060419507685e-06 0.7455190770546114 2.229060532737112e-06 0.7427887939149777 2.229060695258476e-06 0.7388718945951063 \
2.229060867439291e-06 0.7347246296492568 2.229061063444044e-06 0.7300078517193382 2.229061227834023e-06 0.7260553905833119 2.229061380230703e-06 0.7223944885043934 \
2.229061543905858e-06 0.718466402706526 2.229061711831558e-06 0.7144406657912139 2.229061891671935e-06 0.7101336212543717 2.229062067965886e-06 0.7059164985576465 \
2.229062239040521e-06 0.7018286413152719 2.229062407358697e-06 0.6978099102718778 2.229062560624828e-06 0.6941537154717222 2.229062722508398e-06 0.6902960245155986 \
2.229062901459938e-06 0.6860364417190952 2.22906303567149e-06 0.6828448068431195 2.229063139177788e-06 0.6803854168085423 2.2290632384622e-06 0.6780286039046017 \
2.229063339916676e-06 0.6756220912380299 2.229063432373275e-06 0.6734303711245889 2.229063516962075e-06 0.6714267031582685 2.229063610539411e-06 0.6692114082407524 \
2.22906372708163e-06 0.6664546942583044 2.229063836559192e-06 0.6638675763958631 2.229063949672203e-06 0.6611971533414394 2.22906407279097e-06 0.6582923426231613 \
2.229064197017283e-06 0.6553636581362478 2.229064367777427e-06 0.6513432847262797 2.229064526226014e-06 0.6476181700514572 2.229064698513837e-06 0.6435738126612673 \
2.229064844491904e-06 0.6401512360303271 2.22906498628512e-06 0.6368325564797357 2.229065117883574e-06 0.6337564355289309 2.229065248046858e-06 0.630718219665797 \
2.229065373571799e-06 0.6277924818644975 2.229065505354707e-06 0.6247239543970449 2.229065635278202e-06 0.6217046839485236 2.229065771586778e-06 0.6185408917806742 \
2.229065916200345e-06 0.615188962872713 2.229066075692536e-06 0.611499189008522 2.229066249152652e-06 0.6074939486938447 2.229066420159954e-06 0.6035554342946753 \
2.229066651528523e-06 0.5982402936372396 2.229066894990528e-06 0.5926661367297537 2.229067069111016e-06 0.5886942528256315 2.229067215383093e-06 0.5853638081576373 \
2.229067349755312e-06 0.58231230528805 2.229067466850207e-06 0.5796585826255305 2.229067562614553e-06 0.5774900935424465 2.229067661461095e-06 0.5752566196463251 \
2.229067745438414e-06 0.5733628024369305 2.229067823052463e-06 0.571614165956722 2.229067884377937e-06 0.5702331258704825 2.229067949058575e-06 0.5687779664863769 \
2.229068030366711e-06 0.5669528575016536 2.229068080436707e-06 0.5658306078972934 2.229068129757269e-06 0.5647256890740617 2.229068191677069e-06 0.5633393552914843 \
2.229068239508894e-06 0.5622690492396486 2.22906829001368e-06 0.5611395143522533 2.229068350075717e-06 0.559799205480933 2.229068409358512e-06 0.5584782058326896 \
2.229068484415226e-06 0.5568072508052372 2.229068554097882e-06 0.5552574373576753 2.229068639686449e-06 0.5533559356568912 2.229068726753821e-06 0.5514265885063823 \
2.229068810416341e-06 0.5495763264044081 2.229068896561366e-06 0.5476734676082877 2.229068992265987e-06 0.5455621222678217 2.229069096550938e-06 0.5432673229847179 \
2.229069211218113e-06 0.5407497407899529 2.229069319936574e-06 0.5383664115638558 2.229069429508814e-06 0.5359693749054023 2.229069541813574e-06 0.5335193270114367 \
2.229069668589195e-06 0.530759392645703 2.229069790866427e-06 0.5281021910076299 2.229069930952405e-06 0.5250685463469849 2.229070067969762e-06 0.5221084647952599 \
2.229070218271135e-06 0.5188705764247719 2.229070377166376e-06 0.5154582091324615 2.229070551500258e-06 0.5117250894133971 2.229070738517481e-06 0.5077378180012799 \
2.229070943835486e-06 0.5033745272871338 2.229071155677678e-06 0.498891131759938 2.229071408479721e-06 0.4935662239713107 2.22907161056737e-06 0.4893264048484654 \
2.229071845160675e-06 0.4844277613141263 2.229072081275272e-06 0.4795194943790256 2.229072334451769e-06 0.474283574581623 2.229072644981731e-06 0.4679020429045382 \
2.22907286303971e-06 0.4634451779596257 2.229073036485344e-06 0.4599153839204358 2.229073212977781e-06 0.4563351808422506 2.229073492459577e-06 0.4506930409909046 \
2.229073724703484e-06 0.4460279192631412 2.229074011797073e-06 0.44029020239849 2.229074229643181e-06 0.435960758243863 2.229074439695769e-06 0.4318042429497612 \
2.229074640893604e-06 0.4278406951573778 2.229074823313765e-06 0.4242617300271556 2.229074997208751e-06 0.4208637793449936 2.229075162072867e-06 0.4176529694331993 \
2.229075320826839e-06 0.4145718140694327 2.229075487073786e-06 0.4113577680628809 2.229075635718993e-06 0.4084923702366076 2.229075788087249e-06 0.4055658186126443 \
2.229075930150431e-06 0.4028468403491589 2.22907609952631e-06 0.3996150665462138 2.22907621990823e-06 0.3973276483660343 2.229076329881494e-06 0.3952449223617059 \
2.229076444806895e-06 0.3930732253581283 2.229076597048475e-06 0.3902080468194818 2.22907670926954e-06 0.3881039677199808 2.229076816462041e-06 0.386098874836553 \
2.229076968990289e-06 0.383254723448244 2.229077097137419e-06 0.380874963946598 2.229077219985411e-06 0.3786015923730871 2.229077399083788e-06 0.375299968600122 \
2.22907754816842e-06 0.3725653942578417 2.229077715875808e-06 0.3695018296724824 2.229077871273442e-06 0.3666748141177644 2.229077995440288e-06 0.3644243980538668 \
2.229078109332155e-06 0.3623666676050148 2.229078230775526e-06 0.3601804966264144 2.229078410927293e-06 0.3569532670533712 2.229078577415114e-06 0.3539878629329621 \
2.229078767834223e-06 0.3506138544217919 2.229078959590819e-06 0.3472380408565978 2.229079142640212e-06 0.344035729794033 2.229079291612276e-06 0.3414435189591631 \
2.229079411552182e-06 0.3393660536257183 2.229079534213665e-06 0.3372483242714233 2.229079657244151e-06 0.3351324902755385 2.229079802148562e-06 0.3326515017845288 \
2.229079905461337e-06 0.3308907757076019 2.229079999190846e-06 0.3292979229163631 2.229080089851148e-06 0.3277620998585528 2.229080200972602e-06 0.3258853746017661 \
2.229080308145579e-06 0.3240820510456246 2.22908040642023e-06 0.3224338250618513 2.229080518824776e-06 0.3205545940512134 2.229080682764676e-06 0.3178277446588927 \
2.229080844402555e-06 0.3151576097143818 2.229080992189301e-06 0.3127316247504084 2.229081154434516e-06 0.3100832165115083 2.229081314465073e-06 0.3074868334344322 \
2.229081466728372e-06 0.3050304870660137 2.229081620100242e-06 0.3025703731928215 2.229081778808771e-06 0.3000411640344692 2.2290819432579e-06 0.297437246442505 \
2.229082110484976e-06 0.2948063590562646 2.229082263596513e-06 0.292412731930112 2.22908244669444e-06 0.2895700146919417 2.229082637002178e-06 0.2866380344427262 \
2.229082785905236e-06 0.2843603072871506 2.229082959842541e-06 0.2817165165722222 2.22908313671993e-06 0.2790484233348025 2.229083284317149e-06 0.2768363681311815 \
2.229083473948848e-06 0.2740172295061162 2.229083623950767e-06 0.2718052906662373 2.229083761060957e-06 0.2697943906627059 2.229083902591401e-06 0.2677397479842996 \
2.22908401605027e-06 0.2661005451260196 2.229084152340596e-06 0.2641384584581135 2.229084282417217e-06 0.2622807416655737 2.22908440067147e-06 0.2606037730704709 \
2.229084518527066e-06 0.2589348966568543 2.229084649420877e-06 0.2570853888657079 2.229084789659635e-06 0.2551145527343576 2.229084905154221e-06 0.2534976852533538 \
2.229085034005598e-06 0.2516957519945816 2.229085149151579e-06 0.2500885525459272 2.229085302462547e-06 0.2479513765689386 2.229085440316308e-06 0.2460367343642474 \
2.22908557977796e-06 0.2441002375748529 2.229085735245815e-06 0.2419427021952501 2.22908586002843e-06 0.2402176526454788 2.229085999893338e-06 0.2382916534360561 \
2.229086128595514e-06 0.2365220787132559 2.229086249554366e-06 0.234860341242685 2.229086366599666e-06 0.2332541163798121 2.22908649260073e-06 0.2315368940272461 \
2.229086589320323e-06 0.2302195772445239 2.229086681409196e-06 0.2289683907689286 2.229086795826667e-06 0.2274152998827935 2.229086894197314e-06 0.2260807986508055 \
2.229087011344108e-06 0.2244933520241092 2.229087114435225e-06 0.2231010305483718 2.229087219949952e-06 0.2216798666278746 2.229087300868011e-06 0.2205933880575098 \
2.229087374539197e-06 0.2196046443759679 2.229087417268434e-06 0.2190314036349237 2.229087460398579e-06 0.2184540235451489 2.229087511196061e-06 0.217774515685755 \
2.229087548370939e-06 0.217277430841393 2.229087589041954e-06 0.2167338127731004 2.229087631833755e-06 0.2161620985357572 2.229087668244897e-06 0.2156758299561118 \
2.229087710169888e-06 0.2151161507306283 2.229087764712098e-06 0.2143884526296278 2.229087803170856e-06 0.2138756926875936 2.229087842797626e-06 0.2133496230586122 \
2.229087904630127e-06 0.212531488259555 2.229087966356579e-06 0.2117156525305126 2.229088022493854e-06 0.210974237875411 2.229088086149083e-06 0.210134110843225 \
2.229088180240117e-06 0.2088936328424611 2.229088267048376e-06 0.2077505933124353 2.22908836100502e-06 0.2065146061917991 2.229088459047254e-06 0.2052266823513323 \
2.22908856063462e-06 0.2038976009052371 2.229088661543568e-06 0.2025832113009377 2.229088758279377e-06 0.2013244528083448 2.229088860404347e-06 0.1999972806373927 \
2.229088963735905e-06 0.1986583046056677 2.229089073618507e-06 0.1972379690671278 2.229089182560765e-06 0.1958337611883887 2.229089302395884e-06 0.1942937175364915 \
2.229089412679751e-06 0.1928822800638286 2.229089520558496e-06 0.191507108810815 2.229089646621254e-06 0.1899051957406391 2.229089736488961e-06 0.1887671190866151 \
2.2290898469673e-06 0.1873723090993208 2.229089924500249e-06 0.1863971337376019 2.229090008823992e-06 0.1853400660204312 2.22909009641205e-06 0.1842452710069853 \
2.229090184204644e-06 0.18315095174413 2.229090265924515e-06 0.1821357652581398 2.229090363486193e-06 0.1809282658474054 2.229090470197344e-06 0.1796118512064394 \
2.229090570679026e-06 0.178377576484793 2.229090694850238e-06 0.1768595317522179 2.22909082874176e-06 0.1752320886156309 2.229090947653953e-06 0.1737937102924047 \
2.229091098054147e-06 0.1719851742607024 2.22909120888924e-06 0.1706594030660365 2.229091348655982e-06 0.168997130456427 2.22909146718129e-06 0.1675953052211382 \
2.229091572608521e-06 0.1663548750207849 2.22909166731838e-06 0.1652455210322802 2.229091760628154e-06 0.1641568522804657 2.22909186153427e-06 0.1629842804551663 \
2.229091956952102e-06 0.1618800504313296 2.229092054143025e-06 0.1607598891027116 2.229092135704507e-06 0.1598237474547246 2.229092241020952e-06 0.1586229753023833 \
2.229092324500658e-06 0.1576763029943549 2.229092426029949e-06 0.1565306813704828 2.229092503260485e-06 0.1556635090415242 2.229092594132523e-06 0.154647919213242 \
2.229092663483833e-06 0.1538765336840219 2.229092748067885e-06 0.1529397840535594 2.229092822461091e-06 0.1521208717489242 2.229092901831293e-06 0.151251902275755 \
2.229092976418964e-06 0.1504388356812226 2.229093045640521e-06 0.1496871728711989 2.229093140321328e-06 0.1486640077242138 2.229093210087093e-06 0.1479134441579097 \
2.229093294531655e-06 0.147008717574758 2.229093356097001e-06 0.1463518850554192 2.229093430139493e-06 0.1455673550676988 2.229093503525017e-06 0.1447940960774066 \
2.229093584960258e-06 0.1439395015691976 2.229093654409405e-06 0.1432139999234875 2.229093729511102e-06 0.1424323701137583 2.229093819423173e-06 0.1415006120834361 \
2.229093896506793e-06 0.1407052977810757 2.229093995617377e-06 0.1396885207473417 2.22909406515744e-06 0.138983077430453 2.229094146475915e-06 0.1381612812129989 \
2.229094216644325e-06 0.1374549162714094 2.229094295612438e-06 0.1366629455350578 2.22909437459072e-06 0.1358740351737466 2.22909444691251e-06 0.1351544405911459 \
2.229094516277969e-06 0.1344667589602006 2.229094564981976e-06 0.1339854049281765 2.229094655744348e-06 0.1330945614011112 2.229094687765876e-06 0.1327823711724506 \
2.229094775869844e-06 0.131925672678654 2.229094808363886e-06 0.1316105445757083 2.229094907031543e-06 0.1306564447580443 2.229094950687519e-06 0.130235859061297 \
2.229095028669335e-06 0.1294866595045693 2.229095066000294e-06 0.1291289430202982 2.229095168151694e-06 0.128153223240932 2.229095235595654e-06 0.1275115375392494 \
2.229095300748611e-06 0.1268935577290946 2.229095366654626e-06 0.1262729746041904 2.229095437806609e-06 0.1256052797936485 2.22909552074397e-06 0.1248293808775363 \
2.229095606139451e-06 0.1240331657139879 2.229095682226845e-06 0.1233259817834828 2.229095762687521e-06 0.1225806238777534 2.229095820771462e-06 0.1220441728027253 \
2.229095892104936e-06 0.1213870835332726 2.229095976893369e-06 0.1206085709991845 2.229096038048402e-06 0.1200487744399507 2.229096108134853e-06 0.1194096117168642 \
2.229096170640142e-06 0.1188419501154776 2.22909623664509e-06 0.1182453094891599 2.229096305417857e-06 0.1176255789053269 2.229096374874481e-06 0.1170017375875525 \
2.229096458038731e-06 0.1162574953874909 2.229096531156254e-06 0.1156056107435251 2.229096601870241e-06 0.1149774116339468 2.229096661221924e-06 0.1144518657417393 \
2.229096766519135e-06 0.1135239342411639 2.22909681238663e-06 0.1131212254602471 2.229096899340683e-06 0.1123603821649216 2.229096942354463e-06 0.1119852310621949 \
2.229096987221211e-06 0.1115947726395539 2.229097076954706e-06 0.1108164664143028 2.229097147839057e-06 0.110204256460374 2.22909722669257e-06 0.109525796983828 \
2.229097289470346e-06 0.1089876103666232 2.229097349464702e-06 0.1084750215669379 2.229097460462474e-06 0.1075310013968523 2.22909754121676e-06 0.1068475792877216 \
2.229097653680086e-06 0.1059005796323111 2.229097704824629e-06 0.1054717782906781 2.229097787809798e-06 0.1047785948356612 2.229097845974503e-06 0.1042945647727652 \
2.229097960212503e-06 0.1033482075721767 2.22909801011597e-06 0.1029366076865433 2.229098095857569e-06 0.1022320954501846 2.22909814488902e-06 0.1018307629303728 \
2.229098227455441e-06 0.101157455862875 2.229098298387777e-06 0.1005815064560546 2.229098366538127e-06 0.1000302812267231 2.229098444148443e-06 0.0994053199805509 \
2.229098516491814e-06 0.09882546240595018 2.229098594067778e-06 0.09820656846618626 2.229098682738439e-06 0.09750287271560702 2.229098756553227e-06 0.09692010793638871 \
2.229098838144235e-06 0.09627924899616347 2.229098916282703e-06 0.09566870926115327 2.229099002032493e-06 0.09500229249765579 2.229099089729402e-06 0.09432453920671229 \
2.229099183638967e-06 0.09360304191323381 2.229099280098285e-06 0.09286661217778783 2.229099358728946e-06 0.09226977907248698 2.229099461452546e-06 0.09149473120661993 \
2.229099545280196e-06 0.09086620530027881 2.229099666032378e-06 0.08996702094116031 2.229099795302029e-06 0.08901247130467421 2.229099951190493e-06 0.08787237469953549 \
2.229100106290076e-06 0.08675000010972149 2.229100263305882e-06 0.08562614142917294 2.229100443326734e-06 0.08435280068725284 2.229100593847601e-06 0.08330035525696428 \
2.229100742221624e-06 0.08227363395463329 2.229100879838855e-06 0.08133079092382095 2.229101019758505e-06 0.08038162993974078 2.229101156365493e-06 0.07946425488810546 \
2.22910129509279e-06 0.07854214404995859 2.229101440403653e-06 0.07758663187171365 2.229101588151466e-06 0.07662571164688473 2.229101746748333e-06 0.07560598447141591 \
2.229101911000851e-06 0.07456266320243836 2.229102080017927e-06 0.07350246718885647 2.229102261906921e-06 0.07237646636762114 2.229102462529019e-06 0.07115268999588262 \
2.229102676406562e-06 0.0698691158856425 2.229102904040693e-06 0.0685263410462881 2.229103145626235e-06 0.06712722147996912 2.229103427215414e-06 0.06552977831071743 \
2.229103724369535e-06 0.06388229915275011 2.229104047802612e-06 0.06213267023812474 2.229104438962031e-06 0.0600758559534558 2.229104840456333e-06 0.05803293250078725 \
2.229105217397059e-06 0.05617754872181892 2.229105584510791e-06 0.05442503025024555 2.229105934627471e-06 0.05280240270907886 2.229106253933125e-06 0.05136309724710254 \
2.229106558257407e-06 0.05002640192327024 2.229106855163313e-06 0.04875503464657577 2.229107137163638e-06 0.04757867888787161 2.229107417596943e-06 0.04643900623749339 \
2.229107682320566e-06 0.04538777697325767 2.229107958218279e-06 0.04431704973151576 2.229108232683143e-06 0.04327654260273706 2.229108531102423e-06 0.04217254828989973 \
2.22910875761848e-06 0.04135316230013186 2.229109069531317e-06 0.04025053053625379 2.229109289786109e-06 0.03948972371590862 2.229109507050863e-06 0.03875470657060948 \
2.229109716773512e-06 0.03806113111453101 2.2291100269559e-06 0.03705828856757609 2.229110249553778e-06 0.03635538859683734 2.229110496919279e-06 0.03559019656168042 \
2.229110769325655e-06 0.03476651972027592 2.229110989958209e-06 0.03411384091885184 2.22911127423846e-06 0.03329124852897781 2.229111512151752e-06 0.0326183788879464 \
2.229111750241163e-06 0.03195887699386461 2.229111985496491e-06 0.03132132139405813 2.229112214275198e-06 0.03071728735992773 2.229112447005948e-06 0.03011490821398154 \
2.229112666308989e-06 0.02955843195412813 2.229112870252059e-06 0.02905055018162466 2.229113269161795e-06 0.02808303002558106 2.229113456316051e-06 0.02764052191221165 \
2.229113828521772e-06 0.0267814187683372 2.229114015473295e-06 0.02635997027055515 2.229114384827242e-06 0.02554620807076183 2.22911453848041e-06 0.02521471147941385 \
2.229114954694564e-06 0.02434161493068329 2.22911516018238e-06 0.02392065165079968 2.229115499190341e-06 0.02323955384462723 2.229115681885069e-06 0.02287916718068597 \
2.229116138978978e-06 0.02199597290476789 2.229116268719714e-06 0.02174967209293581 2.229116722140138e-06 0.02089828923199067 2.22911686451243e-06 0.0206336680476187 \
2.229117394079191e-06 0.01967289368906444 2.229117520286197e-06 0.01945139161001456 2.229118082520635e-06 0.01850749734048266 2.229118245259022e-06 0.01824627541187189 \
2.229118809439087e-06 0.01738327200207762 2.229118961183154e-06 0.01716165742474803 2.229119662862638e-06 0.01618760396393164 2.229119832951728e-06 0.01596324388168 \
2.229120488009604e-06 0.01513221026437959 2.229120654523916e-06 0.01492874613340729 2.229121387637676e-06 0.01406966818047924 2.229121520900854e-06 0.01391906482409888 \
2.229122372558029e-06 0.01299647369571925 2.229122510500477e-06 0.01285324185793544 2.229123450559966e-06 0.0119198170026788 2.229123614321604e-06 0.01176347583728811 \
2.229124601555038e-06 0.01085909507266535 2.229124736144115e-06 0.0107410715025141 2.229125877583544e-06 0.009819907073012045 2.229125985822443e-06 0.009738548299709823 \
2.229127309069827e-06 0.00880579379490502 2.229127441815525e-06 0.008718202093769473 2.22912896431665e-06 0.007760835273143199 2.229129076858719e-06 0.007690148685505111 \
2.229130769150306e-06 0.00669558715138598 2.229130909416891e-06 0.00662113250846694 2.229132982426193e-06 0.005629132576249021 2.229133174987711e-06 0.005545002188831318 \
2.229135385197559e-06 0.004656096148610405 2.229135791984232e-06 0.004507219767123045 2.229138613724208e-06 0.003590578528330178 2.229139135019958e-06 0.00344214578404881 \
2.229143347121009e-06 0.002447529662748036 2.229143899683877e-06 0.002340875287107731 2.229149782973417e-06 0.001359168649576994 2.229150032246415e-06 0.001311490127959886 \
2.229163182367465e-06 0.0003136950974005476 2.229163299150435e-06 0.0003112730584132499 2.258990000000011e-06 3.042397160644726e-06 2.259e-06 3.042397160644726e-06 \
]
