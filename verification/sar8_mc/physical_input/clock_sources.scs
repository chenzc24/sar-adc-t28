1.229078410927293e-06 0.3569532670533712 1.229078577415114e-06 0.3539878629329621 1.229078767834223e-06 0.3506138544217919 1.229078959590819e-06 0.3472380408565978 \
1.229079142640212e-06 0.344035729794033 1.229079291612277e-06 0.3414435189591631 1.229079411552182e-06 0.3393660536257183 1.229079534213665e-06 0.3372483242714233 \
1.229079657244152e-06 0.3351324902755385 1.229079802148562e-06 0.3326515017845288 1.229079905461337e-06 0.3308907757076019 1.229079999190846e-06 0.3292979229163631 \
1.229080089851149e-06 0.3277620998585528 1.229080200972602e-06 0.3258853746017661 1.229080308145579e-06 0.3240820510456246 1.22908040642023e-06 0.3224338250618513 \
1.229080518824776e-06 0.3205545940512134 1.229080682764676e-06 0.3178277446588927 1.229080844402555e-06 0.3151576097143818 1.229080992189301e-06 0.3127316247504084 \
1.229081154434516e-06 0.3100832165115083 1.229081314465073e-06 0.3074868334344322 1.229081466728372e-06 0.3050304870660137 1.229081620100242e-06 0.3025703731928215 \
1.229081778808771e-06 0.3000411640344692 1.2290819432579e-06 0.297437246442505 1.229082110484976e-06 0.2948063590562646 1.229082263596514e-06 0.292412731930112 \
1.229082446694441e-06 0.2895700146919417 1.229082637002178e-06 0.2866380344427262 1.229082785905237e-06 0.2843603072871506 1.229082959842542e-06 0.2817165165722222 \
1.22908313671993e-06 0.2790484233348025 1.229083284317149e-06 0.2768363681311815 1.229083473948849e-06 0.2740172295061162 1.229083623950768e-06 0.2718052906662373 \
1.229083761060958e-06 0.2697943906627059 1.229083902591401e-06 0.2677397479842996 1.22908401605027e-06 0.2661005451260196 1.229084152340597e-06 0.2641384584581135 \
1.229084282417217e-06 0.2622807416655737 1.22908440067147e-06 0.2606037730704709 1.229084518527066e-06 0.2589348966568543 1.229084649420877e-06 0.2570853888657079 \
1.229084789659635e-06 0.2551145527343576 1.229084905154221e-06 0.2534976852533538 1.229085034005598e-06 0.2516957519945816 1.22908514915158e-06 0.2500885525459272 \
1.229085302462547e-06 0.2479513765689386 1.229085440316308e-06 0.2460367343642474 1.22908557977796e-06 0.2441002375748529 1.229085735245815e-06 0.2419427021952501 \
1.22908586002843e-06 0.2402176526454788 1.229085999893338e-06 0.2382916534360561 1.229086128595514e-06 0.2365220787132559 1.229086249554366e-06 0.234860341242685 \
1.229086366599666e-06 0.2332541163798121 1.22908649260073e-06 0.2315368940272461 1.229086589320323e-06 0.2302195772445239 1.229086681409196e-06 0.2289683907689286 \
1.229086795826667e-06 0.2274152998827935 1.229086894197314e-06 0.2260807986508055 1.229087011344108e-06 0.2244933520241092 1.229087114435226e-06 0.2231010305483718 \
1.229087219949952e-06 0.2216798666278746 1.229087300868012e-06 0.2205933880575098 1.229087374539197e-06 0.2196046443759679 1.229087417268434e-06 0.2190314036349237 \
1.229087460398579e-06 0.2184540235451489 1.229087511196061e-06 0.217774515685755 1.229087548370939e-06 0.217277430841393 1.229087589041954e-06 0.2167338127731004 \
1.229087631833756e-06 0.2161620985357572 1.229087668244897e-06 0.2156758299561118 1.229087710169888e-06 0.2151161507306283 1.229087764712099e-06 0.2143884526296278 \
1.229087803170857e-06 0.2138756926875936 1.229087842797626e-06 0.2133496230586122 1.229087904630128e-06 0.212531488259555 1.229087966356579e-06 0.2117156525305126 \
1.229088022493854e-06 0.210974237875411 1.229088086149084e-06 0.210134110843225 1.229088180240117e-06 0.2088936328424611 1.229088267048376e-06 0.2077505933124353 \
1.22908836100502e-06 0.2065146061917991 1.229088459047254e-06 0.2052266823513323 1.22908856063462e-06 0.2038976009052371 1.229088661543568e-06 0.2025832113009377 \
1.229088758279377e-06 0.2013244528083448 1.229088860404348e-06 0.1999972806373927 1.229088963735906e-06 0.1986583046056677 1.229089073618507e-06 0.1972379690671278 \
1.229089182560765e-06 0.1958337611883887 1.229089302395885e-06 0.1942937175364915 1.229089412679751e-06 0.1928822800638286 1.229089520558496e-06 0.191507108810815 \
1.229089646621254e-06 0.1899051957406391 1.229089736488961e-06 0.1887671190866151 1.2290898469673e-06 0.1873723090993208 1.229089924500249e-06 0.1863971337376019 \
1.229090008823992e-06 0.1853400660204312 1.22909009641205e-06 0.1842452710069853 1.229090184204644e-06 0.18315095174413 1.229090265924516e-06 0.1821357652581398 \
1.229090363486193e-06 0.1809282658474054 1.229090470197344e-06 0.1796118512064394 1.229090570679026e-06 0.178377576484793 1.229090694850238e-06 0.1768595317522179 \
1.229090828741761e-06 0.1752320886156309 1.229090947653953e-06 0.1737937102924047 1.229091098054147e-06 0.1719851742607024 1.22909120888924e-06 0.1706594030660365 \
1.229091348655982e-06 0.168997130456427 1.22909146718129e-06 0.1675953052211382 1.229091572608521e-06 0.1663548750207849 1.22909166731838e-06 0.1652455210322802 \
1.229091760628155e-06 0.1641568522804657 1.229091861534271e-06 0.1629842804551663 1.229091956952102e-06 0.1618800504313296 1.229092054143026e-06 0.1607598891027116 \
1.229092135704507e-06 0.1598237474547246 1.229092241020952e-06 0.1586229753023833 1.229092324500659e-06 0.1576763029943549 1.229092426029949e-06 0.1565306813704828 \
1.229092503260486e-06 0.1556635090415242 1.229092594132523e-06 0.154647919213242 1.229092663483833e-06 0.1538765336840219 1.229092748067885e-06 0.1529397840535594 \
1.229092822461091e-06 0.1521208717489242 1.229092901831293e-06 0.151251902275755 1.229092976418964e-06 0.1504388356812226 1.229093045640521e-06 0.1496871728711989 \
1.229093140321328e-06 0.1486640077242138 1.229093210087093e-06 0.1479134441579097 1.229093294531656e-06 0.147008717574758 1.229093356097002e-06 0.1463518850554192 \
1.229093430139493e-06 0.1455673550676988 1.229093503525017e-06 0.1447940960774066 1.229093584960259e-06 0.1439395015691976 1.229093654409405e-06 0.1432139999234875 \
1.229093729511102e-06 0.1424323701137583 1.229093819423174e-06 0.1415006120834361 1.229093896506793e-06 0.1407052977810757 1.229093995617377e-06 0.1396885207473417 \
1.22909406515744e-06 0.138983077430453 1.229094146475916e-06 0.1381612812129989 1.229094216644325e-06 0.1374549162714094 1.229094295612438e-06 0.1366629455350578 \
1.229094374590721e-06 0.1358740351737466 1.22909444691251e-06 0.1351544405911459 1.229094516277969e-06 0.1344667589602006 1.229094564981977e-06 0.1339854049281765 \
1.229094655744348e-06 0.1330945614011112 1.229094687765876e-06 0.1327823711724506 1.229094775869844e-06 0.131925672678654 1.229094808363886e-06 0.1316105445757083 \
1.229094907031544e-06 0.1306564447580443 1.229094950687519e-06 0.130235859061297 1.229095028669336e-06 0.1294866595045693 1.229095066000294e-06 0.1291289430202982 \
1.229095168151694e-06 0.128153223240932 1.229095235595654e-06 0.1275115375392494 1.229095300748612e-06 0.1268935577290946 1.229095366654626e-06 0.1262729746041904 \
1.229095437806609e-06 0.1256052797936485 1.22909552074397e-06 0.1248293808775363 1.229095606139451e-06 0.1240331657139879 1.229095682226845e-06 0.1233259817834828 \
1.229095762687521e-06 0.1225806238777534 1.229095820771462e-06 0.1220441728027253 1.229095892104936e-06 0.1213870835332726 1.229095976893369e-06 0.1206085709991845 \
1.229096038048402e-06 0.1200487744399507 1.229096108134853e-06 0.1194096117168642 1.229096170640142e-06 0.1188419501154776 1.22909623664509e-06 0.1182453094891599 \
1.229096305417857e-06 0.1176255789053269 1.229096374874481e-06 0.1170017375875525 1.229096458038731e-06 0.1162574953874909 1.229096531156255e-06 0.1156056107435251 \
1.229096601870241e-06 0.1149774116339468 1.229096661221924e-06 0.1144518657417393 1.229096766519136e-06 0.1135239342411639 1.22909681238663e-06 0.1131212254602471 \
1.229096899340684e-06 0.1123603821649216 1.229096942354464e-06 0.1119852310621949 1.229096987221211e-06 0.1115947726395539 1.229097076954706e-06 0.1108164664143028 \
1.229097147839057e-06 0.110204256460374 1.229097226692571e-06 0.109525796983828 1.229097289470346e-06 0.1089876103666232 1.229097349464702e-06 0.1084750215669379 \
1.229097460462474e-06 0.1075310013968523 1.22909754121676e-06 0.1068475792877216 1.229097653680086e-06 0.1059005796323111 1.229097704824629e-06 0.1054717782906781 \
1.229097787809798e-06 0.1047785948356612 1.229097845974503e-06 0.1042945647727652 1.229097960212503e-06 0.1033482075721767 1.22909801011597e-06 0.1029366076865433 \
1.229098095857569e-06 0.1022320954501846 1.22909814488902e-06 0.1018307629303728 1.229098227455441e-06 0.101157455862875 1.229098298387777e-06 0.1005815064560546 \
1.229098366538127e-06 0.1000302812267231 1.229098444148443e-06 0.0994053199805509 1.229098516491814e-06 0.09882546240595018 1.229098594067778e-06 0.09820656846618626 \
1.229098682738439e-06 0.09750287271560702 1.229098756553227e-06 0.09692010793638871 1.229098838144235e-06 0.09627924899616347 1.229098916282703e-06 0.09566870926115327 \
1.229099002032494e-06 0.09500229249765579 1.229099089729402e-06 0.09432453920671229 1.229099183638967e-06 0.09360304191323381 1.229099280098285e-06 0.09286661217778783 \
1.229099358728946e-06 0.09226977907248698 1.229099461452546e-06 0.09149473120661993 1.229099545280196e-06 0.09086620530027881 1.229099666032378e-06 0.08996702094116031 \
1.229099795302029e-06 0.08901247130467421 1.229099951190493e-06 0.08787237469953549 1.229100106290076e-06 0.08675000010972149 1.229100263305882e-06 0.08562614142917294 \
1.229100443326735e-06 0.08435280068725284 1.229100593847601e-06 0.08330035525696428 1.229100742221624e-06 0.08227363395463329 1.229100879838855e-06 0.08133079092382095 \
1.229101019758505e-06 0.08038162993974078 1.229101156365493e-06 0.07946425488810546 1.229101295092791e-06 0.07854214404995859 1.229101440403653e-06 0.07758663187171365 \
1.229101588151466e-06 0.07662571164688473 1.229101746748333e-06 0.07560598447141591 1.229101911000851e-06 0.07456266320243836 1.229102080017927e-06 0.07350246718885647 \
1.229102261906921e-06 0.07237646636762114 1.22910246252902e-06 0.07115268999588262 1.229102676406562e-06 0.0698691158856425 1.229102904040694e-06 0.0685263410462881 \
1.229103145626235e-06 0.06712722147996912 1.229103427215414e-06 0.06552977831071743 1.229103724369535e-06 0.06388229915275011 1.229104047802612e-06 0.06213267023812474 \
1.229104438962031e-06 0.0600758559534558 1.229104840456333e-06 0.05803293250078725 1.22910521739706e-06 0.05617754872181892 1.229105584510791e-06 0.05442503025024555 \
1.229105934627471e-06 0.05280240270907886 1.229106253933125e-06 0.05136309724710254 1.229106558257407e-06 0.05002640192327024 1.229106855163313e-06 0.04875503464657577 \
1.229107137163639e-06 0.04757867888787161 1.229107417596943e-06 0.04643900623749339 1.229107682320567e-06 0.04538777697325767 1.229107958218279e-06 0.04431704973151576 \
1.229108232683143e-06 0.04327654260273706 1.229108531102424e-06 0.04217254828989973 1.22910875761848e-06 0.04135316230013186 1.229109069531318e-06 0.04025053053625379 \
1.229109289786109e-06 0.03948972371590862 1.229109507050864e-06 0.03875470657060948 1.229109716773513e-06 0.03806113111453101 1.2291100269559e-06 0.03705828856757609 \
1.229110249553778e-06 0.03635538859683734 1.229110496919279e-06 0.03559019656168042 1.229110769325656e-06 0.03476651972027592 1.229110989958209e-06 0.03411384091885184 \
1.22911127423846e-06 0.03329124852897781 1.229111512151753e-06 0.0326183788879464 1.229111750241164e-06 0.03195887699386461 1.229111985496492e-06 0.03132132139405813 \
1.229112214275199e-06 0.03071728735992773 1.229112447005948e-06 0.03011490821398154 1.229112666308989e-06 0.02955843195412813 1.22911287025206e-06 0.02905055018162466 \
1.229113269161796e-06 0.02808303002558106 1.229113456316051e-06 0.02764052191221165 1.229113828521772e-06 0.0267814187683372 1.229114015473295e-06 0.02635997027055515 \
1.229114384827242e-06 0.02554620807076183 1.22911453848041e-06 0.02521471147941385 1.229114954694565e-06 0.02434161493068329 1.229115160182381e-06 0.02392065165079968 \
1.229115499190341e-06 0.02323955384462723 1.229115681885069e-06 0.02287916718068597 1.229116138978978e-06 0.02199597290476789 1.229116268719715e-06 0.02174967209293581 \
1.229116722140138e-06 0.02089828923199067 1.22911686451243e-06 0.0206336680476187 1.229117394079191e-06 0.01967289368906444 1.229117520286197e-06 0.01945139161001456 \
1.229118082520636e-06 0.01850749734048266 1.229118245259022e-06 0.01824627541187189 1.229118809439087e-06 0.01738327200207762 1.229118961183154e-06 0.01716165742474803 \
1.229119662862638e-06 0.01618760396393164 1.229119832951728e-06 0.01596324388168 1.229120488009604e-06 0.01513221026437959 1.229120654523917e-06 0.01492874613340729 \
1.229121387637676e-06 0.01406966818047924 1.229121520900854e-06 0.01391906482409888 1.229122372558029e-06 0.01299647369571925 1.229122510500478e-06 0.01285324185793544 \
1.229123450559967e-06 0.0119198170026788 1.229123614321604e-06 0.01176347583728811 1.229124601555039e-06 0.01085909507266535 1.229124736144115e-06 0.0107410715025141 \
1.229125877583545e-06 0.009819907073012045 1.229125985822444e-06 0.009738548299709823 1.229127309069827e-06 0.00880579379490502 1.229127441815525e-06 0.008718202093769473 \
1.22912896431665e-06 0.007760835273143199 1.229129076858719e-06 0.007690148685505111 1.229130769150306e-06 0.00669558715138598 1.229130909416892e-06 0.00662113250846694 \
1.229132982426194e-06 0.005629132576249021 1.229133174987711e-06 0.005545002188831318 1.229135385197559e-06 0.004656096148610405 1.229135791984232e-06 0.004507219767123045 \
1.229138613724209e-06 0.003590578528330178 1.229139135019959e-06 0.00344214578404881 1.229143347121009e-06 0.002447529662748036 1.229143899683877e-06 0.002340875287107731 \
1.229149782973417e-06 0.001359168649576994 1.229150032246415e-06 0.001311490127959886 1.229163182367465e-06 0.0003136950974005476 1.229163299150435e-06 0.0003112730584132499 \
1.258990000000011e-06 3.042397160644726e-06 1.302746667027013e-06 -0.0009024818035526668 1.302746739442629e-06 -0.001022682652537627 1.302747175467347e-06 -0.001858525046639076 \
1.30274726236173e-06 -0.002046124893065343 1.302747617065043e-06 -0.00288168582347465 1.302747716611644e-06 -0.003135075204051477 1.302747976881349e-06 -0.003828199033013717 \
1.30274811720375e-06 -0.004216406518003108 1.302748344689832e-06 -0.004856871791621592 1.302748481897271e-06 -0.005239031028659006 1.30274886679612e-06 -0.006187559915121 \
1.302748998893307e-06 -0.006423332025500122 1.302749687336335e-06 -0.005917035979538006 1.302749844265069e-06 -0.005202654566481615 1.302749971914231e-06 -0.004414133290428114 \
1.302750099456021e-06 -0.003433350487145549 1.302750217130233e-06 -0.002355902309038119 1.30275031626992e-06 -0.001320627313728655 1.30275042165263e-06 -9.507383675133965e-05 \
1.302750535559933e-06 0.001369964538583592 1.302750666615329e-06 0.003229572948258866 1.302750791978547e-06 0.005172303930030842 1.302750983820411e-06 0.008432154569684791 \
1.302751127490204e-06 0.01107975669588844 1.302751285472017e-06 0.01417105828876112 1.302751434071664e-06 0.01723098336859398 1.302751587122593e-06 0.02051714008521248 \
1.302751746187569e-06 0.02405720796424875 1.302751899257778e-06 0.02756764950178633 1.302752047604842e-06 0.03105219347129199 1.302752196711284e-06 0.03462388853332505 \
1.302752351275713e-06 0.03838854885099419 1.302752511961677e-06 0.04235886888523473 1.302752676640863e-06 0.04647718198980624 1.302752853163806e-06 0.05093664320808645 \
1.302753032175606e-06 0.05549818742091989 1.302753222948448e-06 0.0603932190016783 1.3027534277958e-06 0.06567927942044927 1.302753648293053e-06 0.07139554989571946 \
1.302753881211021e-06 0.07745499876455469 1.302754130458799e-06 0.08395499695136356 1.302754403380327e-06 0.09108394918256098 1.302754700173383e-06 0.09884095133633181 \
1.302755027609896e-06 0.1073964775374675 1.302755397423694e-06 0.1170487607486894 1.302755792369976e-06 0.1273407304921971 1.302756250458528e-06 0.1392499850125259 \
1.302756782558388e-06 0.1530377249371455 1.302757408110397e-06 0.169180864038255 1.302758094102463e-06 0.1867931863309214 1.302758896945878e-06 0.2072766958045763 \
1.30275979625821e-06 0.2300508264895909 1.302760696698323e-06 0.2526618731709107 1.302761498589855e-06 0.2726215666318766 1.302762194096996e-06 0.2897857674353052 \
1.302762826931282e-06 0.3052728323588638 1.302763422339773e-06 0.3197161646377594 1.302763969382815e-06 0.3328722959176427 1.302764503143162e-06 0.3455929446372428 \
1.302765022382586e-06 0.3578476146335662 1.302765529774049e-06 0.3697097539883151 1.302766033395218e-06 0.3813674725871593 1.302766545138114e-06 0.3930934709428262 \
1.302767052299123e-06 0.404595334768291 1.302767582595137e-06 0.4164962117964878 1.302768068708626e-06 0.4272847049163567 1.302768546816947e-06 0.437781779057129 \
1.302768986249071e-06 0.4473362978389137 1.302769109408535e-06 0.4500002106608159 1.302769355727463e-06 0.4553046876287923 1.302769698999458e-06 0.4626558934952216 \
1.302770010436459e-06 0.4692815017887791 1.302770261147724e-06 0.4745855323881177 1.302770531976868e-06 0.480281321066213 1.302770868458777e-06 0.4873122872019196 \
1.302771224467388e-06 0.4946959640027882 1.302771541737556e-06 0.5012322602315481 1.302771780618105e-06 0.506122906570856 1.302772021646287e-06 0.5110269393752048 \
1.302772273577991e-06 0.5161276795544476 1.302772513731835e-06 0.5209621749612534 1.302772736483296e-06 0.5254248476203834 1.302772925040943e-06 0.5291850880529715 \
1.302773139790987e-06 0.5334523706207774 1.302773354339378e-06 0.5376948565446859 1.30277361310367e-06 0.5427871977552768 1.302773863931242e-06 0.5477009885064807 \
1.302774119350104e-06 0.5526782776843104 1.302774470392629e-06 0.5594898819265107 1.302774735000954e-06 0.5645984056527484 1.30277500141751e-06 0.569709962982798 \
1.30277526193182e-06 0.5746801970751495 1.302775529021882e-06 0.5797469183389945 1.302775772159962e-06 0.5843213438768613 1.302776027852189e-06 0.5890994944692448 \
1.302776255671159e-06 0.5933243819692556 1.302776493215979e-06 0.5976999800355528 1.302776704606465e-06 0.6015679915939678 1.302776916747224e-06 0.6054277082074113 \
1.302777105936602e-06 0.6088479815213901 1.30277723709492e-06 0.6112112531841202 1.302777369391478e-06 0.6135871094428261 1.302777554614204e-06 0.6169015645304802 \
1.302777716636591e-06 0.6197943209800671 1.302777875055755e-06 0.6226100751126036 1.302778009167621e-06 0.6249846001944386 1.302778181488729e-06 0.6280247049765127 \
1.302778310427531e-06 0.6302937061188456 1.302778430805044e-06 0.6324061607157294 1.302778571333915e-06 0.634864734791624 1.302778764419407e-06 0.6382321981637986 \
1.302778914230185e-06 0.6408363654380513 1.30277908153778e-06 0.6437327988167145 1.302779262592003e-06 0.6468572757970242 1.302779465918433e-06 0.6503523798695617 \
1.302779648771588e-06 0.6534819287355287 1.302779819395834e-06 0.6563879501053153 1.302779996860074e-06 0.6594029650344411 1.302780162839025e-06 0.6622113135173925 \
1.302780320075814e-06 0.6648594636266301 1.302780460561866e-06 0.6672075432495704 1.302780604291994e-06 0.6695987751186935 1.302780737338985e-06 0.6718055529208897 \
1.302780879311128e-06 0.6741523780906628 1.302780999371661e-06 0.6761293215200647 1.302781144309748e-06 0.6785098354674278 1.302781260306798e-06 0.6804095298668216 \
1.302781379886685e-06 0.6823647593763783 1.30278147884666e-06 0.68397755359623 1.302781597355078e-06 0.6859039329668146 1.30278168439936e-06 0.6873150904607619 \
1.302781806410179e-06 0.6892866586554622 1.302781905332791e-06 0.6908817703737582 1.302781997228166e-06 0.6923536807698466 1.302782097196705e-06 0.6939486118486815 \
1.302782195442366e-06 0.6955126686751646 1.302782287156128e-06 0.6969676095571918 1.30278239128907e-06 0.698613189139943 1.302782527015812e-06 0.7007470979739818 \
1.302782681624274e-06 0.7031613517373301 1.302782816731986e-06 0.7052558942641604 1.302782963068532e-06 0.7075085519458914 1.302783091536073e-06 0.7094732734147607 \
1.302783215720207e-06 0.7113609898537658 1.302783325624507e-06 0.7130225953369277 1.302783442207576e-06 0.7147759898693785 1.302783542385407e-06 0.7162749667021007 \
1.302783679474215e-06 0.7183149847558421 1.302783799463242e-06 0.7200901405411056 1.30278391857669e-06 0.7218426783097279 1.302784045072077e-06 0.723693513465353 \
1.302784170939449e-06 0.7255245570057045 1.302784293560467e-06 0.7272980597885179 1.302784421177991e-06 0.7291334326655684 1.302784551426783e-06 0.7309957624152177 \
1.302784673019733e-06 0.73272442801297 1.302784811788425e-06 0.7346853525547948 1.302784912196869e-06 0.7360963845229137 1.302785015584257e-06 0.7375412410987998 \
1.3027851092447e-06 0.7388443755773992 1.302785220866297e-06 0.7403895158541485 1.302785307334899e-06 0.7415798421827293 1.30278540819801e-06 0.7429609798983192 \
1.302785540294732e-06 0.7447573558536402 1.302785649496034e-06 0.7462323422761349 1.302785754027664e-06 0.747635567415085 1.302785877674145e-06 0.7492836897664436 \
1.30278602637058e-06 0.7512497161812216 1.302786148251239e-06 0.7528480713857697 1.302786261855803e-06 0.7543274008692354 1.302786402375488e-06 0.7561429069656862 \
1.30278654356493e-06 0.7579511824827749 1.302786661311106e-06 0.7594470562859095 1.302786790000766e-06 0.7610693809796742 1.302786932555413e-06 0.7628512182523866 \
1.302787048411964e-06 0.7642872416835913 1.30278719417523e-06 0.7660789429779771 1.302787316007677e-06 0.7675637574673733 1.302787434476374e-06 0.7689965471136999 \
1.302787557264006e-06 0.7704700089613156 1.302787683416889e-06 0.7719718272910862 1.302787793785939e-06 0.7732757954107932 1.302787919217035e-06 0.7747465774777432 \
1.302788024698746e-06 0.775974259539018 1.302788157865176e-06 0.7775122819577122 1.302788280546631e-06 0.7789173428708996 1.302788415309674e-06 0.7804473432620218 \
1.302788525980962e-06 0.7816923373676121 1.302788635302591e-06 0.7829118427552927 1.302788770435026e-06 0.7844048889494442 1.30278892121405e-06 0.7860523747618094 \
1.302789061582958e-06 0.7875692293014268 1.302789181294483e-06 0.7888502570533434 1.302789319548824e-06 0.7903153082715967 1.302789442919159e-06 0.7916096503654788 \
1.302789588017784e-06 0.7931164937536124 1.302789727758043e-06 0.7945521172774316 1.302789854939467e-06 0.7958455533278409 1.30278997397922e-06 0.7970449251022731 \
1.302790086337411e-06 0.7981670522831598 1.302790190566191e-06 0.79919939674296 1.302790285905002e-06 0.8001364844871954 1.302790422193112e-06 0.8014634245741865 \
1.302790539085656e-06 0.8025894467082511 1.302790658725145e-06 0.8037305025474466 1.302790780606717e-06 0.8048811831579785 1.302790902985054e-06 0.8060245537852575 \
1.302791031013733e-06 0.8072081965553952 1.302791155658532e-06 0.8083483262222385 1.302791286157279e-06 0.8095291977395493 1.302791412617707e-06 0.8106611567088965 \
1.302791539743675e-06 0.8117869190804841 1.302791644861151e-06 0.8127087429624065 1.30279175011134e-06 0.8136235164943317 1.302791841251591e-06 0.8144090748259969 \
1.302791964669625e-06 0.8154632009865571 1.302792051748274e-06 0.8162003374872545 1.302792151070959e-06 0.8170344894488412 1.302792295992703e-06 0.8182390501293432 \
1.302792432261206e-06 0.8193582434421302 1.302792541723485e-06 0.8202477434185359 1.302792687843586e-06 0.8214214001843773 1.302792839202198e-06 0.8226208465286928 \
1.30279296500612e-06 0.8236052915965452 1.302793109416779e-06 0.824721541823094 1.30279323401773e-06 0.8256729463037898 1.302793384729791e-06 0.8268094083523665 \
1.30279352010105e-06 0.8278169867326588 1.302793645303979e-06 0.8287379047458127 1.302793762973362e-06 0.829593908450195 1.302793908801339e-06 0.8306418458276996 \
1.30279407529732e-06 0.8318207857986918 1.302794206154408e-06 0.8327345044534114 1.302794379603848e-06 0.833928356718921 1.302794547722322e-06 0.8350667646575466 \
1.302794717596124e-06 0.8361988603660855 1.302794898450754e-06 0.8373843006762304 1.302795041633135e-06 0.8383085120571983 1.302795155746479e-06 0.8390361588138326 \
1.30279528581247e-06 0.8398559950134801 1.302795387687706e-06 0.8404909448220066 1.302795504566998e-06 0.8412116130393378 1.302795641678929e-06 0.8420465258793415 \
1.302795839559572e-06 0.843231707656198 1.302796031345765e-06 0.8443585547012582 1.302796240708828e-06 0.8455646258450146 1.302796422822406e-06 0.846593677725298 \
1.302796619917178e-06 0.8476867969181797 1.302796793185875e-06 0.8486305714188691 1.302796976264561e-06 0.8496104335327738 1.302797147401587e-06 0.8505103231661706 \
1.302797322080438e-06 0.8514128411730317 1.302797497318728e-06 0.8523022053693007 1.302797673458367e-06 0.8531802340241421 1.302797863809624e-06 0.8541115036082744 \
1.30279805438677e-06 0.855025905954957 1.302798254818193e-06 0.8559685891497206 1.302798447410669e-06 0.8568563992305701 1.302798658273806e-06 0.8578086227668252 \
1.302798886187182e-06 0.8588150784816577 1.302799152217719e-06 0.8599606428795262 1.302799450738801e-06 0.8612090806949765 1.302799726692482e-06 0.8623286542354505 \
1.302800010954596e-06 0.8634483918036945 1.302800285103046e-06 0.8644969441068078 1.302800557392313e-06 0.8655088801415273 1.302800827558089e-06 0.8664846790737442 \
1.302801084736186e-06 0.8673881555543895 1.302801357299353e-06 0.868319368003445 1.302801633304697e-06 0.8692355072818493 1.302801903418629e-06 0.870106770567397 \
1.302802203245002e-06 0.8710447971670072 1.302802574222291e-06 0.8721640818024149 1.302802869154012e-06 0.8730224021943973 1.302803123432376e-06 0.873740732376842 \
1.302803421677207e-06 0.8745584461000401 1.302803695285219e-06 0.8752856917963749 1.302803931415444e-06 0.8758961959341748 1.302804171760979e-06 0.8765017794770257 \
1.302804394097168e-06 0.8770481951318053 1.302804588102451e-06 0.8775144010549708 1.302804917823794e-06 0.8782846129827527 1.30280507299682e-06 0.8786376896881318 \
1.302805390752408e-06 0.8793424631377607 1.302805569616983e-06 0.8797286397841958 1.302805912078462e-06 0.8804474051285093 1.302806096217817e-06 0.880822800830328 \
1.302806571118475e-06 0.881756283451624 1.302806738513154e-06 0.8820737784441692 1.3028072043462e-06 0.8829272622221894 1.302807385170493e-06 0.8832470363605239 \
1.302807879204793e-06 0.8840891816604841 1.302808020548669e-06 0.8843218944112644 1.302808626940586e-06 0.8852805359894154 1.302808779011766e-06 0.8855111592597558 \
1.302809425691436e-06 0.8864506941541785 1.302809553987642e-06 0.8866295550025313 1.302810202164815e-06 0.8874976172723908 1.302810331923675e-06 0.8876644392549727 \
1.302811100144497e-06 0.8886037370453904 1.302811229881009e-06 0.8887539063021698 1.302812083306654e-06 0.8896836309705964 1.302812226565088e-06 0.8898301468060963 \
1.302813212785821e-06 0.890764641901611 1.302813434267227e-06 0.8909571971396437 1.302814577308628e-06 0.8918770673440963 1.302814707298117e-06 0.8919774876506176 \
1.302816058923389e-06 0.8929731820841386 1.30281620928357e-06 0.89307657739048 1.302817689916169e-06 0.8939986636922405 1.302817928817934e-06 0.8941315911431026 \
1.302819693311633e-06 0.894999985510941 1.302820000994978e-06 0.8951330875684044 1.302822522266181e-06 0.8960612226716312 1.302822959317422e-06 0.8961978289811912 \
1.302826862729643e-06 0.8971619289239613 1.30282710951145e-06 0.8972094058147089 1.302834686001284e-06 0.8981998139535015 1.302834801913031e-06 0.8982099955090975 \
1.302853900445735e-06 0.8992062631372056 1.302854297888509e-06 0.8992194728667773 1.30300471332359e-06 0.9002121614362558 1.303004979381947e-06 0.9002436812458944 \
1.303010247532015e-06 0.8993470931706574 1.303010453902932e-06 0.899191170936528 1.303011932015742e-06 0.8982046351054961 1.303012112466399e-06 0.8981003355419954 \
1.303014334948061e-06 0.8971299612768925 1.303014541040576e-06 0.897079983173831 1.303024949306681e-06 0.8980580240048047 1.303025087164257e-06 0.8980839755683444 \
1.303031884513298e-06 0.8990685088718567 1.303032070084766e-06 0.8990874390200084 1.303528299258968e-06 0.9000706848616691 1.303528359054814e-06 0.9000975977971888 \
1.303529612605432e-06 0.9010828413531861 1.303529718298035e-06 0.9012097231395001 1.303530376428752e-06 0.9021613947651476 1.303530513611021e-06 0.9023918767045529 \
1.303531036637641e-06 0.9033649777562528 1.303531099501233e-06 0.9034908765919824 1.303531572096782e-06 0.904476514442582 1.303531623410595e-06 0.9045863669199017 \
1.303532089373931e-06 0.9055619780118375 1.303532121578392e-06 0.9056252631670594 1.303532838677129e-06 0.9066212416280413 1.303532923113402e-06 0.9066528951765993 \
1.303533523179781e-06 0.9059679814895146 1.303533643037393e-06 0.9055903401525059 1.303533774200172e-06 0.9050640446667092 1.303533909019925e-06 0.9043926011431642 \
1.303534057154984e-06 0.9034897747335404 1.303534194714335e-06 0.902493211317788 1.303534334926095e-06 0.9013135799985507 1.303534433588205e-06 0.9003872218501816 \
1.303534519272014e-06 0.8995148096066522 1.303534601836213e-06 0.8986166894493001 1.303534716618842e-06 0.8972773101170661 1.303534797717086e-06 0.8962642459447687 \
1.303534877134364e-06 0.8952218112132616 1.303534982588892e-06 0.8937633947192651 1.303535105230195e-06 0.8919606744930825 1.303535204954274e-06 0.890414036797163 \
1.303535375148685e-06 0.8876203405523397 1.303535521333777e-06 0.8850727273800474 1.303535689551925e-06 0.8819879035815887 1.303535861713021e-06 0.8786780617039783 \
1.303536046099114e-06 0.8749807502679057 1.303536230665458e-06 0.8711418063496947 1.303536414912944e-06 0.8671917613865908 1.303536600248607e-06 0.8631174608718694 \
1.303536774636335e-06 0.8592060069639053 1.303536957340272e-06 0.8550405244181323 1.303537132687366e-06 0.8509893565349284 1.303537315016877e-06 0.8467313026054767 \
1.303537505330306e-06 0.8422468264612591 1.303537675660435e-06 0.838204894125699 1.303537842184074e-06 0.8342320488410089 1.303538004754937e-06 0.830337741667393 \
1.30353815461616e-06 0.8267359097041467 1.303538305792179e-06 0.8230937075736249 1.303538494937653e-06 0.8185270080344306 1.303538640655707e-06 0.8150026134285653 \
1.303538815646674e-06 0.8107652770601156 1.303538964118217e-06 0.807166938184282 1.303539136005683e-06 0.8029987283123258 1.303539305073922e-06 0.7988973224349885 \
1.303539469252632e-06 0.7949140139776875 1.303539628580169e-06 0.7910485911592836 1.303539789029776e-06 0.7871568543472617 1.303539990849157e-06 0.7822630953020117 \
1.303540139296892e-06 0.7786646206504594 1.303540293464276e-06 0.77492821376164 1.303540430547636e-06 0.7716074476660475 1.303540539933082e-06 0.7689587163513494 \
1.303540645866538e-06 0.7663946531324515 1.303540772880885e-06 0.7633217481666642 1.303540887243854e-06 0.7605561828888391 1.303540990091676e-06 0.7580702160470256 \
1.303541111681992e-06 0.7551325442760125 1.303541222459267e-06 0.7524575925939972 1.303541339308092e-06 0.7496376180588871 1.303541450092818e-06 0.7469652567786068 \
1.303541568458919e-06 0.7441116745915923 1.303541693286014e-06 0.7411038668912771 1.30354184584781e-06 0.7374292753756717 1.303541979744798e-06 0.7342062928952946 \
1.303542100776237e-06 0.7312947572377408 1.303542264973752e-06 0.7273475399259534 1.303542442334699e-06 0.7230877912371642 1.303542624545108e-06 0.7187161681757385 \
1.303542805542373e-06 0.7143786395952922 1.303542986206316e-06 0.7100537072471783 1.303543176357883e-06 0.7055071781827296 1.303543364117777e-06 0.7010230964996226 \
1.303543564650881e-06 0.696237807975249 1.303543773336343e-06 0.6912646166759551 1.303543980979908e-06 0.6863227581165517 1.303544208547776e-06 0.6809140411171237 \
1.30354440082261e-06 0.6763521085712711 1.303544638087858e-06 0.6707310800019505 1.303544831366122e-06 0.6661595641347996 1.303545064098869e-06 0.6606646229758047 \
1.303545269656336e-06 0.6558174602470968 1.303545502009757e-06 0.6503484594495911 1.303545697011728e-06 0.6457674053103037 1.303545900240336e-06 0.6410004262200759 \
1.303546080092881e-06 0.6367906205544323 1.303546259199312e-06 0.6326052789263827 1.303546422576526e-06 0.628795088826817 1.30354659462593e-06 0.6247880828503264 \
1.303546758118769e-06 0.6209892715878097 1.303546933908587e-06 0.6169100951581823 1.303547115847573e-06 0.6126978430086294 1.303547304331305e-06 0.6083422542008314 \
1.303547510763727e-06 0.6035858951323969 1.30354769007839e-06 0.5994633272559844 1.303547887257256e-06 0.5949432360761027 1.303548096345397e-06 0.5901646611556908 \
1.30354830209466e-06 0.5854760387944159 1.303548542605348e-06 0.5800160304866983 1.30354871573345e-06 0.5760958285528379 1.303548880627452e-06 0.5723746772837877 \
1.303549061488027e-06 0.5683014035092815 1.303549218774123e-06 0.5647722902613652 1.303549387756918e-06 0.5609879409349005 1.303549567863379e-06 0.5569709657351898 \
1.303549720846506e-06 0.5535669615732179 1.303549852560951e-06 0.5506462283231492 1.303549999948651e-06 0.5473865746199473 1.303550087374242e-06 0.5454560063082221 \
1.303550172245482e-06 0.5435860258811447 1.303550270874694e-06 0.5414171943998213 1.303550342966855e-06 0.5398340751058975 1.303550440057874e-06 0.5377039800781129 \
1.303550525648258e-06 0.5358302678688993 1.303550590729134e-06 0.5344081412607664 1.303550714329502e-06 0.5317121235594142 1.303550808753772e-06 0.52965475734789 \
1.303550906276994e-06 0.5275349985745696 1.303551079137645e-06 0.5237893654184622 1.303551214133166e-06 0.5208709659121862 1.303551368316628e-06 0.5175498113398643 \
1.303551542781984e-06 0.5138002600288881 1.30355169458797e-06 0.510550000123414 1.303551840818953e-06 0.5074290310664136 1.303551984717826e-06 0.5043644611166801 \
1.303552127739669e-06 0.5013276181140283 1.303552223349517e-06 0.499301733014788 1.303552317793473e-06 0.4973032961550828 1.303552438849414e-06 0.4947494705229025 \
1.30355253372771e-06 0.4927525559781179 1.303552649558553e-06 0.4903172469328811 1.303552736822402e-06 0.4884854516151125 1.303552819252848e-06 0.4867593351188191 \
1.303552914660802e-06 0.484765406725184 1.303553015371081e-06 0.4826639978995959 1.303553112231473e-06 0.4806459052877932 1.303553250961225e-06 0.4777646955734051 \
1.303553386666086e-06 0.4749532752442271 1.303553587150809e-06 0.4708139964547478 1.303553802464962e-06 0.4663911383470885 1.303553984040267e-06 0.462674698484628 \
1.303554183012236e-06 0.4586189944293299 1.303554353577757e-06 0.455154096457448 1.303554527931445e-06 0.4516251957269069 1.303554696864699e-06 0.4482170126441485 \
1.30355486946186e-06 0.4447467276163349 1.30355505206819e-06 0.4410867902598327 1.303555240617055e-06 0.4373240875354826 1.303555434084593e-06 0.4334777823509549 \
1.303555642405232e-06 0.4293535036700135 1.303555856750462e-06 0.4251286740881063 1.303556082455792e-06 0.4207018662297695 1.30355630899916e-06 0.4162771402745992 \
1.303556571175911e-06 0.4111844468197049 1.303556820209735e-06 0.4063709766754009 1.303557121308433e-06 0.4005865607947761 1.30355741072925e-06 0.3950673729298416 \
1.303557718243529e-06 0.3892455819062323 1.303558040439924e-06 0.3831936848847286 1.303558368170407e-06 0.3770882112794804 1.303558700600163e-06 0.3709500980558715 \
1.30355903032917e-06 0.3649083177186754 1.303559351558758e-06 0.3590729273462687 1.303559682375082e-06 0.3531219177045733 1.303560024730645e-06 0.3470224718704957 \
1.303560324371677e-06 0.3417374346434491 1.303560654159242e-06 0.3359723367088904 1.303560981053185e-06 0.3303128110141857 1.303561319032532e-06 0.3245206193888226 \
1.303561628003696e-06 0.3192755432624759 1.303561952801669e-06 0.31382336954194 1.303562268431866e-06 0.3085864885517507 1.303562573419032e-06 0.3035810258414895 \
1.303562828757677e-06 0.2994330834535801 1.303563093620834e-06 0.295170851203172 1.303563380703519e-06 0.2905978071194348 1.303563603673297e-06 0.2870801635277143 \
1.303563803212567e-06 0.2839591363066187 1.30356401286858e-06 0.2807045410859125 1.303564193125121e-06 0.2779290029372279 1.303564355469842e-06 0.2754463208250681 \
1.303564505904816e-06 0.2731629026725527 1.303564656910124e-06 0.2708866524077067 1.303564853800715e-06 0.2679392949564011 1.303564984945479e-06 0.2659970646012914 \
1.303565109682017e-06 0.2641561221543183 1.30356526127406e-06 0.2619266655689588 1.303565357242231e-06 0.2605306204207966 1.3035654537936e-06 0.2591282589302421 \
1.303565578413389e-06 0.2573209601776467 1.303565720989923e-06 0.255257422470362 1.303565879923458e-06 0.25296979123958 1.303566012589525e-06 0.251062957019046 \
1.303566196158294e-06 0.2484301322588876 1.30356637739346e-06 0.2458327969660818 1.303566588907564e-06 0.2428051031600066 1.303566791497399e-06 0.2399069804317323 \
1.303566958053847e-06 0.2375282895552967 1.303567168273059e-06 0.2345337828133105 1.303567341690945e-06 0.2320692345528927 1.303567570533673e-06 0.2288260787734411 \
1.303567791168424e-06 0.2257162440502939 1.303567966830138e-06 0.2232503232699662 1.303568147290643e-06 0.2207258962977968 1.303568318047021e-06 0.2183528725291195 \
1.303568498243287e-06 0.2158619697278009 1.303568664973905e-06 0.2135675266585953 1.303568814095326e-06 0.2115251542210239 1.303568969905344e-06 0.2094125291275523 \
1.303569105085769e-06 0.2075875692769576 1.303569255167197e-06 0.2055694209972212 1.303569387612823e-06 0.2037957203154137 1.303569528157359e-06 0.2019220745191926 \
1.303569645226124e-06 0.2003748851744883 1.30356977493373e-06 0.1986681706274326 1.303569896991199e-06 0.1970700654731777 1.303570019534635e-06 0.1954731161836187 \
1.303570137553958e-06 0.1939418157697267 1.303570272576731e-06 0.1921981789937757 1.303570417201182e-06 0.1903420634523806 1.303570545551681e-06 0.1887049708672087 \
1.303570669186156e-06 0.1871351133418249 1.303570766736279e-06 0.1859021016257166 1.303570881809208e-06 0.1844539912642748 1.303570975507888e-06 0.1832809848801438 \
1.303571074292012e-06 0.1820493959460708 1.303571197226553e-06 0.1805230483556907 1.303571292980556e-06 0.1793400249325384 1.303571422068107e-06 0.177753298391591 \
1.303571524533477e-06 0.1764993061988986 1.303571622786974e-06 0.1753029542432101 1.303571742874187e-06 0.1738483570896001 1.303571845423405e-06 0.1726127298531683 \
1.303571955881064e-06 0.1712877101305652 1.303572084370928e-06 0.1697552709290656 1.303572175855769e-06 0.1686698090598139 1.303572280340358e-06 0.1674358120019214 \
1.303572355277094e-06 0.1665544493622226 1.303572444845591e-06 0.1655049734124585 1.3035724954106e-06 0.164914347906921 1.303572545388976e-06 0.1643318187475747 \
1.303572610358061e-06 0.163576534137217 1.303572645872029e-06 0.1631646263336159 1.303572718071202e-06 0.162329174921529 1.303572785200297e-06 0.1615546732967998 \
1.303572844430032e-06 0.160873195114598 1.30357288817563e-06 0.1603710314414745 1.303572935822458e-06 0.1598254649913795 1.303573006202993e-06 0.1590230739426561 \
1.303573088541159e-06 0.1580883269013631 1.303573166712759e-06 0.1572048664554128 1.303573248765709e-06 0.1562816770844126 1.303573341469331e-06 0.1552436243401225 \
1.303573464249495e-06 0.153877370231325 1.303573563395588e-06 0.1527810927807017 1.303573664895935e-06 0.1516651170047695 1.303573766171127e-06 0.1505582666538253 \
1.303573862662911e-06 0.1495093242781697 1.303573962080946e-06 0.1484346886615803 1.303574046381569e-06 0.1475281828465028 1.303574139320259e-06 0.1465342051547719 \
1.3035742219212e-06 0.1456551508734999 1.303574330687285e-06 0.1445034822456445 1.303574436330265e-06 0.1433917535370727 1.303574517989854e-06 0.1425365900703354 \
1.303574611735024e-06 0.1415598856352903 1.303574705302971e-06 0.1405903867550886 1.303574788187462e-06 0.139735765814107 1.303574876346636e-06 0.1388313836440244 \
1.303574956132722e-06 0.1380170907865772 1.303575049728122e-06 0.1370669869522621 1.303575139660646e-06 0.1361590166429519 1.303575210211042e-06 0.1354501541392388 \
1.303575279971219e-06 0.1347521119166949 1.303575394120126e-06 0.1336164586193709 1.30357547609874e-06 0.1328058651355588 1.303575563704042e-06 0.1319440719770354 \
1.303575663205238e-06 0.1309710196939938 1.303575772385241e-06 0.1299110174488692 1.303575874550573e-06 0.1289256009328031 1.303575982010779e-06 0.1278959836800649 \
1.303576102045057e-06 0.1267549558890445 1.303576196253091e-06 0.1258657925752028 1.303576327232195e-06 0.1246390638240933 1.303576426659896e-06 0.1237164070883829 \
1.303576535781582e-06 0.1227104370444639 1.30357664463475e-06 0.1217138859540913 1.303576736944154e-06 0.120874257454373 1.303576849784484e-06 0.1198547128626846 \
1.303576946796524e-06 0.118986084968971 1.303577051062872e-06 0.1180628196869088 1.303577160029802e-06 0.1171053395831002 1.303577259569368e-06 0.1162371554254778 \
1.303577376562078e-06 0.1152245300989246 1.303577463662868e-06 0.1144761644999183 1.30357757295452e-06 0.1135478691973115 1.303577654479583e-06 0.1128618460838699 \
1.303577754254576e-06 0.1120273350449922 1.303577871679726e-06 0.1110526766231405 1.303577973464844e-06 0.1102143708571793 1.303578061203792e-06 0.1094962336869811 \
1.3035781420033e-06 0.1088432886892514 1.303578228954319e-06 0.1081456845520918 1.303578309740945e-06 0.1075007757815706 1.303578399947511e-06 0.1067842832273628 \
1.303578490898266e-06 0.1060655611559195 1.30357857956879e-06 0.1053685613006139 1.303578678583611e-06 0.1045946508745568 1.303578772289787e-06 0.1038723470842792 \
1.303578866149063e-06 0.1031520741219857 1.303578966976511e-06 0.1023817709659086 1.303579071607409e-06 0.1015861061604995 1.303579195570165e-06 0.1006484085638475 \
1.303579292969478e-06 0.09991551135558702 1.303579413227425e-06 0.09901872452754552 1.3035795240953e-06 0.09819831936474602 1.303579628568336e-06 0.09742874659471555 \
1.303579745805045e-06 0.09656937225591002 1.303579847599366e-06 0.09582695326576983 1.303579945574917e-06 0.09511577589263259 1.303580086079406e-06 0.09410164141823299 \
1.303580191157202e-06 0.09334832721827611 1.303580289770019e-06 0.09264549593674179 1.303580382484827e-06 0.09198739948435641 1.303580468683212e-06 0.09137785861853052 \
1.303580562596188e-06 0.09071637432184691 1.303580659696934e-06 0.09003559055802626 1.303580769117988e-06 0.08927317549644689 1.303580870101537e-06 0.08857281843916648 \
1.303580963759483e-06 0.08792605868920525 1.303581037934155e-06 0.08741581771673042 1.303581175834007e-06 0.08647193599618339 1.303581248191011e-06 0.08597917321277694 \
1.303581383512214e-06 0.08506274029062395 1.303581469423819e-06 0.08448410751389913 1.303581614152054e-06 0.08351486081643937 1.303581710382619e-06 0.0828744112740944 \
1.303581798218398e-06 0.08229260392026354 1.303581914017306e-06 0.08152964121883956 1.303582029145757e-06 0.08077575264951149 1.30358214291219e-06 0.08003553900012179 \
1.303582283169683e-06 0.0791300282244784 1.303582424545716e-06 0.07822490276368012 1.303582574181758e-06 0.07727536491519127 1.303582718670613e-06 0.07636690312463701 \
1.303582869844724e-06 0.07542565384097814 1.303583019215544e-06 0.07450459906593411 1.303583168562251e-06 0.0735926433331697 1.303583328517767e-06 0.07262574717347114 \
1.303583484664678e-06 0.07169171823582712 1.303583659153112e-06 0.07065947636250877 1.303583828862219e-06 0.0696671357044583 1.303584014041303e-06 0.0685979885997255 \
1.30358421076238e-06 0.06747763456279594 1.3035844212802e-06 0.06629631776014881 1.303584643312255e-06 0.06507007089066431 1.303584873524276e-06 0.0638195278444372 \
1.303585116035382e-06 0.06252626147401 1.303585376689467e-06 0.06116236403900636 1.303585656588531e-06 0.05972739422233359 1.303585950172255e-06 0.05825544847408989 \
1.303586265108239e-06 0.05671370145268265 1.303586607914164e-06 0.05507846134953124 1.303586957380758e-06 0.0534565727116736 1.303587366284915e-06 0.05161746230842366 \
1.303587712949942e-06 0.05010669351290297 1.303588100364996e-06 0.04846839895323611 1.303588444582788e-06 0.04705645202362623 1.303588768009047e-06 0.04576625679949029 \
1.303589073054809e-06 0.04458093278443617 1.303589365916806e-06 0.04347099288378908 1.303589650057723e-06 0.04242242262004604 1.303589926078015e-06 0.04142902112907627 \
1.303590192930566e-06 0.04049015932812138 1.303590461822789e-06 0.03956531631184226 1.303590737883211e-06 0.03863769040165695 1.303591025478782e-06 0.03769451689421055 \
1.303591265044408e-06 0.03692662498323904 1.303591554211835e-06 0.03602084344675294 1.303591770003438e-06 0.03535960341037672 1.303591957720476e-06 0.03479599077274986 \
1.303592155849582e-06 0.03421285035004928 1.303592518724446e-06 0.03317032497347058 1.303592776866276e-06 0.03244834222605905 1.30359308657919e-06 0.0316030971185694 \
1.303593352049329e-06 0.03089664771451467 1.303593620168408e-06 0.03019941363307669 1.303593899042439e-06 0.02949128999862272 1.303594145228875e-06 0.02888043298519722 \
1.303594375860285e-06 0.02832033800396738 1.303594614150204e-06 0.02775711540944564 1.303594849157568e-06 0.02721270742060762 1.303595076940031e-06 0.02669509678424227 \
1.303595485552303e-06 0.02579039168486155 1.303595661854632e-06 0.02540904040268441 1.303596016332316e-06 0.02465798827491217 1.303596200203288e-06 0.02427641469830137 \
1.30359653515201e-06 0.02359448510613503 1.303596699060727e-06 0.02326678168937357 1.303597091331304e-06 0.02249905491676728 1.303597247322069e-06 0.02220010404946675 \
1.303597678925426e-06 0.02138321689778962 1.303597816314806e-06 0.0211255367654138 1.303598333123589e-06 0.02017559010600388 1.303598458659483e-06 0.01995091418019728 \
1.303598915901007e-06 0.01915998482559782 1.303599075046989e-06 0.01889493739859509 1.303599682285467e-06 0.01793263500095189 1.303599816822955e-06 0.01772934138481063 \
1.303600480086948e-06 0.01678091027541291 1.303600673410379e-06 0.01651856846389665 1.303601341067039e-06 0.01565087920017967 1.303601502655887e-06 0.01544858341705342 \
1.30360225789114e-06 0.01454101846553843 1.303602407452107e-06 0.01436800730673201 1.303603297789931e-06 0.01338293844200974 1.303603396447817e-06 0.01327873262558703 \
1.303604353121314e-06 0.01230993787860994 1.303604474231021e-06 0.01219243157195396 1.30360546572373e-06 0.01126376273051215 1.30360562925246e-06 0.01111855113153209 \
1.303606759174536e-06 0.01018247077230436 1.303606871621774e-06 0.01009565848301377 1.303608249445262e-06 0.009103273453806031 1.303608388390533e-06 0.009009747578659758 \
1.303609942788868e-06 0.008018073335410726 1.30361005485534e-06 0.00794673960805117 1.30361169983817e-06 0.006958154532207958 1.303611807090665e-06 0.006899512253112593 \
1.303613751584152e-06 0.005937533026687714 1.30361395848211e-06 0.005843834961138424 1.303616297369853e-06 0.00487227039639981 1.303616721356264e-06 0.004712306502041247 \
1.30361949358946e-06 0.003780857497341114 1.303619941898552e-06 0.003647790772321777 1.303623582397237e-06 0.00272553831825111 1.303624079053072e-06 0.002619503085887757 \
1.303629830173496e-06 0.001650572925599863 1.303630116955383e-06 0.001609446887446839 1.303635471944067e-06 0.0006353228983793809 1.303635677300692e-06 0.0005920420449145349 \
1.306282712074507e-06 -0.0002718533828215428 1.306282867950111e-06 -0.0004579010352009555 1.306283416265203e-06 -0.001326296959495401 1.306283529048879e-06 -0.001543805653187533 \
1.306283963541018e-06 -0.002491429791030493 1.306284039366175e-06 -0.002673591589873599 1.306284396016773e-06 -0.003590195133438418 1.306284523065853e-06 -0.003936807634339821 \
1.306284801566247e-06 -0.004716444651655622 1.30628490965073e-06 -0.005020876868076652 1.306285253249855e-06 -0.00592430224391268 1.30628536024372e-06 -0.006162325733041658 \
1.306286259614116e-06 -0.005653094509861465 1.306286438047545e-06 -0.004687598829536962 1.30628654377096e-06 -0.003940993102967527 1.306286668833738e-06 -0.002883597584075996 \
1.306286762417834e-06 -0.001971418478057775 1.306286840257396e-06 -0.001132968824455395 1.306286920329394e-06 -0.0001977429743171 1.306287042702205e-06 0.001370578777960296 \
1.306287160958077e-06 0.003041212838230153 1.306287279607187e-06 0.004860750887681821 1.306287393089626e-06 0.006730904986417607 1.306287496532765e-06 0.008536402178002854 \
1.306287611192018e-06 0.01064190690353853 1.306287801775811e-06 0.0143607330143792 1.306287935565949e-06 0.01711819191720031 1.306288085819515e-06 0.02033933849841947 \
1.306288240988763e-06 0.02378599874269359 1.306288396380811e-06 0.0273434151175349 1.306288544088043e-06 0.03080849965087477 1.306288693077668e-06 0.03437359286003162 \
1.306288848068751e-06 0.03814545786868043 1.306289007439365e-06 0.04208062121327779 1.306289172372776e-06 0.04620305710844342 1.306289347319105e-06 0.0506208066052034 \
1.306289526449176e-06 0.05518387280380205 1.306289716238432e-06 0.06005265756871143 1.3062899199354e-06 0.06530840376289772 1.306290139745932e-06 0.07100650943730057 \
1.306290371497376e-06 0.07703584544314998 1.306290619322673e-06 0.08349927754587044 1.306290890643603e-06 0.09058756662233436 1.306291185356381e-06 0.09829181712822582 \
1.306291510614029e-06 0.106792896697727 1.306291876859735e-06 0.1163551101154179 1.306292270156448e-06 0.1266079356677421 1.306292722809344e-06 0.1383809089651769 \
1.306293248524511e-06 0.1520098384503803 1.306293867738049e-06 0.1679979965193872 1.306294548482366e-06 0.1854865650013753 1.30629534215732e-06 0.2057488551561759 \
1.306296230922953e-06 0.2282732214494322 1.306297044312215e-06 0.2487218262351868 1.306297766061792e-06 0.2667261628598245 1.3062984017258e-06 0.282460740414376 \
1.306298973442562e-06 0.2965101025186013 1.306299508996846e-06 0.3095696210007924 1.306300012355259e-06 0.3217495654069301 1.306300488682702e-06 0.3331878525640654 \
1.306300962606306e-06 0.3444754071334732 1.306301420078024e-06 0.3552759747331513 1.306301886058294e-06 0.3661792384270033 1.306302335046104e-06 0.376592601923634 \
1.306302831152646e-06 0.3879857357798637 1.306303350914508e-06 0.3998002499051578 1.306303730319152e-06 0.4083447473225827 1.306304170327876e-06 0.4181679450526055 \
1.306304640096814e-06 0.4285466970600206 1.306305125617752e-06 0.4391589006481625 1.306305565065858e-06 0.4486701556983262 1.306305626818807e-06 0.4500002248264944 \
1.306305750324704e-06 0.4526540461147197 1.306305997336498e-06 0.4579447795386873 1.306306249931409e-06 0.463325462421476 1.306306447502524e-06 0.467511453725808 \
1.306306673074272e-06 0.4722681264242033 1.306306994642268e-06 0.4790073975813253 1.306307263421497e-06 0.4846013351959894 1.30630748207297e-06 0.4891262574467725 \
1.306307692176936e-06 0.4934547887280634 1.306307918582462e-06 0.4980921872304203 1.306308127687652e-06 0.5023516957637455 1.306308317089911e-06 0.5061927337048852 \
1.306308441251129e-06 0.5086969563931187 1.306308568006226e-06 0.5112441466129884 1.306308728004704e-06 0.5144514110933732 1.306308975647656e-06 0.5193914248715521 \
1.306309154234115e-06 0.5229351592435862 1.306309325187692e-06 0.5263079149198099 1.306309586537288e-06 0.5314455197962068 1.30630981260887e-06 0.5358634945234868 \
1.306310015740537e-06 0.5398188128751134 1.306310180971267e-06 0.5430252218652345 1.306310337758288e-06 0.5460612552756139 1.306310526914905e-06 0.5497137532216215 \
1.306310728782658e-06 0.5535976061995346 1.306310952933981e-06 0.5578986282275192 1.306311191316346e-06 0.5624617013850463 1.306311426077985e-06 0.566941985223824 \
1.30631165634869e-06 0.5713275351537204 1.306311862141324e-06 0.5752375533958141 1.306312067125538e-06 0.5791255875933676 1.30631230994078e-06 0.5837094709690289 \
1.306312564698362e-06 0.588493349632063 1.306312792926793e-06 0.5927514274590796 1.306313030765665e-06 0.5971656109489694 1.306313243043101e-06 0.6010807441713891 \
1.306313454836505e-06 0.6049674646600495 1.306313708720774e-06 0.6095919957414236 1.306313913314301e-06 0.6132953190650409 1.306314165037654e-06 0.6178178328453598 \
1.306314352827174e-06 0.6211736970442716 1.306314605700251e-06 0.6256587164710262 1.306314804109613e-06 0.6291560967673944 1.306314983842284e-06 0.6323071487074056 \
1.306315254113091e-06 0.6370161336915187 1.306315471396857e-06 0.6407803561788556 1.306315651923236e-06 0.6438916924996977 1.306315853084131e-06 0.6473460740030906 \
1.306316021667512e-06 0.650231451944099 1.30631622602572e-06 0.6537144072723954 1.306316371688778e-06 0.6561873372238678 1.306316536247377e-06 0.6589728476742622 \
1.306316705716593e-06 0.6618316558839334 1.306316859256675e-06 0.664412775690417 1.306317000490202e-06 0.6667750288922751 1.306317144066014e-06 0.6691685747430841 \
1.306317277296139e-06 0.6713840140331436 1.306317419196459e-06 0.6737368819239464 1.306317539430086e-06 0.6757233098298149 1.306317684081138e-06 0.6781085120392751 \
1.306317800299844e-06 0.6800197521569988 1.306317919382163e-06 0.6819757159594566 1.306318017960477e-06 0.6835903813535821 1.306318135558183e-06 0.6855122399681081 \
1.306318222994146e-06 0.6869376986921233 1.306318347740232e-06 0.6889650632873403 1.306318447547296e-06 0.6905825000046129 1.306318540037093e-06 0.6920753042469043 \
1.306318641321177e-06 0.6937043390836264 1.306318739114283e-06 0.695273833970533 1.306318830385075e-06 0.6967333967490603 1.306318932842905e-06 0.6983656370917724 \
1.306319065752136e-06 0.7004728611232253 1.306319220767541e-06 0.7029137789397926 1.306319355649227e-06 0.7050222373350452 1.306319501145018e-06 0.7072806469370021 \
1.306319628999685e-06 0.709252249158637 1.306319753457981e-06 0.7111597484283609 1.306319864783685e-06 0.7128563623504806 1.306319978813713e-06 0.7145852226468989 \
1.30632007932493e-06 0.7161013069709498 1.306320216526077e-06 0.7181590832501857 1.306320336471979e-06 0.7199473375636642 1.306320455641778e-06 0.7217141075019444 \
1.306320582586792e-06 0.7235855504531626 1.306320707354209e-06 0.7254141264975077 1.306320830849597e-06 0.7272133847865295 1.30632095763087e-06 0.7290498056238117 \
1.306321088220355e-06 0.730930225429108 1.306321210432258e-06 0.7326797786847141 1.306321347490271e-06 0.7346298644824388 1.306321448705626e-06 0.7360619656663578 \
1.306321553674562e-06 0.7375401619041119 1.306321645165995e-06 0.7388229997694907 1.306321758241356e-06 0.7404001534680551 1.30632184554224e-06 0.7416107338190071 \
1.306321950005571e-06 0.7430512000342341 1.306322080768703e-06 0.7448411286358657 1.3063221906822e-06 0.7463352048609909 1.306322295341958e-06 0.7477488743938407 \
1.30632241917362e-06 0.7494094725133206 1.306322567926971e-06 0.751387874302702 1.306322689842132e-06 0.7529958494242643 1.306322803696392e-06 0.7544867042370438 \
1.30632294419585e-06 0.7563117925204224 1.306323085519364e-06 0.7581313010100689 1.306323203298972e-06 0.7596352654099263 1.306323331697459e-06 0.7612620174900669 \
1.306323474021161e-06 0.7630496612437514 1.306323590410316e-06 0.7644991888858087 1.306323736133978e-06 0.7662987831554334 1.306323857913867e-06 0.7677897310961733 \
1.306323976478797e-06 0.7692300520321635 1.306324099092246e-06 0.7707078417740018 1.306324225543629e-06 0.77221964326554 1.306324335666584e-06 0.7735261258099556 \
1.306324461188726e-06 0.7750039859681491 1.306324566849672e-06 0.7762386743660952 1.306324702026829e-06 0.7778058706872942 1.306324825637346e-06 0.7792267957652825 \
1.306324955634725e-06 0.7807078764205345 1.306325068606223e-06 0.7819831642610904 1.306325176500111e-06 0.7831908181350914 1.306325313030793e-06 0.7847046126527283 \
1.306325463151702e-06 0.7863508260127218 1.306325605416006e-06 0.7878933964149381 1.306325724997519e-06 0.7891771019825847 1.306325861808649e-06 0.7906313890246753 \
1.306325984312413e-06 0.7919206245676671 1.306326128984341e-06 0.7934276941869095 1.306326269769414e-06 0.794878360380241 1.306326396585209e-06 0.796171745508174 \
1.306326515632602e-06 0.7973744708066829 1.306326627895563e-06 0.7984986270115709 1.306326732283333e-06 0.7995352562746869 1.306326827560395e-06 0.8004739840425704 \
1.306326963902891e-06 0.8018044219089175 1.30632708076796e-06 0.8029326473252685 1.306327200364489e-06 0.8040757482679398 1.306327322250299e-06 0.8052288531124292 \
1.306327444838559e-06 0.8063765489401953 1.306327572579618e-06 0.8075599074701925 1.306327697362526e-06 0.8087035441861687 1.306327827862901e-06 0.8098867241643505 \
1.306327954229597e-06 0.8110199871086299 1.306328081578389e-06 0.8121498004723215 1.306328186791179e-06 0.8130740322933268 1.306328291495184e-06 0.8139855427426806 \
1.30632838302539e-06 0.8147757515715357 1.30632850639836e-06 0.8158311616195392 1.306328593352408e-06 0.8165684017534872 1.306328692208245e-06 0.8173999442793862 \
1.306328836710884e-06 0.8186029267949408 1.306328973036573e-06 0.8197243345631372 1.306329082445008e-06 0.8206145128367788 1.306329228461948e-06 0.821788834531623 \
1.306329380203007e-06 0.8229927727264784 1.306329506119585e-06 0.8239792970156907 1.306329650568649e-06 0.8250971468990039 1.306329775264817e-06 0.8260503472050121 \
1.306329925878834e-06 0.8271873005969326 1.306330061249302e-06 0.8281959289694237 1.306330186472937e-06 0.8291179217777711 1.306330304128897e-06 0.8299746468143927 \
1.30633044991051e-06 0.8310230722388168 1.30633061639426e-06 0.8322027532553667 1.306330747215023e-06 0.8331167337813133 1.306330920675045e-06 0.834311196379941 \
1.306331088787841e-06 0.8354501125721271 1.306331258668969e-06 0.8365827385393307 1.306331439512628e-06 0.8377685497174457 1.306331582704692e-06 0.8386931238161603 \
1.306331696822189e-06 0.8394210074154138 1.3063318268738e-06 0.8402408682651782 1.306331928753516e-06 0.8408758513273116 1.306332045641139e-06 0.841596551294542 \
1.306332182786859e-06 0.8424315815669623 1.306332380696072e-06 0.8436167827761205 1.306332572515411e-06 0.8447436440637145 1.306332781866158e-06 0.8459494874145237 \
1.306332964017768e-06 0.8469786287449077 1.30633316110399e-06 0.8480715276019779 1.306333334356719e-06 0.8490148531186206 1.306333517450963e-06 0.8499943787178993 \
1.30633368858243e-06 0.8508936588199895 1.306333863270272e-06 0.8517955326875627 1.306334038504287e-06 0.8526841769874772 1.306334214641154e-06 0.8535614892404448 \
1.306334405008494e-06 0.8544920815553035 1.306334595580845e-06 0.8554057038167108 1.306334795976838e-06 0.8563474066245403 1.306334988566463e-06 0.8572344253714166 \
1.306335199466375e-06 0.858185963363946 1.306335427341862e-06 0.8591913103610016 1.306335693424718e-06 0.8603357477151101 1.306335991926854e-06 0.8615822374427254 \
1.306336267816323e-06 0.8627000332972231 1.306336552083493e-06 0.8638181192989086 1.306336826221443e-06 0.8648650323418529 1.306337098522366e-06 0.8658754039994767 \
1.306337368678562e-06 0.8668495780678541 1.306337625862699e-06 0.8677515347235455 1.306337898421613e-06 0.8686810999091764 1.306338174469332e-06 0.8695957110915412 \
1.306338444589598e-06 0.8704649939918846 1.306338744449489e-06 0.8714007440816277 1.306339115430114e-06 0.8725171209518352 1.306339410352536e-06 0.8733732402027278 \
1.306339664628271e-06 0.8740897163373675 1.306339962841735e-06 0.8749052413925265 1.306340236411346e-06 0.8756305047096297 1.306340472534749e-06 0.8762394088953867 \
1.306340712859886e-06 0.8768433401198644 1.306340935193821e-06 0.8773882060838187 1.306341129200254e-06 0.8778530214284207 1.306341458909681e-06 0.8786208714695904 \
1.30634161408109e-06 0.87897283049042 1.306341931723491e-06 0.8796750328643211 1.306342110604035e-06 0.8800599154915705 1.306342453064798e-06 0.8807759898408113 \
1.30634263726721e-06 0.8811501695110489 1.306343112296513e-06 0.8820806183873429 1.306343279683462e-06 0.8823969901232691 1.306343745459843e-06 0.8832471741583867 \
1.306343926299187e-06 0.8835657112976044 1.306344420308805e-06 0.8844044135654346 1.306344561623711e-06 0.8846360992458032 1.306345167867327e-06 0.8855901496945974 \
1.306345319942526e-06 0.8858196526512701 1.306345966662599e-06 0.8867549368993356 1.306346094949266e-06 0.8869330782847171 1.306346743158686e-06 0.8877977435561634 \
1.306346872882985e-06 0.8879638504720397 1.306347641302053e-06 0.8888993076310558 1.306347771073903e-06 0.8890488273083775 1.306348624736509e-06 0.8899738047157748 \
1.306348767761561e-06 0.8901192131187072 1.306349754067048e-06 0.8910487927319016 1.3063499755536e-06 0.8912403904783051 1.306351118378138e-06 0.8921548233216382 \
1.306351248258076e-06 0.8922544308366913 1.306352600758498e-06 0.8932425879319322 1.306352751041431e-06 0.8933452769452155 1.306354231575698e-06 0.8942627870546499 \
1.306354470485492e-06 0.8943950258099049 1.306356252518433e-06 0.8952625983306248 1.30635663826586e-06 0.895426813549116 1.306359040424079e-06 0.8963023915260389 \
1.306359515360049e-06 0.8964490046842035 1.306363433287165e-06 0.8974035634625627 1.306363903247409e-06 0.8974927205890085 1.306372272035387e-06 0.8984807567386782 \
1.306372492545714e-06 0.8984960697096243 1.306417072074293e-06 0.8994905034760702 1.306418273460192e-06 0.8995076493514624 1.306554083268694e-06 0.9004821828323031 \
1.306554262245419e-06 0.9005421539807538 1.306557707120337e-06 0.8996085030263692 1.306557879904192e-06 0.8994755022453073 1.3065592062239e-06 0.8985168769831137 \
1.306559392989208e-06 0.8983970610744239 1.306561177194233e-06 0.8974304740967198 1.306561389324515e-06 0.8973403978332656 1.306574730020299e-06 0.8983331062395279 \
1.306574843308144e-06 0.8983517458922662 1.306583546661241e-06 0.8993273409280406 1.30658409447182e-06 0.8993637478389299 1.307076621843715e-06 0.9003542216796759 \
1.307076717582566e-06 0.9004233209197793 1.307077660131942e-06 0.9014023545001312 1.307077822585254e-06 0.9016297223302431 1.3070783892915e-06 0.9025464066367429 \
1.307078496462212e-06 0.9027401250447874 1.307078889770564e-06 0.9035002370985188 1.307079022567928e-06 0.9037710185404622 1.307079402169034e-06 0.9045728679206633 \
1.30707953238378e-06 0.9048512534150681 1.307079993790073e-06 0.9057878278182891 1.307080113037131e-06 0.9060008176934132 1.307081542646165e-06 0.9050557440230738 \
1.307081626316292e-06 0.9046580283931719 1.307081751622122e-06 0.9039622140338933 1.30708185943629e-06 0.9032622438705011 1.307081978430637e-06 0.9023800387125585 \
1.307082093802854e-06 0.9014106868475621 1.307082183899751e-06 0.900578017289966 1.307082295347455e-06 0.8994526603282017 1.307082381426603e-06 0.8985125975436928 \
1.307082487392251e-06 0.8972736935213672 1.307082587160618e-06 0.8960214106762436 1.307082668156228e-06 0.8949470092681954 1.307082777804195e-06 0.8934133399212493 \
1.307082863391606e-06 0.8921520042367302 1.307082955514215e-06 0.8907345325087322 1.307083043733598e-06 0.8893220116766375 1.307083152508351e-06 0.8875100775672261 \
1.307083235401386e-06 0.8860780350921965 1.307083343975057e-06 0.8841400608632336 1.307083436201252e-06 0.8824412727986957 1.30708352082175e-06 0.8808423775446282 \
1.30708360666218e-06 0.8791839877465467 1.30708368587706e-06 0.8776224824828824 1.30708376196503e-06 0.8760960492665846 1.307083854301399e-06 0.874210837196514 \
1.307083914177735e-06 0.8729702140710593 1.307083971566019e-06 0.8717685933706794 1.307084033561192e-06 0.8704574090763495 1.307084096840044e-06 0.8691057216070059 \
1.307084146911381e-06 0.8680269866686803 1.307084196353533e-06 0.8669542389500936 1.30708426002324e-06 0.8655623656543436 1.307084335970659e-06 0.8638877358586781 \
1.307084384801671e-06 0.8628032002737418 1.307084433325624e-06 0.8617197496806845 1.307084509037347e-06 0.8600184098866027 1.307084576246125e-06 0.8584975010852487 \
1.307084618952631e-06 0.8575263577286506 1.307084662855204e-06 0.8565244243916033 1.307084750660351e-06 0.8545103166059256 1.307084813513519e-06 0.8530605771626394 \
1.307084872183177e-06 0.8517018597088126 1.307084908361778e-06 0.8508614974547222 1.307084943180258e-06 0.8500510151036469 1.307084978206243e-06 0.8492340038666518 \
1.307085048258213e-06 0.8475953578585981 1.307085096728698e-06 0.8464581214772323 1.307085140673499e-06 0.8454248116355969 1.307085186191255e-06 0.8443523575543517 \
1.307085250092166e-06 0.8428433081697474 1.30708531621854e-06 0.8412777165526386 1.307085421348608e-06 0.8387809254526315 1.307085509283283e-06 0.8366857089760468 \
1.307085588228565e-06 0.834800137446173 1.307085676393602e-06 0.8326899670047023 1.307085763209599e-06 0.8306078985741704 1.307085851101283e-06 0.8284959280419055 \
1.307085942350373e-06 0.8262996967350639 1.307086045112241e-06 0.8238226494465998 1.307086143615716e-06 0.8214450402687625 1.307086255948632e-06 0.8187302447322098 \
1.307086368922768e-06 0.8159967029774419 1.307086490210663e-06 0.8130591602364435 1.307086620717817e-06 0.8098958628758253 1.307086749763719e-06 0.8067658935936169 \
1.30708690323932e-06 0.8030416153605923 1.307087068523541e-06 0.799029304640783 1.307087236264745e-06 0.7949567682299736 1.307087432788334e-06 0.7901857478752816 \
1.307087637550659e-06 0.7852160332972318 1.307087850227715e-06 0.7800563994093253 1.307088050847662e-06 0.7751902022758907 1.307088251706389e-06 0.7703212856706637 \
1.307088401728407e-06 0.766686939713112 1.307088532263574e-06 0.7635264252913375 1.307088666681014e-06 0.7602735436595947 1.307088772876545e-06 0.7577048602246427 \
1.307088906182877e-06 0.754482067181252 1.307089013215803e-06 0.7518959494812111 1.307089156291704e-06 0.7484409822837247 1.307089320797846e-06 0.7444713482725677 \
1.307089441615093e-06 0.74155777711076 1.307089612721757e-06 0.7374334100931738 1.307089773612309e-06 0.733558046396253 1.30708999020493e-06 0.7283457217000903 \
1.307090183460631e-06 0.7236999380850822 1.307090362395765e-06 0.7194029726762079 1.307090529212387e-06 0.7154015770462002 1.307090715418352e-06 0.7109395231330657 \
1.307090903351594e-06 0.7064416825495208 1.307091069273699e-06 0.7024749886985119 1.307091261631787e-06 0.6978803202016938 1.307091402988682e-06 0.6945068232011449 \
1.307091559996444e-06 0.6907636199298515 1.307091755976089e-06 0.6860965106368763 1.307091918410194e-06 0.6822325558671515 1.307092079586376e-06 0.6784034260021697 \
1.307092271894574e-06 0.6738409413562468 1.307092489556454e-06 0.6686845685784016 1.307092737577756e-06 0.6628199086538362 1.307092915635219e-06 0.6586162961343578 \
1.307093164179028e-06 0.6527567611811057 1.307093366786271e-06 0.6479896840619462 1.307093536596938e-06 0.6440011601507294 1.307093695213124e-06 0.6402799599229552 \
1.307093833743559e-06 0.637035894415233 1.307093969951322e-06 0.6338503464729111 1.307094096262698e-06 0.6309003762865483 1.307094225721933e-06 0.6278810604265532 \
1.307094354053672e-06 0.6248911458464299 1.307094485383603e-06 0.6218374290191309 1.307094617410215e-06 0.6187713222160208 1.307094761570095e-06 0.6154276788919771 \
1.307094905778687e-06 0.6120888358645944 1.307095053433791e-06 0.6086753592300279 1.307095200490149e-06 0.6052842859263143 1.307095358304176e-06 0.6016504852589418 \
1.307095490909828e-06 0.5986039825107707 1.307095622374795e-06 0.5955897059985247 1.307095741804593e-06 0.5928552647156846 1.307095877873286e-06 0.5897484304797134 \
1.307095992801548e-06 0.5871283594046445 1.307096143912269e-06 0.5836892419704927 1.307096258561337e-06 0.5810871834776226 1.307096376499006e-06 0.5784138884735546 \
1.307096466280294e-06 0.576381560286313 1.307096556599689e-06 0.5743415774978985 1.307096623290559e-06 0.5728373329037385 1.307096688852372e-06 0.5713590910263378 \
1.307096739894496e-06 0.5702089751121119 1.307096801596215e-06 0.5688198806440578 1.307096864686071e-06 0.5674025889664359 1.307096929044424e-06 0.5659586381304559 \
1.307096982438224e-06 0.5647616504486359 1.307097075080806e-06 0.5626864159088959 1.307097151688078e-06 0.5609719030357503 1.30709720751314e-06 0.5597256439368602 \
1.307097276567267e-06 0.5581857825097393 1.307097383455393e-06 0.5558054549196561 1.307097461199018e-06 0.5540764009223496 1.307097562049117e-06 0.5518382286767042 \
1.307097687729972e-06 0.5490568313009737 1.307097787971657e-06 0.5468419758621708 1.30709789988934e-06 0.5443739014182352 1.307098003155247e-06 0.5421024366463116 \
1.307098122904589e-06 0.5394737463112931 1.307098224637469e-06 0.5372436950013484 1.307098340157213e-06 0.5347185748314579 1.307098455192299e-06 0.5322102907975605 \
1.307098581673211e-06 0.529456475824718 1.307098707047008e-06 0.5267350629320526 1.307098853862932e-06 0.5235577714138258 1.307098989426381e-06 0.5206304261698983 \
1.307099147124634e-06 0.5172373565578411 1.307099309443689e-06 0.5137528589513558 1.307099490267585e-06 0.5098871206809381 1.307099682715905e-06 0.5057874350093188 \
1.307099895621209e-06 0.5012700264709963 1.307100127802608e-06 0.4963634062180514 1.307100385093187e-06 0.4909555076455908 1.30710062471901e-06 0.4859407514401474 \
1.307100926434446e-06 0.479662588092526 1.3071012143538e-06 0.4737079198104491 1.307101527242619e-06 0.4672821326282255 1.307101846980824e-06 0.4607585360408045 \
1.307102186575985e-06 0.4538766993710576 1.307102513478483e-06 0.4472977926730654 1.307102849036864e-06 0.4405887635920606 1.307103166132787e-06 0.4342949501181722 \
1.307103500370541e-06 0.4277061431972559 1.307103851801663e-06 0.4208322784122511 1.307104166327818e-06 0.4147233751108969 1.307104489505308e-06 0.4084912998479469 \
1.307104930620066e-06 0.400057814108821 1.307105272736103e-06 0.3935812134363078 1.307105572680633e-06 0.3879522399691127 1.307105947811638e-06 0.3809760137481454 \
1.307106277555878e-06 0.3749002425561211 1.307106560798804e-06 0.3697269896098562 1.307106860945059e-06 0.3642865787664632 1.307107140547253e-06 0.3592589179584539 \
1.307107364323365e-06 0.3552676761685443 1.307107576103695e-06 0.3515151294490645 1.307107778537159e-06 0.3479514629380864 1.307107979628427e-06 0.3444362246481504 \
1.307108185342845e-06 0.3408632458568372 1.307108452965717e-06 0.3362478643926977 1.307108691897011e-06 0.3321601360780691 1.307108925403074e-06 0.3281974319442653 \
1.307109138868474e-06 0.3246000376975314 1.307109360246046e-06 0.3208952602338652 1.307109560209693e-06 0.3175728982722026 1.307109764482006e-06 0.3142073831356898 \
1.307109961828878e-06 0.3109812293225088 1.307110147201405e-06 0.3079732989686547 1.307110343307796e-06 0.3048147723336881 1.307110545584936e-06 0.3015820927993307 \
1.307110721243233e-06 0.2988007390096292 1.30711090711339e-06 0.295878328903569 1.307111114092783e-06 0.2926488196724605 1.307111299414374e-06 0.2897857719971084 \
1.307111494641182e-06 0.2867989994419413 1.307111650415531e-06 0.28443329608414 1.307111829172313e-06 0.2817356906084737 1.307112010203233e-06 0.2790344478478936 \
1.307112160100347e-06 0.2768142575519123 1.307112361143774e-06 0.273859574769726 1.307112510258904e-06 0.2716833853889438 1.307112648798334e-06 0.2696726034832688 \
1.307112800673409e-06 0.2674956304896134 1.307112915147538e-06 0.2658586287383957 1.307113046677468e-06 0.2639823142040156 1.307113172435956e-06 0.2622048582339201 \
1.307113276776362e-06 0.2607341604582348 1.307113389755722e-06 0.2591418073851619 1.307113506084246e-06 0.2575033437579446 1.307113649011667e-06 0.2554974228347739 \
1.307113762273172e-06 0.2539102348881249 1.307113896429905e-06 0.2520298733123076 1.30711400690271e-06 0.2504818583075984 1.307114162335285e-06 0.2483006006477398 \
1.307114303220383e-06 0.2463217957442577 1.307114454612954e-06 0.2441928603691365 1.307114609775035e-06 0.2420086586735095 1.307114739184283e-06 0.2401849910837116 \
1.307114873896376e-06 0.2382868210192302 1.307115011594202e-06 0.2363478190565156 1.307115129346217e-06 0.2346905900295477 1.30711528867041e-06 0.2324499447852502 \
1.307115425932636e-06 0.2305210708572645 1.307115566678993e-06 0.2285488733964877 1.307115672470167e-06 0.2270688194984586 1.307115802411565e-06 0.2252532503786337 \
1.307115902948028e-06 0.2238506847401111 1.307116005281736e-06 0.2224250970611539 1.307116079010317e-06 0.2214012665004395 1.30711615824426e-06 0.2203047212273054 \
1.307116229215507e-06 0.2193236206014474 1.307116280678535e-06 0.218612902325451 1.307116333626988e-06 0.2178825126218075 1.307116412781991e-06 0.2167921001391954 \
1.307116455054626e-06 0.2162104926182252 1.307116494899171e-06 0.2156628374086678 1.30711653812282e-06 0.2150692779925967 1.307116579029822e-06 0.2145080585354088 \
1.307116649152284e-06 0.2135474129702876 1.307116682837256e-06 0.2130867492099046 1.307116727666638e-06 0.212477723463 1.3071167865238e-06 0.2116792343136102 \
1.30711685130926e-06 0.2108017053965978 1.307116908790025e-06 0.2100241135398916 1.307116969219033e-06 0.209207737948094 1.307117066255463e-06 0.2078991976528634 \
1.307117150945123e-06 0.2067595417901527 1.307117259855885e-06 0.2052972881712416 1.307117356256692e-06 0.2040065614180294 1.307117451273329e-06 0.2027428333585779 \
1.307117554705127e-06 0.2013717100485363 1.307117649634473e-06 0.2001158751783069 1.307117752654899e-06 0.198757993281026 1.307117857737332e-06 0.1973779917312911 \
1.307117967046146e-06 0.1959482000350934 1.307118077489628e-06 0.1945091075764383 1.307118193779903e-06 0.1929996650696684 1.307118303709896e-06 0.1915811184357085 \
1.30711841337232e-06 0.1901717999899754 1.307118515088965e-06 0.1888694322720079 1.307118608043679e-06 0.1876837490531375 1.307118700772569e-06 0.1865049219968967 \
1.307118774458125e-06 0.1855719169757668 1.30711885729934e-06 0.1845269810791141 1.307118931885337e-06 0.1835895008849975 1.307119001608678e-06 0.1827150226754214 \
1.307119068327085e-06 0.1818808699270075 1.307119164170411e-06 0.1806871657728035 1.307119246877184e-06 0.1796611249561687 1.307119340441008e-06 0.1785035608809835 \
1.307119435337095e-06 0.1773351434884491 1.307119546707405e-06 0.1759704596301353 1.307119688349759e-06 0.1742450478777388 1.307119803596612e-06 0.1728486436789435 \
1.307119948144251e-06 0.1711076225712051 1.307120059739928e-06 0.1697708811114609 1.307120200958902e-06 0.1680898955975501 1.307120316696175e-06 0.1667201145354908 \
1.307120422656861e-06 0.1654722325850081 1.307120521416477e-06 0.164314417410061 1.30712061775965e-06 0.1631901152369615 1.307120706417402e-06 0.1621596955203892 \
1.307120831751673e-06 0.1607099933926625 1.307120926277088e-06 0.1596224416957933 1.30712102401604e-06 0.1585042187118262 1.307121132110917e-06 0.1572745454417887 \
1.307121226778605e-06 0.1562036643369483 1.307121334226451e-06 0.1549951394274829 1.307121425315495e-06 0.1539767092330788 1.307121532087207e-06 0.1527896463435911 \
1.307121635480473e-06 0.1516469620792683 1.307121746560958e-06 0.1504267727114754 1.307121835786939e-06 0.1494522115900035 1.307121921266868e-06 0.1485231035185812 \
1.307122005192055e-06 0.1476157397758405 1.307122074898619e-06 0.1468658175993407 1.307122153536697e-06 0.1460232248551682 1.307122231847954e-06 0.1451880611912267 \
1.307122302483827e-06 0.1444378248611795 1.307122387974695e-06 0.1435337156153706 1.307122475363672e-06 0.1426139614481139 1.307122556951186e-06 0.1417594571206545 \
1.307122654270137e-06 0.1407454482154784 1.30712273495966e-06 0.139910090776864 1.30712282574469e-06 0.1389752404035735 1.307122947088963e-06 0.1377336220260025 \
1.307123036138604e-06 0.13682812281983 1.307123134655454e-06 0.1358318692385875 1.307123221741723e-06 0.1349560640726983 1.307123332152611e-06 0.1338550874529322 \
1.307123420611433e-06 0.1329791517134813 1.307123521340027e-06 0.1319874611681985 1.30712362612958e-06 0.1309622419763913 1.307123720519813e-06 0.1300442429014473 \
1.307123817024605e-06 0.1291112112475518 1.307123916511258e-06 0.1281591654439075 1.307124002912429e-06 0.1273384721630967 1.30712409789256e-06 0.1264411177628728 \
1.307124202081388e-06 0.1254629331099751 1.307124311200139e-06 0.124445178694 1.307124405550594e-06 0.1235704029653004 1.307124517846343e-06 0.1225411084520107 \
1.307124613309697e-06 0.1216733466577494 1.307124717520587e-06 0.1207311846737792 1.307124806865944e-06 0.1199276649878674 1.307124877253217e-06 0.1192980345746366 \
1.307124952639251e-06 0.1186268760051257 1.307125028771421e-06 0.1179522201461119 1.307125097748918e-06 0.1173458504859956 1.307125180268091e-06 0.1166263596898966 \
1.307125252211578e-06 0.1160015972854393 1.307125334290304e-06 0.1152916772467617 1.30712541862478e-06 0.1145654108773922 1.307125496418619e-06 0.113898375935255 \
1.307125589183521e-06 0.1131065723182637 1.307125704787342e-06 0.1121254933399327 1.307125810692911e-06 0.1112341778178403 1.307125888349831e-06 0.1105854195321705 \
1.307125976646302e-06 0.1098504899494786 1.307126056703354e-06 0.1091866403929743 1.307126153629479e-06 0.1083861389179563 1.307126248864964e-06 0.1076031391441806 \
1.307126337436159e-06 0.1068780200140514 1.30712643874426e-06 0.1060523297458165 1.307126544289947e-06 0.1051963702337609 1.307126653484312e-06 0.1043160928234657 \
1.307126761601933e-06 0.1034503663302994 1.307126881519694e-06 0.1024949450012773 1.307126982881521e-06 0.1016914181115986 1.307127088891151e-06 0.100855068690839 \
1.30712721468278e-06 0.09986840123414902 1.307127344240086e-06 0.09885896724496235 1.30712747991544e-06 0.09780904711780367 1.307127655987304e-06 0.09645781830037269 \
1.307127819787824e-06 0.09521257997344186 1.307127982612565e-06 0.09398642071914091 1.3071280677512e-06 0.09334985726464029 1.307128137589223e-06 0.09282999162688726 \
1.307128207084828e-06 0.09231474740697931 1.307128281043488e-06 0.09176875214326782 1.307128377198375e-06 0.09106241641841166 1.307128451613741e-06 0.09051841344162129 \
1.30712852960331e-06 0.08995079828656057 1.307128606052139e-06 0.08939693755534793 1.307128693546224e-06 0.08876614459792892 1.307128795722934e-06 0.08803382885421264 \
1.307128884287322e-06 0.08740269463919083 1.30712899395281e-06 0.08662585268124241 1.307129110009217e-06 0.08580942306245626 1.307129251558034e-06 0.0848216759818637 \
1.307129384427017e-06 0.08390253510334872 1.307129525187328e-06 0.08293727564630923 1.307129674896948e-06 0.08192024575105315 1.307129810608835e-06 0.08100683753927941 \
1.307129952125717e-06 0.08006309454860433 1.307130087247591e-06 0.07917070961097784 1.307130228520028e-06 0.07824718349428782 1.30713037561292e-06 0.07729532867436953 \
1.307130527122786e-06 0.07632524417621221 1.3071306924985e-06 0.07527819040792309 1.30713085625969e-06 0.07425356708383206 1.307131032389632e-06 0.07316505371836476 \
1.30713122152861e-06 0.07201151367936541 1.307131432202234e-06 0.07074528708793332 1.307131651768855e-06 0.06944624562626683 1.307131886535262e-06 0.06808094281860989 \
1.3071321449277e-06 0.06660616301228137 1.30713243959236e-06 0.06496103773121734 1.307132743671683e-06 0.06330286177969326 1.307133104582163e-06 0.06138472526627536 \
1.307133440499035e-06 0.05964719353945821 1.307133880676406e-06 0.05743991201668189 1.307134259043809e-06 0.05560437501227136 1.307134701502772e-06 0.05352996728430704 \
1.307135055522916e-06 0.05192508193542229 1.307135442039672e-06 0.05022502935509546 1.307135786643729e-06 0.04875485597254389 1.307136108618665e-06 0.04741934964807833 \
1.307136412152492e-06 0.04619304551845941 1.307136707073488e-06 0.04503122626702559 1.307136989555767e-06 0.04394770877170886 1.307137266636177e-06 0.04291147062934708 \
1.307137532363668e-06 0.04194013461971725 1.307137803594355e-06 0.0409708748276704 1.307138079853372e-06 0.04000619535229137 1.307138369752594e-06 0.03901828782233653 \
1.307138598128987e-06 0.03825741181922668 1.307138903013054e-06 0.03726495139513845 1.30713911968491e-06 0.03657573971894532 1.307139311041637e-06 0.03597943984071691 \
1.307139509636156e-06 0.03537298232318693 1.307139839551497e-06 0.03438820140908775 1.30714008149717e-06 0.03368375433354889 1.307140396809222e-06 0.03278771666975258 \
1.307140666929207e-06 0.03203957074185158 1.307140923300881e-06 0.03134567005659093 1.307141203312881e-06 0.03060515313352298 1.307141448968657e-06 0.02997014710356035 \
1.307141681704302e-06 0.02938120249260199 1.307141924434299e-06 0.02878348292867495 1.307142161161563e-06 0.02821317433052753 1.307142389807974e-06 0.0276732289298247 \
1.307142807093635e-06 0.02671456010533928 1.307143002274328e-06 0.02627749693639509 1.307143383441411e-06 0.02544369227895442 1.307143560694233e-06 0.02506446942885681 \
1.307143903145688e-06 0.02434654114125227 1.30714405641412e-06 0.02403127656358269 1.307144431432584e-06 0.02327616399748992 1.307144569066725e-06 0.02300530455388665 \
1.307145053333359e-06 0.02207084195640928 1.30714517295276e-06 0.02184403312078184 1.307145589991563e-06 0.02106026682208277 1.307145733393791e-06 0.02079332360769017 \
1.307146254605172e-06 0.01984598817089831 1.307146382379043e-06 0.0196205814374062 1.307146966791417e-06 0.01863359713481367 1.307147139226823e-06 0.01835589372257288 \
1.307147743323573e-06 0.01743644241612937 1.307147904755214e-06 0.01720262545858322 1.307148544701434e-06 0.01631831686205014 1.3071487230176e-06 0.016083210242981 \
1.307149371001649e-06 0.01526127675881721 1.30714953625524e-06 0.01505930898173208 1.307150272557175e-06 0.01419381259610907 1.307150406833226e-06 0.01404154276213586 \
1.307151203932743e-06 0.01317592498067951 1.307151344530354e-06 0.01302934089458718 1.307152309873577e-06 0.0120661300044765 1.307152474212383e-06 0.01190857475316222 \
1.307153474943512e-06 0.01099048917119646 1.307153612213369e-06 0.01087009009405628 1.307154750907886e-06 0.009949273443646761 1.307154865085787e-06 0.009863136028526375 \
1.307156245730622e-06 0.008889755784408603 1.307156400087833e-06 0.00878832203975914 1.307157946582061e-06 0.00781340401000951 1.307158030943764e-06 0.007760176032106158 \
1.307159716371082e-06 0.006770348169342283 1.307159839899572e-06 0.00670487246831437 1.307161889714139e-06 0.005720970231232756 1.307162086114296e-06 0.005634691917282852 \
1.307164404793654e-06 0.004698942116576918 1.307164865407989e-06 0.004530544077955615 1.30716760550353e-06 0.003639937533647344 1.307168123648567e-06 0.00349159181499799 \
1.307172274289875e-06 0.002502201117031859 1.307172812139882e-06 0.002396807933581942 1.30717889437533e-06 0.001421603691354927 1.307179153355741e-06 0.001378272220758726 \
1.30718447611909e-06 0.0003814093765652445 1.307184589276134e-06 0.0003711807182531981 1.30983070639237e-06 -0.0004615907568095335 1.309830868831338e-06 -0.0006852153244161934 \
1.309831369832807e-06 -0.001554404032531494 1.30983145401537e-06 -0.001725199767551738 1.309831855538194e-06 -0.002626792336557519 1.309831944873161e-06 -0.002845673237760077 \
1.30983223146497e-06 -0.0035898660494722 1.309832359033499e-06 -0.003937855927128601 1.309832677745161e-06 -0.004830400105952924 1.309832791946313e-06 -0.00515011308870196 \
1.309833074346638e-06 -0.005887653497963378 1.309833204572857e-06 -0.006177415671381139 1.309834182925754e-06 -0.005220113099403402 1.309834370233287e-06 -0.004004368716724641 \
1.309834501677689e-06 -0.002901539130564616 1.309834607105242e-06 -0.001869327786897239 1.309834692822726e-06 -0.0009323217369615201 1.309834774749213e-06 4.151965372454519e-05 \
1.309834895786036e-06 0.001618129410352471 1.309834994714683e-06 0.003024565667809575 1.309835153111357e-06 0.005482561958548801 1.309835370558587e-06 0.00923691162542661 \
1.30983555178081e-06 0.0126653356758144 1.309835763874906e-06 0.01697021734206094 1.309835926898563e-06 0.02046388365739064 1.309836087520978e-06 0.02403759527126768 \
1.309836241061221e-06 0.02755862871109176 1.309836389117902e-06 0.031036270750196 1.309836538198811e-06 0.03460722192241437 1.309836692728722e-06 0.03837091703902212 \
1.309836853379538e-06 0.04234026030123839 1.309837018034219e-06 0.04645786783841532 1.309837194575117e-06 0.05091770581196236 1.309837373537969e-06 0.05547793877747508 \
1.309837564281134e-06 0.0603721650098247 1.309837769062163e-06 0.06565647483694508 1.309837989534449e-06 0.07137203566208646 1.309838222394174e-06 0.0774299331224613 \
1.30983847158165e-06 0.08392829098722057 1.309838744423777e-06 0.09105513637423955 1.309839041127578e-06 0.09880974921055499 1.309839368453968e-06 0.1073623706929605 \
1.309839738105355e-06 0.11701033799881 1.309840132977169e-06 0.1273002725707723 1.30984059081541e-06 0.1392030195235975 1.30984112262225e-06 0.1529832553757746 \
1.309841747860046e-06 0.1691182447448397 1.309842433607517e-06 0.1867241161332086 1.309843236003391e-06 0.2071957342970069 1.309844134802183e-06 0.2299563735557614 \
1.309844940415632e-06 0.2501946571168963 1.309845654166966e-06 0.2679877251922811 1.309846283728848e-06 0.2835633151515627 1.309846854092298e-06 0.2975737963344939 \
1.30984738504768e-06 0.3105173405876944 1.30984788683513e-06 0.3226580892822354 1.309848366129684e-06 0.3341673054699896 1.309848831685103e-06 0.3452566901045974 \
1.309849295481511e-06 0.3562094254686541 1.309849751229541e-06 0.3668794056881832 1.309850211449675e-06 0.3775613305945491 1.309850749733646e-06 0.3899285626759094 \
1.309851250584179e-06 0.4013172511919189 1.309851650806863e-06 0.4103337945930838 1.309852157667644e-06 0.421642452039157 1.309852643633856e-06 0.4323669409017459 \
1.309853043148568e-06 0.4410997362599856 1.309853453760627e-06 0.4500002277813482 1.30985388268706e-06 0.4592207708982954 1.309854284201442e-06 0.4677760623951868 \
1.309854591591889e-06 0.4742753916877908 1.309854941833647e-06 0.4816249679276425 1.309855295073851e-06 0.4889795533930016 1.30985554824443e-06 0.4942125642332652 \
1.30985578118832e-06 0.4989990073547648 1.309856022831611e-06 0.5039392821429431 1.309856247822229e-06 0.5085102868389438 1.309856439858337e-06 0.5123881070394828 \
1.309856624670034e-06 0.5161059569497825 1.30985684696035e-06 0.5205538992744256 1.309857013671757e-06 0.5238726938135662 1.309857230888352e-06 0.5281726418673847 \
1.309857433967244e-06 0.5321820613122353 1.309857611378699e-06 0.5356681922482178 1.309857799451086e-06 0.5393528234657015 1.309858035483266e-06 0.5439555888699217 \
1.30985830136529e-06 0.5491186112539347 1.309858523127178e-06 0.5534070305875756 1.309858803185033e-06 0.5588091140818973 1.309859046184818e-06 0.5634839438879177 \
1.309859321538161e-06 0.5687575845994758 1.309859566533502e-06 0.5734440561015828 1.30985980682772e-06 0.5780305526007354 1.309860047867023e-06 0.5826153106864888 \
1.309860305457841e-06 0.5874946531182738 1.309860540824618e-06 0.5919209497705462 1.309860772126727e-06 0.5962518282209535 1.309860994653448e-06 0.6003950532231523 \
1.309861203013056e-06 0.6042587207462122 1.309861440854871e-06 0.6086392006348278 1.309861651715085e-06 0.612499186772883 1.309861907322267e-06 0.617151767543529 \
1.309862106050033e-06 0.620751700070918 1.309862381682677e-06 0.6257066023742009 1.309862604438798e-06 0.6296824120643636 1.309862897809922e-06 0.6348814180513288 \
1.309863130579923e-06 0.6389753720667986 1.309863350781309e-06 0.6428252659334456 1.309863552051921e-06 0.6463216644290061 1.309863769340793e-06 0.6500784077528632 \
1.309863944056704e-06 0.6530842133917786 1.309864130321333e-06 0.6562672470877895 1.309864309060386e-06 0.6593113758161715 1.309864471764399e-06 0.6620700940033843 \
1.30986463703341e-06 0.6648583661366954 1.309864780301224e-06 0.6672607123132118 1.309864919531648e-06 0.669583864918244 1.309865059332215e-06 0.6719085596965743 \
1.309865194107422e-06 0.6741424479378803 1.309865321601663e-06 0.6762463034350935 1.309865454555775e-06 0.6784344250006583 1.309865576160125e-06 0.680430207161383 \
1.309865704573366e-06 0.6825336955632141 1.309865820340421e-06 0.6844241240890321 1.309865918381594e-06 0.686020684362688 1.3098660190777e-06 0.687656981754083 \
1.309866128831462e-06 0.689434454762776 1.309866245599418e-06 0.6913211166705923 1.309866336826192e-06 0.6927889453402305 1.309866446031605e-06 0.6945396927028351 \
1.309866547140326e-06 0.6961566646470493 1.309866642540618e-06 0.6976767415743361 1.309866752022643e-06 0.6994136821864276 1.309866886474277e-06 0.7015344809028976 \
1.309867035493214e-06 0.7038694457768003 1.309867164423232e-06 0.7058755144243859 1.309867311083691e-06 0.7081418729260142 1.309867437868072e-06 0.7100885084081828 \
1.309867562465961e-06 0.7119899232102255 1.309867674319728e-06 0.7136874821928206 1.309867787275692e-06 0.7153928249203609 1.309867887829089e-06 0.716903336497302 \
1.309868025110592e-06 0.7189542886859326 1.309868144979452e-06 0.7207346491296758 1.309868264162204e-06 0.7224952472954583 1.309868391164314e-06 0.7243608783177121 \
1.309868515712665e-06 0.726179956024653 1.309868639383676e-06 0.7279757435764195 1.309868765971953e-06 0.7298035010246171 1.309868896541188e-06 0.7316777339938921 \
1.309869019056222e-06 0.7334262671520465 1.309869155299713e-06 0.7353588786631546 1.309869256742486e-06 0.7367901064855561 1.309869362765969e-06 0.7382789144707947 \
1.309869453297152e-06 0.7395446819117977 1.309869567123378e-06 0.7411267287627761 1.30986965478496e-06 0.742338113895605 1.309869760680238e-06 0.7437932991468792 \
1.309869891033532e-06 0.7455718205320391 1.30987000160114e-06 0.7470699275523445 1.309870106271611e-06 0.7484790865773925 1.309870230233143e-06 0.7501360792234356 \
1.309870378790597e-06 0.752105598322839 1.309870500473193e-06 0.7537054667443914 1.309870614584882e-06 0.7551949470168074 1.309870755005484e-06 0.7570132059451244 \
1.309870896533544e-06 0.7588296197226846 1.309871014322813e-06 0.7603289862386273 1.309871142522635e-06 0.7619481626911874 1.309871284590468e-06 0.7637269294216019 \
1.309871401465576e-06 0.7651780119234867 1.309871547139362e-06 0.7669714049983392 1.30987166887781e-06 0.7684572223066155 1.309871787518301e-06 0.7698939375992205 \
1.309871909984594e-06 0.7713653733660819 1.309872036701685e-06 0.7728756341192486 1.309872146603679e-06 0.7741754302862822 1.309872272219022e-06 0.7756497674172792 \
1.309872378029431e-06 0.7768823528242577 1.309872514199553e-06 0.7784559787239111 1.309872638546601e-06 0.7798807766277074 1.309872765971877e-06 0.7813271999647126 \
1.309872880527956e-06 0.7826155184370988 1.309872987208226e-06 0.7838050786084815 1.309873125150823e-06 0.785328674235108 1.309873274600319e-06 0.7869612315653352 \
1.309873419452536e-06 0.7885256944569791 1.309873538888287e-06 0.7898026796320731 1.30987367431316e-06 0.7912364721526877 1.309873795807481e-06 0.7925100718437531 \
1.309873939166555e-06 0.7939977458315933 1.309874082600237e-06 0.7954699260458764 1.309874208411247e-06 0.7967479640295563 1.309874327457929e-06 0.7979459892863545 \
1.309874439471573e-06 0.7990632136113104 1.309874544263454e-06 0.8000996927221937 1.309874639456303e-06 0.8010335634530776 1.309874775866829e-06 0.8023587211299719 \
1.309874892679005e-06 0.8034813603122919 1.309875012140248e-06 0.8046180202255495 1.3098751341806e-06 0.8057672874017472 1.309875257080697e-06 0.8069126780167393 \
1.309875384200053e-06 0.8080849010520604 1.309875509341915e-06 0.8092265787736463 1.309875639893142e-06 0.8104047139317369 1.309875765969389e-06 0.811530109085512 \
1.309875893966049e-06 0.8126603425876329 1.309875999427297e-06 0.8135823118114501 1.309876102696598e-06 0.814477091043954 1.309876195349946e-06 0.8152732203909091 \
1.309876319044181e-06 0.8163262937528154 1.309876406664096e-06 0.8170655553659417 1.309876505330151e-06 0.8178914289762149 1.309876648877154e-06 0.819080619224994 \
1.309876784463306e-06 0.8201904093102529 1.309876893653288e-06 0.8210742465492874 1.309877041102747e-06 0.8222539401850584 1.309877191506449e-06 0.8234410273756358 \
1.309877316975412e-06 0.8244188977545531 1.309877461141395e-06 0.8255287290252299 1.30987758542996e-06 0.8264738611628292 1.309877735900256e-06 0.8276038147969816 \
1.309877871506614e-06 0.8286089145501508 1.309877996601616e-06 0.8295251220930787 1.309878114317453e-06 0.8303776282987162 1.309878260203052e-06 0.8314210189912619 \
1.309878426696148e-06 0.8325942517713072 1.309878557562851e-06 0.833503494447128 1.309878731007462e-06 0.8346911703335461 1.309878899140202e-06 0.8358239212093587 \
1.30987906899395e-06 0.8369500705213252 1.309879249886955e-06 0.838129582835239 1.309879393021216e-06 0.8390486258646698 1.309879507119162e-06 0.8397723391454259 \
1.309879637246322e-06 0.8405879656882547 1.309879739102179e-06 0.8412191375388212 1.309879855947599e-06 0.8419354178465567 1.309879992919396e-06 0.84276453896487 \
1.309880190759142e-06 0.843942473808897 1.30988038244463e-06 0.8450620046306492 1.309880591850993e-06 0.8462610422160779 1.309880773861877e-06 0.8472832413425977 \
1.309880970977333e-06 0.8483697584184032 1.309881144290447e-06 0.8493077402131245 1.309881327325656e-06 0.8502809338042043 1.309881498478783e-06 0.8511747489972419 \
1.309881673131736e-06 0.8520708361396651 1.309881848382891e-06 0.8529540285731302 1.309882024530391e-06 0.8538259128238825 1.309882214836779e-06 0.8547503816925358 \
1.309882405427748e-06 0.8556583881771193 1.309882605979791e-06 0.8565949481971697 1.309882798582588e-06 0.8574764650234362 1.309883009331288e-06 0.8584213553684483 \
1.309883237362186e-06 0.8594210644592908 1.309883503241952e-06 0.8605573106989262 1.309883801820094e-06 0.8617960322792503 1.309884077983729e-06 0.8629075153790151 \
1.309884362230229e-06 0.8640180616030438 1.309884636414231e-06 0.8650581816846495 1.30988490866944e-06 0.8660616517296992 1.309885178858914e-06 0.8670295451208139 \
1.309885436023238e-06 0.8679256252637404 1.309885708596972e-06 0.8688492356117473 1.309885984602435e-06 0.8697577927663542 1.309886254710518e-06 0.8706213441784563 \
1.309886554568938e-06 0.8715508809746347 1.309886925582816e-06 0.8726599440782473 1.309887220515529e-06 0.873510245983525 1.309887474800896e-06 0.8742218447789023 \
1.309887773044171e-06 0.8750318897722944 1.309888046640929e-06 0.8757523113099853 1.309888282767907e-06 0.8763571312809064 1.309888523107205e-06 0.876957042728428 \
1.309888745440861e-06 0.8774982514557473 1.309888939446794e-06 0.8779599514934209 1.309889269165228e-06 0.8787226653583874 1.309889424338019e-06 0.8790722725343518 \
1.30988974207141e-06 0.8797700114458387 1.30988992093906e-06 0.880152324917399 1.309890263400534e-06 0.8808637455080008 1.309890447552368e-06 0.8812353200296749 \
1.309890922478418e-06 0.8821594045029107 1.309891089871654e-06 0.8824737723885729 1.309891555692961e-06 0.8833186808430151 1.309891736520447e-06 0.883635209600208 \
1.309892230549786e-06 0.8844687288968743 1.309892371887773e-06 0.8846990198924604 1.309892978249103e-06 0.8856473543416146 1.309893130320955e-06 0.8858754372639542 \
1.309893777008948e-06 0.8868048391838264 1.309893905303109e-06 0.8869818633102416 1.309894553496582e-06 0.8878410756373726 1.309894683245133e-06 0.8880061989117775 \
1.309895451498601e-06 0.8889361126992519 1.309895581240625e-06 0.8890847997417872 1.309896434697557e-06 0.8900046759307325 1.309896577924673e-06 0.8901495209380393 \
1.309897564158077e-06 0.8910738355210844 1.309897785636141e-06 0.8912643084423501 1.309898928653688e-06 0.8921737958641509 1.309899058631989e-06 0.8922730011388891 \
1.309900410338988e-06 0.8932565980587214 1.309900560692342e-06 0.8933589605607284 1.309902041315768e-06 0.8942730372387374 1.30990228021907e-06 0.8944047337041336 \
1.309904061344228e-06 0.8952702388217941 1.309904447325594e-06 0.8954343910560414 1.309906848871634e-06 0.896309305076933 1.30990732380842e-06 0.8964562995603377 \
1.309911141970139e-06 0.8973944547681553 1.309911624459336e-06 0.897487269196476 1.309919510474849e-06 0.898471373493449 1.30992012663754e-06 0.8985180228791175 \
1.310015282612379e-06 0.899508178894561 1.310016773214557e-06 0.8995204306067698 1.310128061288741e-06 0.9005118233983579 1.310128237625743e-06 0.9005706457326812 \
1.310131860757067e-06 0.8996048713171836 1.310132041955094e-06 0.8994654179496379 1.31013335307657e-06 0.8985275682722235 1.310133534953976e-06 0.8984123497545736 \
1.31013535794417e-06 0.8974436520388238 1.310135517857424e-06 0.8973766233009967 1.310148668688723e-06 0.8983720910457982 1.310148779670276e-06 0.8983905835035384 \
1.310157601254383e-06 0.8993863063850064 1.310158148023847e-06 0.8994226481040219 1.310650719976681e-06 0.9003987622903815 1.310650789769166e-06 0.9004496773542636 \
1.310651622421929e-06 0.9012853800543292 1.310651748468094e-06 0.9014513953152168 1.310652328988957e-06 0.9023435091985418 1.310652469953212e-06 0.9025895326188698 \
1.310652869091291e-06 0.9033428289365844 1.310653019240832e-06 0.9036449200440446 1.310653462322153e-06 0.9045762589490434 1.310653619494256e-06 0.9049121924877023 \
1.310654065120987e-06 0.9058152254958243 1.310654163577326e-06 0.9059929146639856 1.31065558025872e-06 0.9052304871087643 1.310655711415865e-06 0.904616184869324 \
1.310655880423041e-06 0.9036290332250884 1.310656045714916e-06 0.9024406226812831 1.310656151980698e-06 0.9015554774641358 1.310656255417528e-06 0.9006052096506509 \
1.310656341184247e-06 0.8997486040545581 1.310656430678233e-06 0.8987887485205278 1.310656554922632e-06 0.8973492764100613 1.31065667300358e-06 0.8958624931586439 \
1.310656760219672e-06 0.8946938835082598 1.310656884526716e-06 0.8929289312882503 1.310656991510644e-06 0.8913158670103165 1.310657091342348e-06 0.8897378501708729 \
1.310657217633174e-06 0.8876466417139378 1.310657385821785e-06 0.884705368138502 1.310657541521538e-06 0.8818365157686672 1.310657738126367e-06 0.8780362649814708 \
1.310657921747617e-06 0.8743271923380105 1.31065813325501e-06 0.8698916163736473 1.31065831406481e-06 0.8659808238081558 1.310658498645858e-06 0.8618945354625286 \
1.310658671649854e-06 0.8579913311618118 1.310658857050504e-06 0.8537436868396935 1.310659036133651e-06 0.8495884889292737 1.310659219722713e-06 0.8452850234109005 \
1.310659386484418e-06 0.8413449312544377 1.310659554574996e-06 0.8373487193315756 1.310659717684167e-06 0.8334514816705533 1.310659872870403e-06 0.829729402178684 \
1.310660045969282e-06 0.8255639501984255 1.310660231959738e-06 0.8210763864673301 1.310660396580222e-06 0.8170961425007568 1.310660561450132e-06 0.8131038678717658 \
1.310660736782164e-06 0.8088537582860886 1.310660901208668e-06 0.8048648186953292 1.310661069844279e-06 0.8007719922541914 1.310661260647645e-06 0.7961398815555145 \
1.310661446171818e-06 0.7916360074082958 1.310661655100628e-06 0.7865651471012967 1.310661879917618e-06 0.7811107659751856 1.310662069732705e-06 0.77650678233121 \
1.310662271590188e-06 0.7716133355283564 1.310662415860827e-06 0.76811790639139 1.310662557504392e-06 0.7646880872338248 1.310662685202102e-06 0.7615975116975136 \
1.310662796247943e-06 0.7589113686396982 1.31066292481058e-06 0.7558028559024855 1.310663057376087e-06 0.7525995467138866 1.310663170697783e-06 0.7498629233610832 \
1.310663307032409e-06 0.7465723252212872 1.310663413431661e-06 0.7440058350410135 1.310663572650447e-06 0.7401674766516904 1.310663745028142e-06 0.7360137588823189 \
1.310663907275386e-06 0.7321074183421575 1.310664079624344e-06 0.7279612819449855 1.310664239010527e-06 0.7241302920521341 1.310664446815714e-06 0.7191408067115369 \
1.310664607355379e-06 0.7152908836069264 1.310664799844715e-06 0.7106793324906435 1.310664985361064e-06 0.7062404417184839 1.310665155237109e-06 0.7021802791355866 \
1.310665347106947e-06 0.6975984806629684 1.310665493330962e-06 0.6941099299715526 1.310665653617309e-06 0.6902897983225644 1.310665856006145e-06 0.6854719661536142 \
1.310666037294609e-06 0.681161582477689 1.310666206116036e-06 0.6771536053116509 1.310666391961911e-06 0.6727470762459599 1.310666597892751e-06 0.6678715161770782 \
1.310666765819558e-06 0.6639016226084196 1.310666926081261e-06 0.6601182542089066 1.310667164933735e-06 0.65448589698252 1.310667332694849e-06 0.6505369020837752 \
1.310667513768288e-06 0.6462813620835641 1.310667674923199e-06 0.642499550819208 1.31066782119046e-06 0.6390715923276049 1.310667959878569e-06 0.6358268652274862 \
1.310668089235615e-06 0.6328040340451749 1.31066821862017e-06 0.6297855584526113 1.31066834694149e-06 0.6267952385336898 1.310668477143629e-06 0.6237652412672913 \
1.310668606160074e-06 0.6207683673242944 1.310668744735633e-06 0.6175525629501428 1.31066889281122e-06 0.6141227553162802 1.310669079138505e-06 0.60981438109949 \
1.310669226822204e-06 0.6064079319686639 1.31066946198641e-06 0.600995965122186 1.310669654434141e-06 0.5965821560879089 1.310669895003955e-06 0.5910808370261941 \
1.310670064051326e-06 0.587228367631822 1.31067020171775e-06 0.5840969866928536 1.310670329822727e-06 0.581191110277254 1.310670443409422e-06 0.5786182870235701 \
1.310670534774226e-06 0.5765512826027382 1.310670624196113e-06 0.5745328691003393 1.310670691457846e-06 0.573016830490748 1.310670757478049e-06 0.5715297341779608 \
1.310670809531724e-06 0.5703577032508095 1.310670873770593e-06 0.5689124506700958 1.310670935307116e-06 0.5675311492520995 1.31067099958866e-06 0.5660899724818867 \
1.310671052779755e-06 0.5648985048860162 1.31067114512554e-06 0.5628316153148989 1.310671221701441e-06 0.5611191615154557 1.310671277545091e-06 0.5598732849310241 \
1.3106713468882e-06 0.5583285932816697 1.310671452739476e-06 0.5559733466166974 1.31067153043128e-06 0.5542469170533902 1.310671631029868e-06 0.5520159549745236 \
1.310671759063078e-06 0.5491849411292137 1.31067185856046e-06 0.5469885705929382 1.310671971125811e-06 0.544508366501287 1.310672074170131e-06 0.5422442603473754 \
1.310672194219017e-06 0.5396115972585003 1.310672295833426e-06 0.5373863339265779 1.310672411457693e-06 0.5348611538529422 1.310672526573874e-06 0.5323536236546169 \
1.310672653010918e-06 0.529604142030661 1.310672778525186e-06 0.5268822104345234 1.310672925204862e-06 0.5237112381511962 1.31067306087557e-06 0.5207845659358002 \
1.310673218641409e-06 0.5173942078023266 1.310673381063349e-06 0.5139116507621072 1.310673561971818e-06 0.5100482739823553 1.310673754563972e-06 0.5059503908118104 \
1.310673967555743e-06 0.5014368974673542 1.310674199988459e-06 0.4965308659362653 1.310674457509373e-06 0.49112491222925 1.310674697473551e-06 0.4861095397820235 \
1.310674998677906e-06 0.4798501326413723 1.310675286975534e-06 0.4738957353990632 1.310675600061861e-06 0.4674739717793394 1.310675919588141e-06 0.4609631488871989 \
1.310676259085406e-06 0.4540919149088484 1.310676585275518e-06 0.4475353831519197 1.31067692175678e-06 0.4408159131180407 1.310677238467587e-06 0.4345373385230166 \
1.31067757255266e-06 0.4279587671099637 1.310677924261529e-06 0.4210864038135054 1.310678238746378e-06 0.4149846225409808 1.310678562192836e-06 0.4087533091618546 \
1.310679003120948e-06 0.400331870031168 1.310679344916025e-06 0.3938679283557566 1.310679644350069e-06 0.3882534014213259 1.310680018872672e-06 0.3812944595528024 \
1.31068034825039e-06 0.375233915169682 1.310680631354694e-06 0.3700684563936956 1.310680931099705e-06 0.3646408765157301 1.310681210595549e-06 0.3596219010422631 \
1.310681434267487e-06 0.3556377385586224 1.310681645979194e-06 0.3518907610576284 1.310681848481927e-06 0.3483292724130969 1.310682049543475e-06 0.3448190020587957 \
1.310682255221384e-06 0.3412518188287665 1.31068247359686e-06 0.3374887625241871 1.310682717359257e-06 0.3333167726275162 1.310682944115829e-06 0.3294678078423895 \
1.310683164026801e-06 0.3257615367192951 1.310683382451408e-06 0.3221060038181086 1.310683586476418e-06 0.318715141566024 1.310683788334208e-06 0.3153870758963987 \
1.310683988657595e-06 0.3121102802474151 1.310684175271502e-06 0.309079115007194 1.310684372573108e-06 0.3058982938882217 1.310684581156335e-06 0.3025606704206737 \
1.310684786791057e-06 0.2992974534031506 1.310685011523137e-06 0.2957609785165763 1.310685228418979e-06 0.2923771984023277 1.310685436098331e-06 0.2891642611511841 \
1.310685667149178e-06 0.2856239464683982 1.310685841949429e-06 0.2829684481899911 1.310686021147604e-06 0.2802647299798244 1.31068619002212e-06 0.2777348429135014 \
1.310686418345393e-06 0.274348458173166 1.310686595082661e-06 0.2717528218126659 1.310686763365392e-06 0.2693020894036587 1.310686935832162e-06 0.2668230333489093 \
1.310687069934441e-06 0.264903804409765 1.310687215894446e-06 0.2628277003548514 1.310687354589946e-06 0.2608803500812688 1.310687476871551e-06 0.2591684246570544 \
1.310687610990381e-06 0.2572942758553639 1.310687740091486e-06 0.2554978336754472 1.31068785952522e-06 0.2538430842138498 1.31068798636042e-06 0.2520939183506197 \
1.310688106001441e-06 0.2504447954274527 1.310688255617635e-06 0.2483797066042054 1.310688390481146e-06 0.2465170278296022 1.31068852003856e-06 0.2447289494531232 \
1.310688677103379e-06 0.2425624627506451 1.310688801099014e-06 0.2408491463446025 1.310688941247149e-06 0.2389135279283614 1.31068907114005e-06 0.2371200701944942 \
1.31068919175767e-06 0.2354534357320198 1.310689354230601e-06 0.2332087289724075 1.310689500284699e-06 0.2311905595759856 1.310689638605484e-06 0.2292825126447264 \
1.310689746532702e-06 0.2277949627009887 1.310689877317609e-06 0.225993474229161 1.310689975823626e-06 0.22463752857886 1.310690079906972e-06 0.2232056532573264 \
1.310690152783836e-06 0.2222046546567725 1.310690234937313e-06 0.2210804129356655 1.310690302346398e-06 0.2201585377209549 1.310690349050661e-06 0.2195201149856669 \
1.31069039846802e-06 0.2188449488487562 1.310690489422163e-06 0.2176035744446363 1.310690555816576e-06 0.2166983392055156 1.310690602779869e-06 0.2160586379972232 \
1.310690653091075e-06 0.2153737902794619 1.310690712240425e-06 0.2145693142997165 1.310690755086328e-06 0.2139870779821451 1.310690798893629e-06 0.2133941263688522 \
1.310690868423894e-06 0.2124566309962414 1.310690955340708e-06 0.2112864027023158 1.310691036529563e-06 0.2101949018929156 1.310691122429026e-06 0.2090416531541652 \
1.310691216575207e-06 0.2077796428137634 1.310691308329081e-06 0.2065517647617813 1.310691403625517e-06 0.2052788208685862 1.310691500104208e-06 0.2039945431316728 \
1.31069160092949e-06 0.2026602783061639 1.310691696885502e-06 0.2013924147365721 1.310691799571213e-06 0.2000377255165624 1.310691902607566e-06 0.1986831378210229 \
1.310692012697906e-06 0.1972405340748948 1.310692121449794e-06 0.1958206085628783 1.310692241171749e-06 0.1942631948714586 1.310692351614651e-06 0.1928328887741874 \
1.310692459617459e-06 0.1914411844406488 1.310692584973803e-06 0.1898318066870429 1.310692677907979e-06 0.1886434908940876 1.310692756278755e-06 0.1876443873000938 \
1.310692832918829e-06 0.1866698667869858 1.310692915430143e-06 0.1856249297118943 1.310692984939759e-06 0.1847473639743596 1.310693050895387e-06 0.1839166514106665 \
1.310693115162722e-06 0.1831089953192083 1.310693227146207e-06 0.1817072258029639 1.310693321200174e-06 0.1805353135896268 1.310693428841935e-06 0.1791985758407087 \
1.310693535314993e-06 0.1778827552324552 1.31069365530692e-06 0.1764073736674057 1.310693793359546e-06 0.174720142305475 1.310693909520101e-06 0.1733081217455876 \
1.310694071616903e-06 0.1713503924599185 1.31069418670542e-06 0.1699688234017716 1.310694326691019e-06 0.1682987764548305 1.310694443897095e-06 0.1669083002780509 \
1.310694554816447e-06 0.1655990025649634 1.310694652444933e-06 0.1644521190704843 1.310694747295481e-06 0.1633427224865242 1.310694863349894e-06 0.161991523106341 \
1.310694954898444e-06 0.1609305136382055 1.31069505100742e-06 0.1598214181625073 1.310695145225553e-06 0.1587403933520305 1.310695238726156e-06 0.1576732160104884 \
1.310695332323478e-06 0.1566104070550305 1.310695428005016e-06 0.1555300824433628 1.310695518592921e-06 0.1545132165873678 1.310695609606078e-06 0.1534969984004868 \
1.310695705154556e-06 0.1524358767948732 1.310695795820268e-06 0.1514342506187442 1.310695898892631e-06 0.1503020548964867 1.31069597134408e-06 0.1495100717445464 \
1.310696050444873e-06 0.148649146151682 1.310696124993091e-06 0.1478424742503694 1.3106961960245e-06 0.1470770917224498 1.310696268788982e-06 0.1462962409077327 \
1.310696343406157e-06 0.1454990959398698 1.310696413389118e-06 0.1447543557055888 1.310696487550038e-06 0.143968261688537 1.310696541295377e-06 0.1434005634796054 \
1.310696594578932e-06 0.1428396203849428 1.31069665977469e-06 0.1421555039833398 1.310696731080731e-06 0.141411576573238 1.310696795450793e-06 0.1407432786314442 \
1.310696868802754e-06 0.1399847409254479 1.310696929420321e-06 0.1393607073002494 1.310697015453805e-06 0.1384787080092832 1.31069709140482e-06 0.1377037134581418 \
1.310697181372726e-06 0.1367902106004182 1.310697263099684e-06 0.1359645165492482 1.310697345789662e-06 0.1351360437760365 1.310697428345969e-06 0.1343145513298757 \
1.310697533908125e-06 0.1332698421778018 1.310697615775408e-06 0.1324642397250402 1.310697713142868e-06 0.1315110876582503 1.310697803143729e-06 0.130634908321232 \
1.310697891113988e-06 0.1297829978838479 1.310697974043842e-06 0.1289892226181523 1.310698048280934e-06 0.1282822873521282 1.310698147931993e-06 0.1273377645104763 \
1.310698243687052e-06 0.1264350619688987 1.310698330534456e-06 0.1256206895242312 1.310698420535994e-06 0.1247808744623497 1.310698500868674e-06 0.1240346855852102 \
1.310698587562703e-06 0.1232365419604467 1.310698686393032e-06 0.1223331159004786 1.31069877647517e-06 0.1215131568528167 1.310698886718427e-06 0.1205141992263624 \
1.310698973949866e-06 0.1197275966302077 1.310699042523e-06 0.1191120727131645 1.310699127185393e-06 0.1183553887582162 1.310699193692874e-06 0.1177634990399222 \
1.310699265148799e-06 0.1171309945267847 1.310699334822604e-06 0.1165184920865242 1.310699412159692e-06 0.1158409171037389 1.310699507902974e-06 0.1150054407698888 \
1.310699579157887e-06 0.1143861389207103 1.31069964652742e-06 0.1138025718558601 1.310699714964191e-06 0.113211685696446 1.310699790554542e-06 0.1125613765304429 \
1.310699881296389e-06 0.1117840233035959 1.310699964000116e-06 0.1110788257213999 1.310700077599187e-06 0.1101151050704521 1.310700187474899e-06 0.1091895325357105 \
1.310700279674213e-06 0.1084169374841771 1.310700403623544e-06 0.1073835127717347 1.310700491987867e-06 0.1066505015902263 1.310700631446837e-06 0.1055001025916527 \
1.310700730743538e-06 0.1046863788921388 1.31070082339359e-06 0.1039306459201802 1.310700933598102e-06 0.1030359883605075 1.310701018892542e-06 0.1023467905686673 \
1.310701103793345e-06 0.101663637589173 1.310701186744308e-06 0.1009989740617136 1.31070130925421e-06 0.1000225794851696 1.310701431196063e-06 0.09905761200121259 \
1.310701557818349e-06 0.09806258992746317 1.310701670630472e-06 0.09718220909187772 1.310701815205956e-06 0.09606278874246346 1.310701952919884e-06 0.09500564015228773 \
1.310702069610674e-06 0.09411672853020667 1.310702197354241e-06 0.0931507147971556 1.310702297018758e-06 0.09240236948627445 1.310702376452637e-06 0.09180921593916676 \
1.310702475187935e-06 0.09107599640376031 1.310702553063239e-06 0.09050081472416407 1.310702634529155e-06 0.08990210528957472 1.310702709246463e-06 0.0893557072655629 \
1.310702789776201e-06 0.08876971652456604 1.310702908608526e-06 0.08791061481419053 1.310702998269062e-06 0.08726673116015753 1.310703103183109e-06 0.08651800316437093 \
1.310703234657667e-06 0.08558693768262025 1.310703395765802e-06 0.08445695903909305 1.310703535947497e-06 0.08348350561263763 1.310703684450103e-06 0.08246223579158835 \
1.310703821170292e-06 0.08153124812726546 1.310703961182002e-06 0.08058696725890066 1.310704098179202e-06 0.07967195061625794 1.310704236789813e-06 0.07875532825288725 \
1.3107043812627e-06 0.07780967510081127 1.310704528808937e-06 0.07685421131041187 1.310704686312648e-06 0.07584560580436887 1.310704850707884e-06 0.07480523464991846 \
1.310705018799982e-06 0.07375451744755303 1.310705199799341e-06 0.07263751640721161 1.310705398512623e-06 0.07142823309373261 1.310705611921415e-06 0.07014922396308329 \
1.3107058380853e-06 0.06881630383186611 1.310706078645623e-06 0.06742468841361035 1.310706356206535e-06 0.06585179211508728 1.310706653410938e-06 0.06420523370201831 \
1.310706971711662e-06 0.06248365192299224 1.310707361695962e-06 0.06043183534616462 1.310707760522748e-06 0.05839861031494715 1.310708202994687e-06 0.05621846258761681 \
1.31070858797559e-06 0.05438828987170503 1.310709000022182e-06 0.05249218901100536 1.310709351759698e-06 0.05092353490091287 1.31070968726435e-06 0.04946969867921969 \
1.310709997763245e-06 0.04816021644386199 1.310710291700064e-06 0.04695194805701195 1.310710584430997e-06 0.04577883625507727 1.310710859274204e-06 0.04470700909733757 \
1.310711133117927e-06 0.04366353526031765 1.310711398807687e-06 0.04267398813878486 1.310711674116703e-06 0.04167180388267511 1.310711958673621e-06 0.04066026046469497 \
1.310712254971736e-06 0.03963283340811159 1.310712513847121e-06 0.03875659098599576 1.310712741803528e-06 0.03800131046948733 1.310712960528722e-06 0.03729095380188759 \
1.310713180383449e-06 0.03659437723507575 1.310713521249513e-06 0.03554043311314246 1.310713797290394e-06 0.03470953269536187 1.310714090721169e-06 0.03384790442147732 \
1.310714373289092e-06 0.03303898052111545 1.310714628198529e-06 0.03232625790162248 1.310714908882988e-06 0.03155947796597136 1.310715154716382e-06 0.03090318379665042 \
1.31071538687767e-06 0.03029616297556957 1.310715627215008e-06 0.02968398395812225 1.310715862851843e-06 0.02909722707395018 1.310716091063021e-06 0.0285403787496557 \
1.310716507835749e-06 0.02755138287878544 1.310716702361127e-06 0.02710176794309662 1.310717088601532e-06 0.02623051698020805 1.310717267770925e-06 0.0258356865503758 \
1.310717618998109e-06 0.02507792837274256 1.310717786904157e-06 0.0247229612172224 1.310718171166812e-06 0.02392944198669211 1.310718286448541e-06 0.02369675911063252 \
1.310718728496378e-06 0.02282172072611499 1.310718950311652e-06 0.02239223679446916 1.310719473931311e-06 0.02139838041889957 1.31071962929382e-06 0.02110714647916685 \
1.310720146999887e-06 0.02015295207761772 1.310720272033152e-06 0.01992792118872039 1.310720796234659e-06 0.01901759738223179 1.310720932454034e-06 0.01879045572456909 \
1.31072153873049e-06 0.01783210191617334 1.310721705739623e-06 0.01758082406519646 1.310722348947267e-06 0.01666064795441237 1.310722528091535e-06 0.0164167113061686 \
1.310723218250269e-06 0.01551958953683085 1.310723381870153e-06 0.01531511209162885 1.31072414235084e-06 0.01440332854054019 1.310724289392963e-06 0.01423371673427115 \
1.310725107264621e-06 0.01333087949608782 1.310725226813134e-06 0.01320411419549955 1.310726142674656e-06 0.01227329163592313 1.310726284027572e-06 0.01213544173166964 \
1.310727232503148e-06 0.01124488043697059 1.310727391142586e-06 0.01110230805801717 1.31072857354363e-06 0.01011356759191894 1.31072867164402e-06 0.01003725601038859 \
1.31072993325548e-06 0.009120360285939955 1.31073006766933e-06 0.009028655389366201 1.310731608240655e-06 0.008043892937307966 1.310731689273999e-06 0.007992925041580451 \
1.310733277867931e-06 0.007023242357651564 1.310733410759078e-06 0.006948518507451114 1.31073538746242e-06 0.005952856104192286 1.310735569200568e-06 0.005869662958407677 \
1.310737671554228e-06 0.004980929874643355 1.310738112345997e-06 0.004810448874467742 1.310740767560855e-06 0.003892108290451164 1.310741244140394e-06 0.003745909362026665 \
1.310744882222615e-06 0.00279447349697209 1.31074540774606e-06 0.002678838783887205 1.310751013810845e-06 0.001700248310874221 1.310751324898547e-06 0.001653333728976835 \
1.310756459226246e-06 0.0006858192122199529 1.310756653206019e-06 0.0006440832883579712 1.313404576914862e-06 -0.0002037173203380238 1.313404741115283e-06 -0.0003889174928863678 \
1.313405314458091e-06 -0.001270938904608877 1.313405389392278e-06 -0.001411855863724778 1.313405849976055e-06 -0.002393592696522268 1.313405961916807e-06 -0.002660411672198376 \
1.313406215188795e-06 -0.003300974950034667 1.3134063815721e-06 -0.003745951779090856 1.31340667656787e-06 -0.004566571567208835 1.313406788055442e-06 -0.00488071790655901 \
1.313407067428216e-06 -0.005641221413069743 1.313407188386555e-06 -0.005938820066262044 1.313408282339388e-06 -0.005180465225493313 1.313408406471631e-06 -0.004410796826645887 \
1.313408530879049e-06 -0.003456122327429311 1.313408650435429e-06 -0.002364170815481491 1.313408748579805e-06 -0.001341064316055312 1.313408855004127e-06 -0.0001052154991983786 \
1.313408967239972e-06 0.001336046702817826 1.313409102195821e-06 0.003249882807978809 1.313409224782331e-06 0.005149402351921401 1.313409413644246e-06 0.008353592055059769 \
1.313409554826579e-06 0.01094873860302964 1.313409708187922e-06 0.01393943619118621 1.313409851561427e-06 0.01687898420971235 1.313410005752867e-06 0.02017576688295359 \
1.313410161892825e-06 0.02363796584892512 1.313410317618878e-06 0.02719811802828209 1.313410465112557e-06 0.03065407560139007 1.313410613784323e-06 0.03420778369279751 \
1.313410769114407e-06 0.03798436241030867 1.313410927740287e-06 0.04189786275883118 1.313411092673448e-06 0.0460171220807938 1.313411267096336e-06 0.05041857973200652 \
1.313411446085736e-06 0.05497510627343041 1.313411635385597e-06 0.05982852266675163 1.313411838393603e-06 0.06506368941101938 1.313412057870669e-06 0.07075025585284363 \
1.313412288935331e-06 0.07675903373893865 1.313412535995649e-06 0.08319974270080552 1.313412806420637e-06 0.0902619122132732 1.313413099984324e-06 0.09793335781011638 \
1.313413424033306e-06 0.1064001814721126 1.313413788254856e-06 0.1159066558703892 1.313414180806326e-06 0.1261372395632307 1.313414630304251e-06 0.1378252442462487 \
1.313415153096484e-06 0.1513754922073403 1.313415766694219e-06 0.1672157090591849 1.313416444455093e-06 0.184625848284817 1.313417232720212e-06 0.2047487967247964 \
1.313418115553072e-06 0.22712469896725 1.313418933839029e-06 0.2476994923478653 1.313419661268608e-06 0.2658503723959502 1.313420301381636e-06 0.2817009601644404 \
1.31342087568535e-06 0.2958213763442377 1.313421413251317e-06 0.3089396094373287 1.313421917248776e-06 0.3211464104224903 1.31342239337143e-06 0.3325930942309646 \
1.313422871259445e-06 0.3439912352478621 1.313423324592551e-06 0.3547121966731367 1.313423795885259e-06 0.3657614311162562 1.313424238561085e-06 0.3760518588326446 \
1.313424757059872e-06 0.3879885572071845 1.313425284221992e-06 0.3999987293386327 1.313425663131623e-06 0.4085537955782026 1.313426193047166e-06 0.4204060347738258 \
1.313426622963746e-06 0.429919877745455 1.313427076664521e-06 0.4398653393542544 1.313427543378037e-06 0.4500002271552926 1.313427981059267e-06 0.4594210430579985 \
1.313428389021531e-06 0.468120704286539 1.313428708454565e-06 0.4748816926501604 1.313429080589837e-06 0.4826992142337162 1.313429315571978e-06 0.4876010339127531 \
1.313429549178225e-06 0.4924491904621348 1.313429797190648e-06 0.4975647713404599 1.313430095592078e-06 0.5036796627825791 1.31343035194848e-06 0.5088948470128004 \
1.31343056424179e-06 0.5131878547336713 1.313430758259862e-06 0.5170959594548015 1.313430905246394e-06 0.5200432695146362 1.313431059224405e-06 0.523118600542271 \
1.313431277106154e-06 0.5274469616807909 1.31343153021048e-06 0.5324525256580425 1.313431740049324e-06 0.5365797337241586 1.313431951502634e-06 0.5407247601751553 \
1.313432233709534e-06 0.5462280430697679 1.313432463254817e-06 0.5506821559930507 1.313432679151023e-06 0.5548604062613707 1.313432961372541e-06 0.560308769190463 \
1.313433212680268e-06 0.5651538146135803 1.31343351034116e-06 0.5708625224168123 1.313433760568061e-06 0.5756519166658941 1.313434016931556e-06 0.5805516059354519 \
1.31343425734157e-06 0.585116682128892 1.313434515521386e-06 0.5900038400537884 1.313434739113591e-06 0.5942175703762435 1.313434977623163e-06 0.5986919452581434 \
1.313435185207862e-06 0.6025689278491061 1.313435401730486e-06 0.6065904171332736 1.313435651033092e-06 0.6111939272561876 1.313435856106535e-06 0.6149609706257601 \
1.31343610737886e-06 0.6195555361399968 1.313436310600886e-06 0.6232455818254186 1.313436507472791e-06 0.6267987644955494 1.313436700764307e-06 0.630267737067843 \
1.313436955542762e-06 0.6348113783570861 1.313437185753374e-06 0.638887973644319 1.313437403107185e-06 0.6427143472883045 1.313437701512908e-06 0.6479268061885751 \
1.313437916915757e-06 0.6516657345437264 1.313438118139476e-06 0.6551344108237934 1.313438293060984e-06 0.6581323437428509 1.313438458126254e-06 0.6609495238976936 \
1.313438627594775e-06 0.6638251431769452 1.313438779731612e-06 0.666392827642013 1.313438917642298e-06 0.6687037209181631 1.313439066478412e-06 0.6711867545200138 \
1.313439194593014e-06 0.6733159837320549 1.313439337815827e-06 0.6756849429836936 1.313439459090078e-06 0.6776819274526149 1.313439596688762e-06 0.6799401191146522 \
1.313439716069216e-06 0.6818929034138137 1.313439863176962e-06 0.6842914131385206 1.313439980378628e-06 0.6861933934268433 1.313440073884205e-06 0.6877071857403232 \
1.313440164873897e-06 0.6891752279197846 1.313440267615961e-06 0.6908280855439021 1.313440369133525e-06 0.6924555900607121 1.313440487516631e-06 0.6943444167618776 \
1.313440599637217e-06 0.6961264383846065 1.313440717192718e-06 0.6979868779962457 1.313440902343005e-06 0.7008959348649784 1.313441033535213e-06 0.7029413755586562 \
1.313441169703753e-06 0.7050491462541959 1.313441291222456e-06 0.7069171228306749 1.313441431145468e-06 0.7090538254196674 1.313441535088117e-06 0.7106315721465845 \
1.313441646249101e-06 0.712309798010818 1.313441750508965e-06 0.7138759052437967 1.313441880147056e-06 0.7158124745844324 1.313441977077769e-06 0.7172526339884565 \
1.313442116000004e-06 0.7193052800722975 1.313442235549293e-06 0.7210612846995991 1.313442355121865e-06 0.7228080613301419 1.313442480897243e-06 0.7246353354365959 \
1.313442607615586e-06 0.7264656873164689 1.313442729655437e-06 0.728218443613998 1.31344285780388e-06 0.7300486655261287 1.313442987872205e-06 0.7318956587421809 \
1.313443108863227e-06 0.7336041830685722 1.313443249633811e-06 0.7355801168346318 1.31344335060338e-06 0.7369898206659778 1.313443452204237e-06 0.7384020079314992 \
1.313443548224548e-06 0.7397310783624924 1.313443659137403e-06 0.7412570822736337 1.31344374678503e-06 0.7424563811251772 1.313443846639401e-06 0.7438154404043728 \
1.313443981404538e-06 0.7456370856934184 1.313444097699018e-06 0.747198032089633 1.313444201190815e-06 0.7485782798032956 1.313444325446263e-06 0.7502239458264747 \
1.313444470359203e-06 0.7521280942578691 1.313444588339771e-06 0.753666143975803 1.313444707270879e-06 0.7552056331692281 1.313444846850418e-06 0.7569980918234445 \
1.313444991202808e-06 0.7588357421297242 1.313445109263616e-06 0.7603265096672839 1.313445234085335e-06 0.7618908200857619 1.313445373916531e-06 0.7636286950759973 \
1.313445498679428e-06 0.7651662633748356 1.313445642192899e-06 0.7669199865864609 1.313445762878377e-06 0.7683824344671055 1.313445883722124e-06 0.7698356273746885 \
1.313446003367048e-06 0.7712633747646481 1.313446133074687e-06 0.7727989859455529 1.31344624181849e-06 0.7740766298596218 1.313446364466226e-06 0.7755070372682662 \
1.313446474242911e-06 0.7767778749889983 1.313446603267025e-06 0.7782599816788072 1.313446735043344e-06 0.7797610257751375 1.31344684835592e-06 0.7810403609326458 \
1.313446969441862e-06 0.7823954393038701 1.313447073314495e-06 0.7835479431998941 1.313447215597517e-06 0.785111775748914 1.313447363800666e-06 0.7867227488076519 \
1.313447522694201e-06 0.7884297907063792 1.313447642887223e-06 0.7897074707829422 1.31344779245393e-06 0.7912811323018302 1.313447916569147e-06 0.7925734175081853 \
1.313448042273444e-06 0.7938699048627912 1.313448145219011e-06 0.7949224966762399 1.313448259590165e-06 0.7960823495211882 1.313448372064409e-06 0.7972131756542409 \
1.313448462336983e-06 0.7981137961420948 1.313448551677879e-06 0.7989989930139054 1.313448676903817e-06 0.800229513878344 1.31344878467518e-06 0.8012785338618679 \
1.313448914342978e-06 0.8025281307685926 1.313449035722257e-06 0.8036855380110038 1.313449152278057e-06 0.8047859282369955 1.313449273083453e-06 0.80591497746663 \
1.313449405708758e-06 0.8071413435168892 1.313449527502378e-06 0.8082555056211007 1.313449654106103e-06 0.8094015704683005 1.313449779719621e-06 0.8105266036187198 \
1.313449899211046e-06 0.8115857443778658 1.313450037409299e-06 0.8127973981963581 1.313450146908547e-06 0.8137473213416323 1.313450231056662e-06 0.8144713378799666 \
1.31345035186072e-06 0.8155017394983226 1.313450447369557e-06 0.8163089346032877 1.31345058366036e-06 0.8174496006492775 1.313450726424414e-06 0.8186303638797883 \
1.313450860857535e-06 0.8197292014569521 1.313450970729519e-06 0.8206175763825388 1.313451114629137e-06 0.8217677661037901 1.31345126795672e-06 0.8229768690765377 \
1.313451395805574e-06 0.8239722812379519 1.313451536202905e-06 0.8250521595273246 1.313451662107844e-06 0.8260088941474263 1.31345181672401e-06 0.8271688948348412 \
1.31345194907934e-06 0.8281489842609937 1.313452075346168e-06 0.8290730392392056 1.313452193006695e-06 0.8299245984162376 1.313452341409092e-06 0.8309852945996649 \
1.31345250860326e-06 0.8321626230293395 1.313452641380572e-06 0.8330844501529713 1.313452814281769e-06 0.8342675727345584 1.313452982699063e-06 0.8354015168591284 \
1.313453152193536e-06 0.8365246342267009 1.313453333630418e-06 0.8377070668209077 1.313453476186559e-06 0.8386219603417975 1.31345359009745e-06 0.8393441765511721 \
1.313453720973658e-06 0.8401643924869071 1.313453822596633e-06 0.8407940582489307 1.313453939036871e-06 0.8415078269750864 1.313454074330057e-06 0.8423269142909066 \
1.313454271595159e-06 0.8435017451489455 1.313454462114483e-06 0.844614933042255 1.313454672039296e-06 0.8458175693076773 1.313454852817827e-06 0.8468334846981137 \
1.313455050185846e-06 0.8479221976595614 1.31345522404434e-06 0.8488638701886076 1.313455406558583e-06 0.8498353939890455 1.313455577902694e-06 0.8507314120859523 \
1.313455752248258e-06 0.8516272398309612 1.313455927651258e-06 0.8525125793730954 1.313456103896448e-06 0.8533864315694911 1.313456293665327e-06 0.8543099749208749 \
1.313456484423344e-06 0.8552205033559714 1.31345668621255e-06 0.8561646193034282 1.313456878916116e-06 0.8570482883232282 1.313457088356793e-06 0.8579892478796384 \
1.313457318098559e-06 0.8589986827500428 1.313457583567511e-06 0.8601360945383778 1.313457882213856e-06 0.8613786760148464 1.313458160601222e-06 0.8625023989005415 \
1.313458444791177e-06 0.8636161469557806 1.313458719285784e-06 0.8646608622318305 1.313458991377281e-06 0.8656672252055042 1.313459261593727e-06 0.8666387059277968 \
1.313459518761915e-06 0.8675381145236246 1.313459791320979e-06 0.8684653318325959 1.31346006734232e-06 0.8693777905953765 1.313460337484171e-06 0.8702455402709716 \
1.313460637231955e-06 0.8711796653984102 1.313461008105812e-06 0.872294745819888 1.313461303028797e-06 0.8731503023941 1.313461557284845e-06 0.8738665406311316 \
1.313461855515577e-06 0.8746822274488602 1.313462129133901e-06 0.8754080260278182 1.313462365269549e-06 0.8760175227551726 1.313462605621406e-06 0.876622281264788 \
1.313462827963785e-06 0.8771680781109068 1.313463021968128e-06 0.8776338860468618 1.313463351691207e-06 0.8784037109613512 1.31346350686397e-06 0.8787567114621292 \
1.313463824616497e-06 0.879461652496718 1.313464003481858e-06 0.8798480920375044 1.313464345943324e-06 0.8805675499479563 1.313464530084847e-06 0.8809434933546246 \
1.313465004990284e-06 0.8818790560183651 1.313465172384703e-06 0.8821975058309585 1.313465638216128e-06 0.8830540251881659 1.313465819040967e-06 0.8833751042472839 \
1.313466313074347e-06 0.8842212008576973 1.313466454417056e-06 0.884455124402366 1.313467060806836e-06 0.8854193259359495 1.313467212878983e-06 0.8856514227360587 \
1.31346785955747e-06 0.8865980751852495 1.313467987853824e-06 0.8867785329419297 1.313468635979926e-06 0.8876550049536978 1.313468765772447e-06 0.8878236738033012 \
1.313469544034095e-06 0.8887860366092379 1.313469659025973e-06 0.8889208282599539 1.313470514758392e-06 0.8898661633196656 1.313470660021537e-06 0.8900169066926564 \
1.313471645777722e-06 0.8909664261264102 1.313471866882863e-06 0.8911622482549515 1.313473011997307e-06 0.8921020388386462 1.313473143207264e-06 0.8922053928944147 \
1.313474330865799e-06 0.8931033243919096 1.313474484486091e-06 0.8932130731307282 1.313475894522803e-06 0.8941348173026452 1.313476117329622e-06 0.8942660193790342 \
1.31347779802033e-06 0.8951452796684343 1.313478125641509e-06 0.8952966652167414 1.313480355582631e-06 0.8961896554712738 1.313480908496592e-06 0.8963788593752812 \
1.313484476711123e-06 0.8973573335043913 1.313484800223538e-06 0.8974284307984646 1.313491156631826e-06 0.8984120886469452 1.313491705534673e-06 0.8984686671268907 \
1.313544207609024e-06 0.8994658645395698 1.313544850637886e-06 0.8994692460188505 1.31373698930852e-06 0.9004073346715066 1.313737190722491e-06 0.9004708280105613 \
1.313741150500432e-06 0.8995366825576255 1.31374133452723e-06 0.8993953949813248 1.313742651124504e-06 0.8984641879157507 1.313742823168359e-06 0.8983566564859006 \
1.313744719544654e-06 0.8973720929359315 1.313744893250842e-06 0.897304621671452 1.313757467177875e-06 0.8982933655523699 1.313757552368112e-06 0.8983081509245614 \
1.313765819241151e-06 0.8993078551592517 1.313766293960572e-06 0.8993433667976791 1.314259794870012e-06 0.9002974142054325 1.314259914349736e-06 0.9003767372269074 \
1.314260807172786e-06 0.9012336455299185 1.314260953429423e-06 0.901423267690772 1.314261548322101e-06 0.9023325668564308 1.314261683292918e-06 0.9025673929107925 \
1.314262187968707e-06 0.9035294259428087 1.314262320579608e-06 0.9038000271808221 1.314262721206973e-06 0.9046475051114249 1.314262865572371e-06 0.9049556543240072 \
1.31426328869358e-06 0.9058123566484279 1.314263384150638e-06 0.9059850892484415 1.314264808709455e-06 0.9052205906349737 1.314264933747309e-06 0.9046352442223391 \
1.314265060157898e-06 0.9039223775493039 1.314265162806642e-06 0.9032486771507763 1.314265290021932e-06 0.9022944222362175 1.314265408867758e-06 0.9012801950564071 \
1.314265506520237e-06 0.9003603330664713 1.314265588522258e-06 0.8995243596151602 1.314265668185821e-06 0.8986589236008835 1.314265778963989e-06 0.8973708307079206 \
1.314265880140003e-06 0.8961049472956977 1.314265963084475e-06 0.8950067229086057 1.314266071529892e-06 0.8934921260891034 1.31426617999385e-06 0.8918872687155874 \
1.314266275049989e-06 0.8904106867557802 1.314266395922641e-06 0.8884444419111864 1.314266516699262e-06 0.8863849482818795 1.314266629744433e-06 0.8843763393508186 \
1.314266732915182e-06 0.8824794505619851 1.314266818515338e-06 0.8808620855018965 1.314266892989399e-06 0.8794251273161163 1.314266987312942e-06 0.8775673968166831 \
1.314267075773858e-06 0.8757888800524039 1.31426715484687e-06 0.8741711975775893 1.314267248834225e-06 0.872216793437976 1.314267330179529e-06 0.8704993514258973 \
1.314267425093555e-06 0.8684673705816817 1.314267518136275e-06 0.8664480751909672 1.314267614922069e-06 0.8643215060814092 1.314267738217441e-06 0.8615778533848952 \
1.314267851664452e-06 0.859022019682563 1.314267977516491e-06 0.8561558571929792 1.314268100844635e-06 0.8533196845306243 1.314268230022926e-06 0.850323637950593 \
1.314268370619783e-06 0.8470370034914 1.314268479399505e-06 0.8444782910716596 1.314268614459257e-06 0.8412850455921466 1.314268724119566e-06 0.8386804253780991 \
1.314268853299345e-06 0.8356002443501571 1.314268979483175e-06 0.8325812421138936 1.31426910657353e-06 0.8295317031556502 1.314269235595804e-06 0.826427745883674 \
1.314269344676045e-06 0.8237985689995477 1.314269484526701e-06 0.8204223029647078 1.314269623954893e-06 0.8170507778356514 1.314269756708524e-06 0.8138366863616762 \
1.314269886777199e-06 0.8106848159989707 1.314270010472646e-06 0.8076853837479523 1.314270147427036e-06 0.8043627031572629 1.314270261138882e-06 0.8016030849198694 \
1.314270388615923e-06 0.7985086235398901 1.314270499416994e-06 0.7958187897651571 1.314270618603452e-06 0.7929254985494992 1.314270731982509e-06 0.7901733724735396 \
1.314270866292901e-06 0.7869138859547327 1.314270973387169e-06 0.7843152933129034 1.314271089404312e-06 0.7815009627552112 1.314271218595275e-06 0.778367508739124 \
1.31427131620771e-06 0.7760002683782802 1.314271421787151e-06 0.773440790716327 1.31427153046932e-06 0.7708069008430674 1.314271632885583e-06 0.7683258101021144 \
1.314271726279241e-06 0.7660641808432364 1.314271845835017e-06 0.7631702213567544 1.314271938307379e-06 0.7609327305817616 1.314272030945494e-06 0.7586922094322426 \
1.31427212937031e-06 0.7563124992069843 1.314272237347962e-06 0.7537030947613649 1.314272333616474e-06 0.7513778334636231 1.314272419872877e-06 0.7492952979736797 \
1.314272522736666e-06 0.7468128004450286 1.314272601580994e-06 0.744910856519283 1.314272702387036e-06 0.7424801602439853 1.314272836915276e-06 0.7392377693660663 \
1.314272974140136e-06 0.7359316755186537 1.314273117619987e-06 0.7324773442723981 1.314273266044177e-06 0.7289066083419234 1.314273409305472e-06 0.7254625447335662 \
1.314273549382451e-06 0.7220977259655398 1.314273705808317e-06 0.7183435968963056 1.314273830210067e-06 0.715360858370426 1.314273951271848e-06 0.7124600029613375 \
1.31427410478411e-06 0.7087850045121084 1.314274239566055e-06 0.7055614325718365 1.314274365665088e-06 0.7025479112911024 1.314274508839371e-06 0.6991289103945657 \
1.314274628921163e-06 0.6962626602560111 1.314274758155491e-06 0.6931807499479741 1.314274864640539e-06 0.6906432840523983 1.314274976916361e-06 0.6879696524977363 \
1.314275073251648e-06 0.6856773754336868 1.31427517606134e-06 0.683232326200841 1.314275270865193e-06 0.6809792012818872 1.314275376187123e-06 0.6784784437814733 \
1.314275484625777e-06 0.6759058899658261 1.314275583635058e-06 0.673558569590366 1.31427570039165e-06 0.6707929011939652 1.314275808476928e-06 0.6682347329991606 \
1.314275918483137e-06 0.6656332609774134 1.314276004570979e-06 0.6635992664604092 1.314276134166118e-06 0.6605400273835189 1.314276226767366e-06 0.6583552307294462 \
1.314276322555092e-06 0.6560965362104854 1.314276407507078e-06 0.6540950852804182 1.314276526801602e-06 0.6512869789851043 1.31427661407154e-06 0.6492343850333612 \
1.314276704778561e-06 0.6471030993779646 1.314276805943536e-06 0.6447280068361273 1.314276885774359e-06 0.6428551652550211 1.314276974560194e-06 0.6407732405330839 \
1.31427705225042e-06 0.6389536101386547 1.314277114019368e-06 0.6375081226244841 1.314277177784013e-06 0.6360167668935747 1.314277241018233e-06 0.634538653569437 \
1.314277280258806e-06 0.6336218002627473 1.314277320897828e-06 0.6326726453797233 1.314277400982362e-06 0.6308039353694699 1.314277470886542e-06 0.6291742390428672 \
1.314277521523257e-06 0.6279942052995945 1.314277560272899e-06 0.6270914175114127 1.314277599267879e-06 0.6261832343283663 1.314277643882627e-06 0.6251445623164014 \
1.314277686739083e-06 0.6241478292286105 1.314277737053687e-06 0.6229782634938205 1.314277788990864e-06 0.6217719122409077 1.314277874058449e-06 0.6197972300178722 \
1.314277934038866e-06 0.6184052992407258 1.314278023826075e-06 0.61632338076978 1.314278100290156e-06 0.6145529519516876 1.314278179854447e-06 0.6127119801362371 \
1.314278260891059e-06 0.6108383709630588 1.314278350105382e-06 0.6087775861620425 1.314278440965394e-06 0.6066826282541496 1.314278528184102e-06 0.6046739453334793 \
1.314278621957293e-06 0.6025158549334848 1.314278723642756e-06 0.6001788642681311 1.314278823240849e-06 0.5978941858483342 1.314278935095889e-06 0.5953317151711254 \
1.314279051129026e-06 0.5926772450523136 1.314279172750132e-06 0.5899020947998995 1.314279277133946e-06 0.5875236635596754 1.314279421924166e-06 0.5842296531729801 \
1.314279534584127e-06 0.5816734289694181 1.314279643596094e-06 0.5792035939892568 1.314279736075537e-06 0.5771100174076607 1.314279829526176e-06 0.5749994714793375 \
1.31427992185204e-06 0.5729181236728181 1.314279994438741e-06 0.571283073141143 1.314280050392967e-06 0.5700232888304386 1.314280111461248e-06 0.5686498830286455 \
1.314280209950764e-06 0.5664400707212188 1.314280273162208e-06 0.5650238531380825 1.314280333588177e-06 0.5636708824310654 1.31428041053656e-06 0.5619492451093103 \
1.314280473695101e-06 0.5605380106414651 1.31428056200871e-06 0.558569506627369 1.314280633210033e-06 0.5569845302974165 1.314280719745787e-06 0.555060151797141 \
1.31428084109856e-06 0.5523665438352664 1.314280969027808e-06 0.5495364947125975 1.314281067158439e-06 0.5473694328713704 1.314281180282434e-06 0.5448752016832871 \
1.314281282350254e-06 0.5426314425864434 1.314281401299124e-06 0.5400217272291628 1.314281504386832e-06 0.5377630705755105 1.314281618593986e-06 0.5352670017334624 \
1.314281732009658e-06 0.532794946211756 1.314281859080713e-06 0.5300302694710822 1.314281982900802e-06 0.5273426867079006 1.314282127689607e-06 0.5242103332418484 \
1.31428226351311e-06 0.5212782585303676 1.314282418567968e-06 0.5179428401013338 1.314282579419853e-06 0.5144913885072363 1.3142827581493e-06 0.5106699876709851 \
1.31428294832834e-06 0.5066200804011861 1.314283158230362e-06 0.5021665212646098 1.314283386936347e-06 0.4973332357952056 1.314283640864285e-06 0.4919960258408594 \
1.314283881797751e-06 0.4869529241725989 1.314284177960236e-06 0.4807889695952298 1.314284467957623e-06 0.4747910561470179 1.314284774200956e-06 0.4684976697011882 \
1.314285094876887e-06 0.4619520863481486 1.314285422744054e-06 0.4553041925245184 1.314285762989109e-06 0.4484521981997251 1.314286088414654e-06 0.4419418052309769 \
1.314286410321802e-06 0.4355465312739703 1.314286740535907e-06 0.4290298934287748 1.314287096528499e-06 0.4220583188787752 1.314287415406929e-06 0.4158579595363656 \
1.314287752858691e-06 0.4093433989943853 1.314288180725407e-06 0.4011531841887147 1.314288529437356e-06 0.3945419525178304 1.314288837073319e-06 0.388759214407489 \
1.314289216899811e-06 0.3816861832573664 1.314289548089372e-06 0.3755780492082042 1.314289831697452e-06 0.370391509977049 1.314290142516397e-06 0.3647512908748707 \
1.314290421833005e-06 0.3597258263082204 1.314290648329153e-06 0.3556836811642302 1.314290864011538e-06 0.3518598964090484 1.314291061295543e-06 0.3483842179544538 \
1.314291266280002e-06 0.3447988491770444 1.314291478501966e-06 0.3411119200457455 1.314291733807154e-06 0.33670771290924 1.314291975329403e-06 0.3325734463267218 \
1.314292206706731e-06 0.3286464933807047 1.314292421559231e-06 0.3250253651850565 1.314292642118388e-06 0.3213332986541765 1.314292843544355e-06 0.3179852906236645 \
1.314293046612606e-06 0.3146379646143546 1.314293244508215e-06 0.3114011111455273 1.314293431469302e-06 0.3083651674074345 1.314293625269522e-06 0.3052406640298299 \
1.314293829186134e-06 0.3019773030815858 1.314294008255468e-06 0.2991336297844484 1.314294243846324e-06 0.2954229173226265 1.314294444650423e-06 0.2922868215109002 \
1.314294645829315e-06 0.2891696385850206 1.314294869639057e-06 0.2857334090862961 1.314295034201803e-06 0.2832271910241367 1.314295211129189e-06 0.2805503385691353 \
1.314295396922194e-06 0.2777610713150803 1.31429557873767e-06 0.2750538970423583 1.314295757762463e-06 0.2724132377985424 1.314295925107616e-06 0.2699606650006489 \
1.314296085536534e-06 0.2676371805838822 1.314296208110285e-06 0.2658719571410424 1.314296357874814e-06 0.2637236906090554 1.31429648557194e-06 0.2619099339733745 \
1.314296592880312e-06 0.2603957336038235 1.314296708880974e-06 0.2587625259947361 1.31429681918957e-06 0.2572125806747212 1.314296945068767e-06 0.2554509781935611 \
1.314297060550618e-06 0.2538402638894013 1.314297195131521e-06 0.2519757335310172 1.314297307194775e-06 0.2504255755821768 1.314297457534135e-06 0.2483447107137444 \
1.314297597159989e-06 0.2464124269747185 1.314297743051809e-06 0.2444035064209518 1.314297876012448e-06 0.2425734862730615 1.314297999574161e-06 0.2408709992523319 \
1.314298146783853e-06 0.2388417729476062 1.314298263370682e-06 0.2372355665500016 1.314298402825831e-06 0.23532008003217 1.314298537000301e-06 0.2334768281602104 \
1.314298662976757e-06 0.2317465561243653 1.31429878237616e-06 0.2301094434087779 1.314298877230585e-06 0.2288105340759602 1.314298990368184e-06 0.2272617792622066 \
1.314299070684642e-06 0.2261626001158484 1.314299158249699e-06 0.2249657246820506 1.314299283786835e-06 0.2232507767215072 1.314299389480543e-06 0.2218101326756785 \
1.314299479135054e-06 0.2205921574607158 1.314299549986253e-06 0.2196300825522397 1.314299593014783e-06 0.2190460135436258 1.314299635305326e-06 0.2184724035808872 \
1.314299677647042e-06 0.2178984240735344 1.314299749842462e-06 0.2169203674089526 1.314299792235817e-06 0.2163464205126744 1.314299827490656e-06 0.2158693585303403 \
1.314299871682239e-06 0.2152716287340076 1.314299941290466e-06 0.2143309212991285 1.314299975633797e-06 0.2138672544767182 1.314300020093325e-06 0.2132698436071631 \
1.314300087771806e-06 0.2123628126304402 1.314300174199065e-06 0.2112058698236149 1.314300248835667e-06 0.2102078598594563 1.314300330137675e-06 0.2091219706754807 \
1.314300427015059e-06 0.2078300362310651 1.314300552998548e-06 0.2061528795789772 1.314300655533384e-06 0.2047906894256944 1.314300757016901e-06 0.2034500128132261 \
1.314300858082597e-06 0.202119416354989 1.314300954696816e-06 0.2008491615811921 1.31430105666124e-06 0.1995112314821507 1.314301163383484e-06 0.1981153840927639 \
1.314301271788624e-06 0.1967018790395962 1.314301383782779e-06 0.1952465002768531 1.314301496249907e-06 0.1937897263683151 1.314301608323246e-06 0.1923454332378671 \
1.314301716215721e-06 0.1909603537828802 1.314301817598649e-06 0.1896629368444172 1.314301909236098e-06 0.1884941330679491 1.314302003211707e-06 0.1872990757663449 \
1.314302074478072e-06 0.1863957871745983 1.31430215115336e-06 0.1854271890400033 1.314302254812475e-06 0.184122202819407 1.314302328479595e-06 0.1831974022686171 \
1.314302401825496e-06 0.1822796569444652 1.314302515215845e-06 0.1808667181969195 1.314302603074485e-06 0.1797760932362061 1.314302686923162e-06 0.1787387947787487 \
1.31430281588559e-06 0.1771515524267008 1.314302917772084e-06 0.1759040172436072 1.314303023472791e-06 0.1746156056808686 1.314303125120866e-06 0.1733818993219825 \
1.314303255982584e-06 0.1718019019596718 1.314303363179221e-06 0.1705140034701537 1.314303492508118e-06 0.168969083715685 1.31430360420461e-06 0.167642098072289 \
1.314303704535189e-06 0.1664555496840579 1.314303800335743e-06 0.1653276075899142 1.314303911148015e-06 0.1640289617085985 1.314303998548296e-06 0.1630090521997956 \
1.314304109869413e-06 0.1617156184952586 1.314304202821272e-06 0.1606409001560029 1.31430429039415e-06 0.1596330843918451 1.314304392025023e-06 0.1584700928658864 \
1.314304476479078e-06 0.1575086241734052 1.314304551583457e-06 0.1566573095634876 1.3143046294057e-06 0.1557789554714152 1.314304709763569e-06 0.1548759612316424 \
1.314304810818399e-06 0.1537464547857493 1.314304893251963e-06 0.1528311848879565 1.314304985556514e-06 0.1518114053368895 1.314305062490987e-06 0.150965812476358 \
1.314305145413557e-06 0.1500585909391909 1.314305216944298e-06 0.1492793026301012 1.314305313327797e-06 0.1482344968214558 1.314305383556283e-06 0.1474766665551334 \
1.314305466536561e-06 0.1465853655470201 1.314305527978825e-06 0.1459298106834085 1.314305599661209e-06 0.1451677491870439 1.314305668289752e-06 0.1444408762699853 \
1.314305718558261e-06 0.1439102090153988 1.314305766138067e-06 0.143409423336876 1.314305820187418e-06 0.1428423132663369 1.314305879529516e-06 0.1422216078256897 \
1.314305947564923e-06 0.1415124633834424 1.314306023828345e-06 0.1407207186008814 1.314306092108144e-06 0.1400161356079559 1.314306186894323e-06 0.1390460813732662 \
1.314306276448135e-06 0.1381341561933974 1.314306348133609e-06 0.1374075731330657 1.314306432085017e-06 0.1365606113096345 1.314306497397473e-06 0.1359045398875483 \
1.314306558840598e-06 0.1352895588344758 1.314306633117097e-06 0.1345490408254265 1.314306695327357e-06 0.1339328028964004 1.314306763298366e-06 0.133265236037424 \
1.314306822505406e-06 0.1326856657519672 1.314306895177878e-06 0.1319767402814105 1.314306970197988e-06 0.1312477270463112 1.314307055651411e-06 0.1304208267333309 \
1.31430714175175e-06 0.1295914604616623 1.314307241877205e-06 0.1286317929389105 1.314307323166875e-06 0.127857435971709 1.314307424934223e-06 0.1268981149578782 \
1.314307509182182e-06 0.1261072369695883 1.314307607998911e-06 0.1251836587365037 1.314307680839456e-06 0.1245055382686853 1.314307760865543e-06 0.1237631876254407 \
1.314307831351338e-06 0.1231117958237987 1.31430790388176e-06 0.1224439308288319 1.314307981350756e-06 0.1217331219782777 1.314308088702104e-06 0.1207554316575004 \
1.31430818934012e-06 0.1198442997624752 1.314308261927674e-06 0.1191899427853172 1.314308330759514e-06 0.1185715582611356 1.314308396546334e-06 0.1179824683205609 \
1.314308466175132e-06 0.1173610347366148 1.314308536558877e-06 0.1167350538439435 1.314308611737249e-06 0.1160688810594495 1.314308715991484e-06 0.1151493019715505 \
1.314308791126139e-06 0.114489769343061 1.314308860041223e-06 0.1138870655592168 1.314308923246095e-06 0.1133369146236164 1.31430899278746e-06 0.1127339156958381 \
1.314309050088964e-06 0.1122385190692166 1.314309121730019e-06 0.1116210355509516 1.314309179565093e-06 0.1111240709857579 1.314309251686527e-06 0.1105063809580559 \
1.31430931410261e-06 0.1099736279351742 1.314309398424131e-06 0.1092565349771765 1.3143094660201e-06 0.1086842173446869 1.314309574816032e-06 0.1077671916889585 \
1.314309679126564e-06 0.1068924975608609 1.314309758614772e-06 0.1062289053282379 1.314309846183183e-06 0.1055008617114655 1.314309909639535e-06 0.1049752776433979 \
1.314309971350652e-06 0.10446579874651 1.314310075190416e-06 0.103612238268202 1.314310157871117e-06 0.1029362225408096 1.314310256339144e-06 0.1021348761715451 \
1.314310340785582e-06 0.101450818648051 1.314310457263062e-06 0.1005121841703865 1.314310591996508e-06 0.09943411943161744 1.314310728066044e-06 0.0983541971400249 \
1.314310842385451e-06 0.09745369041838402 1.314310927852596e-06 0.09678457778867394 1.314311038134269e-06 0.09592640631053104 1.314311118922622e-06 0.09530159220710262 \
1.314311218473493e-06 0.09453592511176086 1.314311308421543e-06 0.09384821103094763 1.314311380924943e-06 0.09329669945188329 1.314311462667009e-06 0.09267796846073476 \
1.314311590787244e-06 0.09171467366828615 1.314311672199308e-06 0.09110674702409056 1.314311746631215e-06 0.09055373306570065 1.314311821605099e-06 0.08999936228352182 \
1.314311901024075e-06 0.08941505746347288 1.314312009684932e-06 0.08862052380504259 1.314312104044903e-06 0.08793517800096999 1.314312193440026e-06 0.08728987318634121 \
1.314312300205743e-06 0.086524181682867 1.314312418708182e-06 0.08568073755029131 1.314312560233253e-06 0.08468224831562859 1.314312693371676e-06 0.08375174214918565 \
1.314312834217007e-06 0.08277682112810406 1.314312983268988e-06 0.08175525972387458 1.314313119066718e-06 0.08083369778093191 1.314313260523232e-06 0.0798830809748103 \
1.314313395783147e-06 0.07898330517332906 1.314313537164988e-06 0.07805242629322809 1.314313684232761e-06 0.07709434677344783 1.314313835960902e-06 0.07611680364043326 \
1.314314001309203e-06 0.07506403321855706 1.314314165176721e-06 0.07403332863189842 1.314314341490649e-06 0.07293832728335037 1.314314530925751e-06 0.07177777688466977 \
1.314314741692455e-06 0.07050569389938771 1.314314961464952e-06 0.06920150027616521 1.314315196433104e-06 0.06783224552442871 1.314315455333654e-06 0.06635227408830123 \
1.314315750264117e-06 0.06470266364809808 1.314316054610178e-06 0.06304001691994518 1.314316416556457e-06 0.06111393619706453 1.314316732684212e-06 0.05947639552636011 \
1.314317174006677e-06 0.0572596911373907 1.314317487572719e-06 0.05573556853365672 1.314317911072189e-06 0.0537382660685313 1.314318255024043e-06 0.05216649213267931 \
1.31431859526531e-06 0.05065508790922631 1.3143189061029e-06 0.04931137323461653 1.314319200574802e-06 0.04807062469528345 1.314319494274299e-06 0.04686392507224969 \
1.314319769145536e-06 0.04576537019482012 1.314320044685701e-06 0.04468949010490332 1.31432030977623e-06 0.04367785045825667 1.314320586533311e-06 0.04264571401740119 \
1.314320869801436e-06 0.04161414314527601 1.314321167794735e-06 0.04055545327485047 1.314321427280131e-06 0.03965542606183669 1.314321657303569e-06 0.03887446236327848 \
1.314321876995156e-06 0.03814321686473518 1.314322101935296e-06 0.0374128399305801 1.31432242218897e-06 0.0363978329183388 1.31432270998682e-06 0.03550963653148703 \
1.314322986382154e-06 0.03467738358988744 1.314323270201283e-06 0.03384352473043348 1.314323508310587e-06 0.03315996078327022 1.314323792621371e-06 0.03236211345273886 \
1.314324034533221e-06 0.03169864947531036 1.314324269673394e-06 0.03106710921041438 1.314324511380923e-06 0.03043352335444016 1.314324748333857e-06 0.02982731501219571 \
1.314324978676274e-06 0.02925002048968134 1.314325192426852e-06 0.02872465224286764 1.314325398273815e-06 0.02822791768061097 1.314325790610838e-06 0.02730524204782691 \
1.314325979002849e-06 0.02687312495148303 1.314326354614307e-06 0.02603163971789 1.314326529081082e-06 0.02564950258131362 1.314326953015541e-06 0.02474274850847508 \
1.314327073769958e-06 0.02449086781212801 1.314327544020721e-06 0.02353384026002922 1.314327693235786e-06 0.02323677291035493 1.314328086867998e-06 0.02246740853134286 \
1.314328257894342e-06 0.02213909006726131 1.314328745173274e-06 0.02121869533024997 1.314328887220983e-06 0.02095326544309953 1.314329420237252e-06 0.01997576278857772 \
1.314329542401289e-06 0.01975737097014436 1.314330064559033e-06 0.01885981776906158 1.314330235137336e-06 0.01857989792133653 1.314330722450399e-06 0.01781360777737795 \
1.314330893973323e-06 0.01755501440977742 1.31433151376008e-06 0.01666567753024489 1.314331684684406e-06 0.0164316648397145 1.314332390235396e-06 0.01551160061118263 \
1.314332552852409e-06 0.01530799450170666 1.314333309745899e-06 0.01439879525764199 1.314333450662544e-06 0.01423641007536438 1.314334350661384e-06 0.01324361033368418 \
1.314334438010635e-06 0.01315122959105692 1.314335342363989e-06 0.01223321097894121 1.314335479555938e-06 0.01209984223734439 1.314336450212214e-06 0.01118944790767422 \
1.314336578130092e-06 0.01107451071402888 1.314337728540039e-06 0.01011008206277823 1.314337822342075e-06 0.01003687265682024 1.314339078387887e-06 0.009120584045805383 \
1.314339215929201e-06 0.009026502753623255 1.314340774683602e-06 0.008029670037698805 1.314340858486287e-06 0.007977066150721189 1.314342463865106e-06 0.00699828665725172 \
1.31434257476345e-06 0.006935886594503895 1.314344507009824e-06 0.005959177461785255 1.31434468671476e-06 0.005876661013304485 1.314346798505876e-06 0.004981749118765498 \
1.314347141291012e-06 0.004848482978762325 1.314349654457045e-06 0.003966891390423618 1.314350124178715e-06 0.003819799497680527 1.31435376449499e-06 0.002847564273158896 \
1.314354280232175e-06 0.002731633924241866 1.314359622062014e-06 0.001773027297371861 1.314359907382299e-06 0.001729522787584184 1.314365136030129e-06 0.0007540451492352357 \
1.314365310176696e-06 0.0007162692714263865 1.317013698769002e-06 -0.0001123232525192561 1.31701387179429e-06 -0.0002901710972538241 1.317014491546044e-06 -0.001202022686018724 \
1.317014580115221e-06 -0.001365806793032466 1.317014941086355e-06 -0.002110727959526865 1.31701506578065e-06 -0.002395793696299351 1.317015429622531e-06 -0.003299857180474864 \
1.3170156008982e-06 -0.003758114451912169 1.317015894896038e-06 -0.004576312838821549 1.317016005104443e-06 -0.004886880824040592 1.317016283358441e-06 -0.005643955697619643 \
1.31701640463225e-06 -0.00594200199557267 1.317017498254348e-06 -0.00517389603226481 1.317017621358228e-06 -0.004409713243767066 1.317017744826303e-06 -0.003462788751204457 \
1.3170178649921e-06 -0.002366010162083454 1.317017962853768e-06 -0.001346276287748183 1.317018069556104e-06 -0.0001076498664581183 1.317018181397488e-06 0.001328007358939307 \
1.317018317371855e-06 0.003256083960376262 1.317018439401011e-06 0.00514709866632534 1.317018627817289e-06 0.008343062029134115 1.317018768805819e-06 0.01093380316938193 \
1.317018921577522e-06 0.01391176330477175 1.317019064280151e-06 0.01683596409946878 1.317019218632387e-06 0.02013443377634912 1.317019374426043e-06 0.02358734537610087 \
1.31701953048334e-06 0.02715365164079262 1.31701967788774e-06 0.03060642997674319 1.317019826504485e-06 0.03415780069914553 1.317019981925702e-06 0.03793559522944389 \
1.317020140311532e-06 0.04184227512730877 1.317020305251154e-06 0.04596085539464361 1.317020479500423e-06 0.05035714787605008 1.317020658443539e-06 0.05491177248689325 \
1.317020847583032e-06 0.0597604232635115 1.31702105036361e-06 0.06498910043066243 1.317021269735637e-06 0.07067233091134768 1.317021500572133e-06 0.07667464705993039 \
1.317021747383969e-06 0.0831083675499642 1.31702201751608e-06 0.09016243555275107 1.317022310704188e-06 0.0978236474935409 1.317022634359626e-06 0.1062798466079799 \
1.317022997926912e-06 0.1157689210849182 1.31702339022043e-06 0.1259925151671456 1.317023838699915e-06 0.1376538644086695 1.3170243603994e-06 0.1511757390224034 \
1.317024972772044e-06 0.1669844191341421 1.317025649417359e-06 0.1843663871188266 1.31702643632765e-06 0.2044554566749352 1.317027317548744e-06 0.2267919980918504 \
1.317028137292384e-06 0.2474048556006221 1.317028865745328e-06 0.2655829647002126 1.317029507221317e-06 0.2814688958417333 1.317030083144485e-06 0.2956305456066151 \
1.317030620401302e-06 0.3087428400511723 1.317031124292597e-06 0.3209487846516751 1.317031601896145e-06 0.3324328152479784 1.317032080019379e-06 0.343838772307344 \
1.317032532118229e-06 0.3545331600964184 1.317033003884519e-06 0.365596737404158 1.31703344758136e-06 0.3759140547845509 1.317033969549898e-06 0.3879344734281669 \
1.31703449708783e-06 0.399956933836353 1.317034876602574e-06 0.4085271910771138 1.317035405564175e-06 0.4203606102508351 1.317035874883255e-06 0.4307444005277802 \
1.317036310038791e-06 0.4402814026247405 1.317036757516117e-06 0.4500002273945978 1.317037197539592e-06 0.4594737646471725 1.317037600841335e-06 0.4680814138276727 \
1.317037919241101e-06 0.4748254127722248 1.317038289219015e-06 0.4826007100982719 1.317038525472097e-06 0.4875314737878706 1.317038760543493e-06 0.4924129045770672 \
1.317039011882831e-06 0.4975994385012801 1.317039318269865e-06 0.5038799449729535 1.317039575228319e-06 0.5091120301871851 1.317039783702615e-06 0.5133309170973237 \
1.317039984084905e-06 0.5173683849445317 1.317040126478606e-06 0.5202244049244739 1.317040275403072e-06 0.5231993726577677 1.317040486949329e-06 0.5274019882470222 \
1.317040713006952e-06 0.5318780389403845 1.317040907549333e-06 0.5357103559602913 1.317041096681229e-06 0.539423417888626 1.317041326128277e-06 0.5439012399750046 \
1.317041508634083e-06 0.5474563135343053 1.317041745996952e-06 0.5520623276458133 1.31704201499126e-06 0.5572695987004129 1.31704226390171e-06 0.5620706638085723 \
1.317042507918531e-06 0.5667633705755619 1.317042780273744e-06 0.5719926523718327 1.317043041669873e-06 0.5769928369418796 1.317043299301279e-06 0.5819084237686675 \
1.317043546144628e-06 0.586601202059797 1.317043791890354e-06 0.5912552023551558 1.317044018467874e-06 0.5955288021520931 1.317044249620064e-06 0.5998646534936181 \
1.317044455900444e-06 0.6037202012184053 1.317044684021204e-06 0.6079592993751251 1.317044906401185e-06 0.6120725203834017 1.317045133377667e-06 0.6162454422471376 \
1.317045348430617e-06 0.6201823359462864 1.31704557780019e-06 0.6243500782103125 1.317045846823065e-06 0.6292041961704016 1.317046069836712e-06 0.6331993632081415 \
1.317046282091289e-06 0.6369772451758789 1.317046493488879e-06 0.6407176358819484 1.317046693558109e-06 0.644236566349866 1.317046923151958e-06 0.6482486956559365 \
1.317047163988886e-06 0.6524328529570182 1.317047345738273e-06 0.6555667906748446 1.3170475342865e-06 0.6588018260593631 1.317047687366139e-06 0.6614154033769962 \
1.317047859374421e-06 0.6643352515471471 1.317048009547239e-06 0.6668697017322168 1.317048146064529e-06 0.6691578850264722 1.317048295693716e-06 0.6716547631652277 \
1.317048423434085e-06 0.673777752640997 1.317048563020223e-06 0.6760856948620949 1.31704868725891e-06 0.6781310478824312 1.31704881840875e-06 0.6802827752320969 \
1.317048942850093e-06 0.6823179209931315 1.317049080080916e-06 0.6845542421253382 1.317049200329086e-06 0.6865048414796368 1.317049341660529e-06 0.6887891282595083 \
1.317049441991641e-06 0.6904033553735033 1.317049563109343e-06 0.6923460943304175 1.317049653886878e-06 0.6937948943079848 1.317049751145344e-06 0.6953408241330762 \
1.317049847353224e-06 0.6968660703265798 1.317049935967068e-06 0.6982647859968389 1.317050033255091e-06 0.6997938110311075 1.317050165723729e-06 0.7018622871835729 \
1.317050320913928e-06 0.7042674555997347 1.317050458791879e-06 0.7063866855441746 1.317050603646153e-06 0.7085960165693863 1.31705073070791e-06 0.7105202221428537 \
1.31705085539347e-06 0.7123960184768648 1.317050968098846e-06 0.7140814553427599 1.317051079889191e-06 0.7157437310299281 1.31705118066784e-06 0.7172341607972841 \
1.317051317946295e-06 0.7192525454101454 1.317051437630367e-06 0.7210013704967912 1.317051557059838e-06 0.7227365757678518 1.31705168394306e-06 0.7245692610776365 \
1.317051808360712e-06 0.7263556789600311 1.317051932093537e-06 0.728121726658988 1.317052058689063e-06 0.7299181396522603 1.317052189074464e-06 0.7317573312219798 \
1.317052311884284e-06 0.7334798522758219 1.317052447320059e-06 0.7353678990088863 1.317052548609838e-06 0.7367723836293941 1.317052656232334e-06 0.7382576460517265 \
1.317052745760416e-06 0.7394878879617913 1.317052860308785e-06 0.7410528648863303 1.317052948337041e-06 0.7422487366778059 1.317053055415107e-06 0.7436953530868765 \
1.3170531854801e-06 0.7454403311053276 1.317053296759795e-06 0.7469230742113165 1.317053401378355e-06 0.7483084058091373 1.31705352546134e-06 0.7499400420429273 \
1.317053673762168e-06 0.7518749696944975 1.317053795162033e-06 0.7534462209622173 1.31705390960278e-06 0.7549170836379747 1.317054049940098e-06 0.7567069362027918 \
1.317054191702981e-06 0.7584995177563068 1.317054309503919e-06 0.759977341175643 1.317054437480785e-06 0.761570846386187 1.317054579183209e-06 0.7633205808366864 \
1.317054696694523e-06 0.7647599110190483 1.317054842299792e-06 0.7665289162262866 1.317054963994099e-06 0.7679951561698679 1.317055082724709e-06 0.7694149786178283 \
1.317055205011304e-06 0.7708662727382939 1.31705533205582e-06 0.77236234268503 1.317055441699792e-06 0.7736439866494906 1.317055567386705e-06 0.7751025186690397 \
1.317055673401805e-06 0.776323977486031 1.317055808987772e-06 0.7778743028704433 1.317055933950769e-06 0.7792913979962601 1.317056059856921e-06 0.7807070123991936 \
1.317056175124167e-06 0.7819915514687489 1.31705628142864e-06 0.7831664991275713 1.317056419833432e-06 0.7846822315516878 1.317056569129882e-06 0.7862997378875561 \
1.317056714637327e-06 0.7878588534534761 1.317056834041839e-06 0.7891257303126159 1.317056969134663e-06 0.7905455128963393 1.317057090387826e-06 0.7918076974797237 \
1.317057233381105e-06 0.7932816011184505 1.31705737758541e-06 0.7947523458802197 1.317057503122239e-06 0.7960199014141693 1.317057622168612e-06 0.7972110037065316 \
1.317057734104495e-06 0.7983213107123885 1.317057838976047e-06 0.7993531099923881 1.317057934226459e-06 0.8002831901653534 1.317058070569705e-06 0.8016020813281191 \
1.317058187393835e-06 0.8027203407102198 1.317058306798445e-06 0.803852171037294 1.317058428905249e-06 0.8049980820693966 1.31705855186025e-06 0.8061401395390313 \
1.317058678828951e-06 0.8073073595000361 1.31705880406856e-06 0.8084467645495962 1.317058934640955e-06 0.8096220968518901 1.317059060631473e-06 0.8107441738369082 \
1.317059188817386e-06 0.8118738099374113 1.317059294347114e-06 0.8127947795787664 1.317059397218887e-06 0.8136847278655364 1.317059490214057e-06 0.8144826950388273 \
1.31705961401066e-06 0.8155354283166244 1.317059701978917e-06 0.8162769513478326 1.317059800709988e-06 0.8171027376706747 1.317059943975142e-06 0.8182889948057973 \
1.317060079253827e-06 0.8193962136425846 1.317060188368449e-06 0.8202800249700468 1.317060336451758e-06 0.8214657808291811 1.317060486222685e-06 0.8226492530953341 \
1.317060611457285e-06 0.8236267526687548 1.317060755448703e-06 0.8247372275730155 1.317060879504774e-06 0.8256825756473101 1.317061029968032e-06 0.8268152483647575 \
1.317061165678884e-06 0.8278240064655301 1.317061290697392e-06 0.828742521381556 1.317061408452322e-06 0.8295983347934622 1.317061554429135e-06 0.8306466023667578 \
1.317061720938452e-06 0.8318251482734692 1.317061851861028e-06 0.8327390940956469 1.317062025288466e-06 0.8339327615268647 1.317062193435348e-06 0.8350717495747054 \
1.317062363270277e-06 0.8362042975620877 1.317062544195048e-06 0.8373912937861997 1.317062687293307e-06 0.8383160748488641 1.317062801379198e-06 0.8390446117604563 \
1.317062931553184e-06 0.8398665237782376 1.317063033394266e-06 0.8405024977857931 1.317063150213615e-06 0.8412243379523001 1.317063287078045e-06 0.8420597162999857 \
1.317063484876668e-06 0.8432475311273343 1.31706367648074e-06 0.8443767279905872 1.317063885921222e-06 0.8455874169714939 1.317064067846852e-06 0.8466193100105236 \
1.317064264979957e-06 0.8477171434207121 1.317064438329848e-06 0.8486653666163242 1.317064621329232e-06 0.8496493024239481 1.317064792495495e-06 0.8505537352954988 \
1.317064967127282e-06 0.8514606693963016 1.317065142389669e-06 0.8523550102558151 1.317065318541785e-06 0.8532381479010797 1.317065508812824e-06 0.8541746551565574 \
1.317065699414775e-06 0.85509499218684 1.317065900062401e-06 0.8560449689899254 1.317066092672966e-06 0.8569390259424264 1.317066303330652e-06 0.8578972157030333 \
1.317066531456051e-06 0.8589122247267402 1.317066797213368e-06 0.8600655879592763 1.317067095837813e-06 0.8613244245924475 1.317067372169332e-06 0.862454900702886 \
1.31706765640239e-06 0.8635842083919951 1.317067930614306e-06 0.8646423892283146 1.317068202842372e-06 0.8656634505877856 1.317068473051191e-06 0.8666487272755322 \
1.317068730204067e-06 0.8675609437488442 1.317069002786335e-06 0.868501515423508 1.317069278771335e-06 0.8694269133137555 1.317069548872911e-06 0.8703069289141475 \
1.317069848734863e-06 0.8712546000783432 1.317070219768993e-06 0.8723856543073821 1.317070514706754e-06 0.8732530157608677 1.317070768997536e-06 0.8739790309043101 \
1.317071067254951e-06 0.8748056771600844 1.317071340863485e-06 0.8755409825400007 1.31707157699155e-06 0.8761583495732972 1.31707181733693e-06 0.876770807053994 \
1.317072039670212e-06 0.8773233906735478 1.31707223367596e-06 0.8777948466981503 1.317072563398506e-06 0.8785737911727464 1.317072718571944e-06 0.8789308835864816 \
1.317073036347473e-06 0.8796437246174529 1.31707321520917e-06 0.8800342982281311 1.317073557671047e-06 0.8807611334253193 1.317073741799519e-06 0.8811407335605206 \
1.317074216677856e-06 0.8820849466541889 1.317074384074053e-06 0.8824061830950772 1.317074849915456e-06 0.8832696475595492 1.317075030737665e-06 0.8835931319180218 \
1.317075524775914e-06 0.8844450822729043 1.317075666124327e-06 0.8846804878101884 1.317076272457385e-06 0.8856498028150036 1.317076424526725e-06 0.8858829444029697 \
1.3170770712152e-06 0.8868329272509302 1.317077199509723e-06 0.8870138524519416 1.317077847626928e-06 0.8878919388991984 1.317077977425792e-06 0.8880607713689423 \
1.317078755627481e-06 0.8890227771434612 1.317078870684414e-06 0.8891574578072456 1.317079726342848e-06 0.8901003239091128 1.317079871707616e-06 0.8902505899439886 \
1.31708085746403e-06 0.8911948786459364 1.31708107856904e-06 0.8913892999646706 1.317082223696019e-06 0.8923206810037944 1.317082354912618e-06 0.892422953350996 \
1.317083696124267e-06 0.8934189515818408 1.317083847523211e-06 0.8935240845833778 1.317085328961459e-06 0.8944568913393511 1.317085567840892e-06 0.8945912088657246 \
1.317087337161074e-06 0.8954685138428928 1.317087726310841e-06 0.895637400736999 1.317090119976628e-06 0.896526474291006 1.31709059568945e-06 0.8966764365754722 \
1.317094011699057e-06 0.8975478548673914 1.317094658849072e-06 0.8976786076740833 1.317102137013678e-06 0.8986646932675814 1.317102809590796e-06 0.8987192862546014 \
1.317195253995367e-06 0.8997188196574962 1.317195917228051e-06 0.8997241906476866 1.317385126389945e-06 0.900686595210158 1.317385288462789e-06 0.9007292695325627 \
1.317387933983676e-06 0.8998161167154269 1.317388102533154e-06 0.8996881690130656 1.317389379285545e-06 0.8987393243250013 1.317389581451881e-06 0.8986030018074492 \
1.317391189561267e-06 0.8976721249252815 1.317391381667192e-06 0.8975774045828077 1.317406495049839e-06 0.8985726115129884 1.317406683108756e-06 0.8986004060702872 \
1.317417988037768e-06 0.8995874924221801 1.317418361423516e-06 0.8996034751727418 1.317907373786698e-06 0.9005892719715856 1.317907484554898e-06 0.9006868984798269 \
1.317908237227259e-06 0.9015617873136611 1.317908339021945e-06 0.9017086238768567 1.31790887442049e-06 0.9025814930725723 1.317908976929663e-06 0.9027670217776843 \
1.317909369148482e-06 0.9035254014384071 1.317909509991429e-06 0.9038129158713877 1.317909951028881e-06 0.9047472953155866 1.317910136514484e-06 0.9051402477015744 \
1.317910652827601e-06 0.9061269394579334 1.317910737502694e-06 0.9062564181617988 1.317911972174744e-06 0.9053011091537977 1.317912129388156e-06 0.9045688862145235 \
1.317912321204817e-06 0.9034162411061901 1.317912488045348e-06 0.9021712267446264 1.317912635003746e-06 0.9008824031243315 1.317912749119943e-06 0.8997575350477262 \
1.317912878992032e-06 0.8983446880789033 1.31791299010955e-06 0.8970273815442567 1.317913082914029e-06 0.8958483937359277 1.317913171236719e-06 0.8946639786015808 \
1.317913274417478e-06 0.8932058048613533 1.317913366625413e-06 0.8918333298588224 1.31791345419561e-06 0.8904732289418564 1.317913568189077e-06 0.8886245408236838 \
1.3179137299935e-06 0.8858564722885236 1.317913914992118e-06 0.8825005184224666 1.317914107151785e-06 0.8788219124347386 1.317914308599139e-06 0.874780227084481 \
1.317914515009728e-06 0.8704697801294994 1.317914700181681e-06 0.8664790122147591 1.317914884689405e-06 0.862405115500708 1.317915057841296e-06 0.8585071391690239 \
1.317915242887321e-06 0.8542751393552932 1.317915420261525e-06 0.8501657390392787 1.317915597007955e-06 0.8460284987362284 1.317915763166606e-06 0.8421077870518131 \
1.317915925211044e-06 0.8382599993991456 1.317916091783925e-06 0.8342839555277276 1.317916250437662e-06 0.8304816347052207 1.317916441313687e-06 0.8258903812682129 \
1.317916616297259e-06 0.8216694867670907 1.317916786243393e-06 0.8175615830390965 1.317916951419567e-06 0.8135626411663678 1.317917124611674e-06 0.8093650119631921 \
1.317917295673877e-06 0.8052155696745213 1.317917463774914e-06 0.801136095357175 1.317917654109863e-06 0.7965156511928794 1.317917837691806e-06 0.7920591698039 \
1.317918045682732e-06 0.7870113041480956 1.317918268259242e-06 0.7816114142545842 1.317918457674258e-06 0.7770174196885687 1.317918650984654e-06 0.7723312127316435 \
1.317918794430241e-06 0.7688556734481145 1.317918943853591e-06 0.7652374066097742 1.317919063006063e-06 0.7623536300085233 1.317919175722544e-06 0.7596269484184472 \
1.317919284997451e-06 0.7569846861296079 1.317919421027209e-06 0.753697254849378 1.317919533823024e-06 0.750972995067179 1.31791965602098e-06 0.7480232093637929 \
1.317919767605753e-06 0.7453311011793381 1.317919892312216e-06 0.7423241425761796 1.317920046694167e-06 0.7386034578119585 1.317920213478233e-06 0.7345862494782525 \
1.317920430642921e-06 0.7293605768817599 1.31792062520351e-06 0.7246835946359503 1.317920785534395e-06 0.7208333202545074 1.317920960959998e-06 0.7166251500492028 \
1.317921150723573e-06 0.7120779400724765 1.317921339451897e-06 0.7075610435995559 1.317921521273264e-06 0.7032145396962334 1.317921705870676e-06 0.6988062725207448 \
1.317921842953811e-06 0.6955348514212173 1.317921996242049e-06 0.6918805091472418 1.317922191613795e-06 0.6872279990818534 1.317922347770547e-06 0.6835136309588888 \
1.317922505722766e-06 0.6797605476340507 1.31792270397403e-06 0.6750570282453686 1.317922897319928e-06 0.6704763548785364 1.317923133825274e-06 0.6648822204491218 \
1.317923320030378e-06 0.6604858901039825 1.317923557652698e-06 0.6548824851665868 1.317923744451452e-06 0.6504854738275335 1.317923925009211e-06 0.6462424706993735 \
1.317924088085156e-06 0.6424159959781919 1.317924232696721e-06 0.6390271817202816 1.317924373299071e-06 0.6357379642635244 1.317924500108657e-06 0.632774906490579 \
1.317924632245193e-06 0.6296924762754078 1.317924758489145e-06 0.6267508340255646 1.317924889752774e-06 0.6236963630311418 1.317925018850514e-06 0.6206978048938425 \
1.317925158276179e-06 0.6174624210713571 1.317925306646171e-06 0.6140261568477932 1.31792550120306e-06 0.6095278574984737 1.317925644648937e-06 0.6062198040692683 \
1.317925879109183e-06 0.6008245134060309 1.317926051007495e-06 0.5968818013610552 1.317926263928033e-06 0.5920102583789468 1.317926436394651e-06 0.5880775912131976 \
1.317926566719198e-06 0.5851108450968721 1.317926698275517e-06 0.5821241897920357 1.317926808505599e-06 0.5796262478458715 1.317926904159846e-06 0.5774603558442819 \
1.317927003393806e-06 0.5752182923213994 1.317927086311908e-06 0.5733484809858778 1.317927165227534e-06 0.5715706040143225 1.317927228156309e-06 0.5701535626562365 \
1.317927293664786e-06 0.5686800671140783 1.317927374150839e-06 0.5668736364148982 1.317927424016847e-06 0.5657560592102344 1.317927473205615e-06 0.5646541775062763 \
1.317927534675401e-06 0.5632780399140616 1.317927582596929e-06 0.5622058085646952 1.317927633441648e-06 0.5610687758404553 1.317927692541903e-06 0.5597501790023616 \
1.31792775115623e-06 0.5584442118409422 1.317927826782323e-06 0.5567607189607793 1.317927897341035e-06 0.5551915720267918 1.317927986471042e-06 0.5532116467156011 \
1.31792807569462e-06 0.5512351177508077 1.31792816099823e-06 0.5493490637975145 1.317928248625197e-06 0.5474138635528197 1.31792834562712e-06 0.545274424894262 \
1.317928449972891e-06 0.5429792414815097 1.317928566264316e-06 0.5404269323775457 1.317928672601932e-06 0.5380963700835184 1.317928784310815e-06 0.5356536306660374 \
1.317928896605295e-06 0.5332047801427824 1.317929023802854e-06 0.5304364255197962 1.317929146572528e-06 0.5277698476303582 1.317929288796925e-06 0.5246912237717902 \
1.317929425160057e-06 0.5217463069543907 1.317929577381123e-06 0.5184691491721333 1.317929737017329e-06 0.5150420887864461 1.317929912992521e-06 0.5112761258030903 \
1.317930101501109e-06 0.5072591542828934 1.31793030856769e-06 0.5028616940969075 1.317930533509662e-06 0.4981043078903621 1.317930784905619e-06 0.4928144328841237 \
1.317931021331185e-06 0.4878598554762091 1.317931318494919e-06 0.4816683149127979 1.317931609172211e-06 0.4756487143466775 1.317931917027196e-06 0.469313240945046 \
1.317932230852953e-06 0.4628991126846517 1.317932559994313e-06 0.4562163541974347 1.31793289337242e-06 0.4494927613461197 1.317933224999028e-06 0.4428490490857003 \
1.317933546548425e-06 0.4364504708187015 1.317933874224238e-06 0.4299742838549845 1.31793422184386e-06 0.4231546934710667 1.317934555065174e-06 0.4166645133789623 \
1.317934900974402e-06 0.4099771621835854 1.317935346388221e-06 0.4014400148089548 1.317935704178092e-06 0.3946500490499754 1.317936018334912e-06 0.3887397205534429 \
1.317936402745392e-06 0.3815756289527631 1.317936732720036e-06 0.3754830843203271 1.317937017930125e-06 0.3702633801070484 1.317937326220382e-06 0.3646649204592909 \
1.317937606017443e-06 0.3596257204303125 1.317937832011793e-06 0.3555880084110294 1.317938046849748e-06 0.3517755993421203 1.31793824528482e-06 0.3482769933469286 \
1.317938449224337e-06 0.3447071465415313 1.317938659760396e-06 0.3410461989361561 1.317938916734521e-06 0.3366091000429626 1.317939157995129e-06 0.3324763702393667 \
1.317939389568845e-06 0.3285420159269506 1.317939604222291e-06 0.3249208057821749 1.317939825046275e-06 0.3212218866489027 1.317940026292867e-06 0.3178749657716667 \
1.31794022938212e-06 0.3145250552959265 1.317940427226991e-06 0.3112865758726304 1.317940614079937e-06 0.3082497660855442 1.317940808016663e-06 0.3051208532403978 \
1.317941011761317e-06 0.30185834615803 1.317941190488583e-06 0.2990186060348319 1.317941428134378e-06 0.2952727068736475 1.317941627896611e-06 0.2921508861588616 \
1.317941829525427e-06 0.2890253490052915 1.317942054991886e-06 0.285561995332 1.317942221086285e-06 0.2830312764183137 1.317942399705387e-06 0.2803277612349699 \
1.317942581409588e-06 0.2775983111934518 1.317942770043305e-06 0.2747882307029562 1.317942947466508e-06 0.2721695222189568 1.317943124659646e-06 0.2695724116247911 \
1.317943284731561e-06 0.2672552081803913 1.317943405132238e-06 0.2655193337608355 1.317943552958303e-06 0.2633957862580221 1.317943681588075e-06 0.2615692882062232 \
1.317943783793658e-06 0.2601227034409412 1.317943902028939e-06 0.2584516051170885 1.3179440224823e-06 0.2567534139348401 1.317944146190618e-06 0.2550183706610066 \
1.317944264442643e-06 0.2533694204037282 1.317944392295773e-06 0.2515887492000971 1.317944512581604e-06 0.249915736161692 1.31794466526121e-06 0.2477917697339537 \
1.317944800173988e-06 0.2459264316518071 1.31794492881341e-06 0.2441493177932957 1.317945086528788e-06 0.2419705448111171 1.317945213210091e-06 0.2402201997919771 \
1.317945348536158e-06 0.2383592392624043 1.317945487448727e-06 0.2364550510890953 1.317945605221031e-06 0.2348405558720491 1.317945764491849e-06 0.2326580599570062 \
1.317945901013704e-06 0.2307878375452989 1.31794604224565e-06 0.2288626996658652 1.317946148058693e-06 0.2274220928889542 1.31794627840164e-06 0.2256484734765637 \
1.317946378112453e-06 0.2242944442559471 1.317946480933888e-06 0.2228991027388591 1.317946554349542e-06 0.2219046249368765 1.317946634181104e-06 0.2208265149641777 \
1.317946704228335e-06 0.2198809561195558 1.317946754631426e-06 0.2192009305305119 1.317946806883225e-06 0.2184966408607167 1.317946886120743e-06 0.2174292050927151 \
1.317946927964696e-06 0.2168658036437602 1.317946967304648e-06 0.216336351877609 1.317947010340057e-06 0.2157575332679269 1.317947054507484e-06 0.2151638767852215 \
1.317947128273224e-06 0.2141731338947761 1.317947163785221e-06 0.2136967174286463 1.317947211500021e-06 0.2130606706933813 1.317947272229561e-06 0.2122518321687151 \
1.317947340486787e-06 0.2113438957752176 1.317947413008566e-06 0.2103801801047663 1.317947485683193e-06 0.2094152724966429 1.317947593999181e-06 0.2079788886429202 \
1.317947691670323e-06 0.20668564243436 1.317947803221819e-06 0.2052110974836689 1.317947901757253e-06 0.2039136008387587 1.317948005250393e-06 0.2025572972554956 \
1.317948101152128e-06 0.2013021587886929 1.317948203780057e-06 0.1999606878451601 1.31794830660317e-06 0.1986207062101238 1.317948416722797e-06 0.1971897063011611 \
1.317948525418353e-06 0.1957815523781236 1.317948645095582e-06 0.1942360962608612 1.317948755373261e-06 0.192818053470401 1.317948863436481e-06 0.1914343471929882 \
1.317948988535148e-06 0.1898375077741012 1.317949078504982e-06 0.1886931806549971 1.317949157191935e-06 0.1876950225942949 1.317949234476806e-06 0.1867173468865102 \
1.317949320985383e-06 0.1856271834369256 1.317949419934593e-06 0.1843848109964498 1.317949490443458e-06 0.1835017733581451 1.317949561894511e-06 0.1826096997732476 \
1.317949667039846e-06 0.1813018727451555 1.317949746279476e-06 0.1803200401832796 1.317949827363369e-06 0.1793174195483187 1.31794992085531e-06 0.1781663090788374 \
1.317950021631285e-06 0.1769308188703378 1.317950171343388e-06 0.175105380089017 1.317950287132704e-06 0.1737009932372819 1.31795043813808e-06 0.1718807311127691 \
1.3179505492465e-06 0.1705485445502526 1.317950691372958e-06 0.168854666407182 1.317950809031379e-06 0.167460358327668 1.317950913935975e-06 0.1662230887079887 \
1.317951008998573e-06 0.1651069099307241 1.317951102429828e-06 0.1640147999883682 1.31795120347649e-06 0.1628388413495604 1.317951299823398e-06 0.1617223204899406 \
1.317951396975644e-06 0.1606011553546776 1.317951480024216e-06 0.1596469772300165 1.31795159006187e-06 0.1583897228513109 1.317951672364432e-06 0.1574542248873526 \
1.317951777364141e-06 0.156267858580057 1.31795185506021e-06 0.1553950893374849 1.317951937879689e-06 0.1544690878994293 1.317952019541594e-06 0.1535604570452941 \
1.317952108890884e-06 0.152571060794856 1.31795218460332e-06 0.1517364980793458 1.317952267165934e-06 0.1508307726525361 1.317952343747367e-06 0.1499942554682341 \
1.317952412035253e-06 0.1492531084507001 1.317952505402265e-06 0.1482449401818621 1.317952574555677e-06 0.1475015570698688 1.317952650180008e-06 0.1466917482325688 \
1.317952711729129e-06 0.1460354497178591 1.317952778977892e-06 0.1453208357145237 1.317952850039892e-06 0.1445684785944268 1.31795292553732e-06 0.143772322008306 \
1.31795298444886e-06 0.1431546944759192 1.31795306112247e-06 0.1423563022825049 1.317953141443211e-06 0.1415233898163201 1.31795321459452e-06 0.1407682091691316 \
1.317953308750941e-06 0.139800669784813 1.317953380355125e-06 0.1390684367429364 1.3179534538159e-06 0.1383201464810226 1.317953537327651e-06 0.1374732033664194 \
1.317953626806795e-06 0.1365744208092838 1.3179536918717e-06 0.1359252211013016 1.317953803997723e-06 0.1348115665849295 1.317953869183864e-06 0.1341670699454539 \
1.317953939222108e-06 0.1334770515823289 1.317953999527163e-06 0.1328849371768329 1.317954054537987e-06 0.1323464455745446 1.317954142654965e-06 0.1314871014507438 \
1.31795418344126e-06 0.131090685705856 1.31795428714401e-06 0.1300923774523848 1.31795433045658e-06 0.1296773144713907 1.317954391675178e-06 0.1290920262082728 \
1.317954436511897e-06 0.1286643765206081 1.317954524107923e-06 0.127831527987147 1.317954565661879e-06 0.1274377589706847 1.317954625523389e-06 0.1268718307679372 \
1.317954697367115e-06 0.1261946708524367 1.317954753579841e-06 0.1256664967939027 1.31795481606734e-06 0.125081039250218 1.317954890295323e-06 0.1243877959456236 \
1.317954964976328e-06 0.1236954937854857 1.317955052159541e-06 0.1228905551604285 1.317955120558092e-06 0.1222610287411191 1.317955201128775e-06 0.1215216597888775 \
1.317955282424256e-06 0.120778012781285 1.317955349340781e-06 0.1201677797529914 1.317955432157726e-06 0.1194156054679852 1.317955491346448e-06 0.1188799972037829 \
1.317955557267448e-06 0.1182853617472536 1.317955637141492e-06 0.1175675408705869 1.31795571363729e-06 0.1168828806096336 1.3179557950994e-06 0.1161574242846086 \
1.317955893570281e-06 0.1152852106851665 1.31795596868063e-06 0.114622623867465 1.31795607166842e-06 0.1137180076826871 1.317956145852371e-06 0.1130691786503039 \
1.317956243471825e-06 0.1122190343868764 1.31795633928278e-06 0.1113890351962442 1.317956435131205e-06 0.110562946039519 1.317956516069412e-06 0.1098685209805978 \
1.317956604452683e-06 0.1091134439098378 1.317956703052662e-06 0.108274944429282 1.317956775836866e-06 0.1076586405352824 1.317956865109775e-06 0.1069058608836731 \
1.317956927091788e-06 0.1063852406583179 1.317956989684956e-06 0.1058613310701875 1.317957074907104e-06 0.105150777260444 1.317957180369478e-06 0.1042758147594986 \
1.317957260199961e-06 0.1036167065755082 1.317957340914214e-06 0.1029530974056021 1.317957423527949e-06 0.1022768941101355 1.317957493972562e-06 0.1017026162492672 \
1.317957597231928e-06 0.1008648142128753 1.317957670072053e-06 0.1002767039768694 1.317957755712335e-06 0.09958839426015198 1.317957874514073e-06 0.09863954321822334 \
1.317957942151898e-06 0.09810250133474645 1.31795801190202e-06 0.09755100310752296 1.317958089237e-06 0.09694230106952094 1.317958181657254e-06 0.09621870517595056 \
1.317958253354782e-06 0.09566033062548993 1.317958339171942e-06 0.09499542738017568 1.317958441597192e-06 0.09420660575030523 1.317958534892083e-06 0.09349264652734962 \
1.317958631208556e-06 0.09276005482712441 1.317958708110818e-06 0.09217843893134048 1.317958801590805e-06 0.09147541043939374 1.317958880833232e-06 0.09088281005358793 \
1.317958995455426e-06 0.0900310686188453 1.317959125063686e-06 0.08907580221142102 1.317959258320877e-06 0.08810234090122065 1.317959402350766e-06 0.08705990691030199 \
1.31795955951891e-06 0.08593388720602639 1.317959709295387e-06 0.08487214151476249 1.317959871762979e-06 0.08373303262435308 1.317960014942984e-06 0.08273971668837025 \
1.317960167622107e-06 0.0816913199659166 1.317960301891878e-06 0.08077856892457436 1.317960443644156e-06 0.07982444400446118 1.317960578643816e-06 0.07892500874648442 \
1.317960720601214e-06 0.07798882638923543 1.317960867448644e-06 0.07703088995320664 1.317961019894053e-06 0.07604750978240994 1.317961185112776e-06 0.07499422991502351 \
1.317961349250621e-06 0.07396067809208305 1.317961526112024e-06 0.07286119333145537 1.31796171645358e-06 0.07169407515132428 1.317961927410093e-06 0.07042030845332216 \
1.317962147819232e-06 0.0691121699798517 1.317962383344393e-06 0.06773900533435212 1.317962643793767e-06 0.0662496528900723 1.317962939459177e-06 0.06459579389282195 \
1.317963244581463e-06 0.06292902455725519 1.317963609576024e-06 0.06098725515092194 1.317964004456839e-06 0.05894944116461652 1.317964410847493e-06 0.05692211719668253 \
1.317964826573035e-06 0.05491854459141238 1.317965189379358e-06 0.0532251207245777 1.317965533980648e-06 0.05166301626031383 1.31796584916051e-06 0.05027284652491828 \
1.317966144689875e-06 0.04900240867073854 1.317966442670382e-06 0.04775344010203557 1.317966718469172e-06 0.04662857640242725 1.317966997243768e-06 0.04551884372531381 \
1.317967261178638e-06 0.04449205559535935 1.317967537201377e-06 0.04344260531795661 1.31796781615763e-06 0.04240676967887352 1.317968129850963e-06 0.04127097799875453 \
1.31796836585125e-06 0.04043636567030678 1.317968621645987e-06 0.03955075129286261 1.317968881769487e-06 0.03867033103466553 1.317969151904759e-06 0.03778142289416799 \
1.317969431124747e-06 0.03688501536902895 1.317969712963396e-06 0.03600226561751176 1.317969989839066e-06 0.03515600409566183 1.317970268932665e-06 0.03432349610146775 \
1.317970501810273e-06 0.03364444121149882 1.317970785646989e-06 0.03283527291840588 1.317971025751924e-06 0.03216626441466421 1.317971265550746e-06 0.0315119836023277 \
1.31797150482792e-06 0.03087436846876356 1.317971740084942e-06 0.03026290129608995 1.317971971011964e-06 0.02967475842909434 1.317972186001007e-06 0.02913788335257221 \
1.31797258815546e-06 0.02816043724496065 1.317972786878278e-06 0.02768988489927659 1.317973160561295e-06 0.0268265706552881 1.317973347359617e-06 0.02640514011949098 \
1.317973694919304e-06 0.02563810810034544 1.317973816848767e-06 0.0253740445387235 1.317974199320207e-06 0.02456430406701914 1.317974370028237e-06 0.02421180751242828 \
1.317974827125621e-06 0.02328894863848502 1.317975012758007e-06 0.0229225623309489 1.31797537621526e-06 0.02221803970155307 1.317975596582612e-06 0.02179832126591805 \
1.31797605430897e-06 0.02093867417890744 1.317976189728599e-06 0.02068687731869814 1.317976719624047e-06 0.01972418011126781 1.317976838945017e-06 0.01951377505543128 \
1.317977404730696e-06 0.01856069823426573 1.317977569110437e-06 0.0182962226476828 1.317978187655734e-06 0.01735107502432094 1.317978357709933e-06 0.01710418363667701 \
1.317978889842166e-06 0.01636278834442301 1.317979086926142e-06 0.01610013864443424 1.317979810045215e-06 0.01517806887136661 1.317979974675381e-06 0.01497647803580381 \
1.317980723800768e-06 0.01409711804523418 1.31798085710012e-06 0.01394643716836554 1.317981717353759e-06 0.01301449210748497 1.317981852457379e-06 0.01287422877142914 \
1.31798279503482e-06 0.01193816285908547 1.317982958630574e-06 0.01178202925388569 1.317983959987201e-06 0.0108653384673985 1.317984097529988e-06 0.01074500730514941 \
1.317985319636371e-06 0.009765086624518643 1.317985426589084e-06 0.00968516078425012 1.317986830780577e-06 0.008707372520026449 1.317986935611284e-06 0.008639312158696611 \
1.317988470448246e-06 0.00767719340797631 1.317988565731547e-06 0.007617466071856052 1.317990174528868e-06 0.006680264535635283 1.317990308605608e-06 0.006609506832171614 \
1.317992405618559e-06 0.005610918814474722 1.317992636163191e-06 0.005510783990371394 1.317994959158435e-06 0.004586584533412417 1.317995440488638e-06 0.004413562233393853 \
1.317998278050269e-06 0.003511943147855551 1.317998822969955e-06 0.003360532104877318 1.318002947178352e-06 0.002408309874554541 1.318003490902011e-06 0.002305347543005144 \
1.318009362191237e-06 0.001333291345955189 1.318009605056421e-06 0.001286469439319215 1.318023932948772e-06 0.0002880570268237783 1.318024077507414e-06 0.0002853642807229123 \
1.320661356428513e-06 -0.0006859155495331031 1.32066149598365e-06 -0.000901903561740745 1.320662005077583e-06 -0.001859438188174024 1.320662094565085e-06 -0.002052812934985279 \
1.320662457959945e-06 -0.00291126965001638 1.320662548982015e-06 -0.003143482006111167 1.320662914420052e-06 -0.004127275145644371 1.320663024680619e-06 -0.004436819103926468 \
1.320663336727774e-06 -0.005309594399865315 1.320663439442621e-06 -0.005584800160857357 1.320663803290477e-06 -0.006384516484886619 1.320663968081209e-06 -0.006586298968823262 \
1.320664547677408e-06 -0.005791490933239759 1.320664722787551e-06 -0.004914057272375438 1.320664839479485e-06 -0.004132845175365214 1.320664966064091e-06 -0.003100877896798674 \
1.320665067873013e-06 -0.002132773363901063 1.320665188361723e-06 -0.0008283127610571584 1.320665278808799e-06 0.0002599396317828252 1.32066537669893e-06 0.001541559978017447 \
1.32066547576324e-06 0.002943971508909197 1.320665646570516e-06 0.005594911825788154 1.320665868338539e-06 0.00944046646559993 1.320666064242384e-06 0.01317281463966807 \
1.320666223123766e-06 0.01639870563256729 1.320666387552263e-06 0.01989779506365397 1.320666541918294e-06 0.02331070396473752 1.320666700690818e-06 0.02693200463312963 \
1.320666847428777e-06 0.03036422445567413 1.320666996052748e-06 0.0339113704936035 1.320667151667245e-06 0.03768995713197771 1.320667308909259e-06 0.04156499463828727 \
1.320667473802058e-06 0.04567927910670353 1.320667647221578e-06 0.05005184210758699 1.320667825915293e-06 0.05459761989277153 1.320668014531131e-06 0.05943075613080645 \
1.320668215431274e-06 0.06460909294799391 1.320668434888064e-06 0.0702927970720964 1.320668664434351e-06 0.07626037976612585 1.320668910133291e-06 0.08266408948881369 \
1.32066917869823e-06 0.08967663153997742 1.320669470040144e-06 0.09728936802005522 1.320669791708172e-06 0.1056939239977524 1.320670152022263e-06 0.1150987971742611 \
1.320670543001701e-06 0.1252892839303718 1.320670986416517e-06 0.1368209045172546 1.320671502729605e-06 0.1502062239570841 1.320672108934821e-06 0.16586000516691 \
1.320672780191848e-06 0.1831102247110778 1.320673559691505e-06 0.20301830483439 1.320674432001389e-06 0.2251413938832897 1.320675262336714e-06 0.2460320778586349 \
1.320675993667063e-06 0.264292249712138 1.320676641612843e-06 0.280346965484095 1.320677224923317e-06 0.29469740877147 1.320677760655584e-06 0.3077798509628869 \
1.320678263914169e-06 0.3199778888071559 1.32067874911767e-06 0.3316516836183861 1.320679228040375e-06 0.3430829066939081 1.320679674471008e-06 0.3536501814456421 \
1.320680148800718e-06 0.3647819492304352 1.320680597991712e-06 0.3752331958288908 1.32068108846397e-06 0.3865396207984229 1.320681617036723e-06 0.3985997842463301 \
1.320681988181062e-06 0.4069920784971888 1.320682515935418e-06 0.4188173133762567 1.320682978292178e-06 0.4290642331729484 1.320683450624318e-06 0.4394285229343968 \
1.320683932409041e-06 0.4498981261869666 1.320683965448159e-06 0.4506126593745911 1.320684003207152e-06 0.45142837879914 1.320684078725137e-06 0.4530572051633331 \
1.320684229761107e-06 0.4563088938659436 1.320684437280373e-06 0.460764549126051 1.320684625319184e-06 0.4647825567212808 1.320684844328398e-06 0.469441659996985 \
1.320685087159409e-06 0.4745824626509371 1.320685386935037e-06 0.4808894567257585 1.320685624728187e-06 0.4858624696070272 1.320685887949588e-06 0.4913374535260851 \
1.320686148847133e-06 0.4967277906005185 1.32068637840122e-06 0.5014431429135263 1.320686601461413e-06 0.506003872007333 1.320686803037404e-06 0.5100983586086808 \
1.320686951867463e-06 0.51310967141356 1.320687196178516e-06 0.5180317772556589 1.320687328783749e-06 0.5206893064287169 1.320687468140331e-06 0.5234717264876519 \
1.320687679105724e-06 0.5276623644271943 1.320687853979606e-06 0.5311266030493931 1.320688122027852e-06 0.5364094032095129 1.32068831705351e-06 0.5402319029111832 \
1.320688496615017e-06 0.5437361368949839 1.320688747571146e-06 0.5486228351952749 1.320689024979257e-06 0.5540035987981641 1.320689308928559e-06 0.5594901708581531 \
1.32068956456585e-06 0.5644152233389156 1.32068985554807e-06 0.570006772487656 1.320690115853754e-06 0.5749917787111524 1.320690384297874e-06 0.5801232573974072 \
1.320690627063004e-06 0.5847450403362237 1.320690883594205e-06 0.5896146675871002 1.320691109757648e-06 0.59388771440121 1.320691347099143e-06 0.5983512154742827 \
1.32069155648786e-06 0.6022720321566808 1.320691770260628e-06 0.6062574570422776 1.320692023713469e-06 0.6109557890491497 1.320692226567816e-06 0.6146943332140289 \
1.320692419372338e-06 0.6182333111593361 1.320692609677365e-06 0.6217090173923294 1.320692800335854e-06 0.6251694921350958 1.32069300291378e-06 0.6288260100903066 \
1.320693265662542e-06 0.6335359534764116 1.320693494630232e-06 0.6376100987349322 1.320693714577867e-06 0.6414991146358265 1.32069394026254e-06 0.6454625140719233 \
1.320694149149966e-06 0.6491091855837361 1.320694370803585e-06 0.652957810138281 1.320694555693011e-06 0.6561429680377227 1.320694745707565e-06 0.6594017273991298 \
1.320694895862686e-06 0.6619630641908443 1.320695070740593e-06 0.6649292185271485 1.32069521646131e-06 0.6673855496832628 1.320695352493842e-06 0.6696641287411549 \
1.320695500856121e-06 0.672138295335571 1.320695630303834e-06 0.6742883907026684 1.320695764169531e-06 0.6764996355878535 1.32069589251393e-06 0.6786115243545502 \
1.320696017902059e-06 0.6806677490053815 1.320696147367755e-06 0.6827843190971332 1.32069627834897e-06 0.6849171426143115 1.320696426722072e-06 0.6873221141612875 \
1.320696534784827e-06 0.6890667486235877 1.3206966633165e-06 0.6911333958680312 1.320696798756283e-06 0.6933004139195943 1.320696923690607e-06 0.6952876996714908 \
1.320697049447875e-06 0.6972799977491608 1.320697155963766e-06 0.6989584331773744 1.320697273081655e-06 0.7007929859467624 1.320697391621401e-06 0.7026383448210159 \
1.320697514924797e-06 0.704545102273978 1.320697618097696e-06 0.7061304255463237 1.320697769068859e-06 0.7084341141567283 1.320697885323065e-06 0.7101955266062138 \
1.320698015883454e-06 0.7121605601685687 1.320698134445982e-06 0.7139335830373704 1.320698240519852e-06 0.7155108922888329 1.320698340544792e-06 0.716990346352101 \
1.320698477870007e-06 0.719009255813789 1.320698596531362e-06 0.7207429633399333 1.320698718230586e-06 0.7225107522614664 1.320698843413151e-06 0.7243181860083944 \
1.320698965432965e-06 0.7260693242762759 1.320699093464719e-06 0.7278954552757622 1.320699217946458e-06 0.7296603419865877 1.320699346245781e-06 0.7314685590147565 \
1.320699473339584e-06 0.7332489547570846 1.320699599364423e-06 0.7350034830462163 1.32069970210311e-06 0.7364262918236342 1.320699816775856e-06 0.7380063527755659 \
1.320699898181918e-06 0.7391232259175492 1.320700017381438e-06 0.7407496908814458 1.320700110023778e-06 0.7420059782745783 1.320700248182835e-06 0.7438668850244906 \
1.320700379238334e-06 0.7456179978167152 1.320700509370502e-06 0.7473439783685625 1.320700614344577e-06 0.7487266533969134 1.320700753484419e-06 0.7505456565005918 \
1.320700907428719e-06 0.7525407731682957 1.320701029372999e-06 0.7541080835708853 1.320701176919359e-06 0.7559892974429111 1.320701298924537e-06 0.7575320275232224 \
1.320701447624467e-06 0.7593968175435225 1.320701581671092e-06 0.7610632318338031 1.320701703924347e-06 0.7625711443351471 1.320701816790257e-06 0.763953046884334 \
1.320701959641225e-06 0.7656882893306027 1.320702086364119e-06 0.7672149413549471 1.320702202168994e-06 0.7685995877768005 1.320702331910823e-06 0.7701390587657672 \
1.320702447649211e-06 0.7715019052061673 1.320702570601637e-06 0.7729391548276606 1.320702688317297e-06 0.7743051053122872 1.320702794287273e-06 0.7755262985206828 \
1.320702910698467e-06 0.7768586864857919 1.3207030173164e-06 0.7780703956921795 1.32070312951512e-06 0.7793369495935717 1.32070321618369e-06 0.7803089322889447 \
1.320703319569181e-06 0.7814603789665585 1.320703432733433e-06 0.7827108149434853 1.320703538380716e-06 0.783868819044773 1.320703647720273e-06 0.7850578567336689 \
1.320703754897288e-06 0.786214126597127 1.320703884303365e-06 0.7875981444497275 1.320703996720751e-06 0.7887899291890393 1.32070412010849e-06 0.7900869036018625 \
1.320704237558825e-06 0.7913106402786101 1.320704381085744e-06 0.7927918312347375 1.320704496005322e-06 0.7939667362870242 1.320704634727735e-06 0.7953719780830618 \
1.320704772759875e-06 0.7967562205547866 1.32070488225303e-06 0.7978444364842524 1.32070498327146e-06 0.7988406866985471 1.32070508435942e-06 0.7998302780396641 \
1.320705216746616e-06 0.8011146558616069 1.320705335472037e-06 0.8022550163876687 1.320705457256542e-06 0.8034134048507504 1.320705576346336e-06 0.8045351524060473 \
1.320705697550853e-06 0.8056657048884367 1.320705829194664e-06 0.8068811249615274 1.320705952212703e-06 0.8080052413861453 1.320706079823023e-06 0.8091594649786741 \
1.320706210891683e-06 0.8103325925767672 1.320706334212046e-06 0.8114249716726942 1.32070644213631e-06 0.8123719892944993 1.320706549931703e-06 0.8133095350680949 \
1.320706631652631e-06 0.8140147772069938 1.320706748520247e-06 0.815015186305849 1.320706839581256e-06 0.8157880755829442 1.320706973749887e-06 0.8169164295805346 \
1.32070711832076e-06 0.8181184617099191 1.320707251823127e-06 0.8192158725965917 1.320707361789037e-06 0.8201107352847025 1.320707505654698e-06 0.8212684563313245 \
1.320707658960262e-06 0.8224861772268215 1.320707786698555e-06 0.8234883060891934 1.320707927340891e-06 0.8245786478120171 1.320708053124456e-06 0.8255423809867173 \
1.320708207742427e-06 0.8267124309768116 1.320708340154194e-06 0.8277017767197102 1.320708466433798e-06 0.8286345641820314 1.320708584064113e-06 0.8294941055817234 \
1.320708732230976e-06 0.8305638349826423 1.320708899375221e-06 0.8317531470681401 1.320709031993881e-06 0.832683775428688 1.320709204938569e-06 0.8338803479528284 \
1.320709373325224e-06 0.8350269493631071 1.320709542859754e-06 0.8361634673386688 1.320709724228909e-06 0.8373596561587384 1.320709866861491e-06 0.8382862741713709 \
1.32070998079734e-06 0.8390176620397163 1.320710111571134e-06 0.8398476357987267 1.320710213225074e-06 0.8404856735008092 1.320710329718803e-06 0.8412091703399448 \
1.320710465236349e-06 0.8420405885319162 1.320710662580143e-06 0.8432318270427018 1.320710853245141e-06 0.8443612543037786 1.32071106310198e-06 0.8455804035625291 \
1.320711244039104e-06 0.8466117334714958 1.320711441374591e-06 0.8477160230260256 1.320711615161427e-06 0.8486711109012058 1.320711797742881e-06 0.8496572451898022 \
1.320711969062461e-06 0.850566499179887 1.320712143447507e-06 0.8514760798656241 1.320712318831052e-06 0.8523748177975867 1.320712495063209e-06 0.8532619682996843 \
1.320712684901452e-06 0.8542000584728613 1.320712875637665e-06 0.8551245802328369 1.320713077434399e-06 0.856083442102113 1.320713270127775e-06 0.8569809170305027 \
1.320713479756076e-06 0.857937542729613 1.32071370919384e-06 0.8589615588718806 1.32071397499048e-06 0.8601183337444025 1.320714273565708e-06 0.8613802063570262 \
1.320714551467221e-06 0.8625196921548358 1.320714835677695e-06 0.8636511027355716 1.320715110089482e-06 0.8647118800460076 1.320715382252364e-06 0.8657341977214618 \
1.320715652421456e-06 0.8667205537246333 1.320715909616139e-06 0.8676338760342862 1.32071618215581e-06 0.868575115807136 1.320716458190291e-06 0.8695013130444248 \
1.320716728342986e-06 0.8703818891200001 1.320717028049788e-06 0.8713292845176382 1.320717398867258e-06 0.8724597217497643 1.320717693785921e-06 0.8733269024855727 \
1.320717948030199e-06 0.8740525764960509 1.320718246254198e-06 0.8748787854419284 1.320718519878969e-06 0.8756137195941651 1.320718756017959e-06 0.8762307200963571 \
1.320718996373686e-06 0.8768427579093606 1.320719218719338e-06 0.8773949085683344 1.320719412723072e-06 0.877865919014753 1.320719742447196e-06 0.878644045115768 \
1.320719897619855e-06 0.8790007149587372 1.320720215373248e-06 0.879712598742095 1.320720394238605e-06 0.8801026384247937 1.320720736700093e-06 0.8808283583858193 \
1.320720920841293e-06 0.8812073588304842 1.320721395746114e-06 0.8821499412898334 1.320721563140601e-06 0.8824705695712217 1.320722028971889e-06 0.8833323038036038 \
1.320722209796771e-06 0.8836551183393088 1.320722703830028e-06 0.8845051821644966 1.320722845172603e-06 0.8847400410050358 1.320723451563118e-06 0.8857071861637142 \
1.320723603635685e-06 0.8859397703602404 1.320724250313758e-06 0.8868873789663725 1.320724378610247e-06 0.8870678433440622 1.320725026723245e-06 0.8879435266410994 \
1.320725156528523e-06 0.8881118897635528 1.320725934785608e-06 0.8890711781604964 1.320726049780423e-06 0.8892053868933587 1.320726905511062e-06 0.8901454611437621 \
1.320727050777629e-06 0.8902951528450479 1.320728036533732e-06 0.8912364417375994 1.320728257640946e-06 0.8914302300078862 1.320729402752027e-06 0.892358484239638 \
1.320729533960174e-06 0.8924604119362172 1.320730875263369e-06 0.8934531785430913 1.32073102665103e-06 0.8935579568409697 1.320732508109867e-06 0.8944876667405802 \
1.320732746990229e-06 0.894621531696939 1.320734516461986e-06 0.8954958910368339 1.320734905568823e-06 0.8956641700186337 1.320737299334232e-06 0.8965498195158238 \
1.320737774894223e-06 0.8966991754584082 1.320741837950387e-06 0.8976977719002629 1.320742329424408e-06 0.8977905759376156 1.320750645951487e-06 0.8987839664765119 \
1.320751565805377e-06 0.8988472044554419 1.320877770945903e-06 0.8998441026240215 1.320878784754255e-06 0.8998514601858095 1.321070497347411e-06 0.8990059056521554 \
1.321070727348974e-06 0.8988405173838494 1.321072342221535e-06 0.8978439928078279 1.321072519935389e-06 0.8977495532019018 1.321089285710428e-06 0.8987316330193963 \
1.321089421698825e-06 0.8987497732072308 1.321104884427938e-06 0.8997471920221268 1.32110515229253e-06 0.8997526389354535 1.321588977619798e-06 0.9006560548284696 \
1.321589098408999e-06 0.9007687033315858 1.321589886180037e-06 0.9017381658104292 1.321590020318756e-06 0.901943163319478 1.32159051393353e-06 0.9027850367016239 \
1.321590658833145e-06 0.9030569221572713 1.32159105464053e-06 0.9038490360455199 1.321591174436184e-06 0.9041001886668685 1.321591558609717e-06 0.9049189780371781 \
1.321591670731365e-06 0.9051556495331843 1.321592178052336e-06 0.9061253139956988 1.321592272051192e-06 0.90626859229291 1.321593430700898e-06 0.9055667778886739 \
1.321593533663832e-06 0.9051589876696525 1.321593617506701e-06 0.9047707260375384 1.321593751246752e-06 0.9040404158978201 1.321593851964133e-06 0.9033957423200318 \
1.321593959579919e-06 0.9026166239542108 1.321594077153173e-06 0.9016533104038295 1.321594165418223e-06 0.90085556431878 1.321594285051691e-06 0.8996698288011099 \
1.321594382373389e-06 0.8986166602050341 1.321594493390828e-06 0.8973222354192386 1.321594595500415e-06 0.8960407982554908 1.321594678931815e-06 0.8949326975987755 \
1.321594783112883e-06 0.8934749428758865 1.321594874199646e-06 0.8921321265381427 1.321594966740432e-06 0.8907058396397178 1.32159506189443e-06 0.8891776325191247 \
1.321595176449407e-06 0.88725933118288 1.321595265292509e-06 0.8857137884271823 1.321595363531691e-06 0.8839502506198179 1.321595448901865e-06 0.8823735982707064 \
1.321595529802107e-06 0.8808434949738935 1.3215956027634e-06 0.8794355441897157 1.321595669782045e-06 0.8781198554636557 1.321595738393124e-06 0.8767515715160701 \
1.321595821888036e-06 0.8750591081124355 1.321595884015366e-06 0.8737811510706814 1.321595946997964e-06 0.8724704924326797 1.321596042153715e-06 0.8704632161180945 \
1.321596142764353e-06 0.8683077530860182 1.321596222643545e-06 0.8665738309361769 1.321596306905814e-06 0.8647250601592834 1.321596386016074e-06 0.8629723295901451 \
1.321596448831519e-06 0.8615696597604833 1.321596536288554e-06 0.8596016864744445 1.321596602182084e-06 0.8581079708060287 1.321596670243626e-06 0.856556281928966 \
1.321596719556134e-06 0.8554267461646872 1.321596774792924e-06 0.85415654045335 1.321596815532529e-06 0.8532164928603474 1.321596861834283e-06 0.8521450198670055 \
1.321596892048343e-06 0.8514441160591502 1.321596921089625e-06 0.8507691938976955 1.32159695172822e-06 0.8500558939662993 1.32159701300541e-06 0.8486254874746039 \
1.321597066077972e-06 0.8473828229799116 1.321597119733165e-06 0.8461232012188223 1.321597182390447e-06 0.8446482873934593 1.321597245673395e-06 0.8431545995644786 \
1.321597336171269e-06 0.8410121009440262 1.321597433169049e-06 0.8387078554355326 1.32159751614655e-06 0.8367307351423475 1.321597598150905e-06 0.8347721678896715 \
1.321597687219307e-06 0.8326403548070889 1.321597771732643e-06 0.8306135893189693 1.321597862591523e-06 0.8284303722590877 1.321597954526378e-06 0.8262176456275642 \
1.321598056957309e-06 0.8237486178045141 1.32159815707534e-06 0.8213320995840899 1.321598271896223e-06 0.8185572053828121 1.32159838410276e-06 0.8158423448209959 \
1.321598509096305e-06 0.8128151787794674 1.321598640356713e-06 0.8096337870015397 1.321598785627755e-06 0.8061104108175116 1.321598940135368e-06 0.8023613213197434 \
1.321599111575989e-06 0.7981999722344618 1.321599275625781e-06 0.794217661721315 1.321599460041203e-06 0.7897413884478564 1.321599666533577e-06 0.7847307375046715 \
1.32159985602742e-06 0.7801344622909899 1.321600049421183e-06 0.775444374634302 1.321600249988037e-06 0.7705834242206392 1.321600397552439e-06 0.7670092004965298 \
1.32160052756389e-06 0.7638619034739171 1.321600662428303e-06 0.7605987503374771 1.321600768918754e-06 0.7580234999254772 1.321600900608547e-06 0.7548403390839162 \
1.321601007032976e-06 0.7522693550468039 1.321601150211605e-06 0.7488125398635642 1.321601311338716e-06 0.7449250928176189 1.321601429565533e-06 0.7420746008290786 \
1.321601599798354e-06 0.7379721584775248 1.321601765724623e-06 0.7339761998059781 1.321601985266954e-06 0.7286940862104242 1.321602178454078e-06 0.724050920820232 \
1.321602353368041e-06 0.719851304223293 1.321602520315139e-06 0.7158476177432674 1.3216027078061e-06 0.711355754450834 1.321602895234537e-06 0.7068709122373377 \
1.321603063571096e-06 0.7028473835914892 1.32160325640163e-06 0.6982428782038785 1.321603396451378e-06 0.694901318858167 1.321603552708666e-06 0.6911769338170629 \
1.321603746878113e-06 0.6865540563080536 1.321603905984602e-06 0.6827702245679255 1.321604064344632e-06 0.679008548037742 1.32160425966174e-06 0.6743756772263459 \
1.321604470090519e-06 0.6693917663527935 1.321604722792665e-06 0.6634173774538097 1.321604902460615e-06 0.6591769455535931 1.321605154037489e-06 0.6532475027332399 \
1.321605354410306e-06 0.6485340174553987 1.321605526064158e-06 0.6445032789616798 1.321605684756275e-06 0.6407814961122935 1.321605823964202e-06 0.637522316374186 \
1.321605960288252e-06 0.6343349641335875 1.321606087501276e-06 0.6313646237382058 1.321606216993834e-06 0.6283457899522861 1.321606344985121e-06 0.6253646753452949 \
1.32160647605963e-06 0.6223174651643489 1.321606606771705e-06 0.6192830747181834 1.321606749379757e-06 0.6159760732208495 1.321606892103236e-06 0.612672916206165 \
1.321607044651037e-06 0.6091471600588 1.321607189155025e-06 0.6058158037532523 1.321607353173272e-06 0.6020406322262999 1.321607490637933e-06 0.5988837056407329 \
1.321607625454949e-06 0.5957940466067043 1.321607746953592e-06 0.5930134750293682 1.321607885803897e-06 0.5898448108574432 1.321607999450713e-06 0.5872554148224447 \
1.321608150860885e-06 0.5838116422847746 1.32160826457956e-06 0.5812320812748947 1.321608383992651e-06 0.5785269636915771 1.321608472673178e-06 0.5765205397309219 \
1.321608563818269e-06 0.5744630259469776 1.321608629157145e-06 0.5729901393713442 1.321608693626847e-06 0.5715377831648228 1.321608744447459e-06 0.5703933076453638 \
1.321608803422398e-06 0.569066051987989 1.321608870867106e-06 0.5675516747474645 1.321608937959298e-06 0.5660472084764079 1.321608990879742e-06 0.5648615894615425 \
1.321609086527225e-06 0.5627204246953637 1.321609143708362e-06 0.5614413394337 1.321609197510977e-06 0.5602399192081799 1.321609259253082e-06 0.5588634520375642 \
1.321609345086214e-06 0.5569525037715509 1.321609427781862e-06 0.5551133137453282 1.321609553910589e-06 0.552313430559463 1.321609689009665e-06 0.5493247407981657 \
1.321609787329828e-06 0.5471534914294828 1.32160989990789e-06 0.5446716589975775 1.321610002452305e-06 0.5424173856211837 1.321610122561131e-06 0.5397821662853191 \
1.321610224248782e-06 0.5375541863492928 1.321610339752746e-06 0.5350300289250629 1.321610454643861e-06 0.5325260225312031 1.321610581121134e-06 0.5297740207092871 \
1.32161070633833e-06 0.5270565158317848 1.321610853184312e-06 0.5238798967507053 1.321610988642446e-06 0.5209557060405445 1.321611146203055e-06 0.5175672114705414 \
1.321611308357229e-06 0.5140875588169389 1.321611489068307e-06 0.5102248342695275 1.32161168131606e-06 0.5061308236654174 1.321611894038323e-06 0.5016182665703952 \
1.321612125943484e-06 0.4967183500883584 1.321612383137188e-06 0.4913135654247419 1.321612622690498e-06 0.4863004534671564 1.321612924620373e-06 0.4800178499336004 \
1.321613212386814e-06 0.4740665530855001 1.321613525189057e-06 0.4676409412178996 1.321613845020806e-06 0.4611139840073785 1.321614184657409e-06 0.4542292677834274 \
1.321614511873228e-06 0.4476411633207955 1.321614847034797e-06 0.4409363684817221 1.321615164291458e-06 0.4346351592989786 1.321615498111436e-06 0.4280489847791872 \
1.32161584979678e-06 0.4211625252737479 1.321616163864498e-06 0.4150547397555842 1.321616486893702e-06 0.4088175946446666 1.321616927873099e-06 0.4003732788922496 \
1.321617270275942e-06 0.3938810608698495 1.32161757072383e-06 0.3882325136127223 1.321617946053401e-06 0.3812375944419973 1.32161827612863e-06 0.3751439175705365 \
1.321618559406411e-06 0.3699597784791666 1.321618859913772e-06 0.3645020109013299 1.321619139561233e-06 0.3594637112692664 1.321619363423524e-06 0.3554634414471464 \
1.321619575274513e-06 0.35170280677964 1.321619777623113e-06 0.3481338771034005 1.321619978758139e-06 0.3446120049995081 1.321620184535657e-06 0.3410324794262659 \
1.321620445514371e-06 0.3365252478245505 1.321620685004553e-06 0.3324209773202946 1.321620917679624e-06 0.3284665339262754 1.321621131761216e-06 0.3248537323113044 \
1.321621352906983e-06 0.3211475567840967 1.321621553789873e-06 0.3178053707831449 1.321621757181075e-06 0.3144500223650613 1.321621954849488e-06 0.3112139453100684 \
1.321622141093175e-06 0.3081862077816076 1.321622336074257e-06 0.3050391973134606 1.321622539536502e-06 0.3017803754370622 1.321622717477408e-06 0.2989521325826759 \
1.321622953201112e-06 0.2952356640875101 1.321623151333966e-06 0.2921385263640672 1.321623352678033e-06 0.2890160050544278 1.32162357696723e-06 0.2855690750291008 \
1.321623741897129e-06 0.2830551950838826 1.321623919525814e-06 0.2803657404651576 1.321624103924961e-06 0.2775946687427531 1.321624287746306e-06 0.2748547260732712 \
1.321624466202979e-06 0.2722194282383935 1.321624638103246e-06 0.2696976713509589 1.321624798643653e-06 0.2673699088296289 1.321624920125711e-06 0.265617282026588 \
1.321625073047239e-06 0.2634201198254058 1.321625200480934e-06 0.2616085083773952 1.321625304654605e-06 0.2601317890528609 1.321625421559082e-06 0.2584775571399547 \
1.321625536570573e-06 0.2568557450124987 1.321625660932803e-06 0.2551103168403305 1.321625776507087e-06 0.2534925198640895 1.321625910614607e-06 0.2516172680784447 \
1.321626025601849e-06 0.2500177396912131 1.321626179351445e-06 0.2478798443778067 1.321626316154646e-06 0.2459790966208961 1.321626450740453e-06 0.2441094379339017 \
1.321626606604589e-06 0.2419575875351012 1.321626731253411e-06 0.2402378086535915 1.321626870468935e-06 0.2383186229544463 1.32162700069296e-06 0.236525770455347 \
1.321627121045801e-06 0.2348769158236033 1.321627256439084e-06 0.233027137746051 1.321627407644063e-06 0.2309620730808924 1.321627542400533e-06 0.2291249940296414 \
1.32162764708672e-06 0.2277003186426776 1.321627769622861e-06 0.2260366668203369 1.32162790456742e-06 0.2242086518061946 1.321627999683167e-06 0.2229209267876512 \
1.321628114943222e-06 0.2213657311907907 1.321628197476202e-06 0.2202562617028589 1.321628268681533e-06 0.2192992955643472 1.321628317389017e-06 0.2186449771734718 \
1.321628364583973e-06 0.2180112263680214 1.321628411132791e-06 0.2173864029843717 1.321628464521355e-06 0.2166701476649976 1.321628501898025e-06 0.2161690444847812 \
1.321628539283138e-06 0.2156680710113931 1.321628579604508e-06 0.2151283464800275 1.321628650854647e-06 0.2141753141901174 1.321628685068904e-06 0.2137180869447317 \
1.321628731463534e-06 0.2131018213873352 1.321628791907201e-06 0.2122998083652294 1.32162886091012e-06 0.2113853596849882 1.321628926205072e-06 0.210520730631805 \
1.321628994183195e-06 0.2096212333552783 1.321629110629525e-06 0.2080823984153433 1.321629200551713e-06 0.2068957989735914 1.32162930821762e-06 0.2054771097790837 \
1.321629404278935e-06 0.2042146625011118 1.321629507657509e-06 0.2028641889872041 1.321629604342544e-06 0.2016026287683381 1.321629707152397e-06 0.2002625524503448 \
1.321629807912368e-06 0.1989526210414513 1.321629919058034e-06 0.1975116692735505 1.321630026097528e-06 0.1961279675313261 1.321630144004064e-06 0.1946083430154048 \
1.321630252114387e-06 0.1932197128021231 1.321630361412988e-06 0.1918224631760269 1.321630482044739e-06 0.1902849927564414 1.321630576945331e-06 0.1890796997295432 \
1.32163070550625e-06 0.18745262875399 1.321630798541038e-06 0.1862801166370808 1.321630900937595e-06 0.1849947785893032 1.321630988904886e-06 0.1838942174288659 \
1.321631087175557e-06 0.182668828510528 1.321631183776179e-06 0.1814691026470878 1.321631270414692e-06 0.1803971466393716 1.321631356823704e-06 0.1793305247657973 \
1.321631452660814e-06 0.1781527189679156 1.321631557387688e-06 0.1768710765218302 1.321631703199975e-06 0.1750963017969037 1.321631819167907e-06 0.1736923427161618 \
1.321631975631711e-06 0.1718092975148396 1.32163208681163e-06 0.1704786474822015 1.321632227061631e-06 0.1688098560703619 1.321632350073035e-06 0.1673544160765056 \
1.321632456564033e-06 0.1661007559767333 1.321632552889491e-06 0.1649724583647661 1.321632650322958e-06 0.1638357962207703 1.321632754176237e-06 0.1626293386330815 \
1.32163284597681e-06 0.1615673458739011 1.321632944364525e-06 0.1604337426303964 1.32163302728317e-06 0.1594828374885931 1.321633122651503e-06 0.1583950132920943 \
1.321633205213852e-06 0.1574587876231885 1.321633307798537e-06 0.1563016192679324 1.321633384076854e-06 0.1554454316211293 1.321633472662479e-06 0.1544557264474612 \
1.321633544831984e-06 0.1536532700165102 1.321633626541473e-06 0.1527486200895024 1.321633700220281e-06 0.1519363404455653 1.321633780440409e-06 0.1510573496788611 \
1.321633852168484e-06 0.1502755532525617 1.321633920425463e-06 0.149534520573691 1.321634018141422e-06 0.1484788062294206 1.321634087591606e-06 0.147731872792437 \
1.321634170343085e-06 0.1468455801890639 1.321634230379995e-06 0.1462052652532956 1.321634300618659e-06 0.1454587420502366 1.321634372046193e-06 0.1447037411390827 \
1.321634452559695e-06 0.1438588888651768 1.321634515822599e-06 0.1431977449412327 1.321634593496578e-06 0.1423892845091393 1.321634682806343e-06 0.141463758692191 \
1.321634752169929e-06 0.1407479403162204 1.321634850118149e-06 0.1397418416088305 1.321634940462669e-06 0.1388188591118084 1.321635026242994e-06 0.1379520826379384 \
1.321635093896779e-06 0.1372719511642241 1.321635160204629e-06 0.1366075914250998 1.321635238824321e-06 0.1358227655030745 1.32163531951923e-06 0.135020537018139 \
1.321635377921894e-06 0.1344419857224206 1.321635438674417e-06 0.1338420332148588 1.321635532580729e-06 0.1329184183639811 1.321635574978232e-06 0.1325029080242558 \
1.321635654222426e-06 0.1317336600863391 1.321635694592585e-06 0.1313430593815061 1.321635784293463e-06 0.130477658168832 1.32163582324155e-06 0.1301029732927899 \
1.321635918857236e-06 0.1291862249441596 1.321635957741065e-06 0.1288146335111444 1.321636050975841e-06 0.1279263274670414 1.32163611931843e-06 0.1272775968534341 \
1.321636171639285e-06 0.1267823325594629 1.321636253739999e-06 0.1260075984242486 1.321636324903378e-06 0.1253406747583812 1.321636402856366e-06 0.1246136378429537 \
1.321636481976102e-06 0.1238779526756392 1.321636560619333e-06 0.1231489004754178 1.321636640654242e-06 0.122409328367501 1.321636702388658e-06 0.1218405706457005 \
1.32163677598364e-06 0.1211645344030958 1.321636859363458e-06 0.120401093559758 1.321636923460189e-06 0.1198161795466899 1.321636992898777e-06 0.119184869057559 \
1.321637065921715e-06 0.1185234239195788 1.321637150796627e-06 0.1177582144838446 1.321637230159478e-06 0.117046673033812 1.321637314893136e-06 0.1162898833629492 \
1.321637405604425e-06 0.1154830714735263 1.321637481187504e-06 0.1148135241260771 1.321637546915428e-06 0.1142333070693714 1.321637606975201e-06 0.1137047561823949 \
1.321637676580917e-06 0.1130943456353956 1.321637742999968e-06 0.1125141752866663 1.321637822411231e-06 0.1118230150855203 1.321637912674161e-06 0.1110406875128299 \
1.321637981718461e-06 0.1104447270551955 1.32163805627358e-06 0.1098035355921305 1.321638144757501e-06 0.1090456469739195 1.321638223865648e-06 0.1083709350695736 \
1.321638293734029e-06 0.1077773127978274 1.321638374743399e-06 0.1070920034756896 1.321638430948213e-06 0.106618206733547 1.321638493607492e-06 0.1060916009495399 \
1.321638558754098e-06 0.105545887371837 1.321638630089726e-06 0.1049504956797945 1.321638750386101e-06 0.1039516085561449 1.321638801939674e-06 0.103525508500865 \
1.321638857088742e-06 0.1030709598036589 1.321638947785926e-06 0.1023262935955709 1.321639030175778e-06 0.1016530765296615 1.321639125755585e-06 0.1008759670630478 \
1.321639232965152e-06 0.1000092507657299 1.321639336624558e-06 0.09917656019160864 1.321639422832161e-06 0.09848810438956324 1.321639509074386e-06 0.09780303991321163 \
1.321639588615461e-06 0.09717448010577609 1.321639668628333e-06 0.09654538840876434 1.321639759916661e-06 0.09583163072761708 1.321639841662079e-06 0.09519620281310773 \
1.321639930588917e-06 0.09450872319168514 1.321640020366224e-06 0.09381864801001834 1.321640097328872e-06 0.09323024625953365 1.321640187653689e-06 0.0925435244861572 \
1.321640251462415e-06 0.09206084550525626 1.321640323925983e-06 0.09151514907748673 1.321640388054635e-06 0.09103438864950099 1.321640466302011e-06 0.09045054736970405 \
1.321640566003292e-06 0.08971110930136832 1.321640640056444e-06 0.08916512281998501 1.321640726664979e-06 0.08852997392441805 1.321640872964685e-06 0.08746544055362569 \
1.321640983676948e-06 0.08666684197409438 1.321641093986626e-06 0.08587717033461532 1.321641236182269e-06 0.08486839672072237 1.32164137623472e-06 0.08388450488753585 \
1.321641518880534e-06 0.08289222299161547 1.321641667651249e-06 0.08186778387581196 1.321641804363935e-06 0.08093569403044946 1.321641946484565e-06 0.07997640434545976 \
1.321642081061545e-06 0.07907728405019222 1.321642221281423e-06 0.07814997945867638 1.321642369028229e-06 0.07718353387841098 1.321642518982415e-06 0.07621348085094087 \
1.321642683698247e-06 0.07516037195605636 1.321642847284363e-06 0.07412732798506308 1.321643021932716e-06 0.07303837372665309 1.321643208986408e-06 0.07188781219077654 \
1.321643418972926e-06 0.0706159374129187 1.321643637046174e-06 0.06931715807027321 1.321643870366327e-06 0.06795188046253516 1.321644124845882e-06 0.0664909822812602 \
1.32164441780254e-06 0.06484528303377844 1.321644719953089e-06 0.06318745987130532 1.321645057674792e-06 0.06138078634948794 1.321645452783393e-06 0.05932807220464856 \
1.321645820234636e-06 0.05747953410674719 1.321646237842402e-06 0.05544691527644593 1.321646582838376e-06 0.0538196438399016 1.321646933380665e-06 0.05221302159193914 \
1.321647248341029e-06 0.0508087490907442 1.321647547582395e-06 0.049508488261462 1.321647846948248e-06 0.04824029756235761 1.321648122190958e-06 0.04710512226277328 \
1.321648405654525e-06 0.04596497870754415 1.321648667254947e-06 0.04493681260994405 1.321648944707071e-06 0.04387103439794762 1.321649220766506e-06 0.04283531238677037 \
1.321649529036243e-06 0.04170718945545093 1.321649751468863e-06 0.0409114719535993 1.321650039009947e-06 0.03990505631995635 1.32165027524288e-06 0.0390969788355163 \
1.321650593704555e-06 0.03803800466874574 1.321650844115589e-06 0.03722710566490722 1.321651167100391e-06 0.03620720400565681 1.321651425436406e-06 0.03541203096995557 \
1.321651715410285e-06 0.03454066075983582 1.321651945205103e-06 0.0338658635512188 1.321652230100444e-06 0.03304787219836024 1.321652469846563e-06 0.03237513696606491 \
1.321652710481132e-06 0.03171392889024889 1.321652949599619e-06 0.03107212555077287 1.32165318553853e-06 0.03045460689686571 1.321653416367391e-06 0.02986254663395104 \
1.321653631393919e-06 0.02932175456294728 1.32165403355976e-06 0.0283374222946415 1.32165423211788e-06 0.02786401170979088 1.321654605819066e-06 0.02699470773596776 \
1.321654792632261e-06 0.02657042318767052 1.321655138633508e-06 0.02580176906824739 1.321655260576946e-06 0.02553595448027303 1.321655643429963e-06 0.02472011952872977 \
1.321655803864149e-06 0.02438657631284594 1.321656246865303e-06 0.02348572425118655 1.321656417479345e-06 0.02314627247835563 1.321656738055941e-06 0.02251902970747987 \
1.321656938340868e-06 0.0221336684630111 1.321657385278801e-06 0.02128811173678137 1.321657513222917e-06 0.02104854104185888 1.321658001100276e-06 0.02014826272243131 \
1.321658136077553e-06 0.01990454278080647 1.321658618329071e-06 0.0190640092473091 1.321658780655186e-06 0.01879235028057063 1.321659267049527e-06 0.01801148170254873 \
1.321659430077186e-06 0.01776103207540622 1.321660110298877e-06 0.01676849304257711 1.321660249382614e-06 0.01657541006259178 1.321660981877148e-06 0.01560782569993242 \
1.32166114077078e-06 0.01540693214221847 1.321661923851867e-06 0.01445869962397344 1.321662069644422e-06 0.01428952172302696 1.321662920425781e-06 0.01334248985256295 \
1.321663031529053e-06 0.01322388191882306 1.321663964823417e-06 0.0122699293983148 1.321664098661466e-06 0.01213902814618388 1.321665057199482e-06 0.01123495036716388 \
1.321665178316551e-06 0.01112486091825863 1.321666300400349e-06 0.01017270671243764 1.321666405901602e-06 0.01008921053061839 1.321667734976014e-06 0.009112307258623473 \
1.321667855180288e-06 0.009029744095492466 1.321669403542048e-06 0.008036808760534916 1.321669484329818e-06 0.007986285493236449 1.321671055209352e-06 0.007024564730313319 \
1.321671122625551e-06 0.006986095570813155 1.321673043392229e-06 0.006001386377072119 1.321673230194113e-06 0.005914747648762168 1.32167554560806e-06 0.0049318160947762 \
1.321675945134908e-06 0.004777795182599986 1.321678508944408e-06 0.003889929704329555 1.321679007815328e-06 0.003736330440833864 1.321682637539317e-06 0.002784984367379526 \
1.321683188233292e-06 0.002663729254427667 1.321688586673671e-06 0.001711392372544448 1.321688899941243e-06 0.001662511220227468 1.321693892233791e-06 0.0006970413096974805 \
1.321694076252826e-06 0.0006571176749162138 1.32434255539561e-06 -0.0002691198397987355 1.324342711454572e-06 -0.0004551674219448388 1.324343259438427e-06 -0.001322174727784445 \
1.32434337237642e-06 -0.001539785040943742 1.32434380163135e-06 -0.002474302920374066 1.324343907888515e-06 -0.002730173903076456 1.324344190690667e-06 -0.003454402452283872 \
1.32434430428521e-06 -0.003760966378165151 1.324344642839789e-06 -0.004705104513819927 1.32434475526375e-06 -0.005021586953003071 1.324345083541651e-06 -0.005887841248467669 \
1.324345191080172e-06 -0.006130875888161453 1.324346071006203e-06 -0.005789627805322099 1.32434624621225e-06 -0.004910736584223327 1.324346363043013e-06 -0.004127745010746014 \
1.324346489910137e-06 -0.00309221842859156 1.324346591442863e-06 -0.002125750314016509 1.324346712864133e-06 -0.0008095618968406578 1.324346803029046e-06 0.0002767910803854594 \
1.324346900212696e-06 0.001550247908954045 1.32434699828696e-06 0.002938803805678211 1.324347165508045e-06 0.005530627736217106 1.324347387813323e-06 0.009378371294171852 \
1.324347573551714e-06 0.01290572951649239 1.324347797633049e-06 0.01747895571448658 1.324347957277782e-06 0.02091945933227325 1.324348121767111e-06 0.02459614091902196 \
1.324348271591569e-06 0.0280452875125503 1.324348420991461e-06 0.03156498790849799 1.324348570522767e-06 0.03515592969144176 1.324348724602661e-06 0.03891669635189081 \
1.324348886786809e-06 0.0429309674228065 1.324349053210035e-06 0.0470989728378523 1.324349229143508e-06 0.05154884981278444 1.324349410271779e-06 0.05616867911875007 \
1.324349602402705e-06 0.06110225049351239 1.324349810098117e-06 0.0664648391313285 1.324350032018198e-06 0.07222051812179281 1.32435026721968e-06 0.07834079218654426 \
1.324350519405989e-06 0.08491829088081257 1.324350795545224e-06 0.09213111703448683 1.324351096666701e-06 0.1000001933597138 1.324351428586562e-06 0.1086702418150647 \
1.32435180590533e-06 0.1185147411083515 1.324352204195387e-06 0.1288888856248832 1.324352673503706e-06 0.1410822143415975 1.324353219529231e-06 0.1552200475789812 \
1.324353854489538e-06 0.1715918832733369 1.324354553890129e-06 0.1895291194622146 1.324355372129055e-06 0.2103807608661494 1.324356277823022e-06 0.2332840710921665 \
1.324357067334088e-06 0.253091928008631 1.324357771092906e-06 0.2706124241987875 1.324358388943719e-06 0.2858796548825839 1.324358954567131e-06 0.2997575097153312 \
1.324359476302405e-06 0.3124620269501652 1.324359974086121e-06 0.3244932238414255 1.324360457724081e-06 0.3360954048923613 1.324360914598215e-06 0.3469667650518959 \
1.324361387439109e-06 0.3581213589834248 1.324361827052466e-06 0.3684065070151987 1.324362314929562e-06 0.379719432411247 1.324362845729985e-06 0.3919028193132517 \
1.324363343625359e-06 0.4032143644097119 1.324363775002613e-06 0.41292177789323 1.324364261889801e-06 0.4237731225600331 1.324364761989243e-06 0.4348012155672935 \
1.324365106609934e-06 0.4423321287141763 1.324365460003778e-06 0.4500000647748709 1.324365887773617e-06 0.4592134948422093 1.324366279634688e-06 0.4675816212925634 \
1.324366579929044e-06 0.4739471552041949 1.324366921860125e-06 0.4811428413521782 1.32436726519457e-06 0.4883132334011818 1.324367525955058e-06 0.4937215836208605 \
1.324367768011588e-06 0.4987106167174703 1.324368034010056e-06 0.5041617362307154 1.324368293498239e-06 0.5094435946950286 1.32436848341454e-06 0.5132872703533161 \
1.324368698649141e-06 0.5176241792560061 1.3243688371999e-06 0.5204025546691405 1.324368982080679e-06 0.5232962183003332 1.324369195494746e-06 0.5275364624051522 \
1.32436939751936e-06 0.5315382148201082 1.324369590248024e-06 0.5353370730264509 1.324369775503404e-06 0.5389735557287745 1.324369952500928e-06 0.5424323215059959 \
1.324370261764263e-06 0.5484573594957171 1.324370522912311e-06 0.5535233414883098 1.324370824731481e-06 0.5593562770234363 1.324371080160122e-06 0.5642781701956761 \
1.324371372515619e-06 0.5698968483756405 1.324371631969813e-06 0.5748654731717864 1.32437190208979e-06 0.5800301911327002 1.324372144100348e-06 0.5846380733684551 \
1.324372401610146e-06 0.5895273573494454 1.324372628054483e-06 0.5938057549890672 1.324372864942966e-06 0.5982619499065401 1.324373074987873e-06 0.6021962733001386 \
1.324373287918585e-06 0.6061670177072124 1.324373541397282e-06 0.6108668889270118 1.324373744692931e-06 0.6146150465592417 1.324373936381114e-06 0.6181346807088086 \
1.324374125007478e-06 0.6215812235468744 1.324374312325416e-06 0.6249823889551316 1.324374517937406e-06 0.6286953279350977 1.324374767760625e-06 0.6331759959753138 \
1.324374971572403e-06 0.6368063379741715 1.324375179211121e-06 0.6404826298163093 1.324375371862737e-06 0.6438748386876914 1.32437561647481e-06 0.6481531432733096 \
1.324375864373314e-06 0.6524620620600715 1.324376044208219e-06 0.6555644139995785 1.324376234982255e-06 0.6588391718544121 1.324376388158437e-06 0.6614554104590837 \
1.324376559827147e-06 0.6643705886591137 1.324376710293968e-06 0.6669108747194671 1.324376846897971e-06 0.6692010654183506 1.324376996338372e-06 0.6716954191563786 \
1.324377124072523e-06 0.6738189269502312 1.32437726394477e-06 0.6761323074508511 1.324377388021905e-06 0.6781756764962316 1.32437751938327e-06 0.6803315871556701 \
1.324377643554731e-06 0.6823627547057004 1.324377781331592e-06 0.6846081866267727 1.324377901575812e-06 0.6865586181592046 1.324378043628417e-06 0.6888545186016138 \
1.324378143856122e-06 0.6904668682779994 1.324378265160113e-06 0.6924123325129877 1.324378356135388e-06 0.6938641504265992 1.324378453518671e-06 0.695411869780077 \
1.324378550601538e-06 0.6969507228893711 1.324378639884158e-06 0.6983595753378042 1.324378737855943e-06 0.699898781449533 1.32437886813103e-06 0.7019319515314388 \
1.324379021543255e-06 0.7043083163565919 1.324379157109067e-06 0.7063909659299702 1.324379301449562e-06 0.708591461371511 1.324379427320445e-06 0.710496752775434 \
1.324379552347831e-06 0.712376488910674 1.324379666630191e-06 0.7140841686551523 1.324379777613335e-06 0.7157331888171029 1.324379877308405e-06 0.7172065512867005 \
1.324380014352622e-06 0.7192196995505324 1.324380133379835e-06 0.7209572005600779 1.324380253677943e-06 0.7227029412191364 1.324380380176863e-06 0.7245276185835638 \
1.324380504108467e-06 0.7263044524160376 1.3243806283948e-06 0.7280754330070212 1.324380754759953e-06 0.7298652243312684 1.324380884571695e-06 0.7316925631262517 \
1.324381008410214e-06 0.7334254795816325 1.3243811411911e-06 0.735272086289578 1.324381242042306e-06 0.7366670415914529 1.324381355233975e-06 0.738224777043618 \
1.324381442019956e-06 0.7394137384482823 1.324381558645253e-06 0.7410021813026957 1.32438164793451e-06 0.7422110784210975 1.324381759111394e-06 0.7437075443329063 \
1.324381888370158e-06 0.7454347509364776 1.324382002229194e-06 0.7469455276109591 1.324382106633406e-06 0.74832188588007 1.324382231000437e-06 0.7499498655229884 \
1.324382378240616e-06 0.7518616907275563 1.324382498520907e-06 0.753411006437983 1.324382614425446e-06 0.7548933175676444 1.32438275450129e-06 0.7566706674475765 \
1.32438289711296e-06 0.7584645678799224 1.324383015067203e-06 0.7599365027959469 1.324383141883712e-06 0.7615071445339606 1.324383282766856e-06 0.7632375905494565 \
1.324383402560354e-06 0.7646969139886852 1.324383547519211e-06 0.7664484133613445 1.324383669077996e-06 0.7679052725436226 1.32438378811749e-06 0.7693214142140735 \
1.324383909748853e-06 0.7707575700077021 1.324384037717832e-06 0.772256936813787 1.324384146933014e-06 0.7735272422640712 1.324384271823892e-06 0.774969549136603 \
1.324384378939953e-06 0.7761978171588899 1.324384512193147e-06 0.7777146071439789 1.324384639296593e-06 0.7791497354387434 1.324384761047568e-06 0.7805132846941326 \
1.324384877632151e-06 0.7818078758210534 1.324384983459753e-06 0.7829735233300771 1.324385122825895e-06 0.7844949153190801 1.324385271897694e-06 0.786105286864636 \
1.324385419626362e-06 0.7876841235632186 1.32438553893224e-06 0.7889471147195867 1.324385672939052e-06 0.7903527806482344 1.324385793365227e-06 0.791604423795974 \
1.324385934910404e-06 0.7930616786923709 1.324386082336417e-06 0.7945638089648995 1.324386206810925e-06 0.7958198087139573 1.324386325854918e-06 0.7970105506108808 \
1.324386437445202e-06 0.7981174590942314 1.324386542674491e-06 0.7991530841216606 1.324386638185594e-06 0.8000862307887144 1.324386774247548e-06 0.8014036057482816 \
1.324386891123682e-06 0.8025237700417888 1.324387010277354e-06 0.8036549841722296 1.324387132589548e-06 0.8048050501807249 1.324387255861622e-06 0.8059526272620129 \
1.324387382358398e-06 0.8071184350969989 1.324387507861062e-06 0.8082633544790385 1.324387638586967e-06 0.8094437311890262 1.324387764154939e-06 0.8105658358439867 \
1.324387893209803e-06 0.8117072367686948 1.324387999065961e-06 0.8126345588578442 1.324388100234837e-06 0.8135133322873783 1.324388194854657e-06 0.8143286754242188 \
1.32438831913574e-06 0.8153900871385379 1.324388408847426e-06 0.816149614585347 1.32438850788495e-06 0.8169816577628611 1.324388645662827e-06 0.8181280288377792 \
1.324388780198677e-06 0.81923501721715 1.324388888604944e-06 0.8201180631035904 1.324389038518447e-06 0.8213254631869725 1.324389189097026e-06 0.8225223201378843 \
1.32438931459218e-06 0.8235077122548546 1.324389458438707e-06 0.8246238332260477 1.324389583021971e-06 0.8255790649890803 1.324389731875191e-06 0.8267066458678887 \
1.324389868023775e-06 0.827725029289517 1.324389993047602e-06 0.8286494160599757 1.324390110754582e-06 0.8295103773055483 1.32439025639358e-06 0.8305630309532103 \
1.324390422774875e-06 0.8317484146982921 1.324390553358565e-06 0.8326660250626342 1.324390726880675e-06 0.8338683097812621 1.324390895002578e-06 0.8350147136930499 \
1.32439106486518e-06 0.8361549927788252 1.324391245766883e-06 0.8373497079260466 1.324391388876165e-06 0.8382806519784776 1.324391502965127e-06 0.839013953006387 \
1.324391633127604e-06 0.8398410866028793 1.324391734972734e-06 0.8404811280669765 1.32439185179894e-06 0.8412075886390841 1.32439198869038e-06 0.8420483852080155 \
1.324392186497604e-06 0.843243620449199 1.324392378122751e-06 0.8443797466267589 1.324392587554618e-06 0.8455974227529048 1.3243927695013e-06 0.8466352798309468 \
1.324392966630154e-06 0.8477391449715804 1.324393139971014e-06 0.8486924050423899 1.324393322979321e-06 0.8496814535024207 1.324393494142356e-06 0.8505903669473519 \
1.324393668779451e-06 0.851501688465695 1.324393844039281e-06 0.8524001683007644 1.32439402018973e-06 0.8532872510191711 1.32439421047003e-06 0.8542278331088334 \
1.32439440106916e-06 0.8551519386507073 1.324394601692395e-06 0.8561055033533737 1.32439479430095e-06 0.8570028516027762 1.324395004981641e-06 0.8579644845832216 \
1.324395233083109e-06 0.8589827023971403 1.324395498871092e-06 0.860139640227508 1.324395797483852e-06 0.8614018215255795 1.324396073772491e-06 0.8625348754565382 \
1.32439635800901e-06 0.8636666213345715 1.32439663221378e-06 0.8647267940813509 1.324396904448638e-06 0.8657495569722869 1.32439717465278e-06 0.8667361702337206 \
1.324397431808391e-06 0.867649441901348 1.324397704388604e-06 0.8685908808535525 1.32439798037489e-06 0.8695169452638583 1.324398250477721e-06 0.870397355937691 \
1.324398550334798e-06 0.8713451925332844 1.324398921362456e-06 0.8724761722512941 1.324399216299767e-06 0.8733433185969293 1.324399470589206e-06 0.8740690226522811 \
1.324399768845991e-06 0.874895168896023 1.324400042455427e-06 0.8756299040683481 1.324400278583914e-06 0.8762466977562872 1.324400518929827e-06 0.8768585021646264 \
1.324400741263492e-06 0.8774104263690854 1.324400935269169e-06 0.8778812671168952 1.324401264991885e-06 0.8786590883967833 1.324401420165319e-06 0.8790156160651978 \
1.324401737941389e-06 0.8797272612331356 1.324401916803032e-06 0.8801171459162566 1.324402259264861e-06 0.8808425821290963 1.324402443393021e-06 0.881221400612852 \
1.324402918270754e-06 0.8821634994206867 1.324403085666965e-06 0.8824839765989225 1.324403551508905e-06 0.8833452998114757 1.324403732330958e-06 0.8836679564577563 \
1.324404226369383e-06 0.8845176198113115 1.324404367718007e-06 0.8847523712107549 1.324404974052073e-06 0.8857188576377059 1.324405126121396e-06 0.8859512996759633 \
1.324405772809558e-06 0.8868983431897121 1.32440590110417e-06 0.8870786909355212 1.324406549221232e-06 0.8879538337624689 1.324406679020295e-06 0.8881220828502663 \
1.324407457223772e-06 0.8890807033877333 1.324407572278734e-06 0.8892148977954012 1.324408427940207e-06 0.8901543051721961 1.324408573301076e-06 0.8903040038307473 \
1.324409559057127e-06 0.8912446482480114 1.324409780162496e-06 0.8914382978987679 1.324410925289423e-06 0.8923659558950503 1.324411056506439e-06 0.8924678262926897 \
1.324412397715013e-06 0.8934599079028542 1.324412549114272e-06 0.8935646301988298 1.324414030551995e-06 0.8944937559627255 1.324414269431373e-06 0.8946275407274444 \
1.324416038746979e-06 0.8955013787854181 1.324416427898191e-06 0.8956696032899972 1.324418821561142e-06 0.8965547188539188 1.32441929727014e-06 0.8967039926079825 \
1.32442336043021e-06 0.8977020505850396 1.324423851854269e-06 0.8977948037134476 1.324432168453822e-06 0.898787348739254 1.32443308835295e-06 0.8988506593152591 \
1.32457657358348e-06 0.8998476076348748 1.324577692016456e-06 0.8998537475785264 1.324782783635956e-06 0.898985773748599 1.324783010725457e-06 0.8988224379910277 \
1.324784620332255e-06 0.8978282360369357 1.324784797740799e-06 0.8977338482811539 1.3248017048891e-06 0.8987315468430059 1.324801814328198e-06 0.8987460089186867 \
1.324817595049444e-06 0.8997418097871094 1.324817891375339e-06 0.8997476966799167 1.325301325027745e-06 0.9007060148833608 1.325301454078085e-06 0.9008313386292994 \
1.32530210422793e-06 0.9016292186224167 1.325302293723661e-06 0.9019133038041363 1.32530279694564e-06 0.9027675859898705 1.325302932418299e-06 0.9030208676018907 \
1.325303332877016e-06 0.9038195223753869 1.325303464814953e-06 0.9040958310886574 1.325303866030017e-06 0.9049509627747726 1.325303964290194e-06 0.9051582028152527 \
1.325304430164004e-06 0.9060587574877488 1.325304591662727e-06 0.9063060456044927 1.32530573567525e-06 0.9055153668657776 1.325305880654596e-06 0.9049059606760256 \
1.325306059207354e-06 0.9039396653125833 1.325306239402631e-06 0.9027054491383806 1.325306382093561e-06 0.9015369228101149 1.325306499253165e-06 0.9004524619440171 \
1.325306588234525e-06 0.8995505656965809 1.325306679878178e-06 0.8985529714258781 1.32530681299011e-06 0.8969831049011855 1.325306906711193e-06 0.8957895978311226 \
1.325306997850002e-06 0.8945634483845346 1.325307111142313e-06 0.8929516940777753 1.325307214251226e-06 0.8913998138690341 1.325307310518406e-06 0.8898830246517148 \
1.325307429655523e-06 0.8879200664089764 1.325307598240772e-06 0.8849885378698126 1.325307760012273e-06 0.8820195265790133 1.325307953231332e-06 0.8782956415026882 \
1.325308138794443e-06 0.8745571577041361 1.325308349060748e-06 0.8701566079887386 1.325308531309789e-06 0.8662213066841463 1.325308716173183e-06 0.8621339172744639 \
1.32530888885833e-06 0.8582419637438897 1.325309074966403e-06 0.8539816046497358 1.325309252782491e-06 0.849858603441091 1.325309433499072e-06 0.8456251963850057 \
1.325309598637331e-06 0.8417258760277182 1.325309763911433e-06 0.837798995916667 1.325309927159096e-06 0.8339004324287677 1.32531008574937e-06 0.8300982805770993 \
1.325310262673771e-06 0.8258418712800655 1.325310459187584e-06 0.8211009660847696 1.325310626744125e-06 0.8170498602679914 1.325310793484544e-06 0.8130123908857781 \
1.325310967908062e-06 0.8087844286215062 1.325311137277684e-06 0.8046757316210446 1.325311305476779e-06 0.8005936994537799 1.325311494325046e-06 0.7960093488074458 \
1.325311685140882e-06 0.7913773844868103 1.325311893523092e-06 0.7863203192056716 1.325312119942597e-06 0.7808277108969495 1.325312309142794e-06 0.7762391340290878 \
1.325312519289483e-06 0.7711455503222944 1.325312668057987e-06 0.7675418410361046 1.325312799050976e-06 0.7643705172588006 1.325312936616212e-06 0.7610417440783073 \
1.325313042367441e-06 0.7584842184275663 1.325313177141075e-06 0.7552262509102785 1.3253132889738e-06 0.7525244432456109 1.325313418408964e-06 0.7493992292091655 \
1.325313573597688e-06 0.7456545577979357 1.325313685233441e-06 0.7429626190147979 1.325313844808055e-06 0.7391166470929011 1.325314020129688e-06 0.7348935218456193 \
1.325314232505151e-06 0.7297828120356423 1.325314425387679e-06 0.7251458607116523 1.325314582088971e-06 0.7213823872711312 1.325314768763662e-06 0.716903961299824 \
1.325314957650011e-06 0.7123775767926828 1.325315148534203e-06 0.70780884692282 1.325315335282138e-06 0.7033444557767304 1.325315518366954e-06 0.698972331957095 \
1.325315655685935e-06 0.6956951921588121 1.325315808928892e-06 0.6920418367118417 1.325316004057543e-06 0.6873949992893974 1.325316161351872e-06 0.6836535194673684 \
1.325316320746467e-06 0.6798660670227984 1.32531651649026e-06 0.6752219404489795 1.325316708689394e-06 0.6706682621108646 1.325316943641022e-06 0.6651105611269369 \
1.32531713111727e-06 0.6606839627962382 1.325317368354404e-06 0.6550894036851447 1.325317557534366e-06 0.6506361170423679 1.325317738150179e-06 0.6463915264929231 \
1.325317901844741e-06 0.6425504277539856 1.32531804639615e-06 0.6391628119244788 1.32531818686792e-06 0.6358764726647652 1.325318313968707e-06 0.6329064225879303 \
1.325318446276184e-06 0.6298198307262635 1.32531857286323e-06 0.626870110582017 1.325318703443498e-06 0.62383130535404 1.325318832712897e-06 0.6208285625908692 \
1.325318971819793e-06 0.6176004736356133 1.325319120330103e-06 0.6141606483517721 1.325319309878658e-06 0.6097777958748198 1.325319455581914e-06 0.6064170107178907 \
1.325319690632478e-06 0.601007464699683 1.325319873631749e-06 0.5968099615921 1.325320097973423e-06 0.5916778694808832 1.325320269146672e-06 0.5877753019413697 \
1.325320401480491e-06 0.5847634284691802 1.32532053327703e-06 0.5817721407249107 1.325320639820933e-06 0.5793579518205488 1.325320735711292e-06 0.5771868999037388 \
1.325320828211542e-06 0.5750974572268882 1.325320920638905e-06 0.5730134868920421 1.325320993067211e-06 0.5713818265150021 1.325321048796317e-06 0.5701269325864891 \
1.325321109905405e-06 0.5687522410723198 1.32532120667008e-06 0.5665806864277688 1.325321268161595e-06 0.5652027770813386 1.325321327214216e-06 0.5638802801505602 \
1.325321402840882e-06 0.5621878686488651 1.32532146986366e-06 0.5606896577364279 1.32532154346077e-06 0.5590483558003441 1.325321611066772e-06 0.5575429304381756 \
1.325321727135829e-06 0.5549610936632026 1.325321827342234e-06 0.5527359403974305 1.325321939349424e-06 0.5502565947066531 1.325322033841475e-06 0.5481686943853854 \
1.325322154996173e-06 0.5454955387196141 1.325322255183939e-06 0.5432910220514219 1.325322371174451e-06 0.5407443765731218 1.325322478878289e-06 0.5383833065966291 \
1.325322588456977e-06 0.5359861028148916 1.325322700578421e-06 0.5335400310751951 1.325322827515605e-06 0.5307765704644959 1.325322949665123e-06 0.5281221248815906 \
1.325323089426038e-06 0.525095489155881 1.325323226564154e-06 0.522132778766487 1.325323376529244e-06 0.5189020692106626 1.325323535302247e-06 0.5154923220538846 \
1.325323709327904e-06 0.511765695450105 1.325323896158028e-06 0.5077823379664483 1.325324101125994e-06 0.5034264211640872 1.325324323834942e-06 0.4987133299464507 \
1.325324576739139e-06 0.4933874474923696 1.325324811693046e-06 0.4884604410272814 1.325325107961308e-06 0.4822828691822955 1.325325397751266e-06 0.4762763831984252 \
1.325325704087085e-06 0.4699660956099861 1.325326016405612e-06 0.4635767846525711 1.325326354971068e-06 0.4566963260653934 1.325326678082485e-06 0.4501741115777416 \
1.325327016477788e-06 0.4433881855507311 1.325327340309053e-06 0.4369378830387565 1.325327664703474e-06 0.4305204627449936 1.32532800763776e-06 0.4237851826852676 \
1.325328346918578e-06 0.4171698123421442 1.325328686393212e-06 0.4105997181257849 1.325329129505058e-06 0.4020958655332711 1.325329491573227e-06 0.3952155038183801 \
1.325329812124964e-06 0.3891775711374149 1.325330199059534e-06 0.3819561902961204 1.325330526929795e-06 0.3758957719299574 1.325330812088851e-06 0.3706704968427373 \
1.325331130457646e-06 0.3648820026298218 1.325331413288573e-06 0.3597820188690578 1.325331641977337e-06 0.3556924369094372 1.325331859870142e-06 0.3518226517641353 \
1.325332055119486e-06 0.3483769517668343 1.325332262027586e-06 0.344751588202948 1.325332476824342e-06 0.3410137651016431 1.325332729050892e-06 0.3366564674340092 \
1.325332971046205e-06 0.3325077909124976 1.325333201898484e-06 0.3285822460490526 1.325333416746675e-06 0.3249550452085373 1.325333637103364e-06 0.3212604562488142 \
1.325333838674264e-06 0.3179050685021769 1.32533404175821e-06 0.3145531374773136 1.325334239655597e-06 0.3113121771742085 1.325334426754836e-06 0.3082694484595072 \
1.325334620655179e-06 0.3051385396431291 1.325334825703514e-06 0.3018527636900292 1.325335005938266e-06 0.2989872106339772 1.325335241836277e-06 0.2952669081535775 \
1.325335443123828e-06 0.2921198200609627 1.325335644514631e-06 0.2889965001417216 1.325335869163794e-06 0.2855437159941698 1.325336034543768e-06 0.2830223598911593 \
1.325336212348105e-06 0.280330186126118 1.325336396004319e-06 0.277570343839212 1.325336581246076e-06 0.2748090658167894 1.325336759391454e-06 0.2721781298892599 \
1.325336932983517e-06 0.2696316866093095 1.32533709334837e-06 0.267306655456324 1.325337214459553e-06 0.2655585721882695 1.325337367654341e-06 0.2633570345323199 \
1.325337494985789e-06 0.2615475749425888 1.325337598313628e-06 0.2600830587034867 1.325337715638424e-06 0.2584225376281647 1.325337833445381e-06 0.2567591557214636 \
1.325337957409147e-06 0.2550199666844239 1.325338074393314e-06 0.2533821414201824 1.325338205189442e-06 0.2515535495016885 1.325338322399552e-06 0.2499173892700276 \
1.325338475652677e-06 0.2477853623028658 1.325338611183197e-06 0.2459029165157107 1.325338742864406e-06 0.244074199323236 1.325338899457317e-06 0.2419017673596028 \
1.325339024653875e-06 0.2401755227310949 1.325339160371501e-06 0.2383060149301216 1.325339292798663e-06 0.2364844144139329 1.325339412772324e-06 0.2348355337769661 \
1.325339575820161e-06 0.232606585912384 1.325339714627252e-06 0.230713852557009 1.325339853100972e-06 0.2288300961780371 1.325339958645721e-06 0.2273962817971701 \
1.325340087007401e-06 0.2256537837490921 1.325340191135024e-06 0.2242444877898851 1.325340291651026e-06 0.222886569499566 1.325340366695402e-06 0.2218745444235658 \
1.325340444028458e-06 0.2208349692306942 1.325340518791637e-06 0.2198305887827458 1.325340596755314e-06 0.218785487158918 1.325340651621824e-06 0.2180503923904892 \
1.3253407081186e-06 0.2172938400168352 1.325340751572119e-06 0.2167123195211523 1.325340791613165e-06 0.2161767335077376 1.325340830852113e-06 0.2156521099473339 \
1.32534087172635e-06 0.2151058606261434 1.32534092587884e-06 0.2143825797409383 1.325340964295972e-06 0.2138698309421548 1.325341003584678e-06 0.2133480458229882 \
1.325341065121386e-06 0.2125332203444249 1.325341127098915e-06 0.2117131287842428 1.325341183575664e-06 0.2109664019951111 1.325341248207255e-06 0.2101124842966758 \
1.325341343715876e-06 0.2088522205996687 1.325341431031607e-06 0.207701294711168 1.325341527641208e-06 0.2064291756790013 1.325341624870762e-06 0.2051510266126755 \
1.325341725717823e-06 0.2038307158897115 1.325341826317594e-06 0.2025192706911573 1.325341922808891e-06 0.2012627769767186 1.325342024991065e-06 0.1999338657614989 \
1.325342128630721e-06 0.1985898465970496 1.325342238404734e-06 0.1971698847140261 1.32534234757976e-06 0.1957617939809042 1.325342467677852e-06 0.1942174441246506 \
1.325342577697376e-06 0.1928086337505992 1.325342685809285e-06 0.1914295694688549 1.325342808837984e-06 0.1898652723262108 1.325342898948554e-06 0.1887234630454603 \
1.325343006314044e-06 0.1873671680421656 1.325343083125353e-06 0.1864004060894758 1.325343166570621e-06 0.1853535952511875 1.325343256102432e-06 0.1842338297700716 \
1.325343340667899e-06 0.1831790839553313 1.325343420384039e-06 0.1821880912968773 1.325343521709242e-06 0.1809331989518758 1.325343630056471e-06 0.1795959386230563 \
1.325343726532169e-06 0.1784102562612937 1.325343851909986e-06 0.1768766438339704 1.325343984693456e-06 0.1752616821119887 1.325344102464279e-06 0.1738362801839788 \
1.325344248115856e-06 0.1720835746408261 1.325344358713008e-06 0.1707596463148658 1.325344500843447e-06 0.1690680578777541 1.32534461655307e-06 0.1676985735146403 \
1.325344722027083e-06 0.166456424915798 1.325344816543742e-06 0.1653485352650968 1.325344912181115e-06 0.1642320043563913 1.325345009252958e-06 0.1631032360400927 \
1.325345108304212e-06 0.161956192050434 1.325345202227769e-06 0.1608730077890209 1.325345287503444e-06 0.1598934595213354 1.325345387883236e-06 0.1587475631033795 \
1.325345472186073e-06 0.1577906478848196 1.325345574585582e-06 0.1566342854655733 1.325345651979844e-06 0.1557646215197878 1.325345744324758e-06 0.154731814591042 \
1.32534581457623e-06 0.1539498814072817 1.325345910750659e-06 0.1528844393027091 1.325345987575322e-06 0.152038051282755 1.325346066345474e-06 0.1511758489440315 \
1.325346140238395e-06 0.150370438825067 1.325346207936138e-06 0.1496353997608715 1.325346304000026e-06 0.1485973848112393 1.325346373572453e-06 0.1478489919002561 \
1.325346457461625e-06 0.1469503328160803 1.325346518593461e-06 0.146298213254472 1.325346590861543e-06 0.1455309799806117 1.325346663300106e-06 0.1447677488542132 \
1.325346744281147e-06 0.1439178685120187 1.325346810355616e-06 0.1432275520600639 1.325346887756114e-06 0.1424219220725307 1.325346977131571e-06 0.1414956876531561 \
1.325347047992216e-06 0.1407644282175171 1.325347146879283e-06 0.1397487730030469 1.325347224198192e-06 0.1389620820751095 1.325347306243418e-06 0.1381330876879582 \
1.32534739435453e-06 0.1372467208126059 1.325347461981677e-06 0.1365690714953818 1.325347542278859e-06 0.1357674830239305 1.325347617062888e-06 0.1350239185327315 \
1.325347685064065e-06 0.1343502586094245 1.325347731746974e-06 0.1338891847862563 1.325347820998567e-06 0.1330118383700247 1.325347859221617e-06 0.1326395291833771 \
1.325347928213527e-06 0.1319690872918072 1.325347980961596e-06 0.1314578750898332 1.325348063954378e-06 0.1306559489775353 1.325348104132829e-06 0.1302688434457458 \
1.325348196650203e-06 0.1293805059784019 1.32534823536857e-06 0.1290098403727171 1.325348309129285e-06 0.1283055160094505 1.325348370757287e-06 0.1277188748199021 \
1.325348442784976e-06 0.1270353589407805 1.325348510952008e-06 0.1263909833196726 1.325348585574169e-06 0.1256908956540175 1.325348667426635e-06 0.1249253613889138 \
1.325348750880797e-06 0.124147338931438 1.325348823832511e-06 0.1234692772477456 1.325348896559441e-06 0.122795332839617 1.325348956549436e-06 0.1222410931008323 \
1.325349042917447e-06 0.121445549533078 1.325349103886165e-06 0.1208856452315438 1.325349162271955e-06 0.1203507897957366 1.32534922790662e-06 0.119751336354628 \
1.325349287260861e-06 0.1192111367930785 1.325349355292642e-06 0.1185941868697126 1.325349452587012e-06 0.11771710490035 1.325349531078992e-06 0.1170124163111649 \
1.325349621315123e-06 0.1162055395685231 1.325349717161808e-06 0.1153523005684616 1.325349792119505e-06 0.1146878351828532 1.325349896478921e-06 0.1137670532163148 \
1.325349983267518e-06 0.1130053589403202 1.325350092924934e-06 0.1120476726212376 1.325350174478997e-06 0.1113387926087848 1.325350270092629e-06 0.1105114393564785 \
1.325350346804822e-06 0.10985058581598 1.325350441723287e-06 0.1090364400125625 1.325350517546392e-06 0.1083889268999046 1.325350595246049e-06 0.1077282965354292 \
1.3253506775775e-06 0.1070311517075373 1.325350737142764e-06 0.1065286079538068 1.325350800900501e-06 0.1059924133642201 1.325350861995109e-06 0.1054803128126646 \
1.325350957858847e-06 0.1046801683739134 1.325351002721942e-06 0.1043071445723913 1.325351085962687e-06 0.1036173314376927 1.325351135082509e-06 0.1032117000904133 \
1.325351244131271e-06 0.1023149933518279 1.325351288967354e-06 0.1019479364619093 1.325351379228585e-06 0.1012117400678687 1.325351420105203e-06 0.1008795969612472 \
1.325351490563617e-06 0.1003088525914566 1.325351576851038e-06 0.09961307626065434 1.325351668628597e-06 0.09887705578174606 1.32535173815669e-06 0.09832225024344161 \
1.325351816683849e-06 0.09769854072774181 1.325351907412525e-06 0.09698178745350861 1.325351983228664e-06 0.09638605854785212 1.325352065241407e-06 0.09574500473888557 \
1.325352146994443e-06 0.09510943278387665 1.325352237502267e-06 0.09440967388330095 1.325352327061564e-06 0.09372126988887708 1.325352412671398e-06 0.09306698857649189 \
1.325352505450896e-06 0.09236212353634379 1.325352586338857e-06 0.0917510971760913 1.325352687467827e-06 0.09099177263830999 1.325352767961352e-06 0.09039108594384238 \
1.325352852204218e-06 0.08976589684797046 1.325352926049265e-06 0.08922077348043934 1.325353002898743e-06 0.08865632925481931 1.325353091039112e-06 0.08801255002475737 \
1.325353171103481e-06 0.08743108261130086 1.325353264139672e-06 0.08675939571108145 1.325353382140385e-06 0.08591369538214398 1.325353524513612e-06 0.08490278100234279 \
1.325353668761962e-06 0.08388867104764453 1.325353811089671e-06 0.08289807427203813 1.325353960667415e-06 0.08186746790234835 1.325354096981161e-06 0.08093761126893445 \
1.325354239101592e-06 0.0799778356000513 1.32535437365502e-06 0.07907840240745091 1.32535451400773e-06 0.07814980287393705 1.325354661689802e-06 0.0771833418413561 \
1.325354811805299e-06 0.07621180464723754 1.325354976525776e-06 0.07515824360926991 1.325355140155128e-06 0.07412455432658185 1.325355314933688e-06 0.07303438636984133 \
1.325355502186304e-06 0.07188220095900363 1.325355712231308e-06 0.07060976590783831 1.325355930441531e-06 0.06930979572898451 1.32535616389862e-06 0.06794333957253913 \
1.325356418744638e-06 0.06648001693367038 1.325356711839195e-06 0.06483321328442151 1.325357014178957e-06 0.06317411115207273 1.325357328765833e-06 0.06148945259513613 \
1.325357725026527e-06 0.05942677493938087 1.325358058743672e-06 0.05774249301432461 1.325358466054501e-06 0.05574994498853819 1.32535879393926e-06 0.05419380357502902 \
1.325359150629899e-06 0.05254809000207299 1.32535946386806e-06 0.05114243792209583 1.325359766835193e-06 0.04981740498512215 1.325360064375718e-06 0.04854875663330436 \
1.325360343155274e-06 0.04739109061078805 1.325360626155169e-06 0.04624570307560639 1.325360887895477e-06 0.04521055793698023 1.32536116713437e-06 0.04413130357485813 \
1.32536143924029e-06 0.0431040186124033 1.325361746607047e-06 0.04197194005652995 1.325361968409948e-06 0.04117329707315532 1.325362274870428e-06 0.04009446155587663 \
1.325362501059881e-06 0.03931650950691581 1.325362739977206e-06 0.03851359500741255 1.325362964401039e-06 0.03777663690506906 1.32536316666332e-06 0.03712468825868943 \
1.325363367705949e-06 0.03648814235703791 1.325363719479983e-06 0.03540095449820539 1.325363969725821e-06 0.03464776841732944 1.325364216044101e-06 0.03392252499723709 \
1.325364497376965e-06 0.03311308780599518 1.32536474046795e-06 0.03242954897046491 1.325364975941701e-06 0.03178112583711486 1.325365217601206e-06 0.03113119522156456 \
1.325365454483484e-06 0.03050988948014832 1.325365685016041e-06 0.02991733361391674 1.325365898984568e-06 0.02937801894285819 1.325366104927116e-06 0.02886851641492237 \
1.325366497651603e-06 0.02792196059063811 1.325366685729283e-06 0.02747992420741849 1.325367061168249e-06 0.02661861215736662 1.325367236042477e-06 0.02622659266649364 \
1.325367659365491e-06 0.02530049759795254 1.325367780614875e-06 0.02504150687334681 1.325368221176528e-06 0.02412433837770948 1.325368363674648e-06 0.02383402682615681 \
1.325368695728157e-06 0.02316883068419595 1.325368878693682e-06 0.02280879143785283 1.325369267997886e-06 0.02205689891561978 1.325369436343594e-06 0.02173705378531499 \
1.325369908457993e-06 0.02085107653961301 1.325370048202727e-06 0.0205916297664938 1.325370543782805e-06 0.01969297428531048 1.325370671008237e-06 0.01946923320191776 \
1.325371238917342e-06 0.01851512288677271 1.32537140317129e-06 0.0182513999453204 1.325372013043028e-06 0.0173209960017622 1.325372172728257e-06 0.01708922829277545 \
1.325372699639798e-06 0.01635462467776483 1.325372904157091e-06 0.01608193551804103 1.325373627634478e-06 0.01515939662837778 1.32537379307661e-06 0.01495683325581705 \
1.325374539636356e-06 0.01408081084911163 1.325374672939569e-06 0.01393008075245666 1.325375533124155e-06 0.01299799962960837 1.32537566920557e-06 0.01285670227674402 \
1.325376609799459e-06 0.01192267652923807 1.325376773572533e-06 0.01176632439256516 1.325377774751464e-06 0.01084959205883911 1.325377912229187e-06 0.01072929995296418 \
1.325379082926798e-06 0.009787962024485789 1.325379175323166e-06 0.009718668544398181 1.325380593399014e-06 0.008725931027897449 1.325380680375162e-06 0.00866912727384293 \
1.325382221370793e-06 0.00770199130002063 1.325382330686807e-06 0.007633428668288294 1.325383973934629e-06 0.006673746291950173 1.325384106791908e-06 0.006603544020797993 \
1.325386201172206e-06 0.005605323336654431 1.325386409576941e-06 0.00551468736035817 1.325388763913366e-06 0.004577307911602986 1.325389237472123e-06 0.004407121484391641 \
1.325392122908979e-06 0.003492041675788492 1.325392652573326e-06 0.00334538389506189 1.325396860800552e-06 0.00237996320858989 1.325397374234803e-06 0.002283557532494709 \
1.325403133485495e-06 0.001325291758975802 1.325403368066713e-06 0.001279502680325907 1.325418035894088e-06 0.0002809017338477542 1.32541814896418e-06 0.0002788534805396912 \
1.32805516904393e-06 -0.0006849217749926401 1.328055335205606e-06 -0.0009443270389602415 1.328055814074993e-06 -0.001850320037528519 1.32805590679462e-06 -0.002050462221988249 \
1.328056272019697e-06 -0.002913187630468476 1.328056363676814e-06 -0.00314709230904735 1.328056729783165e-06 -0.004133001189868674 1.328056839930291e-06 -0.004442309109773816 \
1.328057150668543e-06 -0.005311341427314526 1.328057252407188e-06 -0.005583925258601597 1.328057616111313e-06 -0.00638370916272213 1.328057780957636e-06 -0.006585924750287024 \
1.328058360754957e-06 -0.005792290386912202 1.328058535589415e-06 -0.004916934050781314 1.328058652279015e-06 -0.00413641027497409 1.328058778708708e-06 -0.00310656561120747 \
1.328058880730911e-06 -0.002137079422087956 1.328059000577393e-06 -0.0008406209844352954 1.328059091214629e-06 0.0002489246187367611 1.328059189634679e-06 0.001536790859923857 \
1.328059289358324e-06 0.002948496343048522 1.328059456842332e-06 0.005545701385567424 1.328059675420934e-06 0.009327395936412004 1.328059861491256e-06 0.0128572688386996 \
1.328060082873864e-06 0.01737012273305725 1.328060243533997e-06 0.02082840415615294 1.328060406999647e-06 0.02447866954313523 1.328060557635164e-06 0.02794359528291388 \
1.328060706690917e-06 0.03145289236167962 1.328060856153671e-06 0.03504014479003619 1.328061010184684e-06 0.03879791952579481 1.328061172300943e-06 0.04280891157365373 \
1.328061338330408e-06 0.04696567134311741 1.328061514283228e-06 0.05141478668696391 1.328061694953866e-06 0.05602187592747932 1.328061886774812e-06 0.06094655248807559 \
1.328062093880316e-06 0.06629309753158302 1.328062315452046e-06 0.07203901748582854 1.328062550186215e-06 0.07814662931008168 1.328062801725783e-06 0.08470684589377442 \
1.328063077167849e-06 0.09190125212984442 1.328063377363668e-06 0.09974607960254324 1.328063708295878e-06 0.108390578238945 1.328064083962612e-06 0.1181923833971668 \
1.32806448154548e-06 0.1285487285136021 1.328064948370082e-06 0.1406786766767902 1.328065491362617e-06 0.1547396794802719 1.32806612478764e-06 0.1710742296429572 \
1.328066820727691e-06 0.1889259607126788 1.3280676362848e-06 0.2097135943149445 1.328068546312904e-06 0.2327316641523666 1.328069339569124e-06 0.2526372689279454 \
1.3280700450442e-06 0.2702038474981599 1.328070663988468e-06 0.2855008995781749 1.328071231094408e-06 0.2994177966724069 1.328071754174414e-06 0.3121574438576628 \
1.328072253153207e-06 0.3242197130846058 1.328072737193214e-06 0.3358335658028451 1.328073192420047e-06 0.3466679577370423 1.328073666932009e-06 0.3578644504627745 \
1.328074106840717e-06 0.368158604789619 1.328074592685345e-06 0.3794271463718566 1.328075124288118e-06 0.3916316501999784 1.328075626951417e-06 0.4030538969706937 \
1.32807605602367e-06 0.4127111343288326 1.328076547040338e-06 0.4236561147984291 1.328077048470419e-06 0.434714731975362 1.328077395015009e-06 0.442288187401736 \
1.328077750424386e-06 0.4500000616404133 1.328078177652114e-06 0.4592019891792938 1.328078569851637e-06 0.4675774400278049 1.328078870233395e-06 0.4739448723400065 \
1.328079212045155e-06 0.4811381049525967 1.328079555484969e-06 0.4883107756756314 1.328079816220095e-06 0.4937186470393492 1.328080058250048e-06 0.4987071765458648 \
1.328080324195292e-06 0.5041573145298286 1.328080581464587e-06 0.509394255416739 1.32808077158369e-06 0.5132422368582924 1.328080985109851e-06 0.5175451019736222 \
1.328081124800157e-06 0.5203466115392713 1.328081271000449e-06 0.5232668091041763 1.32808148498835e-06 0.5275186200231483 1.32808169300461e-06 0.5316389396023125 \
1.328081885465879e-06 0.5354321131715788 1.32808207058211e-06 0.5390651926504321 1.328082244955557e-06 0.5424725330931349 1.328082549497633e-06 0.5484058192982523 \
1.328082810056515e-06 0.5534602958276967 1.328083111487545e-06 0.5592859190791987 1.328083365805138e-06 0.5641865993769294 1.328083658661328e-06 0.5698153316805189 \
1.32808391787448e-06 0.5747800306938655 1.328084188950812e-06 0.579963273174682 1.328084430794571e-06 0.5845680738798381 1.328084688299729e-06 0.5894577538325241 \
1.328084915043605e-06 0.5937419314630586 1.328085152044424e-06 0.5982006324572362 1.328085362230986e-06 0.6021379329905048 1.32808557499152e-06 0.6061060319396779 \
1.328085827870286e-06 0.6107954169450593 1.328086031533554e-06 0.6145509252949414 1.328086222250936e-06 0.6180531102377972 1.328086409587374e-06 0.6214768531423983 \
1.328086598465652e-06 0.6249070011644339 1.328086806665447e-06 0.6286671070650327 1.328087050997562e-06 0.6330499453121026 1.328087250564095e-06 0.6366057789565548 \
1.328087454709836e-06 0.6402215701419991 1.32808763934909e-06 0.643474671963314 1.328087908884781e-06 0.6481901084955864 1.328088136591637e-06 0.652149230294136 \
1.328088324263375e-06 0.6553888277830079 1.32808850516352e-06 0.6584949378977958 1.328088664704602e-06 0.661221510907812 1.328088835167002e-06 0.6641177016088209 \
1.328088986918443e-06 0.6666817235716488 1.328089124561455e-06 0.6689905419339194 1.328089273556319e-06 0.6714784915997724 1.328089401298182e-06 0.6736028790357499 \
1.328089544284695e-06 0.675968899142866 1.328089666067751e-06 0.6779749688503388 1.328089802351161e-06 0.6802121872853304 1.328089922180063e-06 0.682172759947357 \
1.328090068775623e-06 0.6845626218370968 1.328090187248565e-06 0.6864845934661837 1.328090283181927e-06 0.6880368302455475 1.328090375701511e-06 0.6895284278106264 \
1.328090480762022e-06 0.6912169000724893 1.328090578843908e-06 0.6927871490736753 1.328090715959225e-06 0.6949707622226827 1.328090835157868e-06 0.6968607547931925 \
1.328090945097838e-06 0.6985951241089645 1.328091082597081e-06 0.7007503743809057 1.328091214026983e-06 0.7027960765825516 1.328091346256499e-06 0.7048392108129343 \
1.328091459433897e-06 0.7065756917706891 1.328091613866752e-06 0.708927873976708 1.328091744646745e-06 0.7109048231498766 1.328091867315455e-06 0.7127465601965561 \
1.328091973583711e-06 0.7143329262278221 1.328092095963735e-06 0.7161490373358268 1.328092197817232e-06 0.7176517022913665 1.328092331955131e-06 0.7196190116794019 \
1.328092452648172e-06 0.7213783352064487 1.32809257178997e-06 0.7231049829175343 1.328092696807985e-06 0.7249059312823601 1.328092826647791e-06 0.7267645120560844 \
1.328092946459962e-06 0.7284691779696002 1.328093075453213e-06 0.730293808329565 1.328093207560277e-06 0.7321507998840678 1.328093325866095e-06 0.7338038328985433 \
1.328093469126786e-06 0.7357927618453034 1.328093571581473e-06 0.7372070005703254 1.328093667788359e-06 0.7385290937783453 1.32809377280598e-06 0.7399656334130889 \
1.328093883577511e-06 0.7414708009413548 1.328093985256052e-06 0.7428439364018735 1.328094088217507e-06 0.7442258341871242 1.32809420514366e-06 0.7457850038572696 \
1.328094333903936e-06 0.747489965072781 1.328094435062908e-06 0.7488201182152049 1.328094583931952e-06 0.7507626302114226 1.328094731611489e-06 0.75267249971878 \
1.328094850976855e-06 0.7542038164026367 1.3280949974607e-06 0.7560679527984652 1.32809512063619e-06 0.7576223900169708 1.328095261439865e-06 0.7593848990234215 \
1.328095398032531e-06 0.7610800595258669 1.328095520190381e-06 0.7625841275516777 1.328095632846779e-06 0.7639610711610054 1.32809577457292e-06 0.7656796138775311 \
1.32809590073942e-06 0.767196844592689 1.328096016156724e-06 0.768574452686535 1.328096146464904e-06 0.7701179991486644 1.328096262177572e-06 0.7714782821591826 \
1.32809638500186e-06 0.7729116492687436 1.328096502846128e-06 0.7742769236963016 1.328096608476119e-06 0.7754922619072108 1.328096723849553e-06 0.7768108638983861 \
1.328096829112716e-06 0.7780056027231214 1.328096940062529e-06 0.7792565499870431 1.328097026467031e-06 0.7802246528436213 1.328097130500851e-06 0.7813823422463088 \
1.328097244396594e-06 0.7826398494046257 1.328097347430013e-06 0.7837684443710583 1.328097455512714e-06 0.7849432998269023 1.32809756376437e-06 0.7861107422109641 \
1.328097699181616e-06 0.7875582910536544 1.328097811855724e-06 0.7887521292973186 1.328097936279784e-06 0.7900592323105087 1.328098054252648e-06 0.7912877959129118 \
1.328098198720603e-06 0.7927781272271259 1.328098316389742e-06 0.7939806363584788 1.328098452269582e-06 0.7953567374150946 1.328098587013954e-06 0.7967081403609936 \
1.328098698084933e-06 0.7978123285366109 1.328098797974273e-06 0.7987978371087655 1.328098899654231e-06 0.7997937268659365 1.328099032867897e-06 0.8010867894381996 \
1.328099151240716e-06 0.8022243628210853 1.32809927278179e-06 0.8033812848148773 1.328099392145442e-06 0.8045065422543012 1.328099513276819e-06 0.80563739819571 \
1.328099644976236e-06 0.8068544426691319 1.328099767984513e-06 0.8079795872959963 1.32809989582812e-06 0.8091371804586788 1.32810002673464e-06 0.8103101881504271 \
1.328100150327798e-06 0.8114062915203997 1.328100257500303e-06 0.8123479140825919 1.328100364929502e-06 0.8132835730547656 1.32810044759862e-06 0.8139979974227743 \
1.32810056531038e-06 0.8150069815425507 1.328100655915986e-06 0.8157770472204025 1.328100786569431e-06 0.8168774959419571 1.328100930959301e-06 0.8180800468042847 \
1.328101064133715e-06 0.8191766687328477 1.328101174025106e-06 0.8200725423139092 1.328101317623991e-06 0.8212302325252553 1.328101471014683e-06 0.8224508494407716 \
1.328101599092908e-06 0.8234574467428303 1.328101738880276e-06 0.8245431382086058 1.328101865129839e-06 0.8255122018650548 1.328102019728392e-06 0.8266841987320058 \
1.328102151939368e-06 0.8276738265999063 1.328102278166151e-06 0.8286078934539939 1.328102395913874e-06 0.8294698388787296 1.328102544986668e-06 0.8305480062617677 \
1.32810271231822e-06 0.8317406852496945 1.328102845539497e-06 0.8326770812274722 1.32810301832082e-06 0.8338744310092966 1.328103186826193e-06 0.8350236380668206 \
1.328103356205492e-06 0.8361608866600232 1.328103537840761e-06 0.8373606451951652 1.328103680174083e-06 0.8382866867625347 1.328103794011069e-06 0.8390185116470331 \
1.328103925192579e-06 0.8398522525089582 1.328104026724794e-06 0.8404903982372576 1.328104143009054e-06 0.8412135669902132 1.328104277643808e-06 0.8420406924792603 \
1.328104474666644e-06 0.8432316292878405 1.328104664772186e-06 0.8443592803112207 1.328104874895499e-06 0.8455816023960827 1.328105055213604e-06 0.8466107566581813 \
1.328105252676705e-06 0.8477171937062282 1.32810542674582e-06 0.8486750118570332 1.32810560906524e-06 0.8496608982186138 1.328105780480376e-06 0.8505716849290491 \
1.328105954593653e-06 0.8514808063694008 1.328106130324621e-06 0.8523822271368225 1.328106306436321e-06 0.8532696099472232 1.328106496054173e-06 0.8542074684498208 \
1.32810668683567e-06 0.8551330189126392 1.328106888431747e-06 0.8560917259710515 1.328107081166005e-06 0.856990088884472 1.328107290037826e-06 0.8579439907476532 \
1.328107520740263e-06 0.8589743400177088 1.328107785183227e-06 0.8601259267840322 1.328108084005915e-06 0.8613896125360476 1.328108363960216e-06 0.8625380186322354 \
1.328108648086082e-06 0.8636694076724545 1.328108922855057e-06 0.8647317823994775 1.328109194712217e-06 0.8657531067718063 1.328109465089334e-06 0.8667403371654003 \
1.328109722167856e-06 0.8676533221001362 1.328109994792687e-06 0.868594905839151 1.328110270759836e-06 0.8695208838709013 1.328110540864093e-06 0.8704012674911344 \
1.328110840740104e-06 0.8713491368600049 1.328111211801162e-06 0.8724801680184872 1.32811150674079e-06 0.8733472453740196 1.328111761036548e-06 0.8740729094291386 \
1.328112059297474e-06 0.8748989982677786 1.328112332904015e-06 0.8756336613858092 1.328112569029958e-06 0.876250392688866 1.328112809374056e-06 0.8768621356511911 \
1.328113031706182e-06 0.8774140071409635 1.328113225712247e-06 0.8778848105679672 1.328113555434997e-06 0.8786625669521169 1.328113710608526e-06 0.8790190643519731 \
1.328114028387606e-06 0.879730644938159 1.328114207248864e-06 0.8801204696806418 1.328114549710761e-06 0.8808457867651537 1.328114733837363e-06 0.8812245477320809 \
1.328115208711942e-06 0.8821665346129511 1.328115376108352e-06 0.8824869809105039 1.328115841951854e-06 0.883348261932613 1.328116022773548e-06 0.8836708855253055 \
1.328116516812651e-06 0.8845204537290557 1.328116658162059e-06 0.8847551796839913 1.328117264500122e-06 0.8857215808967022 1.328117416569336e-06 0.8859539944113424 \
1.328118063256356e-06 0.8869009218298172 1.328118191551239e-06 0.8870812460539503 1.328118839667745e-06 0.8879562712787433 1.328118969467641e-06 0.8881245027440973 \
1.32811974767834e-06 0.8890830197250962 1.328119862725472e-06 0.8892171882189283 1.328120718396314e-06 0.8901564861234483 1.328120863744077e-06 0.8903061494816453 \
1.328121849499649e-06 0.8912466483555094 1.328122070607711e-06 0.8914402669210102 1.328123215727714e-06 0.892367747196105 1.328123346939159e-06 0.8924695935232408 \
1.328124688211624e-06 0.8934615053489913 1.3281248396029e-06 0.8935661991834861 1.32812632105512e-06 0.8944951400107031 1.328126559934816e-06 0.8946288932334222 \
1.328128329356654e-06 0.895502508848118 1.328128718477945e-06 0.895670668133377 1.328131112210654e-06 0.8965556062201232 1.328131587750592e-06 0.8967047758494365 \
1.328135650819818e-06 0.8977025964496719 1.328136142295654e-06 0.8977953148389237 1.328144458892796e-06 0.8987880790885289 1.328145378794248e-06 0.8988514070442593 \
1.328299242370168e-06 0.8998485708192639 1.328302885496457e-06 0.8998628537402877 1.328529614276672e-06 0.8989664306490068 1.328529844616583e-06 0.8988008565867064 \
1.32853145953688e-06 0.897804750401333 1.328531637269166e-06 0.8977103535805105 1.328548403669271e-06 0.8986978311584225 1.328548539768403e-06 0.8987160394686986 \
1.328563710608672e-06 0.8997133888183054 1.328563987713508e-06 0.899719468756186 1.329048028906422e-06 0.9005852143835333 1.329048202241039e-06 0.9007408621809421 \
1.329048862730638e-06 0.9015135064485434 1.32904902879582e-06 0.9017527716291757 1.329049555130528e-06 0.9026184054967997 1.329049746244447e-06 0.9029704910143604 \
1.329050110465499e-06 0.9036902342402512 1.329050289664921e-06 0.9040628043424317 1.329050651551594e-06 0.9048333795345931 1.329050846661164e-06 0.9052442844328937 \
1.329051379059525e-06 0.9062266394381637 1.329051561413164e-06 0.9064623886473868 1.329052553393556e-06 0.905594670761786 1.329052714934123e-06 0.9049318860608667 \
1.329052882926576e-06 0.9040378649110347 1.329053042758061e-06 0.9029782421366458 1.329053180254799e-06 0.9018984154159868 1.329053313162111e-06 0.9007052793196499 \
1.329053439587579e-06 0.8994328447569792 1.329053546986819e-06 0.8982475863895881 1.329053651483477e-06 0.8970047013543965 1.329053765533147e-06 0.8955451342423859 \
1.329053855502734e-06 0.8943225684615312 1.329053960321373e-06 0.8928208677113324 1.329054049769612e-06 0.891473284704788 1.329054132145393e-06 0.8901820884368528 \
1.329054223238393e-06 0.8887006634027688 1.329054360574471e-06 0.8863657732814155 1.329054459067403e-06 0.8846195012157601 1.329054571141153e-06 0.8825649218508906 \
1.329054702024186e-06 0.880080778639088 1.329054838495216e-06 0.8774018563482072 1.329054991949379e-06 0.8742910281085086 1.329055151043747e-06 0.8709679977889497 \
1.329055315327649e-06 0.867445283300377 1.329055471995751e-06 0.8640104344288071 1.329055624086531e-06 0.860615744772629 1.329055777800206e-06 0.857132398554192 \
1.329055937362381e-06 0.853469801378647 1.329056092451083e-06 0.8498714074018293 1.329056266130402e-06 0.8458039138600054 1.329056429161269e-06 0.8419559450883216 \
1.329056590803684e-06 0.8381170660338335 1.329056753450421e-06 0.8342344554797501 1.329056914868927e-06 0.8303657475978833 1.329057083463406e-06 0.8263109424305363 \
1.329057266356504e-06 0.8219002364007665 1.329057434185218e-06 0.8178440888239877 1.329057602471033e-06 0.8137703061148112 1.329057773299085e-06 0.8096302849976138 \
1.329057945473642e-06 0.8054541271740473 1.329058113235561e-06 0.8013830614994394 1.329058296865018e-06 0.7969255463994016 1.329058468271496e-06 0.7927646873948894 \
1.329058653714802e-06 0.7882638003278283 1.329058820385454e-06 0.7842196820467244 1.329058989271585e-06 0.7801233737411432 1.329059173427882e-06 0.7756572567105651 \
1.32905936803791e-06 0.7709405333854473 1.329059515293241e-06 0.7673736106648734 1.329059641923832e-06 0.7643079795643375 1.329059783780644e-06 0.7608754495129878 \
1.329059888184422e-06 0.7583505812556488 1.329060020577074e-06 0.7551502542766809 1.329060130161271e-06 0.7525028097975122 1.329060263325923e-06 0.7492875979647342 \
1.329060419507685e-06 0.7455190770546114 1.329060532737112e-06 0.7427887939149777 1.329060695258476e-06 0.7388718945951063 1.329060867439291e-06 0.7347246296492568 \
1.329061063444044e-06 0.7300078517193382 1.329061227834023e-06 0.7260553905833119 1.329061380230704e-06 0.7223944885043934 1.329061543905858e-06 0.718466402706526 \
1.329061711831558e-06 0.7144406657912139 1.329061891671936e-06 0.7101336212543717 1.329062067965886e-06 0.7059164985576465 1.329062239040521e-06 0.7018286413152719 \
1.329062407358697e-06 0.6978099102718778 1.329062560624829e-06 0.6941537154717222 1.329062722508398e-06 0.6902960245155986 1.329062901459938e-06 0.6860364417190952 \
1.32906303567149e-06 0.6828448068431195 1.329063139177788e-06 0.6803854168085423 1.3290632384622e-06 0.6780286039046017 1.329063339916677e-06 0.6756220912380299 \
1.329063432373276e-06 0.6734303711245889 1.329063516962075e-06 0.6714267031582685 1.329063610539411e-06 0.6692114082407524 1.329063727081631e-06 0.6664546942583044 \
1.329063836559192e-06 0.6638675763958631 1.329063949672203e-06 0.6611971533414394 1.32906407279097e-06 0.6582923426231613 1.329064197017283e-06 0.6553636581362478 \
1.329064367777427e-06 0.6513432847262797 1.329064526226014e-06 0.6476181700514572 1.329064698513837e-06 0.6435738126612673 1.329064844491904e-06 0.6401512360303271 \
1.32906498628512e-06 0.6368325564797357 1.329065117883574e-06 0.6337564355289309 1.329065248046859e-06 0.630718219665797 1.3290653735718e-06 0.6277924818644975 \
1.329065505354707e-06 0.6247239543970449 1.329065635278203e-06 0.6217046839485236 1.329065771586778e-06 0.6185408917806742 1.329065916200345e-06 0.615188962872713 \
1.329066075692536e-06 0.611499189008522 1.329066249152652e-06 0.6074939486938447 1.329066420159954e-06 0.6035554342946753 1.329066651528522e-06 0.5982402936372396 \
1.329066894990528e-06 0.5926661367297537 1.329067069111016e-06 0.5886942528256315 1.329067215383093e-06 0.5853638081576373 1.329067349755312e-06 0.58231230528805 \
1.329067466850207e-06 0.5796585826255305 1.329067562614553e-06 0.5774900935424465 1.329067661461096e-06 0.5752566196463251 1.329067745438414e-06 0.5733628024369305 \
1.329067823052463e-06 0.571614165956722 1.329067884377937e-06 0.5702331258704825 1.329067949058576e-06 0.5687779664863769 1.329068030366711e-06 0.5669528575016536 \
1.329068080436707e-06 0.5658306078972934 1.329068129757269e-06 0.5647256890740617 1.329068191677069e-06 0.5633393552914843 1.329068239508894e-06 0.5622690492396486 \
1.32906829001368e-06 0.5611395143522533 1.329068350075717e-06 0.559799205480933 1.329068409358512e-06 0.5584782058326896 1.329068484415226e-06 0.5568072508052372 \
1.329068554097883e-06 0.5552574373576753 1.329068639686449e-06 0.5533559356568912 1.329068726753821e-06 0.5514265885063823 1.329068810416341e-06 0.5495763264044081 \
1.329068896561366e-06 0.5476734676082877 1.329068992265987e-06 0.5455621222678217 1.329069096550939e-06 0.5432673229847179 1.329069211218113e-06 0.5407497407899529 \
1.329069319936574e-06 0.5383664115638558 1.329069429508814e-06 0.5359693749054023 1.329069541813574e-06 0.5335193270114367 1.329069668589195e-06 0.530759392645703 \
1.329069790866427e-06 0.5281021910076299 1.329069930952405e-06 0.5250685463469849 1.329070067969763e-06 0.5221084647952599 1.329070218271135e-06 0.5188705764247719 \
1.329070377166376e-06 0.5154582091324615 1.329070551500259e-06 0.5117250894133971 1.329070738517481e-06 0.5077378180012799 1.329070943835486e-06 0.5033745272871338 \
1.329071155677679e-06 0.498891131759938 1.329071408479721e-06 0.4935662239713107 1.32907161056737e-06 0.4893264048484654 1.329071845160675e-06 0.4844277613141263 \
1.329072081275272e-06 0.4795194943790256 1.329072334451769e-06 0.474283574581623 1.329072644981732e-06 0.4679020429045382 1.32907286303971e-06 0.4634451779596257 \
1.329073036485344e-06 0.4599153839204358 1.329073212977781e-06 0.4563351808422506 1.329073492459578e-06 0.4506930409909046 1.329073724703484e-06 0.4460279192631412 \
1.329074011797073e-06 0.44029020239849 1.329074229643181e-06 0.435960758243863 1.329074439695769e-06 0.4318042429497612 1.329074640893605e-06 0.4278406951573778 \
1.329074823313766e-06 0.4242617300271556 1.329074997208751e-06 0.4208637793449936 1.329075162072867e-06 0.4176529694331993 1.32907532082684e-06 0.4145718140694327 \
1.329075487073787e-06 0.4113577680628809 1.329075635718993e-06 0.4084923702366076 1.329075788087249e-06 0.4055658186126443 1.329075930150432e-06 0.4028468403491589 \
1.32907609952631e-06 0.3996150665462138 1.32907621990823e-06 0.3973276483660343 1.329076329881494e-06 0.3952449223617059 1.329076444806895e-06 0.3930732253581283 \
1.329076597048475e-06 0.3902080468194818 1.32907670926954e-06 0.3881039677199808 1.329076816462041e-06 0.386098874836553 1.32907696899029e-06 0.383254723448244 \
1.329077097137419e-06 0.380874963946598 1.329077219985412e-06 0.3786015923730871 1.329077399083788e-06 0.375299968600122 1.32907754816842e-06 0.3725653942578417 \
1.329077715875808e-06 0.3695018296724824 1.329077871273443e-06 0.3666748141177644 1.329077995440288e-06 0.3644243980538668 1.329078109332156e-06 0.3623666676050148 \
1.329078230775526e-06 0.3601804966264144 1.329078410927293e-06 0.3569532670533712 1.329078577415113e-06 0.3539878629329621 1.329078767834223e-06 0.3506138544217919 \
1.329078959590819e-06 0.3472380408565978 1.329079142640212e-06 0.344035729794033 1.329079291612277e-06 0.3414435189591631 1.329079411552182e-06 0.3393660536257183 \
1.329079534213665e-06 0.3372483242714233 1.329079657244151e-06 0.3351324902755385 1.329079802148562e-06 0.3326515017845288 1.329079905461337e-06 0.3308907757076019 \
1.329079999190846e-06 0.3292979229163631 1.329080089851148e-06 0.3277620998585528 1.329080200972602e-06 0.3258853746017661 1.329080308145579e-06 0.3240820510456246 \
1.32908040642023e-06 0.3224338250618513 1.329080518824776e-06 0.3205545940512134 1.329080682764676e-06 0.3178277446588927 1.329080844402555e-06 0.3151576097143818 \
1.329080992189301e-06 0.3127316247504084 1.329081154434516e-06 0.3100832165115083 1.329081314465073e-06 0.3074868334344322 1.329081466728372e-06 0.3050304870660137 \
1.329081620100242e-06 0.3025703731928215 1.329081778808771e-06 0.3000411640344692 1.3290819432579e-06 0.297437246442505 1.329082110484976e-06 0.2948063590562646 \
1.329082263596513e-06 0.292412731930112 1.329082446694441e-06 0.2895700146919417 1.329082637002178e-06 0.2866380344427262 1.329082785905236e-06 0.2843603072871506 \
1.329082959842542e-06 0.2817165165722222 1.32908313671993e-06 0.2790484233348025 1.329083284317149e-06 0.2768363681311815 1.329083473948849e-06 0.2740172295061162 \
1.329083623950767e-06 0.2718052906662373 1.329083761060958e-06 0.2697943906627059 1.329083902591401e-06 0.2677397479842996 1.32908401605027e-06 0.2661005451260196 \
1.329084152340596e-06 0.2641384584581135 1.329084282417217e-06 0.2622807416655737 1.32908440067147e-06 0.2606037730704709 1.329084518527066e-06 0.2589348966568543 \
1.329084649420877e-06 0.2570853888657079 1.329084789659635e-06 0.2551145527343576 1.329084905154221e-06 0.2534976852533538 1.329085034005598e-06 0.2516957519945816 \
1.329085149151579e-06 0.2500885525459272 1.329085302462547e-06 0.2479513765689386 1.329085440316308e-06 0.2460367343642474 1.32908557977796e-06 0.2441002375748529 \
1.329085735245815e-06 0.2419427021952501 1.32908586002843e-06 0.2402176526454788 1.329085999893338e-06 0.2382916534360561 1.329086128595514e-06 0.2365220787132559 \
1.329086249554366e-06 0.234860341242685 1.329086366599666e-06 0.2332541163798121 1.32908649260073e-06 0.2315368940272461 1.329086589320323e-06 0.2302195772445239 \
1.329086681409196e-06 0.2289683907689286 1.329086795826667e-06 0.2274152998827935 1.329086894197314e-06 0.2260807986508055 1.329087011344108e-06 0.2244933520241092 \
1.329087114435226e-06 0.2231010305483718 1.329087219949952e-06 0.2216798666278746 1.329087300868012e-06 0.2205933880575098 1.329087374539197e-06 0.2196046443759679 \
1.329087417268434e-06 0.2190314036349237 1.329087460398579e-06 0.2184540235451489 1.329087511196061e-06 0.217774515685755 1.329087548370939e-06 0.217277430841393 \
1.329087589041954e-06 0.2167338127731004 1.329087631833756e-06 0.2161620985357572 1.329087668244897e-06 0.2156758299561118 1.329087710169888e-06 0.2151161507306283 \
1.329087764712098e-06 0.2143884526296278 1.329087803170857e-06 0.2138756926875936 1.329087842797626e-06 0.2133496230586122 1.329087904630128e-06 0.212531488259555 \
1.329087966356579e-06 0.2117156525305126 1.329088022493854e-06 0.210974237875411 1.329088086149084e-06 0.210134110843225 1.329088180240117e-06 0.2088936328424611 \
1.329088267048376e-06 0.2077505933124353 1.32908836100502e-06 0.2065146061917991 1.329088459047254e-06 0.2052266823513323 1.329088560634619e-06 0.2038976009052371 \
1.329088661543568e-06 0.2025832113009377 1.329088758279377e-06 0.2013244528083448 1.329088860404348e-06 0.1999972806373927 1.329088963735905e-06 0.1986583046056677 \
1.329089073618507e-06 0.1972379690671278 1.329089182560765e-06 0.1958337611883887 1.329089302395885e-06 0.1942937175364915 1.329089412679751e-06 0.1928822800638286 \
1.329089520558496e-06 0.191507108810815 1.329089646621254e-06 0.1899051957406391 1.329089736488961e-06 0.1887671190866151 1.3290898469673e-06 0.1873723090993208 \
1.329089924500249e-06 0.1863971337376019 1.329090008823992e-06 0.1853400660204312 1.32909009641205e-06 0.1842452710069853 1.329090184204644e-06 0.18315095174413 \
1.329090265924516e-06 0.1821357652581398 1.329090363486193e-06 0.1809282658474054 1.329090470197344e-06 0.1796118512064394 1.329090570679026e-06 0.178377576484793 \
1.329090694850238e-06 0.1768595317522179 1.329090828741761e-06 0.1752320886156309 1.329090947653953e-06 0.1737937102924047 1.329091098054147e-06 0.1719851742607024 \
1.32909120888924e-06 0.1706594030660365 1.329091348655982e-06 0.168997130456427 1.32909146718129e-06 0.1675953052211382 1.329091572608521e-06 0.1663548750207849 \
1.32909166731838e-06 0.1652455210322802 1.329091760628154e-06 0.1641568522804657 1.32909186153427e-06 0.1629842804551663 1.329091956952102e-06 0.1618800504313296 \
1.329092054143025e-06 0.1607598891027116 1.329092135704507e-06 0.1598237474547246 1.329092241020952e-06 0.1586229753023833 1.329092324500659e-06 0.1576763029943549 \
1.329092426029949e-06 0.1565306813704828 1.329092503260486e-06 0.1556635090415242 1.329092594132523e-06 0.154647919213242 1.329092663483833e-06 0.1538765336840219 \
1.329092748067884e-06 0.1529397840535594 1.329092822461091e-06 0.1521208717489242 1.329092901831293e-06 0.151251902275755 1.329092976418964e-06 0.1504388356812226 \
1.329093045640521e-06 0.1496871728711989 1.329093140321328e-06 0.1486640077242138 1.329093210087093e-06 0.1479134441579097 1.329093294531656e-06 0.147008717574758 \
1.329093356097002e-06 0.1463518850554192 1.329093430139493e-06 0.1455673550676988 1.329093503525017e-06 0.1447940960774066 1.329093584960259e-06 0.1439395015691976 \
1.329093654409405e-06 0.1432139999234875 1.329093729511102e-06 0.1424323701137583 1.329093819423173e-06 0.1415006120834361 1.329093896506793e-06 0.1407052977810757 \
1.329093995617377e-06 0.1396885207473417 1.32909406515744e-06 0.138983077430453 1.329094146475915e-06 0.1381612812129989 1.329094216644325e-06 0.1374549162714094 \
1.329094295612438e-06 0.1366629455350578 1.32909437459072e-06 0.1358740351737466 1.32909444691251e-06 0.1351544405911459 1.329094516277969e-06 0.1344667589602006 \
1.329094564981977e-06 0.1339854049281765 1.329094655744348e-06 0.1330945614011112 1.329094687765876e-06 0.1327823711724506 1.329094775869844e-06 0.131925672678654 \
1.329094808363886e-06 0.1316105445757083 1.329094907031543e-06 0.1306564447580443 1.329094950687519e-06 0.130235859061297 1.329095028669336e-06 0.1294866595045693 \
1.329095066000294e-06 0.1291289430202982 1.329095168151694e-06 0.128153223240932 1.329095235595654e-06 0.1275115375392494 1.329095300748612e-06 0.1268935577290946 \
1.329095366654626e-06 0.1262729746041904 1.329095437806609e-06 0.1256052797936485 1.32909552074397e-06 0.1248293808775363 1.329095606139451e-06 0.1240331657139879 \
1.329095682226844e-06 0.1233259817834828 1.329095762687521e-06 0.1225806238777534 1.329095820771462e-06 0.1220441728027253 1.329095892104936e-06 0.1213870835332726 \
1.329095976893369e-06 0.1206085709991845 1.329096038048402e-06 0.1200487744399507 1.329096108134853e-06 0.1194096117168642 1.329096170640142e-06 0.1188419501154776 \
1.32909623664509e-06 0.1182453094891599 1.329096305417857e-06 0.1176255789053269 1.329096374874481e-06 0.1170017375875525 1.329096458038731e-06 0.1162574953874909 \
1.329096531156255e-06 0.1156056107435251 1.329096601870241e-06 0.1149774116339468 1.329096661221924e-06 0.1144518657417393 1.329096766519136e-06 0.1135239342411639 \
1.32909681238663e-06 0.1131212254602471 1.329096899340683e-06 0.1123603821649216 1.329096942354464e-06 0.1119852310621949 1.329096987221211e-06 0.1115947726395539 \
1.329097076954706e-06 0.1108164664143028 1.329097147839057e-06 0.110204256460374 1.329097226692571e-06 0.109525796983828 1.329097289470346e-06 0.1089876103666232 \
1.329097349464702e-06 0.1084750215669379 1.329097460462474e-06 0.1075310013968523 1.32909754121676e-06 0.1068475792877216 1.329097653680086e-06 0.1059005796323111 \
1.329097704824629e-06 0.1054717782906781 1.329097787809798e-06 0.1047785948356612 1.329097845974503e-06 0.1042945647727652 1.329097960212503e-06 0.1033482075721767 \
1.32909801011597e-06 0.1029366076865433 1.329098095857569e-06 0.1022320954501846 1.329098144889019e-06 0.1018307629303728 1.329098227455441e-06 0.101157455862875 \
1.329098298387777e-06 0.1005815064560546 1.329098366538127e-06 0.1000302812267231 1.329098444148443e-06 0.0994053199805509 1.329098516491814e-06 0.09882546240595018 \
1.329098594067778e-06 0.09820656846618626 1.329098682738439e-06 0.09750287271560702 1.329098756553227e-06 0.09692010793638871 1.329098838144235e-06 0.09627924899616347 \
1.329098916282703e-06 0.09566870926115327 1.329099002032494e-06 0.09500229249765579 1.329099089729402e-06 0.09432453920671229 1.329099183638967e-06 0.09360304191323381 \
1.329099280098285e-06 0.09286661217778783 1.329099358728946e-06 0.09226977907248698 1.329099461452546e-06 0.09149473120661993 1.329099545280196e-06 0.09086620530027881 \
1.329099666032378e-06 0.08996702094116031 1.329099795302029e-06 0.08901247130467421 1.329099951190493e-06 0.08787237469953549 1.329100106290076e-06 0.08675000010972149 \
1.329100263305882e-06 0.08562614142917294 1.329100443326735e-06 0.08435280068725284 1.329100593847601e-06 0.08330035525696428 1.329100742221624e-06 0.08227363395463329 \
1.329100879838855e-06 0.08133079092382095 1.329101019758505e-06 0.08038162993974078 1.329101156365493e-06 0.07946425488810546 1.329101295092791e-06 0.07854214404995859 \
1.329101440403653e-06 0.07758663187171365 1.329101588151466e-06 0.07662571164688473 1.329101746748333e-06 0.07560598447141591 1.329101911000851e-06 0.07456266320243836 \
1.329102080017927e-06 0.07350246718885647 1.329102261906921e-06 0.07237646636762114 1.329102462529019e-06 0.07115268999588262 1.329102676406562e-06 0.0698691158856425 \
1.329102904040694e-06 0.0685263410462881 1.329103145626235e-06 0.06712722147996912 1.329103427215414e-06 0.06552977831071743 1.329103724369535e-06 0.06388229915275011 \
1.329104047802611e-06 0.06213267023812474 1.329104438962031e-06 0.0600758559534558 1.329104840456333e-06 0.05803293250078725 1.329105217397059e-06 0.05617754872181892 \
1.329105584510791e-06 0.05442503025024555 1.329105934627471e-06 0.05280240270907886 1.329106253933125e-06 0.05136309724710254 1.329106558257407e-06 0.05002640192327024 \
1.329106855163312e-06 0.04875503464657577 1.329107137163639e-06 0.04757867888787161 1.329107417596943e-06 0.04643900623749339 1.329107682320567e-06 0.04538777697325767 \
1.329107958218279e-06 0.04431704973151576 1.329108232683143e-06 0.04327654260273706 1.329108531102423e-06 0.04217254828989973 1.32910875761848e-06 0.04135316230013186 \
1.329109069531318e-06 0.04025053053625379 1.329109289786109e-06 0.03948972371590862 1.329109507050863e-06 0.03875470657060948 1.329109716773513e-06 0.03806113111453101 \
1.3291100269559e-06 0.03705828856757609 1.329110249553778e-06 0.03635538859683734 1.329110496919279e-06 0.03559019656168042 1.329110769325655e-06 0.03476651972027592 \
1.329110989958209e-06 0.03411384091885184 1.32911127423846e-06 0.03329124852897781 1.329111512151752e-06 0.0326183788879464 1.329111750241164e-06 0.03195887699386461 \
1.329111985496492e-06 0.03132132139405813 1.329112214275199e-06 0.03071728735992773 1.329112447005948e-06 0.03011490821398154 1.329112666308989e-06 0.02955843195412813 \
1.329112870252059e-06 0.02905055018162466 1.329113269161795e-06 0.02808303002558106 1.329113456316051e-06 0.02764052191221165 1.329113828521772e-06 0.0267814187683372 \
1.329114015473295e-06 0.02635997027055515 1.329114384827242e-06 0.02554620807076183 1.32911453848041e-06 0.02521471147941385 1.329114954694564e-06 0.02434161493068329 \
1.329115160182381e-06 0.02392065165079968 1.329115499190341e-06 0.02323955384462723 1.329115681885069e-06 0.02287916718068597 1.329116138978978e-06 0.02199597290476789 \
1.329116268719714e-06 0.02174967209293581 1.329116722140138e-06 0.02089828923199067 1.32911686451243e-06 0.0206336680476187 1.32911739407919e-06 0.01967289368906444 \
1.329117520286197e-06 0.01945139161001456 1.329118082520635e-06 0.01850749734048266 1.329118245259022e-06 0.01824627541187189 1.329118809439087e-06 0.01738327200207762 \
1.329118961183154e-06 0.01716165742474803 1.329119662862638e-06 0.01618760396393164 1.329119832951728e-06 0.01596324388168 1.329120488009604e-06 0.01513221026437959 \
1.329120654523916e-06 0.01492874613340729 1.329121387637676e-06 0.01406966818047924 1.329121520900854e-06 0.01391906482409888 1.329122372558029e-06 0.01299647369571925 \
1.329122510500477e-06 0.01285324185793544 1.329123450559967e-06 0.0119198170026788 1.329123614321604e-06 0.01176347583728811 1.329124601555039e-06 0.01085909507266535 \
1.329124736144114e-06 0.0107410715025141 1.329125877583545e-06 0.009819907073012045 1.329125985822443e-06 0.009738548299709823 1.329127309069827e-06 0.00880579379490502 \
1.329127441815525e-06 0.008718202093769473 1.32912896431665e-06 0.007760835273143199 1.329129076858719e-06 0.007690148685505111 1.329130769150306e-06 0.00669558715138598 \
1.329130909416892e-06 0.00662113250846694 1.329132982426194e-06 0.005629132576249021 1.32913317498771e-06 0.005545002188831318 1.329135385197559e-06 0.004656096148610405 \
1.329135791984232e-06 0.004507219767123045 1.329138613724209e-06 0.003590578528330178 1.329139135019959e-06 0.00344214578404881 1.329143347121009e-06 0.002447529662748036 \
1.329143899683877e-06 0.002340875287107731 1.329149782973417e-06 0.001359168649576994 1.329150032246415e-06 0.001311490127959886 1.329163182367465e-06 0.0003136950974005476 \
1.329163299150435e-06 0.0003112730584132499 1.358990000000011e-06 3.042397160644726e-06 1.402746667027013e-06 -0.0009024818035526668 1.402746739442629e-06 -0.001022682652537627 \
1.402747175467347e-06 -0.001858525046639076 1.40274726236173e-06 -0.002046124893065343 1.402747617065043e-06 -0.00288168582347465 1.402747716611644e-06 -0.003135075204051477 \
1.402747976881348e-06 -0.003828199033013717 1.40274811720375e-06 -0.004216406518003108 1.402748344689832e-06 -0.004856871791621592 1.402748481897271e-06 -0.005239031028659006 \
1.40274886679612e-06 -0.006187559915121 1.402748998893307e-06 -0.006423332025500122 1.402749687336335e-06 -0.005917035979538006 1.402749844265069e-06 -0.005202654566481615 \
1.402749971914231e-06 -0.004414133290428114 1.402750099456021e-06 -0.003433350487145549 1.402750217130233e-06 -0.002355902309038119 1.40275031626992e-06 -0.001320627313728655 \
1.40275042165263e-06 -9.507383675133965e-05 1.402750535559933e-06 0.001369964538583592 1.402750666615328e-06 0.003229572948258866 1.402750791978547e-06 0.005172303930030842 \
1.402750983820411e-06 0.008432154569684791 1.402751127490204e-06 0.01107975669588844 1.402751285472017e-06 0.01417105828876112 1.402751434071664e-06 0.01723098336859398 \
1.402751587122593e-06 0.02051714008521248 1.402751746187569e-06 0.02405720796424875 1.402751899257778e-06 0.02756764950178633 1.402752047604842e-06 0.03105219347129199 \
1.402752196711284e-06 0.03462388853332505 1.402752351275713e-06 0.03838854885099419 1.402752511961677e-06 0.04235886888523473 1.402752676640863e-06 0.04647718198980624 \
1.402752853163806e-06 0.05093664320808645 1.402753032175606e-06 0.05549818742091989 1.402753222948448e-06 0.0603932190016783 1.4027534277958e-06 0.06567927942044927 \
1.402753648293053e-06 0.07139554989571946 1.402753881211021e-06 0.07745499876455469 1.402754130458799e-06 0.08395499695136356 1.402754403380326e-06 0.09108394918256098 \
1.402754700173383e-06 0.09884095133633181 1.402755027609895e-06 0.1073964775374675 1.402755397423694e-06 0.1170487607486894 1.402755792369975e-06 0.1273407304921971 \
1.402756250458528e-06 0.1392499850125259 1.402756782558388e-06 0.1530377249371455 1.402757408110397e-06 0.169180864038255 1.402758094102463e-06 0.1867931863309214 \
1.402758896945878e-06 0.2072766958045763 1.40275979625821e-06 0.2300508264895909 1.402760696698322e-06 0.2526618731709107 1.402761498589855e-06 0.2726215666318766 \
1.402762194096996e-06 0.2897857674353052 1.402762826931282e-06 0.3052728323588638 1.402763422339773e-06 0.3197161646377594 1.402763969382815e-06 0.3328722959176427 \
1.402764503143162e-06 0.3455929446372428 1.402765022382586e-06 0.3578476146335662 1.402765529774049e-06 0.3697097539883151 1.402766033395218e-06 0.3813674725871593 \
1.402766545138114e-06 0.3930934709428262 1.402767052299123e-06 0.404595334768291 1.402767582595136e-06 0.4164962117964878 1.402768068708626e-06 0.4272847049163567 \
1.402768546816947e-06 0.437781779057129 1.402768986249071e-06 0.4473362978389137 1.402769109408535e-06 0.4500002106608159 1.402769355727462e-06 0.4553046876287923 \
1.402769698999458e-06 0.4626558934952216 1.402770010436459e-06 0.4692815017887791 1.402770261147724e-06 0.4745855323881177 1.402770531976868e-06 0.480281321066213 \
1.402770868458777e-06 0.4873122872019196 1.402771224467388e-06 0.4946959640027882 1.402771541737556e-06 0.5012322602315481 1.402771780618105e-06 0.506122906570856 \
1.402772021646287e-06 0.5110269393752048 1.402772273577991e-06 0.5161276795544476 1.402772513731834e-06 0.5209621749612534 1.402772736483296e-06 0.5254248476203834 \
1.402772925040943e-06 0.5291850880529715 1.402773139790986e-06 0.5334523706207774 1.402773354339378e-06 0.5376948565446859 1.40277361310367e-06 0.5427871977552768 \
1.402773863931241e-06 0.5477009885064807 1.402774119350104e-06 0.5526782776843104 1.402774470392629e-06 0.5594898819265107 1.402774735000954e-06 0.5645984056527484 \
1.40277500141751e-06 0.569709962982798 1.40277526193182e-06 0.5746801970751495 1.402775529021882e-06 0.5797469183389945 1.402775772159962e-06 0.5843213438768613 \
1.402776027852189e-06 0.5890994944692448 1.402776255671159e-06 0.5933243819692556 1.402776493215979e-06 0.5976999800355528 1.402776704606465e-06 0.6015679915939678 \
1.402776916747224e-06 0.6054277082074113 1.402777105936602e-06 0.6088479815213901 1.40277723709492e-06 0.6112112531841202 1.402777369391478e-06 0.6135871094428261 \
1.402777554614204e-06 0.6169015645304802 1.402777716636591e-06 0.6197943209800671 1.402777875055755e-06 0.6226100751126036 1.402778009167621e-06 0.6249846001944386 \
1.402778181488729e-06 0.6280247049765127 1.402778310427531e-06 0.6302937061188456 1.402778430805044e-06 0.6324061607157294 1.402778571333915e-06 0.634864734791624 \
1.402778764419407e-06 0.6382321981637986 1.402778914230185e-06 0.6408363654380513 1.402779081537779e-06 0.6437327988167145 1.402779262592003e-06 0.6468572757970242 \
1.402779465918433e-06 0.6503523798695617 1.402779648771588e-06 0.6534819287355287 1.402779819395834e-06 0.6563879501053153 1.402779996860074e-06 0.6594029650344411 \
1.402780162839024e-06 0.6622113135173925 1.402780320075814e-06 0.6648594636266301 1.402780460561866e-06 0.6672075432495704 1.402780604291994e-06 0.6695987751186935 \
1.402780737338985e-06 0.6718055529208897 1.402780879311128e-06 0.6741523780906628 1.402780999371661e-06 0.6761293215200647 1.402781144309748e-06 0.6785098354674278 \
1.402781260306798e-06 0.6804095298668216 1.402781379886685e-06 0.6823647593763783 1.40278147884666e-06 0.68397755359623 1.402781597355078e-06 0.6859039329668146 \
1.40278168439936e-06 0.6873150904607619 1.402781806410179e-06 0.6892866586554622 1.402781905332791e-06 0.6908817703737582 1.402781997228166e-06 0.6923536807698466 \
1.402782097196705e-06 0.6939486118486815 1.402782195442366e-06 0.6955126686751646 1.402782287156128e-06 0.6969676095571918 1.40278239128907e-06 0.698613189139943 \
1.402782527015812e-06 0.7007470979739818 1.402782681624274e-06 0.7031613517373301 1.402782816731986e-06 0.7052558942641604 1.402782963068532e-06 0.7075085519458914 \
1.402783091536073e-06 0.7094732734147607 1.402783215720207e-06 0.7113609898537658 1.402783325624507e-06 0.7130225953369277 1.402783442207576e-06 0.7147759898693785 \
1.402783542385407e-06 0.7162749667021007 1.402783679474215e-06 0.7183149847558421 1.402783799463242e-06 0.7200901405411056 1.40278391857669e-06 0.7218426783097279 \
1.402784045072077e-06 0.723693513465353 1.402784170939449e-06 0.7255245570057045 1.402784293560467e-06 0.7272980597885179 1.402784421177991e-06 0.7291334326655684 \
1.402784551426783e-06 0.7309957624152177 1.402784673019733e-06 0.73272442801297 1.402784811788425e-06 0.7346853525547948 1.402784912196869e-06 0.7360963845229137 \
1.402785015584257e-06 0.7375412410987998 1.4027851092447e-06 0.7388443755773992 1.402785220866296e-06 0.7403895158541485 1.402785307334899e-06 0.7415798421827293 \
1.40278540819801e-06 0.7429609798983192 1.402785540294732e-06 0.7447573558536402 1.402785649496034e-06 0.7462323422761349 1.402785754027664e-06 0.747635567415085 \
1.402785877674144e-06 0.7492836897664436 1.40278602637058e-06 0.7512497161812216 1.402786148251239e-06 0.7528480713857697 1.402786261855803e-06 0.7543274008692354 \
1.402786402375488e-06 0.7561429069656862 1.40278654356493e-06 0.7579511824827749 1.402786661311106e-06 0.7594470562859095 1.402786790000766e-06 0.7610693809796742 \
1.402786932555413e-06 0.7628512182523866 1.402787048411964e-06 0.7642872416835913 1.40278719417523e-06 0.7660789429779771 1.402787316007677e-06 0.7675637574673733 \
1.402787434476374e-06 0.7689965471136999 1.402787557264006e-06 0.7704700089613156 1.402787683416888e-06 0.7719718272910862 1.402787793785939e-06 0.7732757954107932 \
1.402787919217035e-06 0.7747465774777432 1.402788024698746e-06 0.775974259539018 1.402788157865176e-06 0.7775122819577122 1.402788280546631e-06 0.7789173428708996 \
1.402788415309674e-06 0.7804473432620218 1.402788525980962e-06 0.7816923373676121 1.402788635302591e-06 0.7829118427552927 1.402788770435025e-06 0.7844048889494442 \
1.40278892121405e-06 0.7860523747618094 1.402789061582958e-06 0.7875692293014268 1.402789181294483e-06 0.7888502570533434 1.402789319548823e-06 0.7903153082715967 \
1.402789442919159e-06 0.7916096503654788 1.402789588017784e-06 0.7931164937536124 1.402789727758043e-06 0.7945521172774316 1.402789854939466e-06 0.7958455533278409 \
1.40278997397922e-06 0.7970449251022731 1.402790086337411e-06 0.7981670522831598 1.40279019056619e-06 0.79919939674296 1.402790285905002e-06 0.8001364844871954 \
1.402790422193112e-06 0.8014634245741865 1.402790539085656e-06 0.8025894467082511 1.402790658725145e-06 0.8037305025474466 1.402790780606717e-06 0.8048811831579785 \
1.402790902985054e-06 0.8060245537852575 1.402791031013733e-06 0.8072081965553952 1.402791155658532e-06 0.8083483262222385 1.402791286157279e-06 0.8095291977395493 \
1.402791412617707e-06 0.8106611567088965 1.402791539743674e-06 0.8117869190804841 1.402791644861151e-06 0.8127087429624065 1.40279175011134e-06 0.8136235164943317 \
1.40279184125159e-06 0.8144090748259969 1.402791964669625e-06 0.8154632009865571 1.402792051748274e-06 0.8162003374872545 1.402792151070959e-06 0.8170344894488412 \
1.402792295992703e-06 0.8182390501293432 1.402792432261206e-06 0.8193582434421302 1.402792541723485e-06 0.8202477434185359 1.402792687843586e-06 0.8214214001843773 \
1.402792839202198e-06 0.8226208465286928 1.40279296500612e-06 0.8236052915965452 1.402793109416779e-06 0.824721541823094 1.402793234017729e-06 0.8256729463037898 \
1.402793384729791e-06 0.8268094083523665 1.40279352010105e-06 0.8278169867326588 1.402793645303979e-06 0.8287379047458127 1.402793762973362e-06 0.829593908450195 \
1.402793908801339e-06 0.8306418458276996 1.40279407529732e-06 0.8318207857986918 1.402794206154408e-06 0.8327345044534114 1.402794379603848e-06 0.833928356718921 \
1.402794547722322e-06 0.8350667646575466 1.402794717596124e-06 0.8361988603660855 1.402794898450754e-06 0.8373843006762304 1.402795041633135e-06 0.8383085120571983 \
1.402795155746479e-06 0.8390361588138326 1.402795285812469e-06 0.8398559950134801 1.402795387687705e-06 0.8404909448220066 1.402795504566998e-06 0.8412116130393378 \
1.402795641678929e-06 0.8420465258793415 1.402795839559572e-06 0.843231707656198 1.402796031345765e-06 0.8443585547012582 1.402796240708828e-06 0.8455646258450146 \
1.402796422822406e-06 0.846593677725298 1.402796619917178e-06 0.8476867969181797 1.402796793185875e-06 0.8486305714188691 1.402796976264561e-06 0.8496104335327738 \
1.402797147401587e-06 0.8505103231661706 1.402797322080438e-06 0.8514128411730317 1.402797497318728e-06 0.8523022053693007 1.402797673458367e-06 0.8531802340241421 \
1.402797863809624e-06 0.8541115036082744 1.40279805438677e-06 0.855025905954957 1.402798254818193e-06 0.8559685891497206 1.402798447410669e-06 0.8568563992305701 \
1.402798658273806e-06 0.8578086227668252 1.402798886187182e-06 0.8588150784816577 1.402799152217719e-06 0.8599606428795262 1.402799450738801e-06 0.8612090806949765 \
1.402799726692481e-06 0.8623286542354505 1.402800010954596e-06 0.8634483918036945 1.402800285103046e-06 0.8644969441068078 1.402800557392313e-06 0.8655088801415273 \
1.402800827558089e-06 0.8664846790737442 1.402801084736186e-06 0.8673881555543895 1.402801357299353e-06 0.868319368003445 1.402801633304697e-06 0.8692355072818493 \
1.402801903418629e-06 0.870106770567397 1.402802203245002e-06 0.8710447971670072 1.402802574222291e-06 0.8721640818024149 1.402802869154012e-06 0.8730224021943973 \
1.402803123432376e-06 0.873740732376842 1.402803421677207e-06 0.8745584461000401 1.402803695285219e-06 0.8752856917963749 1.402803931415444e-06 0.8758961959341748 \
1.402804171760979e-06 0.8765017794770257 1.402804394097168e-06 0.8770481951318053 1.40280458810245e-06 0.8775144010549708 1.402804917823793e-06 0.8782846129827527 \
1.402805072996819e-06 0.8786376896881318 1.402805390752408e-06 0.8793424631377607 1.402805569616983e-06 0.8797286397841958 1.402805912078462e-06 0.8804474051285093 \
1.402806096217817e-06 0.880822800830328 1.402806571118475e-06 0.881756283451624 1.402806738513154e-06 0.8820737784441692 1.4028072043462e-06 0.8829272622221894 \
1.402807385170493e-06 0.8832470363605239 1.402807879204793e-06 0.8840891816604841 1.402808020548669e-06 0.8843218944112644 1.402808626940586e-06 0.8852805359894154 \
1.402808779011766e-06 0.8855111592597558 1.402809425691436e-06 0.8864506941541785 1.402809553987642e-06 0.8866295550025313 1.402810202164815e-06 0.8874976172723908 \
1.402810331923675e-06 0.8876644392549727 1.402811100144497e-06 0.8886037370453904 1.402811229881009e-06 0.8887539063021698 1.402812083306654e-06 0.8896836309705964 \
1.402812226565087e-06 0.8898301468060963 1.402813212785821e-06 0.890764641901611 1.402813434267227e-06 0.8909571971396437 1.402814577308627e-06 0.8918770673440963 \
1.402814707298116e-06 0.8919774876506176 1.402816058923388e-06 0.8929731820841386 1.40281620928357e-06 0.89307657739048 1.402817689916169e-06 0.8939986636922405 \
1.402817928817934e-06 0.8941315911431026 1.402819693311632e-06 0.894999985510941 1.402820000994978e-06 0.8951330875684044 1.402822522266181e-06 0.8960612226716312 \
1.402822959317422e-06 0.8961978289811912 1.402826862729643e-06 0.8971619289239613 1.40282710951145e-06 0.8972094058147089 1.402834686001284e-06 0.8981998139535015 \
1.402834801913031e-06 0.8982099955090975 1.402853900445735e-06 0.8992062631372056 1.402854297888509e-06 0.8992194728667773 1.40300471332359e-06 0.9002121614362558 \
1.403004979381947e-06 0.9002436812458944 1.403010247532015e-06 0.8993470931706574 1.403010453902932e-06 0.899191170936528 1.403011932015742e-06 0.8982046351054961 \
1.403012112466398e-06 0.8981003355419954 1.403014334948061e-06 0.8971299612768925 1.403014541040575e-06 0.897079983173831 1.403024949306681e-06 0.8980580240048047 \
1.403025087164257e-06 0.8980839755683444 1.403031884513298e-06 0.8990685088718567 1.403032070084766e-06 0.8990874390200084 1.403528299258968e-06 0.9000706848616691 \
1.403528359054814e-06 0.9000975977971888 1.403529612605432e-06 0.9010828413531861 1.403529718298035e-06 0.9012097231395001 1.403530376428752e-06 0.9021613947651476 \
1.403530513611021e-06 0.9023918767045529 1.403531036637641e-06 0.9033649777562528 1.403531099501233e-06 0.9034908765919824 1.403531572096782e-06 0.904476514442582 \
1.403531623410595e-06 0.9045863669199017 1.403532089373931e-06 0.9055619780118375 1.403532121578392e-06 0.9056252631670594 1.403532838677129e-06 0.9066212416280413 \
1.403532923113402e-06 0.9066528951765993 1.403533523179781e-06 0.9059679814895146 1.403533643037393e-06 0.9055903401525059 1.403533774200172e-06 0.9050640446667092 \
1.403533909019925e-06 0.9043926011431642 1.403534057154984e-06 0.9034897747335404 1.403534194714335e-06 0.902493211317788 1.403534334926095e-06 0.9013135799985507 \
1.403534433588205e-06 0.9003872218501816 1.403534519272014e-06 0.8995148096066522 1.403534601836213e-06 0.8986166894493001 1.403534716618842e-06 0.8972773101170661 \
1.403534797717086e-06 0.8962642459447687 1.403534877134364e-06 0.8952218112132616 1.403534982588891e-06 0.8937633947192651 1.403535105230195e-06 0.8919606744930825 \
1.403535204954274e-06 0.890414036797163 1.403535375148685e-06 0.8876203405523397 1.403535521333776e-06 0.8850727273800474 1.403535689551925e-06 0.8819879035815887 \
1.403535861713021e-06 0.8786780617039783 1.403536046099114e-06 0.8749807502679057 1.403536230665458e-06 0.8711418063496947 1.403536414912943e-06 0.8671917613865908 \
1.403536600248607e-06 0.8631174608718694 1.403536774636335e-06 0.8592060069639053 1.403536957340271e-06 0.8550405244181323 1.403537132687366e-06 0.8509893565349284 \
1.403537315016877e-06 0.8467313026054767 1.403537505330306e-06 0.8422468264612591 1.403537675660435e-06 0.838204894125699 1.403537842184073e-06 0.8342320488410089 \
1.403538004754937e-06 0.830337741667393 1.40353815461616e-06 0.8267359097041467 1.403538305792179e-06 0.8230937075736249 1.403538494937653e-06 0.8185270080344306 \
1.403538640655707e-06 0.8150026134285653 1.403538815646674e-06 0.8107652770601156 1.403538964118217e-06 0.807166938184282 1.403539136005683e-06 0.8029987283123258 \
1.403539305073922e-06 0.7988973224349885 1.403539469252632e-06 0.7949140139776875 1.403539628580169e-06 0.7910485911592836 1.403539789029776e-06 0.7871568543472617 \
1.403539990849157e-06 0.7822630953020117 1.403540139296892e-06 0.7786646206504594 1.403540293464276e-06 0.77492821376164 1.403540430547636e-06 0.7716074476660475 \
1.403540539933082e-06 0.7689587163513494 1.403540645866538e-06 0.7663946531324515 1.403540772880885e-06 0.7633217481666642 1.403540887243854e-06 0.7605561828888391 \
1.403540990091676e-06 0.7580702160470256 1.403541111681992e-06 0.7551325442760125 1.403541222459267e-06 0.7524575925939972 1.403541339308092e-06 0.7496376180588871 \
1.403541450092818e-06 0.7469652567786068 1.403541568458919e-06 0.7441116745915923 1.403541693286014e-06 0.7411038668912771 1.40354184584781e-06 0.7374292753756717 \
1.403541979744798e-06 0.7342062928952946 1.403542100776237e-06 0.7312947572377408 1.403542264973752e-06 0.7273475399259534 1.403542442334699e-06 0.7230877912371642 \
1.403542624545107e-06 0.7187161681757385 1.403542805542372e-06 0.7143786395952922 1.403542986206316e-06 0.7100537072471783 1.403543176357883e-06 0.7055071781827296 \
1.403543364117777e-06 0.7010230964996226 1.403543564650881e-06 0.696237807975249 1.403543773336343e-06 0.6912646166759551 1.403543980979908e-06 0.6863227581165517 \
1.403544208547776e-06 0.6809140411171237 1.40354440082261e-06 0.6763521085712711 1.403544638087858e-06 0.6707310800019505 1.403544831366122e-06 0.6661595641347996 \
1.403545064098868e-06 0.6606646229758047 1.403545269656336e-06 0.6558174602470968 1.403545502009757e-06 0.6503484594495911 1.403545697011727e-06 0.6457674053103037 \
1.403545900240336e-06 0.6410004262200759 1.403546080092881e-06 0.6367906205544323 1.403546259199312e-06 0.6326052789263827 1.403546422576526e-06 0.628795088826817 \
1.40354659462593e-06 0.6247880828503264 1.403546758118769e-06 0.6209892715878097 1.403546933908587e-06 0.6169100951581823 1.403547115847573e-06 0.6126978430086294 \
1.403547304331305e-06 0.6083422542008314 1.403547510763727e-06 0.6035858951323969 1.403547690078389e-06 0.5994633272559844 1.403547887257256e-06 0.5949432360761027 \
1.403548096345397e-06 0.5901646611556908 1.40354830209466e-06 0.5854760387944159 1.403548542605348e-06 0.5800160304866983 1.403548715733449e-06 0.5760958285528379 \
1.403548880627452e-06 0.5723746772837877 1.403549061488026e-06 0.5683014035092815 1.403549218774123e-06 0.5647722902613652 1.403549387756918e-06 0.5609879409349005 \
1.403549567863379e-06 0.5569709657351898 1.403549720846506e-06 0.5535669615732179 1.403549852560951e-06 0.5506462283231492 1.403549999948651e-06 0.5473865746199473 \
1.403550087374242e-06 0.5454560063082221 1.403550172245481e-06 0.5435860258811447 1.403550270874694e-06 0.5414171943998213 1.403550342966855e-06 0.5398340751058975 \
1.403550440057874e-06 0.5377039800781129 1.403550525648258e-06 0.5358302678688993 1.403550590729134e-06 0.5344081412607664 1.403550714329502e-06 0.5317121235594142 \
1.403550808753772e-06 0.52965475734789 1.403550906276994e-06 0.5275349985745696 1.403551079137645e-06 0.5237893654184622 1.403551214133166e-06 0.5208709659121862 \
1.403551368316627e-06 0.5175498113398643 1.403551542781984e-06 0.5138002600288881 1.40355169458797e-06 0.510550000123414 1.403551840818953e-06 0.5074290310664136 \
1.403551984717826e-06 0.5043644611166801 1.403552127739669e-06 0.5013276181140283 1.403552223349517e-06 0.499301733014788 1.403552317793473e-06 0.4973032961550828 \
1.403552438849414e-06 0.4947494705229025 1.40355253372771e-06 0.4927525559781179 1.403552649558553e-06 0.4903172469328811 1.403552736822402e-06 0.4884854516151125 \
1.403552819252848e-06 0.4867593351188191 1.403552914660801e-06 0.484765406725184 1.403553015371081e-06 0.4826639978995959 1.403553112231473e-06 0.4806459052877932 \
1.403553250961224e-06 0.4777646955734051 1.403553386666086e-06 0.4749532752442271 1.403553587150809e-06 0.4708139964547478 1.403553802464962e-06 0.4663911383470885 \
1.403553984040267e-06 0.462674698484628 1.403554183012236e-06 0.4586189944293299 1.403554353577757e-06 0.455154096457448 1.403554527931445e-06 0.4516251957269069 \
1.403554696864699e-06 0.4482170126441485 1.40355486946186e-06 0.4447467276163349 1.40355505206819e-06 0.4410867902598327 1.403555240617055e-06 0.4373240875354826 \
1.403555434084593e-06 0.4334777823509549 1.403555642405232e-06 0.4293535036700135 1.403555856750462e-06 0.4251286740881063 1.403556082455792e-06 0.4207018662297695 \
1.40355630899916e-06 0.4162771402745992 1.403556571175911e-06 0.4111844468197049 1.403556820209735e-06 0.4063709766754009 1.403557121308432e-06 0.4005865607947761 \
1.40355741072925e-06 0.3950673729298416 1.403557718243529e-06 0.3892455819062323 1.403558040439924e-06 0.3831936848847286 1.403558368170407e-06 0.3770882112794804 \
1.403558700600163e-06 0.3709500980558715 1.40355903032917e-06 0.3649083177186754 1.403559351558758e-06 0.3590729273462687 1.403559682375082e-06 0.3531219177045733 \
1.403560024730645e-06 0.3470224718704957 1.403560324371677e-06 0.3417374346434491 1.403560654159242e-06 0.3359723367088904 1.403560981053185e-06 0.3303128110141857 \
1.403561319032532e-06 0.3245206193888226 1.403561628003696e-06 0.3192755432624759 1.403561952801668e-06 0.31382336954194 1.403562268431866e-06 0.3085864885517507 \
1.403562573419032e-06 0.3035810258414895 1.403562828757677e-06 0.2994330834535801 1.403563093620834e-06 0.295170851203172 1.403563380703519e-06 0.2905978071194348 \
1.403563603673297e-06 0.2870801635277143 1.403563803212566e-06 0.2839591363066187 1.403564012868579e-06 0.2807045410859125 1.403564193125121e-06 0.2779290029372279 \
1.403564355469842e-06 0.2754463208250681 1.403564505904816e-06 0.2731629026725527 1.403564656910124e-06 0.2708866524077067 1.403564853800715e-06 0.2679392949564011 \
1.403564984945479e-06 0.2659970646012914 1.403565109682017e-06 0.2641561221543183 1.40356526127406e-06 0.2619266655689588 1.403565357242231e-06 0.2605306204207966 \
1.403565453793599e-06 0.2591282589302421 1.403565578413389e-06 0.2573209601776467 1.403565720989923e-06 0.255257422470362 1.403565879923458e-06 0.25296979123958 \
1.403566012589525e-06 0.251062957019046 1.403566196158294e-06 0.2484301322588876 1.40356637739346e-06 0.2458327969660818 1.403566588907564e-06 0.2428051031600066 \
1.403566791497399e-06 0.2399069804317323 1.403566958053847e-06 0.2375282895552967 1.403567168273059e-06 0.2345337828133105 1.403567341690945e-06 0.2320692345528927 \
1.403567570533673e-06 0.2288260787734411 1.403567791168424e-06 0.2257162440502939 1.403567966830137e-06 0.2232503232699662 1.403568147290643e-06 0.2207258962977968 \
1.403568318047021e-06 0.2183528725291195 1.403568498243287e-06 0.2158619697278009 1.403568664973905e-06 0.2135675266585953 1.403568814095326e-06 0.2115251542210239 \
1.403568969905344e-06 0.2094125291275523 1.403569105085769e-06 0.2075875692769576 1.403569255167196e-06 0.2055694209972212 1.403569387612823e-06 0.2037957203154137 \
1.403569528157359e-06 0.2019220745191926 1.403569645226124e-06 0.2003748851744883 1.40356977493373e-06 0.1986681706274326 1.403569896991199e-06 0.1970700654731777 \
1.403570019534635e-06 0.1954731161836187 1.403570137553958e-06 0.1939418157697267 1.403570272576731e-06 0.1921981789937757 1.403570417201182e-06 0.1903420634523806 \
1.403570545551681e-06 0.1887049708672087 1.403570669186156e-06 0.1871351133418249 1.403570766736279e-06 0.1859021016257166 1.403570881809208e-06 0.1844539912642748 \
1.403570975507888e-06 0.1832809848801438 1.403571074292012e-06 0.1820493959460708 1.403571197226553e-06 0.1805230483556907 1.403571292980556e-06 0.1793400249325384 \
1.403571422068107e-06 0.177753298391591 1.403571524533477e-06 0.1764993061988986 1.403571622786974e-06 0.1753029542432101 1.403571742874186e-06 0.1738483570896001 \
1.403571845423405e-06 0.1726127298531683 1.403571955881064e-06 0.1712877101305652 1.403572084370928e-06 0.1697552709290656 1.403572175855769e-06 0.1686698090598139 \
1.403572280340358e-06 0.1674358120019214 1.403572355277094e-06 0.1665544493622226 1.403572444845591e-06 0.1655049734124585 1.4035724954106e-06 0.164914347906921 \
1.403572545388976e-06 0.1643318187475747 1.403572610358061e-06 0.163576534137217 1.403572645872028e-06 0.1631646263336159 1.403572718071202e-06 0.162329174921529 \
1.403572785200297e-06 0.1615546732967998 1.403572844430032e-06 0.160873195114598 1.40357288817563e-06 0.1603710314414745 1.403572935822458e-06 0.1598254649913795 \
1.403573006202993e-06 0.1590230739426561 1.403573088541159e-06 0.1580883269013631 1.403573166712759e-06 0.1572048664554128 1.403573248765708e-06 0.1562816770844126 \
1.403573341469331e-06 0.1552436243401225 1.403573464249494e-06 0.153877370231325 1.403573563395588e-06 0.1527810927807017 1.403573664895935e-06 0.1516651170047695 \
1.403573766171126e-06 0.1505582666538253 1.40357386266291e-06 0.1495093242781697 1.403573962080945e-06 0.1484346886615803 1.403574046381569e-06 0.1475281828465028 \
1.403574139320259e-06 0.1465342051547719 1.4035742219212e-06 0.1456551508734999 1.403574330687285e-06 0.1445034822456445 1.403574436330265e-06 0.1433917535370727 \
1.403574517989854e-06 0.1425365900703354 1.403574611735024e-06 0.1415598856352903 1.403574705302971e-06 0.1405903867550886 1.403574788187462e-06 0.139735765814107 \
1.403574876346636e-06 0.1388313836440244 1.403574956132722e-06 0.1380170907865772 1.403575049728122e-06 0.1370669869522621 1.403575139660646e-06 0.1361590166429519 \
1.403575210211042e-06 0.1354501541392388 1.403575279971219e-06 0.1347521119166949 1.403575394120126e-06 0.1336164586193709 1.40357547609874e-06 0.1328058651355588 \
1.403575563704042e-06 0.1319440719770354 1.403575663205238e-06 0.1309710196939938 1.403575772385241e-06 0.1299110174488692 1.403575874550573e-06 0.1289256009328031 \
1.403575982010779e-06 0.1278959836800649 1.403576102045057e-06 0.1267549558890445 1.403576196253091e-06 0.1258657925752028 1.403576327232195e-06 0.1246390638240933 \
1.403576426659896e-06 0.1237164070883829 1.403576535781582e-06 0.1227104370444639 1.40357664463475e-06 0.1217138859540913 1.403576736944153e-06 0.120874257454373 \
1.403576849784484e-06 0.1198547128626846 1.403576946796524e-06 0.118986084968971 1.403577051062872e-06 0.1180628196869088 1.403577160029802e-06 0.1171053395831002 \
1.403577259569368e-06 0.1162371554254778 1.403577376562078e-06 0.1152245300989246 1.403577463662868e-06 0.1144761644999183 1.40357757295452e-06 0.1135478691973115 \
1.403577654479582e-06 0.1128618460838699 1.403577754254576e-06 0.1120273350449922 1.403577871679726e-06 0.1110526766231405 1.403577973464844e-06 0.1102143708571793 \
1.403578061203792e-06 0.1094962336869811 1.4035781420033e-06 0.1088432886892514 1.403578228954319e-06 0.1081456845520918 1.403578309740945e-06 0.1075007757815706 \
1.403578399947511e-06 0.1067842832273628 1.403578490898266e-06 0.1060655611559195 1.40357857956879e-06 0.1053685613006139 1.403578678583611e-06 0.1045946508745568 \
1.403578772289787e-06 0.1038723470842792 1.403578866149063e-06 0.1031520741219857 1.403578966976511e-06 0.1023817709659086 1.403579071607409e-06 0.1015861061604995 \
1.403579195570165e-06 0.1006484085638475 1.403579292969478e-06 0.09991551135558702 1.403579413227425e-06 0.09901872452754552 1.4035795240953e-06 0.09819831936474602 \
1.403579628568336e-06 0.09742874659471555 1.403579745805045e-06 0.09656937225591002 1.403579847599366e-06 0.09582695326576983 1.403579945574917e-06 0.09511577589263259 \
1.403580086079406e-06 0.09410164141823299 1.403580191157202e-06 0.09334832721827611 1.403580289770019e-06 0.09264549593674179 1.403580382484827e-06 0.09198739948435641 \
1.403580468683212e-06 0.09137785861853052 1.403580562596188e-06 0.09071637432184691 1.403580659696933e-06 0.09003559055802626 1.403580769117988e-06 0.08927317549644689 \
1.403580870101537e-06 0.08857281843916648 1.403580963759483e-06 0.08792605868920525 1.403581037934155e-06 0.08741581771673042 1.403581175834007e-06 0.08647193599618339 \
1.403581248191011e-06 0.08597917321277694 1.403581383512214e-06 0.08506274029062395 1.403581469423819e-06 0.08448410751389913 1.403581614152054e-06 0.08351486081643937 \
1.403581710382619e-06 0.0828744112740944 1.403581798218398e-06 0.08229260392026354 1.403581914017306e-06 0.08152964121883956 1.403582029145757e-06 0.08077575264951149 \
1.40358214291219e-06 0.08003553900012179 1.403582283169683e-06 0.0791300282244784 1.403582424545716e-06 0.07822490276368012 1.403582574181757e-06 0.07727536491519127 \
1.403582718670613e-06 0.07636690312463701 1.403582869844724e-06 0.07542565384097814 1.403583019215544e-06 0.07450459906593411 1.403583168562251e-06 0.0735926433331697 \
1.403583328517767e-06 0.07262574717347114 1.403583484664678e-06 0.07169171823582712 1.403583659153112e-06 0.07065947636250877 1.403583828862219e-06 0.0696671357044583 \
1.403584014041303e-06 0.0685979885997255 1.40358421076238e-06 0.06747763456279594 1.4035844212802e-06 0.06629631776014881 1.403584643312255e-06 0.06507007089066431 \
1.403584873524276e-06 0.0638195278444372 1.403585116035382e-06 0.06252626147401 1.403585376689467e-06 0.06116236403900636 1.403585656588531e-06 0.05972739422233359 \
1.403585950172255e-06 0.05825544847408989 1.403586265108239e-06 0.05671370145268265 1.403586607914164e-06 0.05507846134953124 1.403586957380758e-06 0.0534565727116736 \
1.403587366284915e-06 0.05161746230842366 1.403587712949942e-06 0.05010669351290297 1.403588100364995e-06 0.04846839895323611 1.403588444582787e-06 0.04705645202362623 \
1.403588768009047e-06 0.04576625679949029 1.403589073054809e-06 0.04458093278443617 1.403589365916806e-06 0.04347099288378908 1.403589650057723e-06 0.04242242262004604 \
1.403589926078015e-06 0.04142902112907627 1.403590192930566e-06 0.04049015932812138 1.403590461822789e-06 0.03956531631184226 1.403590737883211e-06 0.03863769040165695 \
1.403591025478782e-06 0.03769451689421055 1.403591265044408e-06 0.03692662498323904 1.403591554211835e-06 0.03602084344675294 1.403591770003438e-06 0.03535960341037672 \
1.403591957720476e-06 0.03479599077274986 1.403592155849582e-06 0.03421285035004928 1.403592518724446e-06 0.03317032497347058 1.403592776866276e-06 0.03244834222605905 \
1.40359308657919e-06 0.0316030971185694 1.403593352049328e-06 0.03089664771451467 1.403593620168408e-06 0.03019941363307669 1.403593899042439e-06 0.02949128999862272 \
1.403594145228875e-06 0.02888043298519722 1.403594375860285e-06 0.02832033800396738 1.403594614150204e-06 0.02775711540944564 1.403594849157568e-06 0.02721270742060762 \
1.403595076940031e-06 0.02669509678424227 1.403595485552303e-06 0.02579039168486155 1.403595661854632e-06 0.02540904040268441 1.403596016332316e-06 0.02465798827491217 \
1.403596200203288e-06 0.02427641469830137 1.40359653515201e-06 0.02359448510613503 1.403596699060727e-06 0.02326678168937357 1.403597091331304e-06 0.02249905491676728 \
1.403597247322069e-06 0.02220010404946675 1.403597678925426e-06 0.02138321689778962 1.403597816314806e-06 0.0211255367654138 1.403598333123589e-06 0.02017559010600388 \
1.403598458659483e-06 0.01995091418019728 1.403598915901007e-06 0.01915998482559782 1.403599075046989e-06 0.01889493739859509 1.403599682285467e-06 0.01793263500095189 \
1.403599816822955e-06 0.01772934138481063 1.403600480086948e-06 0.01678091027541291 1.403600673410379e-06 0.01651856846389665 1.403601341067039e-06 0.01565087920017967 \
1.403601502655887e-06 0.01544858341705342 1.40360225789114e-06 0.01454101846553843 1.403602407452107e-06 0.01436800730673201 1.403603297789931e-06 0.01338293844200974 \
1.403603396447817e-06 0.01327873262558703 1.403604353121314e-06 0.01230993787860994 1.403604474231021e-06 0.01219243157195396 1.40360546572373e-06 0.01126376273051215 \
1.40360562925246e-06 0.01111855113153209 1.403606759174535e-06 0.01018247077230436 1.403606871621774e-06 0.01009565848301377 1.403608249445262e-06 0.009103273453806031 \
1.403608388390533e-06 0.009009747578659758 1.403609942788868e-06 0.008018073335410726 1.40361005485534e-06 0.00794673960805117 1.40361169983817e-06 0.006958154532207958 \
1.403611807090664e-06 0.006899512253112593 1.403613751584152e-06 0.005937533026687714 1.40361395848211e-06 0.005843834961138424 1.403616297369852e-06 0.00487227039639981 \
1.403616721356264e-06 0.004712306502041247 1.40361949358946e-06 0.003780857497341114 1.403619941898552e-06 0.003647790772321777 1.403623582397237e-06 0.00272553831825111 \
1.403624079053071e-06 0.002619503085887757 1.403629830173496e-06 0.001650572925599863 1.403630116955382e-06 0.001609446887446839 1.403635471944067e-06 0.0006353228983793809 \
1.403635677300692e-06 0.0005920420449145349 1.406282712074507e-06 -0.0002718533828215428 1.40628286795011e-06 -0.0004579010352009555 1.406283416265203e-06 -0.001326296959495401 \
1.406283529048879e-06 -0.001543805653187533 1.406283963541018e-06 -0.002491429791030493 1.406284039366175e-06 -0.002673591589873599 1.406284396016773e-06 -0.003590195133438418 \
1.406284523065853e-06 -0.003936807634339821 1.406284801566247e-06 -0.004716444651655622 1.40628490965073e-06 -0.005020876868076652 1.406285253249855e-06 -0.00592430224391268 \
1.40628536024372e-06 -0.006162325733041658 1.406286259614116e-06 -0.005653094509861465 1.406286438047545e-06 -0.004687598829536962 1.40628654377096e-06 -0.003940993102967527 \
1.406286668833738e-06 -0.002883597584075996 1.406286762417834e-06 -0.001971418478057775 1.406286840257396e-06 -0.001132968824455395 1.406286920329394e-06 -0.0001977429743171 \
1.406287042702204e-06 0.001370578777960296 1.406287160958077e-06 0.003041212838230153 1.406287279607187e-06 0.004860750887681821 1.406287393089626e-06 0.006730904986417607 \
1.406287496532764e-06 0.008536402178002854 1.406287611192018e-06 0.01064190690353853 1.406287801775811e-06 0.0143607330143792 1.406287935565949e-06 0.01711819191720031 \
1.406288085819515e-06 0.02033933849841947 1.406288240988762e-06 0.02378599874269359 1.406288396380811e-06 0.0273434151175349 1.406288544088042e-06 0.03080849965087477 \
1.406288693077668e-06 0.03437359286003162 1.406288848068751e-06 0.03814545786868043 1.406289007439365e-06 0.04208062121327779 1.406289172372775e-06 0.04620305710844342 \
1.406289347319104e-06 0.0506208066052034 1.406289526449176e-06 0.05518387280380205 1.406289716238431e-06 0.06005265756871143 1.4062899199354e-06 0.06530840376289772 \
1.406290139745932e-06 0.07100650943730057 1.406290371497376e-06 0.07703584544314998 1.406290619322673e-06 0.08349927754587044 1.406290890643603e-06 0.09058756662233436 \
1.406291185356381e-06 0.09829181712822582 1.406291510614029e-06 0.106792896697727 1.406291876859735e-06 0.1163551101154179 1.406292270156448e-06 0.1266079356677421 \
1.406292722809343e-06 0.1383809089651769 1.406293248524511e-06 0.1520098384503803 1.406293867738049e-06 0.1679979965193872 1.406294548482365e-06 0.1854865650013753 \
1.40629534215732e-06 0.2057488551561759 1.406296230922953e-06 0.2282732214494322 1.406297044312215e-06 0.2487218262351868 1.406297766061792e-06 0.2667261628598245 \
1.4062984017258e-06 0.282460740414376 1.406298973442562e-06 0.2965101025186013 1.406299508996846e-06 0.3095696210007924 1.406300012355259e-06 0.3217495654069301 \
1.406300488682701e-06 0.3331878525640654 1.406300962606306e-06 0.3444754071334732 1.406301420078024e-06 0.3552759747331513 1.406301886058294e-06 0.3661792384270033 \
1.406302335046104e-06 0.376592601923634 1.406302831152645e-06 0.3879857357798637 1.406303350914508e-06 0.3998002499051578 1.406303730319152e-06 0.4083447473225827 \
1.406304170327876e-06 0.4181679450526055 1.406304640096813e-06 0.4285466970600206 1.406305125617752e-06 0.4391589006481625 1.406305565065858e-06 0.4486701556983262 \
1.406305626818807e-06 0.4500002248264944 1.406305750324704e-06 0.4526540461147197 1.406305997336497e-06 0.4579447795386873 1.406306249931409e-06 0.463325462421476 \
1.406306447502524e-06 0.467511453725808 1.406306673074271e-06 0.4722681264242033 1.406306994642268e-06 0.4790073975813253 1.406307263421496e-06 0.4846013351959894 \
1.40630748207297e-06 0.4891262574467725 1.406307692176936e-06 0.4934547887280634 1.406307918582461e-06 0.4980921872304203 1.406308127687652e-06 0.5023516957637455 \
1.406308317089911e-06 0.5061927337048852 1.406308441251129e-06 0.5086969563931187 1.406308568006226e-06 0.5112441466129884 1.406308728004704e-06 0.5144514110933732 \
1.406308975647656e-06 0.5193914248715521 1.406309154234115e-06 0.5229351592435862 1.406309325187692e-06 0.5263079149198099 1.406309586537288e-06 0.5314455197962068 \
1.40630981260887e-06 0.5358634945234868 1.406310015740537e-06 0.5398188128751134 1.406310180971267e-06 0.5430252218652345 1.406310337758288e-06 0.5460612552756139 \
1.406310526914905e-06 0.5497137532216215 1.406310728782658e-06 0.5535976061995346 1.406310952933981e-06 0.5578986282275192 1.406311191316346e-06 0.5624617013850463 \
1.406311426077985e-06 0.566941985223824 1.40631165634869e-06 0.5713275351537204 1.406311862141324e-06 0.5752375533958141 1.406312067125538e-06 0.5791255875933676 \
1.406312309940779e-06 0.5837094709690289 1.406312564698362e-06 0.588493349632063 1.406312792926793e-06 0.5927514274590796 1.406313030765665e-06 0.5971656109489694 \
1.406313243043101e-06 0.6010807441713891 1.406313454836505e-06 0.6049674646600495 1.406313708720774e-06 0.6095919957414236 1.406313913314301e-06 0.6132953190650409 \
1.406314165037654e-06 0.6178178328453598 1.406314352827174e-06 0.6211736970442716 1.406314605700251e-06 0.6256587164710262 1.406314804109613e-06 0.6291560967673944 \
1.406314983842284e-06 0.6323071487074056 1.406315254113091e-06 0.6370161336915187 1.406315471396857e-06 0.6407803561788556 1.406315651923236e-06 0.6438916924996977 \
1.406315853084131e-06 0.6473460740030906 1.406316021667512e-06 0.650231451944099 1.40631622602572e-06 0.6537144072723954 1.406316371688778e-06 0.6561873372238678 \
1.406316536247377e-06 0.6589728476742622 1.406316705716593e-06 0.6618316558839334 1.406316859256675e-06 0.664412775690417 1.406317000490202e-06 0.6667750288922751 \
1.406317144066013e-06 0.6691685747430841 1.406317277296139e-06 0.6713840140331436 1.406317419196459e-06 0.6737368819239464 1.406317539430086e-06 0.6757233098298149 \
1.406317684081138e-06 0.6781085120392751 1.406317800299843e-06 0.6800197521569988 1.406317919382163e-06 0.6819757159594566 1.406318017960477e-06 0.6835903813535821 \
1.406318135558183e-06 0.6855122399681081 1.406318222994146e-06 0.6869376986921233 1.406318347740232e-06 0.6889650632873403 1.406318447547296e-06 0.6905825000046129 \
1.406318540037093e-06 0.6920753042469043 1.406318641321177e-06 0.6937043390836264 1.406318739114283e-06 0.695273833970533 1.406318830385074e-06 0.6967333967490603 \
1.406318932842905e-06 0.6983656370917724 1.406319065752135e-06 0.7004728611232253 1.406319220767541e-06 0.7029137789397926 1.406319355649227e-06 0.7050222373350452 \
1.406319501145018e-06 0.7072806469370021 1.406319628999685e-06 0.709252249158637 1.406319753457981e-06 0.7111597484283609 1.406319864783685e-06 0.7128563623504806 \
1.406319978813713e-06 0.7145852226468989 1.40632007932493e-06 0.7161013069709498 1.406320216526077e-06 0.7181590832501857 1.406320336471979e-06 0.7199473375636642 \
1.406320455641778e-06 0.7217141075019444 1.406320582586792e-06 0.7235855504531626 1.406320707354209e-06 0.7254141264975077 1.406320830849597e-06 0.7272133847865295 \
1.40632095763087e-06 0.7290498056238117 1.406321088220355e-06 0.730930225429108 1.406321210432258e-06 0.7326797786847141 1.406321347490271e-06 0.7346298644824388 \
1.406321448705626e-06 0.7360619656663578 1.406321553674562e-06 0.7375401619041119 1.406321645165995e-06 0.7388229997694907 1.406321758241356e-06 0.7404001534680551 \
1.40632184554224e-06 0.7416107338190071 1.406321950005571e-06 0.7430512000342341 1.406322080768703e-06 0.7448411286358657 1.4063221906822e-06 0.7463352048609909 \
1.406322295341958e-06 0.7477488743938407 1.40632241917362e-06 0.7494094725133206 1.406322567926971e-06 0.751387874302702 1.406322689842132e-06 0.7529958494242643 \
1.406322803696392e-06 0.7544867042370438 1.40632294419585e-06 0.7563117925204224 1.406323085519364e-06 0.7581313010100689 1.406323203298971e-06 0.7596352654099263 \
1.406323331697459e-06 0.7612620174900669 1.406323474021161e-06 0.7630496612437514 1.406323590410315e-06 0.7644991888858087 1.406323736133977e-06 0.7662987831554334 \
1.406323857913867e-06 0.7677897310961733 1.406323976478797e-06 0.7692300520321635 1.406324099092246e-06 0.7707078417740018 1.406324225543629e-06 0.77221964326554 \
1.406324335666584e-06 0.7735261258099556 1.406324461188726e-06 0.7750039859681491 1.406324566849672e-06 0.7762386743660952 1.406324702026829e-06 0.7778058706872942 \
1.406324825637345e-06 0.7792267957652825 1.406324955634725e-06 0.7807078764205345 1.406325068606223e-06 0.7819831642610904 1.406325176500111e-06 0.7831908181350914 \
1.406325313030793e-06 0.7847046126527283 1.406325463151702e-06 0.7863508260127218 1.406325605416006e-06 0.7878933964149381 1.406325724997519e-06 0.7891771019825847 \
1.406325861808649e-06 0.7906313890246753 1.406325984312413e-06 0.7919206245676671 1.406326128984341e-06 0.7934276941869095 1.406326269769414e-06 0.794878360380241 \
1.406326396585209e-06 0.796171745508174 1.406326515632602e-06 0.7973744708066829 1.406326627895563e-06 0.7984986270115709 1.406326732283333e-06 0.7995352562746869 \
1.406326827560395e-06 0.8004739840425704 1.406326963902891e-06 0.8018044219089175 1.40632708076796e-06 0.8029326473252685 1.406327200364489e-06 0.8040757482679398 \
1.406327322250299e-06 0.8052288531124292 1.406327444838559e-06 0.8063765489401953 1.406327572579618e-06 0.8075599074701925 1.406327697362526e-06 0.8087035441861687 \
1.4063278278629e-06 0.8098867241643505 1.406327954229597e-06 0.8110199871086299 1.406328081578389e-06 0.8121498004723215 1.406328186791179e-06 0.8130740322933268 \
1.406328291495184e-06 0.8139855427426806 1.40632838302539e-06 0.8147757515715357 1.40632850639836e-06 0.8158311616195392 1.406328593352408e-06 0.8165684017534872 \
1.406328692208245e-06 0.8173999442793862 1.406328836710884e-06 0.8186029267949408 1.406328973036573e-06 0.8197243345631372 1.406329082445008e-06 0.8206145128367788 \
1.406329228461948e-06 0.821788834531623 1.406329380203007e-06 0.8229927727264784 1.406329506119585e-06 0.8239792970156907 1.406329650568649e-06 0.8250971468990039 \
1.406329775264817e-06 0.8260503472050121 1.406329925878834e-06 0.8271873005969326 1.406330061249302e-06 0.8281959289694237 1.406330186472937e-06 0.8291179217777711 \
1.406330304128897e-06 0.8299746468143927 1.40633044991051e-06 0.8310230722388168 1.40633061639426e-06 0.8322027532553667 1.406330747215023e-06 0.8331167337813133 \
1.406330920675045e-06 0.834311196379941 1.406331088787841e-06 0.8354501125721271 1.406331258668969e-06 0.8365827385393307 1.406331439512628e-06 0.8377685497174457 \
1.406331582704692e-06 0.8386931238161603 1.406331696822189e-06 0.8394210074154138 1.406331826873799e-06 0.8402408682651782 1.406331928753516e-06 0.8408758513273116 \
1.406332045641139e-06 0.841596551294542 1.406332182786859e-06 0.8424315815669623 1.406332380696072e-06 0.8436167827761205 1.406332572515411e-06 0.8447436440637145 \
1.406332781866157e-06 0.8459494874145237 1.406332964017768e-06 0.8469786287449077 1.40633316110399e-06 0.8480715276019779 1.406333334356719e-06 0.8490148531186206 \
1.406333517450963e-06 0.8499943787178993 1.40633368858243e-06 0.8508936588199895 1.406333863270272e-06 0.8517955326875627 1.406334038504287e-06 0.8526841769874772 \
1.406334214641154e-06 0.8535614892404448 1.406334405008494e-06 0.8544920815553035 1.406334595580845e-06 0.8554057038167108 1.406334795976838e-06 0.8563474066245403 \
1.406334988566463e-06 0.8572344253714166 1.406335199466375e-06 0.858185963363946 1.406335427341862e-06 0.8591913103610016 1.406335693424718e-06 0.8603357477151101 \
1.406335991926854e-06 0.8615822374427254 1.406336267816323e-06 0.8627000332972231 1.406336552083492e-06 0.8638181192989086 1.406336826221443e-06 0.8648650323418529 \
1.406337098522366e-06 0.8658754039994767 1.406337368678562e-06 0.8668495780678541 1.406337625862699e-06 0.8677515347235455 1.406337898421613e-06 0.8686810999091764 \
1.406338174469331e-06 0.8695957110915412 1.406338444589598e-06 0.8704649939918846 1.406338744449489e-06 0.8714007440816277 1.406339115430114e-06 0.8725171209518352 \
1.406339410352536e-06 0.8733732402027278 1.406339664628271e-06 0.8740897163373675 1.406339962841735e-06 0.8749052413925265 1.406340236411346e-06 0.8756305047096297 \
1.406340472534748e-06 0.8762394088953867 1.406340712859886e-06 0.8768433401198644 1.406340935193821e-06 0.8773882060838187 1.406341129200254e-06 0.8778530214284207 \
1.406341458909681e-06 0.8786208714695904 1.40634161408109e-06 0.87897283049042 1.406341931723491e-06 0.8796750328643211 1.406342110604035e-06 0.8800599154915705 \
1.406342453064798e-06 0.8807759898408113 1.40634263726721e-06 0.8811501695110489 1.406343112296513e-06 0.8820806183873429 1.406343279683462e-06 0.8823969901232691 \
1.406343745459843e-06 0.8832471741583867 1.406343926299187e-06 0.8835657112976044 1.406344420308805e-06 0.8844044135654346 1.406344561623711e-06 0.8846360992458032 \
1.406345167867326e-06 0.8855901496945974 1.406345319942526e-06 0.8858196526512701 1.406345966662599e-06 0.8867549368993356 1.406346094949266e-06 0.8869330782847171 \
1.406346743158686e-06 0.8877977435561634 1.406346872882985e-06 0.8879638504720397 1.406347641302052e-06 0.8888993076310558 1.406347771073903e-06 0.8890488273083775 \
1.406348624736509e-06 0.8899738047157748 1.406348767761561e-06 0.8901192131187072 1.406349754067048e-06 0.8910487927319016 1.4063499755536e-06 0.8912403904783051 \
1.406351118378138e-06 0.8921548233216382 1.406351248258076e-06 0.8922544308366913 1.406352600758498e-06 0.8932425879319322 1.406352751041431e-06 0.8933452769452155 \
1.406354231575697e-06 0.8942627870546499 1.406354470485492e-06 0.8943950258099049 1.406356252518433e-06 0.8952625983306248 1.40635663826586e-06 0.895426813549116 \
1.406359040424079e-06 0.8963023915260389 1.406359515360048e-06 0.8964490046842035 1.406363433287165e-06 0.8974035634625627 1.406363903247409e-06 0.8974927205890085 \
1.406372272035387e-06 0.8984807567386782 1.406372492545714e-06 0.8984960697096243 1.406417072074293e-06 0.8994905034760702 1.406418273460191e-06 0.8995076493514624 \
1.406554083268694e-06 0.9004821828323031 1.406554262245419e-06 0.9005421539807538 1.406557707120337e-06 0.8996085030263692 1.406557879904192e-06 0.8994755022453073 \
1.406559206223899e-06 0.8985168769831137 1.406559392989208e-06 0.8983970610744239 1.406561177194233e-06 0.8974304740967198 1.406561389324515e-06 0.8973403978332656 \
1.406574730020299e-06 0.8983331062395279 1.406574843308144e-06 0.8983517458922662 1.406583546661241e-06 0.8993273409280406 1.40658409447182e-06 0.8993637478389299 \
1.407076621843715e-06 0.9003542216796759 1.407076717582566e-06 0.9004233209197793 1.407077660131942e-06 0.9014023545001312 1.407077822585254e-06 0.9016297223302431 \
1.4070783892915e-06 0.9025464066367429 1.407078496462212e-06 0.9027401250447874 1.407078889770564e-06 0.9035002370985188 1.407079022567928e-06 0.9037710185404622 \
1.407079402169034e-06 0.9045728679206633 1.40707953238378e-06 0.9048512534150681 1.407079993790073e-06 0.9057878278182891 1.407080113037131e-06 0.9060008176934132 \
1.407081542646165e-06 0.9050557440230738 1.407081626316292e-06 0.9046580283931719 1.407081751622122e-06 0.9039622140338933 1.40708185943629e-06 0.9032622438705011 \
1.407081978430637e-06 0.9023800387125585 1.407082093802854e-06 0.9014106868475621 1.407082183899751e-06 0.900578017289966 1.407082295347455e-06 0.8994526603282017 \
1.407082381426603e-06 0.8985125975436928 1.407082487392251e-06 0.8972736935213672 1.407082587160617e-06 0.8960214106762436 1.407082668156227e-06 0.8949470092681954 \
1.407082777804195e-06 0.8934133399212493 1.407082863391606e-06 0.8921520042367302 1.407082955514215e-06 0.8907345325087322 1.407083043733598e-06 0.8893220116766375 \
1.407083152508351e-06 0.8875100775672261 1.407083235401386e-06 0.8860780350921965 1.407083343975057e-06 0.8841400608632336 1.407083436201252e-06 0.8824412727986957 \
1.40708352082175e-06 0.8808423775446282 1.40708360666218e-06 0.8791839877465467 1.40708368587706e-06 0.8776224824828824 1.40708376196503e-06 0.8760960492665846 \
1.407083854301399e-06 0.874210837196514 1.407083914177735e-06 0.8729702140710593 1.407083971566019e-06 0.8717685933706794 1.407084033561192e-06 0.8704574090763495 \
1.407084096840043e-06 0.8691057216070059 1.407084146911381e-06 0.8680269866686803 1.407084196353533e-06 0.8669542389500936 1.40708426002324e-06 0.8655623656543436 \
1.407084335970659e-06 0.8638877358586781 1.407084384801671e-06 0.8628032002737418 1.407084433325624e-06 0.8617197496806845 1.407084509037347e-06 0.8600184098866027 \
1.407084576246125e-06 0.8584975010852487 1.407084618952631e-06 0.8575263577286506 1.407084662855204e-06 0.8565244243916033 1.407084750660351e-06 0.8545103166059256 \
1.407084813513519e-06 0.8530605771626394 1.407084872183177e-06 0.8517018597088126 1.407084908361778e-06 0.8508614974547222 1.407084943180258e-06 0.8500510151036469 \
1.407084978206243e-06 0.8492340038666518 1.407085048258213e-06 0.8475953578585981 1.407085096728698e-06 0.8464581214772323 1.407085140673499e-06 0.8454248116355969 \
1.407085186191255e-06 0.8443523575543517 1.407085250092166e-06 0.8428433081697474 1.40708531621854e-06 0.8412777165526386 1.407085421348608e-06 0.8387809254526315 \
1.407085509283283e-06 0.8366857089760468 1.407085588228565e-06 0.834800137446173 1.407085676393602e-06 0.8326899670047023 1.407085763209599e-06 0.8306078985741704 \
1.407085851101283e-06 0.8284959280419055 1.407085942350373e-06 0.8262996967350639 1.407086045112241e-06 0.8238226494465998 1.407086143615716e-06 0.8214450402687625 \
1.407086255948631e-06 0.8187302447322098 1.407086368922768e-06 0.8159967029774419 1.407086490210663e-06 0.8130591602364435 1.407086620717817e-06 0.8098958628758253 \
1.407086749763719e-06 0.8067658935936169 1.40708690323932e-06 0.8030416153605923 1.40708706852354e-06 0.799029304640783 1.407087236264745e-06 0.7949567682299736 \
1.407087432788334e-06 0.7901857478752816 1.407087637550659e-06 0.7852160332972318 1.407087850227715e-06 0.7800563994093253 1.407088050847662e-06 0.7751902022758907 \
1.407088251706389e-06 0.7703212856706637 1.407088401728407e-06 0.766686939713112 1.407088532263574e-06 0.7635264252913375 1.407088666681014e-06 0.7602735436595947 \
1.407088772876544e-06 0.7577048602246427 1.407088906182877e-06 0.754482067181252 1.407089013215803e-06 0.7518959494812111 1.407089156291704e-06 0.7484409822837247 \
1.407089320797846e-06 0.7444713482725677 1.407089441615092e-06 0.74155777711076 1.407089612721756e-06 0.7374334100931738 1.407089773612309e-06 0.733558046396253 \
1.40708999020493e-06 0.7283457217000903 1.407090183460631e-06 0.7236999380850822 1.407090362395765e-06 0.7194029726762079 1.407090529212387e-06 0.7154015770462002 \
1.407090715418352e-06 0.7109395231330657 1.407090903351593e-06 0.7064416825495208 1.407091069273699e-06 0.7024749886985119 1.407091261631787e-06 0.6978803202016938 \
1.407091402988682e-06 0.6945068232011449 1.407091559996444e-06 0.6907636199298515 1.407091755976089e-06 0.6860965106368763 1.407091918410194e-06 0.6822325558671515 \
1.407092079586376e-06 0.6784034260021697 1.407092271894574e-06 0.6738409413562468 1.407092489556454e-06 0.6686845685784016 1.407092737577756e-06 0.6628199086538362 \
1.407092915635219e-06 0.6586162961343578 1.407093164179028e-06 0.6527567611811057 1.407093366786271e-06 0.6479896840619462 1.407093536596938e-06 0.6440011601507294 \
1.407093695213124e-06 0.6402799599229552 1.407093833743559e-06 0.637035894415233 1.407093969951321e-06 0.6338503464729111 1.407094096262698e-06 0.6309003762865483 \
1.407094225721933e-06 0.6278810604265532 1.407094354053672e-06 0.6248911458464299 1.407094485383602e-06 0.6218374290191309 1.407094617410215e-06 0.6187713222160208 \
1.407094761570095e-06 0.6154276788919771 1.407094905778687e-06 0.6120888358645944 1.407095053433791e-06 0.6086753592300279 1.407095200490149e-06 0.6052842859263143 \
1.407095358304176e-06 0.6016504852589418 1.407095490909828e-06 0.5986039825107707 1.407095622374795e-06 0.5955897059985247 1.407095741804593e-06 0.5928552647156846 \
1.407095877873286e-06 0.5897484304797134 1.407095992801548e-06 0.5871283594046445 1.407096143912269e-06 0.5836892419704927 1.407096258561337e-06 0.5810871834776226 \
1.407096376499006e-06 0.5784138884735546 1.407096466280294e-06 0.576381560286313 1.407096556599689e-06 0.5743415774978985 1.407096623290559e-06 0.5728373329037385 \
1.407096688852372e-06 0.5713590910263378 1.407096739894496e-06 0.5702089751121119 1.407096801596215e-06 0.5688198806440578 1.407096864686071e-06 0.5674025889664359 \
1.407096929044424e-06 0.5659586381304559 1.407096982438223e-06 0.5647616504486359 1.407097075080806e-06 0.5626864159088959 1.407097151688078e-06 0.5609719030357503 \
1.40709720751314e-06 0.5597256439368602 1.407097276567267e-06 0.5581857825097393 1.407097383455392e-06 0.5558054549196561 1.407097461199017e-06 0.5540764009223496 \
1.407097562049117e-06 0.5518382286767042 1.407097687729972e-06 0.5490568313009737 1.407097787971657e-06 0.5468419758621708 1.40709789988934e-06 0.5443739014182352 \
1.407098003155247e-06 0.5421024366463116 1.407098122904589e-06 0.5394737463112931 1.407098224637469e-06 0.5372436950013484 1.407098340157213e-06 0.5347185748314579 \
1.407098455192299e-06 0.5322102907975605 1.407098581673211e-06 0.529456475824718 1.407098707047008e-06 0.5267350629320526 1.407098853862932e-06 0.5235577714138258 \
1.407098989426381e-06 0.5206304261698983 1.407099147124634e-06 0.5172373565578411 1.407099309443689e-06 0.5137528589513558 1.407099490267585e-06 0.5098871206809381 \
1.407099682715905e-06 0.5057874350093188 1.407099895621208e-06 0.5012700264709963 1.407100127802608e-06 0.4963634062180514 1.407100385093187e-06 0.4909555076455908 \
1.40710062471901e-06 0.4859407514401474 1.407100926434446e-06 0.479662588092526 1.4071012143538e-06 0.4737079198104491 1.407101527242619e-06 0.4672821326282255 \
1.407101846980824e-06 0.4607585360408045 1.407102186575984e-06 0.4538766993710576 1.407102513478483e-06 0.4472977926730654 1.407102849036864e-06 0.4405887635920606 \
1.407103166132787e-06 0.4342949501181722 1.407103500370541e-06 0.4277061431972559 1.407103851801663e-06 0.4208322784122511 1.407104166327818e-06 0.4147233751108969 \
1.407104489505308e-06 0.4084912998479469 1.407104930620066e-06 0.400057814108821 1.407105272736103e-06 0.3935812134363078 1.407105572680633e-06 0.3879522399691127 \
1.407105947811638e-06 0.3809760137481454 1.407106277555877e-06 0.3749002425561211 1.407106560798803e-06 0.3697269896098562 1.407106860945059e-06 0.3642865787664632 \
1.407107140547253e-06 0.3592589179584539 1.407107364323365e-06 0.3552676761685443 1.407107576103695e-06 0.3515151294490645 1.407107778537159e-06 0.3479514629380864 \
1.407107979628427e-06 0.3444362246481504 1.407108185342845e-06 0.3408632458568372 1.407108452965717e-06 0.3362478643926977 1.407108691897011e-06 0.3321601360780691 \
1.407108925403074e-06 0.3281974319442653 1.407109138868473e-06 0.3246000376975314 1.407109360246046e-06 0.3208952602338652 1.407109560209693e-06 0.3175728982722026 \
1.407109764482006e-06 0.3142073831356898 1.407109961828878e-06 0.3109812293225088 1.407110147201405e-06 0.3079732989686547 1.407110343307796e-06 0.3048147723336881 \
1.407110545584936e-06 0.3015820927993307 1.407110721243233e-06 0.2988007390096292 1.40711090711339e-06 0.295878328903569 1.407111114092782e-06 0.2926488196724605 \
1.407111299414374e-06 0.2897857719971084 1.407111494641182e-06 0.2867989994419413 1.407111650415531e-06 0.28443329608414 1.407111829172313e-06 0.2817356906084737 \
1.407112010203233e-06 0.2790344478478936 1.407112160100347e-06 0.2768142575519123 1.407112361143774e-06 0.273859574769726 1.407112510258904e-06 0.2716833853889438 \
1.407112648798333e-06 0.2696726034832688 1.407112800673409e-06 0.2674956304896134 1.407112915147537e-06 0.2658586287383957 1.407113046677468e-06 0.2639823142040156 \
1.407113172435956e-06 0.2622048582339201 1.407113276776362e-06 0.2607341604582348 1.407113389755722e-06 0.2591418073851619 1.407113506084246e-06 0.2575033437579446 \
1.407113649011667e-06 0.2554974228347739 1.407113762273172e-06 0.2539102348881249 1.407113896429905e-06 0.2520298733123076 1.40711400690271e-06 0.2504818583075984 \
1.407114162335285e-06 0.2483006006477398 1.407114303220383e-06 0.2463217957442577 1.407114454612954e-06 0.2441928603691365 1.407114609775035e-06 0.2420086586735095 \
1.407114739184283e-06 0.2401849910837116 1.407114873896376e-06 0.2382868210192302 1.407115011594201e-06 0.2363478190565156 1.407115129346217e-06 0.2346905900295477 \
1.40711528867041e-06 0.2324499447852502 1.407115425932636e-06 0.2305210708572645 1.407115566678993e-06 0.2285488733964877 1.407115672470167e-06 0.2270688194984586 \
1.407115802411564e-06 0.2252532503786337 1.407115902948028e-06 0.2238506847401111 1.407116005281736e-06 0.2224250970611539 1.407116079010317e-06 0.2214012665004395 \
1.40711615824426e-06 0.2203047212273054 1.407116229215507e-06 0.2193236206014474 1.407116280678535e-06 0.218612902325451 1.407116333626988e-06 0.2178825126218075 \
1.407116412781991e-06 0.2167921001391954 1.407116455054626e-06 0.2162104926182252 1.407116494899171e-06 0.2156628374086678 1.40711653812282e-06 0.2150692779925967 \
1.407116579029822e-06 0.2145080585354088 1.407116649152284e-06 0.2135474129702876 1.407116682837255e-06 0.2130867492099046 1.407116727666638e-06 0.212477723463 \
1.4071167865238e-06 0.2116792343136102 1.40711685130926e-06 0.2108017053965978 1.407116908790024e-06 0.2100241135398916 1.407116969219033e-06 0.209207737948094 \
1.407117066255463e-06 0.2078991976528634 1.407117150945123e-06 0.2067595417901527 1.407117259855885e-06 0.2052972881712416 1.407117356256692e-06 0.2040065614180294 \
1.407117451273329e-06 0.2027428333585779 1.407117554705127e-06 0.2013717100485363 1.407117649634473e-06 0.2001158751783069 1.407117752654899e-06 0.198757993281026 \
1.407117857737332e-06 0.1973779917312911 1.407117967046146e-06 0.1959482000350934 1.407118077489628e-06 0.1945091075764383 1.407118193779903e-06 0.1929996650696684 \
1.407118303709896e-06 0.1915811184357085 1.40711841337232e-06 0.1901717999899754 1.407118515088965e-06 0.1888694322720079 1.407118608043679e-06 0.1876837490531375 \
1.407118700772569e-06 0.1865049219968967 1.407118774458125e-06 0.1855719169757668 1.40711885729934e-06 0.1845269810791141 1.407118931885336e-06 0.1835895008849975 \
1.407119001608678e-06 0.1827150226754214 1.407119068327085e-06 0.1818808699270075 1.407119164170411e-06 0.1806871657728035 1.407119246877184e-06 0.1796611249561687 \
1.407119340441007e-06 0.1785035608809835 1.407119435337095e-06 0.1773351434884491 1.407119546707405e-06 0.1759704596301353 1.407119688349759e-06 0.1742450478777388 \
1.407119803596612e-06 0.1728486436789435 1.407119948144251e-06 0.1711076225712051 1.407120059739928e-06 0.1697708811114609 1.407120200958902e-06 0.1680898955975501 \
1.407120316696175e-06 0.1667201145354908 1.407120422656861e-06 0.1654722325850081 1.407120521416477e-06 0.164314417410061 1.40712061775965e-06 0.1631901152369615 \
1.407120706417402e-06 0.1621596955203892 1.407120831751673e-06 0.1607099933926625 1.407120926277088e-06 0.1596224416957933 1.40712102401604e-06 0.1585042187118262 \
1.407121132110917e-06 0.1572745454417887 1.407121226778605e-06 0.1562036643369483 1.407121334226451e-06 0.1549951394274829 1.407121425315495e-06 0.1539767092330788 \
1.407121532087207e-06 0.1527896463435911 1.407121635480473e-06 0.1516469620792683 1.407121746560957e-06 0.1504267727114754 1.407121835786939e-06 0.1494522115900035 \
1.407121921266868e-06 0.1485231035185812 1.407122005192055e-06 0.1476157397758405 1.407122074898619e-06 0.1468658175993407 1.407122153536697e-06 0.1460232248551682 \
1.407122231847954e-06 0.1451880611912267 1.407122302483827e-06 0.1444378248611795 1.407122387974695e-06 0.1435337156153706 1.407122475363672e-06 0.1426139614481139 \
1.407122556951186e-06 0.1417594571206545 1.407122654270137e-06 0.1407454482154784 1.407122734959659e-06 0.139910090776864 1.40712282574469e-06 0.1389752404035735 \
1.407122947088963e-06 0.1377336220260025 1.407123036138604e-06 0.13682812281983 1.407123134655454e-06 0.1358318692385875 1.407123221741723e-06 0.1349560640726983 \
1.407123332152611e-06 0.1338550874529322 1.407123420611433e-06 0.1329791517134813 1.407123521340026e-06 0.1319874611681985 1.40712362612958e-06 0.1309622419763913 \
1.407123720519813e-06 0.1300442429014473 1.407123817024605e-06 0.1291112112475518 1.407123916511258e-06 0.1281591654439075 1.407124002912429e-06 0.1273384721630967 \
1.40712409789256e-06 0.1264411177628728 1.407124202081388e-06 0.1254629331099751 1.407124311200138e-06 0.124445178694 1.407124405550594e-06 0.1235704029653004 \
1.407124517846343e-06 0.1225411084520107 1.407124613309696e-06 0.1216733466577494 1.407124717520587e-06 0.1207311846737792 1.407124806865944e-06 0.1199276649878674 \
1.407124877253217e-06 0.1192980345746366 1.407124952639251e-06 0.1186268760051257 1.407125028771421e-06 0.1179522201461119 1.407125097748918e-06 0.1173458504859956 \
1.407125180268091e-06 0.1166263596898966 1.407125252211578e-06 0.1160015972854393 1.407125334290304e-06 0.1152916772467617 1.40712541862478e-06 0.1145654108773922 \
1.407125496418619e-06 0.113898375935255 1.407125589183521e-06 0.1131065723182637 1.407125704787342e-06 0.1121254933399327 1.407125810692911e-06 0.1112341778178403 \
1.407125888349831e-06 0.1105854195321705 1.407125976646302e-06 0.1098504899494786 1.407126056703354e-06 0.1091866403929743 1.407126153629479e-06 0.1083861389179563 \
1.407126248864964e-06 0.1076031391441806 1.407126337436159e-06 0.1068780200140514 1.40712643874426e-06 0.1060523297458165 1.407126544289947e-06 0.1051963702337609 \
1.407126653484312e-06 0.1043160928234657 1.407126761601933e-06 0.1034503663302994 1.407126881519694e-06 0.1024949450012773 1.407126982881521e-06 0.1016914181115986 \
1.407127088891151e-06 0.100855068690839 1.40712721468278e-06 0.09986840123414902 1.407127344240085e-06 0.09885896724496235 1.40712747991544e-06 0.09780904711780367 \
1.407127655987304e-06 0.09645781830037269 1.407127819787824e-06 0.09521257997344186 1.407127982612565e-06 0.09398642071914091 1.4071280677512e-06 0.09334985726464029 \
1.407128137589223e-06 0.09282999162688726 1.407128207084828e-06 0.09231474740697931 1.407128281043488e-06 0.09176875214326782 1.407128377198375e-06 0.09106241641841166 \
1.407128451613741e-06 0.09051841344162129 1.407128529603309e-06 0.08995079828656057 1.407128606052139e-06 0.08939693755534793 1.407128693546224e-06 0.08876614459792892 \
1.407128795722934e-06 0.08803382885421264 1.407128884287322e-06 0.08740269463919083 1.40712899395281e-06 0.08662585268124241 1.407129110009217e-06 0.08580942306245626 \
1.407129251558034e-06 0.0848216759818637 1.407129384427017e-06 0.08390253510334872 1.407129525187328e-06 0.08293727564630923 1.407129674896948e-06 0.08192024575105315 \
1.407129810608835e-06 0.08100683753927941 1.407129952125717e-06 0.08006309454860433 1.407130087247591e-06 0.07917070961097784 1.407130228520028e-06 0.07824718349428782 \
1.40713037561292e-06 0.07729532867436953 1.407130527122786e-06 0.07632524417621221 1.4071306924985e-06 0.07527819040792309 1.40713085625969e-06 0.07425356708383206 \
1.407131032389632e-06 0.07316505371836476 1.40713122152861e-06 0.07201151367936541 1.407131432202233e-06 0.07074528708793332 1.407131651768855e-06 0.06944624562626683 \
1.407131886535262e-06 0.06808094281860989 1.4071321449277e-06 0.06660616301228137 1.40713243959236e-06 0.06496103773121734 1.407132743671683e-06 0.06330286177969326 \
1.407133104582163e-06 0.06138472526627536 1.407133440499035e-06 0.05964719353945821 1.407133880676406e-06 0.05743991201668189 1.407134259043809e-06 0.05560437501227136 \
1.407134701502771e-06 0.05352996728430704 1.407135055522916e-06 0.05192508193542229 1.407135442039672e-06 0.05022502935509546 1.407135786643729e-06 0.04875485597254389 \
1.407136108618665e-06 0.04741934964807833 1.407136412152492e-06 0.04619304551845941 1.407136707073488e-06 0.04503122626702559 1.407136989555767e-06 0.04394770877170886 \
1.407137266636177e-06 0.04291147062934708 1.407137532363668e-06 0.04194013461971725 1.407137803594355e-06 0.0409708748276704 1.407138079853372e-06 0.04000619535229137 \
1.407138369752594e-06 0.03901828782233653 1.407138598128987e-06 0.03825741181922668 1.407138903013054e-06 0.03726495139513845 1.40713911968491e-06 0.03657573971894532 \
1.407139311041637e-06 0.03597943984071691 1.407139509636156e-06 0.03537298232318693 1.407139839551497e-06 0.03438820140908775 1.40714008149717e-06 0.03368375433354889 \
1.407140396809222e-06 0.03278771666975258 1.407140666929207e-06 0.03203957074185158 1.40714092330088e-06 0.03134567005659093 1.407141203312881e-06 0.03060515313352298 \
1.407141448968657e-06 0.02997014710356035 1.407141681704302e-06 0.02938120249260199 1.407141924434299e-06 0.02878348292867495 1.407142161161563e-06 0.02821317433052753 \
1.407142389807974e-06 0.0276732289298247 1.407142807093634e-06 0.02671456010533928 1.407143002274328e-06 0.02627749693639509 1.407143383441411e-06 0.02544369227895442 \
1.407143560694233e-06 0.02506446942885681 1.407143903145688e-06 0.02434654114125227 1.40714405641412e-06 0.02403127656358269 1.407144431432584e-06 0.02327616399748992 \
1.407144569066725e-06 0.02300530455388665 1.407145053333359e-06 0.02207084195640928 1.40714517295276e-06 0.02184403312078184 1.407145589991563e-06 0.02106026682208277 \
1.407145733393791e-06 0.02079332360769017 1.407146254605172e-06 0.01984598817089831 1.407146382379043e-06 0.0196205814374062 1.407146966791417e-06 0.01863359713481367 \
1.407147139226823e-06 0.01835589372257288 1.407147743323573e-06 0.01743644241612937 1.407147904755214e-06 0.01720262545858322 1.407148544701434e-06 0.01631831686205014 \
1.4071487230176e-06 0.016083210242981 1.407149371001648e-06 0.01526127675881721 1.40714953625524e-06 0.01505930898173208 1.407150272557175e-06 0.01419381259610907 \
1.407150406833225e-06 0.01404154276213586 1.407151203932743e-06 0.01317592498067951 1.407151344530354e-06 0.01302934089458718 1.407152309873577e-06 0.0120661300044765 \
1.407152474212383e-06 0.01190857475316222 1.407153474943512e-06 0.01099048917119646 1.407153612213369e-06 0.01087009009405628 1.407154750907886e-06 0.009949273443646761 \
1.407154865085787e-06 0.009863136028526375 1.407156245730621e-06 0.008889755784408603 1.407156400087833e-06 0.00878832203975914 1.407157946582061e-06 0.00781340401000951 \
1.407158030943764e-06 0.007760176032106158 1.407159716371082e-06 0.006770348169342283 1.407159839899572e-06 0.00670487246831437 1.407161889714139e-06 0.005720970231232756 \
1.407162086114296e-06 0.005634691917282852 1.407164404793653e-06 0.004698942116576918 1.407164865407988e-06 0.004530544077955615 1.40716760550353e-06 0.003639937533647344 \
1.407168123648567e-06 0.00349159181499799 1.407172274289875e-06 0.002502201117031859 1.407172812139882e-06 0.002396807933581942 1.40717889437533e-06 0.001421603691354927 \
1.40717915335574e-06 0.001378272220758726 1.40718447611909e-06 0.0003814093765652445 1.407184589276134e-06 0.0003711807182531981 1.40983070639237e-06 -0.0004615907568095335 \
1.409830868831338e-06 -0.0006852153244161934 1.409831369832807e-06 -0.001554404032531494 1.40983145401537e-06 -0.001725199767551738 1.409831855538194e-06 -0.002626792336557519 \
1.409831944873161e-06 -0.002845673237760077 1.40983223146497e-06 -0.0035898660494722 1.409832359033499e-06 -0.003937855927128601 1.409832677745161e-06 -0.004830400105952924 \
1.409832791946313e-06 -0.00515011308870196 1.409833074346638e-06 -0.005887653497963378 1.409833204572857e-06 -0.006177415671381139 1.409834182925754e-06 -0.005220113099403402 \
1.409834370233287e-06 -0.004004368716724641 1.409834501677689e-06 -0.002901539130564616 1.409834607105242e-06 -0.001869327786897239 1.409834692822726e-06 -0.0009323217369615201 \
1.409834774749213e-06 4.151965372454519e-05 1.409834895786036e-06 0.001618129410352471 1.409834994714683e-06 0.003024565667809575 1.409835153111357e-06 0.005482561958548801 \
1.409835370558586e-06 0.00923691162542661 1.40983555178081e-06 0.0126653356758144 1.409835763874906e-06 0.01697021734206094 1.409835926898563e-06 0.02046388365739064 \
1.409836087520978e-06 0.02403759527126768 1.409836241061221e-06 0.02755862871109176 1.409836389117902e-06 0.031036270750196 1.409836538198811e-06 0.03460722192241437 \
1.409836692728722e-06 0.03837091703902212 1.409836853379538e-06 0.04234026030123839 1.409837018034219e-06 0.04645786783841532 1.409837194575117e-06 0.05091770581196236 \
1.409837373537969e-06 0.05547793877747508 1.409837564281134e-06 0.0603721650098247 1.409837769062163e-06 0.06565647483694508 1.409837989534449e-06 0.07137203566208646 \
1.409838222394174e-06 0.0774299331224613 1.40983847158165e-06 0.08392829098722057 1.409838744423777e-06 0.09105513637423955 1.409839041127577e-06 0.09880974921055499 \
1.409839368453968e-06 0.1073623706929605 1.409839738105355e-06 0.11701033799881 1.409840132977169e-06 0.1273002725707723 1.40984059081541e-06 0.1392030195235975 \
1.40984112262225e-06 0.1529832553757746 1.409841747860046e-06 0.1691182447448397 1.409842433607517e-06 0.1867241161332086 1.409843236003391e-06 0.2071957342970069 \
1.409844134802183e-06 0.2299563735557614 1.409844940415632e-06 0.2501946571168963 1.409845654166966e-06 0.2679877251922811 1.409846283728848e-06 0.2835633151515627 \
1.409846854092298e-06 0.2975737963344939 1.40984738504768e-06 0.3105173405876944 1.40984788683513e-06 0.3226580892822354 1.409848366129684e-06 0.3341673054699896 \
1.409848831685103e-06 0.3452566901045974 1.409849295481511e-06 0.3562094254686541 1.409849751229541e-06 0.3668794056881832 1.409850211449675e-06 0.3775613305945491 \
1.409850749733646e-06 0.3899285626759094 1.409851250584179e-06 0.4013172511919189 1.409851650806863e-06 0.4103337945930838 1.409852157667644e-06 0.421642452039157 \
1.409852643633856e-06 0.4323669409017459 1.409853043148568e-06 0.4410997362599856 1.409853453760627e-06 0.4500002277813482 1.40985388268706e-06 0.4592207708982954 \
1.409854284201442e-06 0.4677760623951868 1.409854591591889e-06 0.4742753916877908 1.409854941833647e-06 0.4816249679276425 1.40985529507385e-06 0.4889795533930016 \
1.40985554824443e-06 0.4942125642332652 1.40985578118832e-06 0.4989990073547648 1.409856022831611e-06 0.5039392821429431 1.409856247822229e-06 0.5085102868389438 \
1.409856439858337e-06 0.5123881070394828 1.409856624670034e-06 0.5161059569497825 1.40985684696035e-06 0.5205538992744256 1.409857013671757e-06 0.5238726938135662 \
1.409857230888352e-06 0.5281726418673847 1.409857433967244e-06 0.5321820613122353 1.409857611378699e-06 0.5356681922482178 1.409857799451086e-06 0.5393528234657015 \
1.409858035483266e-06 0.5439555888699217 1.409858301365289e-06 0.5491186112539347 1.409858523127178e-06 0.5534070305875756 1.409858803185033e-06 0.5588091140818973 \
1.409859046184818e-06 0.5634839438879177 1.409859321538161e-06 0.5687575845994758 1.409859566533501e-06 0.5734440561015828 1.40985980682772e-06 0.5780305526007354 \
1.409860047867023e-06 0.5826153106864888 1.409860305457841e-06 0.5874946531182738 1.409860540824618e-06 0.5919209497705462 1.409860772126727e-06 0.5962518282209535 \
1.409860994653448e-06 0.6003950532231523 1.409861203013056e-06 0.6042587207462122 1.40986144085487e-06 0.6086392006348278 1.409861651715085e-06 0.612499186772883 \
1.409861907322267e-06 0.617151767543529 1.409862106050033e-06 0.620751700070918 1.409862381682677e-06 0.6257066023742009 1.409862604438798e-06 0.6296824120643636 \
1.409862897809921e-06 0.6348814180513288 1.409863130579923e-06 0.6389753720667986 1.409863350781309e-06 0.6428252659334456 1.409863552051921e-06 0.6463216644290061 \
1.409863769340793e-06 0.6500784077528632 1.409863944056703e-06 0.6530842133917786 1.409864130321333e-06 0.6562672470877895 1.409864309060386e-06 0.6593113758161715 \
1.409864471764399e-06 0.6620700940033843 1.40986463703341e-06 0.6648583661366954 1.409864780301224e-06 0.6672607123132118 1.409864919531648e-06 0.669583864918244 \
1.409865059332214e-06 0.6719085596965743 1.409865194107422e-06 0.6741424479378803 1.409865321601663e-06 0.6762463034350935 1.409865454555775e-06 0.6784344250006583 \
1.409865576160125e-06 0.680430207161383 1.409865704573366e-06 0.6825336955632141 1.409865820340421e-06 0.6844241240890321 1.409865918381594e-06 0.686020684362688 \
1.4098660190777e-06 0.687656981754083 1.409866128831462e-06 0.689434454762776 1.409866245599418e-06 0.6913211166705923 1.409866336826191e-06 0.6927889453402305 \
1.409866446031605e-06 0.6945396927028351 1.409866547140326e-06 0.6961566646470493 1.409866642540618e-06 0.6976767415743361 1.409866752022642e-06 0.6994136821864276 \
1.409866886474277e-06 0.7015344809028976 1.409867035493214e-06 0.7038694457768003 1.409867164423232e-06 0.7058755144243859 1.409867311083691e-06 0.7081418729260142 \
1.409867437868072e-06 0.7100885084081828 1.409867562465961e-06 0.7119899232102255 1.409867674319728e-06 0.7136874821928206 1.409867787275692e-06 0.7153928249203609 \
1.409867887829089e-06 0.716903336497302 1.409868025110592e-06 0.7189542886859326 1.409868144979452e-06 0.7207346491296758 1.409868264162204e-06 0.7224952472954583 \
1.409868391164313e-06 0.7243608783177121 1.409868515712665e-06 0.726179956024653 1.409868639383676e-06 0.7279757435764195 1.409868765971953e-06 0.7298035010246171 \
1.409868896541188e-06 0.7316777339938921 1.409869019056222e-06 0.7334262671520465 1.409869155299713e-06 0.7353588786631546 1.409869256742486e-06 0.7367901064855561 \
1.409869362765969e-06 0.7382789144707947 1.409869453297152e-06 0.7395446819117977 1.409869567123378e-06 0.7411267287627761 1.40986965478496e-06 0.742338113895605 \
1.409869760680238e-06 0.7437932991468792 1.409869891033532e-06 0.7455718205320391 1.40987000160114e-06 0.7470699275523445 1.409870106271611e-06 0.7484790865773925 \
1.409870230233143e-06 0.7501360792234356 1.409870378790597e-06 0.752105598322839 1.409870500473193e-06 0.7537054667443914 1.409870614584882e-06 0.7551949470168074 \
1.409870755005483e-06 0.7570132059451244 1.409870896533543e-06 0.7588296197226846 1.409871014322813e-06 0.7603289862386273 1.409871142522635e-06 0.7619481626911874 \
1.409871284590468e-06 0.7637269294216019 1.409871401465576e-06 0.7651780119234867 1.409871547139362e-06 0.7669714049983392 1.409871668877809e-06 0.7684572223066155 \
1.409871787518301e-06 0.7698939375992205 1.409871909984594e-06 0.7713653733660819 1.409872036701684e-06 0.7728756341192486 1.409872146603679e-06 0.7741754302862822 \
1.409872272219022e-06 0.7756497674172792 1.409872378029431e-06 0.7768823528242577 1.409872514199553e-06 0.7784559787239111 1.409872638546601e-06 0.7798807766277074 \
1.409872765971877e-06 0.7813271999647126 1.409872880527956e-06 0.7826155184370988 1.409872987208226e-06 0.7838050786084815 1.409873125150823e-06 0.785328674235108 \
1.409873274600319e-06 0.7869612315653352 1.409873419452536e-06 0.7885256944569791 1.409873538888287e-06 0.7898026796320731 1.40987367431316e-06 0.7912364721526877 \
1.409873795807481e-06 0.7925100718437531 1.409873939166555e-06 0.7939977458315933 1.409874082600237e-06 0.7954699260458764 1.409874208411246e-06 0.7967479640295563 \
1.409874327457928e-06 0.7979459892863545 1.409874439471573e-06 0.7990632136113104 1.409874544263454e-06 0.8000996927221937 1.409874639456303e-06 0.8010335634530776 \
1.409874775866828e-06 0.8023587211299719 1.409874892679005e-06 0.8034813603122919 1.409875012140248e-06 0.8046180202255495 1.4098751341806e-06 0.8057672874017472 \
1.409875257080697e-06 0.8069126780167393 1.409875384200053e-06 0.8080849010520604 1.409875509341915e-06 0.8092265787736463 1.409875639893142e-06 0.8104047139317369 \
1.409875765969389e-06 0.811530109085512 1.409875893966049e-06 0.8126603425876329 1.409875999427297e-06 0.8135823118114501 1.409876102696598e-06 0.814477091043954 \
1.409876195349946e-06 0.8152732203909091 1.409876319044181e-06 0.8163262937528154 1.409876406664095e-06 0.8170655553659417 1.409876505330151e-06 0.8178914289762149 \
1.409876648877154e-06 0.819080619224994 1.409876784463306e-06 0.8201904093102529 1.409876893653288e-06 0.8210742465492874 1.409877041102747e-06 0.8222539401850584 \
1.409877191506449e-06 0.8234410273756358 1.409877316975412e-06 0.8244188977545531 1.409877461141395e-06 0.8255287290252299 1.40987758542996e-06 0.8264738611628292 \
1.409877735900256e-06 0.8276038147969816 1.409877871506614e-06 0.8286089145501508 1.409877996601616e-06 0.8295251220930787 1.409878114317453e-06 0.8303776282987162 \
1.409878260203052e-06 0.8314210189912619 1.409878426696148e-06 0.8325942517713072 1.409878557562851e-06 0.833503494447128 1.409878731007462e-06 0.8346911703335461 \
1.409878899140202e-06 0.8358239212093587 1.409879068993949e-06 0.8369500705213252 1.409879249886955e-06 0.838129582835239 1.409879393021216e-06 0.8390486258646698 \
1.409879507119162e-06 0.8397723391454259 1.409879637246322e-06 0.8405879656882547 1.409879739102179e-06 0.8412191375388212 1.409879855947599e-06 0.8419354178465567 \
1.409879992919396e-06 0.84276453896487 1.409880190759142e-06 0.843942473808897 1.409880382444629e-06 0.8450620046306492 1.409880591850993e-06 0.8462610422160779 \
1.409880773861877e-06 0.8472832413425977 1.409880970977333e-06 0.8483697584184032 1.409881144290447e-06 0.8493077402131245 1.409881327325656e-06 0.8502809338042043 \
1.409881498478783e-06 0.8511747489972419 1.409881673131736e-06 0.8520708361396651 1.409881848382891e-06 0.8529540285731302 1.409882024530391e-06 0.8538259128238825 \
1.409882214836778e-06 0.8547503816925358 1.409882405427748e-06 0.8556583881771193 1.409882605979791e-06 0.8565949481971697 1.409882798582588e-06 0.8574764650234362 \
1.409883009331288e-06 0.8584213553684483 1.409883237362185e-06 0.8594210644592908 1.409883503241952e-06 0.8605573106989262 1.409883801820094e-06 0.8617960322792503 \
1.409884077983729e-06 0.8629075153790151 1.409884362230229e-06 0.8640180616030438 1.409884636414231e-06 0.8650581816846495 1.40988490866944e-06 0.8660616517296992 \
1.409885178858914e-06 0.8670295451208139 1.409885436023238e-06 0.8679256252637404 1.409885708596972e-06 0.8688492356117473 1.409885984602435e-06 0.8697577927663542 \
1.409886254710518e-06 0.8706213441784563 1.409886554568938e-06 0.8715508809746347 1.409886925582816e-06 0.8726599440782473 1.409887220515529e-06 0.873510245983525 \
1.409887474800895e-06 0.8742218447789023 1.409887773044171e-06 0.8750318897722944 1.409888046640929e-06 0.8757523113099853 1.409888282767907e-06 0.8763571312809064 \
1.409888523107205e-06 0.876957042728428 1.409888745440861e-06 0.8774982514557473 1.409888939446794e-06 0.8779599514934209 1.409889269165228e-06 0.8787226653583874 \
1.409889424338019e-06 0.8790722725343518 1.409889742071409e-06 0.8797700114458387 1.40988992093906e-06 0.880152324917399 1.409890263400534e-06 0.8808637455080008 \
1.409890447552368e-06 0.8812353200296749 1.409890922478418e-06 0.8821594045029107 1.409891089871653e-06 0.8824737723885729 1.40989155569296e-06 0.8833186808430151 \
1.409891736520447e-06 0.883635209600208 1.409892230549786e-06 0.8844687288968743 1.409892371887773e-06 0.8846990198924604 1.409892978249103e-06 0.8856473543416146 \
1.409893130320955e-06 0.8858754372639542 1.409893777008947e-06 0.8868048391838264 1.409893905303109e-06 0.8869818633102416 1.409894553496582e-06 0.8878410756373726 \
1.409894683245133e-06 0.8880061989117775 1.409895451498601e-06 0.8889361126992519 1.409895581240625e-06 0.8890847997417872 1.409896434697557e-06 0.8900046759307325 \
1.409896577924673e-06 0.8901495209380393 1.409897564158077e-06 0.8910738355210844 1.409897785636141e-06 0.8912643084423501 1.409898928653688e-06 0.8921737958641509 \
1.409899058631989e-06 0.8922730011388891 1.409900410338988e-06 0.8932565980587214 1.409900560692342e-06 0.8933589605607284 1.409902041315768e-06 0.8942730372387374 \
1.40990228021907e-06 0.8944047337041336 1.409904061344227e-06 0.8952702388217941 1.409904447325594e-06 0.8954343910560414 1.409906848871634e-06 0.896309305076933 \
1.40990732380842e-06 0.8964562995603377 1.409911141970139e-06 0.8973944547681553 1.409911624459336e-06 0.897487269196476 1.409919510474849e-06 0.898471373493449 \
1.409920126637539e-06 0.8985180228791175 1.410015282612379e-06 0.899508178894561 1.410016773214557e-06 0.8995204306067698 1.410128061288741e-06 0.9005118233983579 \
1.410128237625743e-06 0.9005706457326812 1.410131860757067e-06 0.8996048713171836 1.410132041955094e-06 0.8994654179496379 1.41013335307657e-06 0.8985275682722235 \
1.410133534953976e-06 0.8984123497545736 1.41013535794417e-06 0.8974436520388238 1.410135517857424e-06 0.8973766233009967 1.410148668688723e-06 0.8983720910457982 \
1.410148779670276e-06 0.8983905835035384 1.410157601254383e-06 0.8993863063850064 1.410158148023847e-06 0.8994226481040219 1.41065071997668e-06 0.9003987622903815 \
1.410650789769165e-06 0.9004496773542636 1.410651622421929e-06 0.9012853800543292 1.410651748468094e-06 0.9014513953152168 1.410652328988957e-06 0.9023435091985418 \
1.410652469953212e-06 0.9025895326188698 1.410652869091291e-06 0.9033428289365844 1.410653019240831e-06 0.9036449200440446 1.410653462322153e-06 0.9045762589490434 \
1.410653619494256e-06 0.9049121924877023 1.410654065120987e-06 0.9058152254958243 1.410654163577326e-06 0.9059929146639856 1.41065558025872e-06 0.9052304871087643 \
1.410655711415865e-06 0.904616184869324 1.410655880423041e-06 0.9036290332250884 1.410656045714916e-06 0.9024406226812831 1.410656151980698e-06 0.9015554774641358 \
1.410656255417528e-06 0.9006052096506509 1.410656341184247e-06 0.8997486040545581 1.410656430678233e-06 0.8987887485205278 1.410656554922632e-06 0.8973492764100613 \
1.41065667300358e-06 0.8958624931586439 1.410656760219672e-06 0.8946938835082598 1.410656884526716e-06 0.8929289312882503 1.410656991510644e-06 0.8913158670103165 \
1.410657091342348e-06 0.8897378501708729 1.410657217633174e-06 0.8876466417139378 1.410657385821785e-06 0.884705368138502 1.410657541521538e-06 0.8818365157686672 \
1.410657738126367e-06 0.8780362649814708 1.410657921747617e-06 0.8743271923380105 1.41065813325501e-06 0.8698916163736473 1.41065831406481e-06 0.8659808238081558 \
1.410658498645858e-06 0.8618945354625286 1.410658671649854e-06 0.8579913311618118 1.410658857050504e-06 0.8537436868396935 1.410659036133651e-06 0.8495884889292737 \
1.410659219722713e-06 0.8452850234109005 1.410659386484418e-06 0.8413449312544377 1.410659554574996e-06 0.8373487193315756 1.410659717684167e-06 0.8334514816705533 \
1.410659872870403e-06 0.829729402178684 1.410660045969282e-06 0.8255639501984255 1.410660231959738e-06 0.8210763864673301 1.410660396580221e-06 0.8170961425007568 \
1.410660561450132e-06 0.8131038678717658 1.410660736782164e-06 0.8088537582860886 1.410660901208668e-06 0.8048648186953292 1.410661069844279e-06 0.8007719922541914 \
1.410661260647645e-06 0.7961398815555145 1.410661446171818e-06 0.7916360074082958 1.410661655100628e-06 0.7865651471012967 1.410661879917618e-06 0.7811107659751856 \
1.410662069732705e-06 0.77650678233121 1.410662271590188e-06 0.7716133355283564 1.410662415860827e-06 0.76811790639139 1.410662557504392e-06 0.7646880872338248 \
1.410662685202102e-06 0.7615975116975136 1.410662796247943e-06 0.7589113686396982 1.410662924810579e-06 0.7558028559024855 1.410663057376087e-06 0.7525995467138866 \
1.410663170697783e-06 0.7498629233610832 1.410663307032409e-06 0.7465723252212872 1.410663413431661e-06 0.7440058350410135 1.410663572650447e-06 0.7401674766516904 \
1.410663745028142e-06 0.7360137588823189 1.410663907275386e-06 0.7321074183421575 1.410664079624343e-06 0.7279612819449855 1.410664239010527e-06 0.7241302920521341 \
1.410664446815714e-06 0.7191408067115369 1.410664607355379e-06 0.7152908836069264 1.410664799844715e-06 0.7106793324906435 1.410664985361064e-06 0.7062404417184839 \
1.410665155237109e-06 0.7021802791355866 1.410665347106947e-06 0.6975984806629684 1.410665493330962e-06 0.6941099299715526 1.410665653617309e-06 0.6902897983225644 \
1.410665856006145e-06 0.6854719661536142 1.410666037294609e-06 0.681161582477689 1.410666206116036e-06 0.6771536053116509 1.410666391961911e-06 0.6727470762459599 \
1.410666597892751e-06 0.6678715161770782 1.410666765819558e-06 0.6639016226084196 1.410666926081261e-06 0.6601182542089066 1.410667164933735e-06 0.65448589698252 \
1.410667332694848e-06 0.6505369020837752 1.410667513768288e-06 0.6462813620835641 1.410667674923199e-06 0.642499550819208 1.41066782119046e-06 0.6390715923276049 \
1.410667959878569e-06 0.6358268652274862 1.410668089235615e-06 0.6328040340451749 1.41066821862017e-06 0.6297855584526113 1.41066834694149e-06 0.6267952385336898 \
1.410668477143629e-06 0.6237652412672913 1.410668606160073e-06 0.6207683673242944 1.410668744735633e-06 0.6175525629501428 1.41066889281122e-06 0.6141227553162802 \
1.410669079138505e-06 0.60981438109949 1.410669226822204e-06 0.6064079319686639 1.41066946198641e-06 0.600995965122186 1.410669654434141e-06 0.5965821560879089 \
1.410669895003955e-06 0.5910808370261941 1.410670064051325e-06 0.587228367631822 1.41067020171775e-06 0.5840969866928536 1.410670329822726e-06 0.581191110277254 \
1.410670443409422e-06 0.5786182870235701 1.410670534774226e-06 0.5765512826027382 1.410670624196113e-06 0.5745328691003393 1.410670691457846e-06 0.573016830490748 \
1.410670757478049e-06 0.5715297341779608 1.410670809531724e-06 0.5703577032508095 1.410670873770593e-06 0.5689124506700958 1.410670935307116e-06 0.5675311492520995 \
1.41067099958866e-06 0.5660899724818867 1.410671052779755e-06 0.5648985048860162 1.41067114512554e-06 0.5628316153148989 1.410671221701441e-06 0.5611191615154557 \
1.410671277545091e-06 0.5598732849310241 1.4106713468882e-06 0.5583285932816697 1.410671452739476e-06 0.5559733466166974 1.41067153043128e-06 0.5542469170533902 \
1.410671631029867e-06 0.5520159549745236 1.410671759063078e-06 0.5491849411292137 1.41067185856046e-06 0.5469885705929382 1.410671971125811e-06 0.544508366501287 \
1.410672074170131e-06 0.5422442603473754 1.410672194219017e-06 0.5396115972585003 1.410672295833426e-06 0.5373863339265779 1.410672411457693e-06 0.5348611538529422 \
1.410672526573874e-06 0.5323536236546169 1.410672653010918e-06 0.529604142030661 1.410672778525186e-06 0.5268822104345234 1.410672925204862e-06 0.5237112381511962 \
1.41067306087557e-06 0.5207845659358002 1.410673218641408e-06 0.5173942078023266 1.410673381063349e-06 0.5139116507621072 1.410673561971818e-06 0.5100482739823553 \
1.410673754563972e-06 0.5059503908118104 1.410673967555743e-06 0.5014368974673542 1.410674199988459e-06 0.4965308659362653 1.410674457509373e-06 0.49112491222925 \
1.410674697473551e-06 0.4861095397820235 1.410674998677905e-06 0.4798501326413723 1.410675286975534e-06 0.4738957353990632 1.410675600061861e-06 0.4674739717793394 \
1.410675919588141e-06 0.4609631488871989 1.410676259085406e-06 0.4540919149088484 1.410676585275518e-06 0.4475353831519197 1.41067692175678e-06 0.4408159131180407 \
1.410677238467587e-06 0.4345373385230166 1.41067757255266e-06 0.4279587671099637 1.410677924261528e-06 0.4210864038135054 1.410678238746378e-06 0.4149846225409808 \
1.410678562192836e-06 0.4087533091618546 1.410679003120948e-06 0.400331870031168 1.410679344916025e-06 0.3938679283557566 1.410679644350069e-06 0.3882534014213259 \
1.410680018872672e-06 0.3812944595528024 1.410680348250389e-06 0.375233915169682 1.410680631354694e-06 0.3700684563936956 1.410680931099705e-06 0.3646408765157301 \
1.410681210595549e-06 0.3596219010422631 1.410681434267487e-06 0.3556377385586224 1.410681645979194e-06 0.3518907610576284 1.410681848481927e-06 0.3483292724130969 \
1.410682049543475e-06 0.3448190020587957 1.410682255221383e-06 0.3412518188287665 1.41068247359686e-06 0.3374887625241871 1.410682717359257e-06 0.3333167726275162 \
1.410682944115829e-06 0.3294678078423895 1.410683164026801e-06 0.3257615367192951 1.410683382451408e-06 0.3221060038181086 1.410683586476418e-06 0.318715141566024 \
1.410683788334207e-06 0.3153870758963987 1.410683988657595e-06 0.3121102802474151 1.410684175271502e-06 0.309079115007194 1.410684372573108e-06 0.3058982938882217 \
1.410684581156335e-06 0.3025606704206737 1.410684786791057e-06 0.2992974534031506 1.410685011523137e-06 0.2957609785165763 1.410685228418979e-06 0.2923771984023277 \
1.410685436098331e-06 0.2891642611511841 1.410685667149177e-06 0.2856239464683982 1.410685841949429e-06 0.2829684481899911 1.410686021147604e-06 0.2802647299798244 \
1.41068619002212e-06 0.2777348429135014 1.410686418345393e-06 0.274348458173166 1.410686595082661e-06 0.2717528218126659 1.410686763365392e-06 0.2693020894036587 \
1.410686935832162e-06 0.2668230333489093 1.410687069934441e-06 0.264903804409765 1.410687215894446e-06 0.2628277003548514 1.410687354589946e-06 0.2608803500812688 \
1.410687476871551e-06 0.2591684246570544 1.410687610990381e-06 0.2572942758553639 1.410687740091486e-06 0.2554978336754472 1.41068785952522e-06 0.2538430842138498 \
1.410687986360419e-06 0.2520939183506197 1.410688106001441e-06 0.2504447954274527 1.410688255617635e-06 0.2483797066042054 1.410688390481146e-06 0.2465170278296022 \
1.41068852003856e-06 0.2447289494531232 1.410688677103379e-06 0.2425624627506451 1.410688801099014e-06 0.2408491463446025 1.410688941247149e-06 0.2389135279283614 \
1.41068907114005e-06 0.2371200701944942 1.41068919175767e-06 0.2354534357320198 1.410689354230601e-06 0.2332087289724075 1.410689500284699e-06 0.2311905595759856 \
1.410689638605484e-06 0.2292825126447264 1.410689746532702e-06 0.2277949627009887 1.410689877317609e-06 0.225993474229161 1.410689975823625e-06 0.22463752857886 \
1.410690079906972e-06 0.2232056532573264 1.410690152783836e-06 0.2222046546567725 1.410690234937313e-06 0.2210804129356655 1.410690302346398e-06 0.2201585377209549 \
1.410690349050661e-06 0.2195201149856669 1.41069039846802e-06 0.2188449488487562 1.410690489422163e-06 0.2176035744446363 1.410690555816576e-06 0.2166983392055156 \
1.410690602779869e-06 0.2160586379972232 1.410690653091075e-06 0.2153737902794619 1.410690712240425e-06 0.2145693142997165 1.410690755086328e-06 0.2139870779821451 \
1.410690798893629e-06 0.2133941263688522 1.410690868423894e-06 0.2124566309962414 1.410690955340708e-06 0.2112864027023158 1.410691036529563e-06 0.2101949018929156 \
1.410691122429026e-06 0.2090416531541652 1.410691216575207e-06 0.2077796428137634 1.410691308329081e-06 0.2065517647617813 1.410691403625517e-06 0.2052788208685862 \
1.410691500104208e-06 0.2039945431316728 1.41069160092949e-06 0.2026602783061639 1.410691696885502e-06 0.2013924147365721 1.410691799571213e-06 0.2000377255165624 \
1.410691902607566e-06 0.1986831378210229 1.410692012697906e-06 0.1972405340748948 1.410692121449794e-06 0.1958206085628783 1.410692241171749e-06 0.1942631948714586 \
1.410692351614651e-06 0.1928328887741874 1.410692459617459e-06 0.1914411844406488 1.410692584973803e-06 0.1898318066870429 1.410692677907979e-06 0.1886434908940876 \
1.410692756278755e-06 0.1876443873000938 1.410692832918829e-06 0.1866698667869858 1.410692915430143e-06 0.1856249297118943 1.410692984939759e-06 0.1847473639743596 \
1.410693050895387e-06 0.1839166514106665 1.410693115162722e-06 0.1831089953192083 1.410693227146207e-06 0.1817072258029639 1.410693321200173e-06 0.1805353135896268 \
1.410693428841935e-06 0.1791985758407087 1.410693535314993e-06 0.1778827552324552 1.41069365530692e-06 0.1764073736674057 1.410693793359546e-06 0.174720142305475 \
1.4106939095201e-06 0.1733081217455876 1.410694071616903e-06 0.1713503924599185 1.410694186705419e-06 0.1699688234017716 1.410694326691019e-06 0.1682987764548305 \
1.410694443897094e-06 0.1669083002780509 1.410694554816447e-06 0.1655990025649634 1.410694652444933e-06 0.1644521190704843 1.410694747295481e-06 0.1633427224865242 \
1.410694863349893e-06 0.161991523106341 1.410694954898444e-06 0.1609305136382055 1.41069505100742e-06 0.1598214181625073 1.410695145225553e-06 0.1587403933520305 \
1.410695238726156e-06 0.1576732160104884 1.410695332323478e-06 0.1566104070550305 1.410695428005016e-06 0.1555300824433628 1.410695518592921e-06 0.1545132165873678 \
1.410695609606078e-06 0.1534969984004868 1.410695705154555e-06 0.1524358767948732 1.410695795820268e-06 0.1514342506187442 1.410695898892631e-06 0.1503020548964867 \
1.41069597134408e-06 0.1495100717445464 1.410696050444872e-06 0.148649146151682 1.410696124993091e-06 0.1478424742503694 1.4106961960245e-06 0.1470770917224498 \
1.410696268788981e-06 0.1462962409077327 1.410696343406157e-06 0.1454990959398698 1.410696413389118e-06 0.1447543557055888 1.410696487550038e-06 0.143968261688537 \
1.410696541295377e-06 0.1434005634796054 1.410696594578932e-06 0.1428396203849428 1.41069665977469e-06 0.1421555039833398 1.410696731080731e-06 0.141411576573238 \
1.410696795450793e-06 0.1407432786314442 1.410696868802754e-06 0.1399847409254479 1.41069692942032e-06 0.1393607073002494 1.410697015453804e-06 0.1384787080092832 \
1.41069709140482e-06 0.1377037134581418 1.410697181372726e-06 0.1367902106004182 1.410697263099684e-06 0.1359645165492482 1.410697345789661e-06 0.1351360437760365 \
1.410697428345969e-06 0.1343145513298757 1.410697533908125e-06 0.1332698421778018 1.410697615775408e-06 0.1324642397250402 1.410697713142868e-06 0.1315110876582503 \
1.410697803143728e-06 0.130634908321232 1.410697891113988e-06 0.1297829978838479 1.410697974043842e-06 0.1289892226181523 1.410698048280934e-06 0.1282822873521282 \
1.410698147931993e-06 0.1273377645104763 1.410698243687052e-06 0.1264350619688987 1.410698330534456e-06 0.1256206895242312 1.410698420535994e-06 0.1247808744623497 \
1.410698500868674e-06 0.1240346855852102 1.410698587562703e-06 0.1232365419604467 1.410698686393032e-06 0.1223331159004786 1.41069877647517e-06 0.1215131568528167 \
1.410698886718427e-06 0.1205141992263624 1.410698973949866e-06 0.1197275966302077 1.410699042523e-06 0.1191120727131645 1.410699127185392e-06 0.1183553887582162 \
1.410699193692874e-06 0.1177634990399222 1.410699265148799e-06 0.1171309945267847 1.410699334822604e-06 0.1165184920865242 1.410699412159692e-06 0.1158409171037389 \
1.410699507902974e-06 0.1150054407698888 1.410699579157887e-06 0.1143861389207103 1.41069964652742e-06 0.1138025718558601 1.410699714964191e-06 0.113211685696446 \
1.410699790554542e-06 0.1125613765304429 1.410699881296388e-06 0.1117840233035959 1.410699964000116e-06 0.1110788257213999 1.410700077599187e-06 0.1101151050704521 \
1.410700187474899e-06 0.1091895325357105 1.410700279674213e-06 0.1084169374841771 1.410700403623544e-06 0.1073835127717347 1.410700491987867e-06 0.1066505015902263 \
1.410700631446837e-06 0.1055001025916527 1.410700730743538e-06 0.1046863788921388 1.41070082339359e-06 0.1039306459201802 1.410700933598102e-06 0.1030359883605075 \
1.410701018892542e-06 0.1023467905686673 1.410701103793345e-06 0.101663637589173 1.410701186744308e-06 0.1009989740617136 1.41070130925421e-06 0.1000225794851696 \
1.410701431196062e-06 0.09905761200121259 1.410701557818349e-06 0.09806258992746317 1.410701670630472e-06 0.09718220909187772 1.410701815205956e-06 0.09606278874246346 \
1.410701952919884e-06 0.09500564015228773 1.410702069610674e-06 0.09411672853020667 1.410702197354241e-06 0.0931507147971556 1.410702297018758e-06 0.09240236948627445 \
1.410702376452637e-06 0.09180921593916676 1.410702475187935e-06 0.09107599640376031 1.410702553063239e-06 0.09050081472416407 1.410702634529155e-06 0.08990210528957472 \
1.410702709246463e-06 0.0893557072655629 1.4107027897762e-06 0.08876971652456604 1.410702908608526e-06 0.08791061481419053 1.410702998269062e-06 0.08726673116015753 \
1.410703103183109e-06 0.08651800316437093 1.410703234657666e-06 0.08558693768262025 1.410703395765802e-06 0.08445695903909305 1.410703535947497e-06 0.08348350561263763 \
1.410703684450103e-06 0.08246223579158835 1.410703821170292e-06 0.08153124812726546 1.410703961182002e-06 0.08058696725890066 1.410704098179202e-06 0.07967195061625794 \
1.410704236789813e-06 0.07875532825288725 1.4107043812627e-06 0.07780967510081127 1.410704528808937e-06 0.07685421131041187 1.410704686312648e-06 0.07584560580436887 \
1.410704850707884e-06 0.07480523464991846 1.410705018799982e-06 0.07375451744755303 1.410705199799341e-06 0.07263751640721161 1.410705398512623e-06 0.07142823309373261 \
1.410705611921415e-06 0.07014922396308329 1.4107058380853e-06 0.06881630383186611 1.410706078645622e-06 0.06742468841361035 1.410706356206535e-06 0.06585179211508728 \
1.410706653410938e-06 0.06420523370201831 1.410706971711662e-06 0.06248365192299224 1.410707361695962e-06 0.06043183534616462 1.410707760522748e-06 0.05839861031494715 \
1.410708202994687e-06 0.05621846258761681 1.41070858797559e-06 0.05438828987170503 1.410709000022182e-06 0.05249218901100536 1.410709351759698e-06 0.05092353490091287 \
1.410709687264349e-06 0.04946969867921969 1.410709997763245e-06 0.04816021644386199 1.410710291700064e-06 0.04695194805701195 1.410710584430997e-06 0.04577883625507727 \
1.410710859274204e-06 0.04470700909733757 1.410711133117927e-06 0.04366353526031765 1.410711398807687e-06 0.04267398813878486 1.410711674116703e-06 0.04167180388267511 \
1.410711958673621e-06 0.04066026046469497 1.410712254971736e-06 0.03963283340811159 1.410712513847121e-06 0.03875659098599576 1.410712741803527e-06 0.03800131046948733 \
1.410712960528722e-06 0.03729095380188759 1.410713180383449e-06 0.03659437723507575 1.410713521249513e-06 0.03554043311314246 1.410713797290394e-06 0.03470953269536187 \
1.410714090721169e-06 0.03384790442147732 1.410714373289092e-06 0.03303898052111545 1.410714628198528e-06 0.03232625790162248 1.410714908882988e-06 0.03155947796597136 \
1.410715154716382e-06 0.03090318379665042 1.41071538687767e-06 0.03029616297556957 1.410715627215008e-06 0.02968398395812225 1.410715862851843e-06 0.02909722707395018 \
1.410716091063021e-06 0.0285403787496557 1.410716507835749e-06 0.02755138287878544 1.410716702361127e-06 0.02710176794309662 1.410717088601532e-06 0.02623051698020805 \
1.410717267770925e-06 0.0258356865503758 1.410717618998109e-06 0.02507792837274256 1.410717786904156e-06 0.0247229612172224 1.410718171166812e-06 0.02392944198669211 \
1.410718286448541e-06 0.02369675911063252 1.410718728496378e-06 0.02282172072611499 1.410718950311652e-06 0.02239223679446916 1.410719473931311e-06 0.02139838041889957 \
1.410719629293819e-06 0.02110714647916685 1.410720146999887e-06 0.02015295207761772 1.410720272033152e-06 0.01992792118872039 1.410720796234659e-06 0.01901759738223179 \
1.410720932454034e-06 0.01879045572456909 1.41072153873049e-06 0.01783210191617334 1.410721705739623e-06 0.01758082406519646 1.410722348947266e-06 0.01666064795441237 \
1.410722528091535e-06 0.0164167113061686 1.410723218250269e-06 0.01551958953683085 1.410723381870153e-06 0.01531511209162885 1.41072414235084e-06 0.01440332854054019 \
1.410724289392963e-06 0.01423371673427115 1.410725107264621e-06 0.01333087949608782 1.410725226813134e-06 0.01320411419549955 1.410726142674655e-06 0.01227329163592313 \
1.410726284027572e-06 0.01213544173166964 1.410727232503148e-06 0.01124488043697059 1.410727391142586e-06 0.01110230805801717 1.41072857354363e-06 0.01011356759191894 \
1.41072867164402e-06 0.01003725601038859 1.41072993325548e-06 0.009120360285939955 1.41073006766933e-06 0.009028655389366201 1.410731608240655e-06 0.008043892937307966 \
1.410731689273999e-06 0.007992925041580451 1.410733277867931e-06 0.007023242357651564 1.410733410759078e-06 0.006948518507451114 1.41073538746242e-06 0.005952856104192286 \
1.410735569200568e-06 0.005869662958407677 1.410737671554228e-06 0.004980929874643355 1.410738112345997e-06 0.004810448874467742 1.410740767560855e-06 0.003892108290451164 \
1.410741244140394e-06 0.003745909362026665 1.410744882222615e-06 0.00279447349697209 1.41074540774606e-06 0.002678838783887205 1.410751013810845e-06 0.001700248310874221 \
1.410751324898547e-06 0.001653333728976835 1.410756459226246e-06 0.0006858192122199529 1.410756653206019e-06 0.0006440832883579712 1.413404576914862e-06 -0.0002037173203380238 \
1.413404741115283e-06 -0.0003889174928863678 1.413405314458091e-06 -0.001270938904608877 1.413405389392278e-06 -0.001411855863724778 1.413405849976055e-06 -0.002393592696522268 \
1.413405961916807e-06 -0.002660411672198376 1.413406215188795e-06 -0.003300974950034667 1.413406381572099e-06 -0.003745951779090856 1.413406676567869e-06 -0.004566571567208835 \
1.413406788055442e-06 -0.00488071790655901 1.413407067428216e-06 -0.005641221413069743 1.413407188386555e-06 -0.005938820066262044 1.413408282339388e-06 -0.005180465225493313 \
1.413408406471631e-06 -0.004410796826645887 1.413408530879049e-06 -0.003456122327429311 1.413408650435428e-06 -0.002364170815481491 1.413408748579805e-06 -0.001341064316055312 \
1.413408855004127e-06 -0.0001052154991983786 1.413408967239972e-06 0.001336046702817826 1.413409102195821e-06 0.003249882807978809 1.413409224782331e-06 0.005149402351921401 \
1.413409413644245e-06 0.008353592055059769 1.413409554826578e-06 0.01094873860302964 1.413409708187922e-06 0.01393943619118621 1.413409851561427e-06 0.01687898420971235 \
1.413410005752867e-06 0.02017576688295359 1.413410161892825e-06 0.02363796584892512 1.413410317618878e-06 0.02719811802828209 1.413410465112557e-06 0.03065407560139007 \
1.413410613784323e-06 0.03420778369279751 1.413410769114407e-06 0.03798436241030867 1.413410927740287e-06 0.04189786275883118 1.413411092673448e-06 0.0460171220807938 \
1.413411267096336e-06 0.05041857973200652 1.413411446085736e-06 0.05497510627343041 1.413411635385597e-06 0.05982852266675163 1.413411838393603e-06 0.06506368941101938 \
1.413412057870669e-06 0.07075025585284363 1.41341228893533e-06 0.07675903373893865 1.413412535995649e-06 0.08319974270080552 1.413412806420637e-06 0.0902619122132732 \
1.413413099984324e-06 0.09793335781011638 1.413413424033306e-06 0.1064001814721126 1.413413788254856e-06 0.1159066558703892 1.413414180806326e-06 0.1261372395632307 \
1.413414630304251e-06 0.1378252442462487 1.413415153096484e-06 0.1513754922073403 1.413415766694219e-06 0.1672157090591849 1.413416444455093e-06 0.184625848284817 \
1.413417232720212e-06 0.2047487967247964 1.413418115553071e-06 0.22712469896725 1.413418933839029e-06 0.2476994923478653 1.413419661268608e-06 0.2658503723959502 \
1.413420301381636e-06 0.2817009601644404 1.41342087568535e-06 0.2958213763442377 1.413421413251317e-06 0.3089396094373287 1.413421917248776e-06 0.3211464104224903 \
1.41342239337143e-06 0.3325930942309646 1.413422871259445e-06 0.3439912352478621 1.413423324592551e-06 0.3547121966731367 1.413423795885259e-06 0.3657614311162562 \
1.413424238561085e-06 0.3760518588326446 1.413424757059872e-06 0.3879885572071845 1.413425284221992e-06 0.3999987293386327 1.413425663131623e-06 0.4085537955782026 \
1.413426193047166e-06 0.4204060347738258 1.413426622963746e-06 0.429919877745455 1.413427076664521e-06 0.4398653393542544 1.413427543378037e-06 0.4500002271552926 \
1.413427981059267e-06 0.4594210430579985 1.413428389021531e-06 0.468120704286539 1.413428708454565e-06 0.4748816926501604 1.413429080589836e-06 0.4826992142337162 \
1.413429315571977e-06 0.4876010339127531 1.413429549178225e-06 0.4924491904621348 1.413429797190648e-06 0.4975647713404599 1.413430095592078e-06 0.5036796627825791 \
1.41343035194848e-06 0.5088948470128004 1.41343056424179e-06 0.5131878547336713 1.413430758259862e-06 0.5170959594548015 1.413430905246394e-06 0.5200432695146362 \
1.413431059224404e-06 0.523118600542271 1.413431277106154e-06 0.5274469616807909 1.41343153021048e-06 0.5324525256580425 1.413431740049324e-06 0.5365797337241586 \
1.413431951502633e-06 0.5407247601751553 1.413432233709534e-06 0.5462280430697679 1.413432463254817e-06 0.5506821559930507 1.413432679151023e-06 0.5548604062613707 \
1.413432961372541e-06 0.560308769190463 1.413433212680268e-06 0.5651538146135803 1.41343351034116e-06 0.5708625224168123 1.41343376056806e-06 0.5756519166658941 \
1.413434016931555e-06 0.5805516059354519 1.41343425734157e-06 0.585116682128892 1.413434515521386e-06 0.5900038400537884 1.413434739113591e-06 0.5942175703762435 \
1.413434977623163e-06 0.5986919452581434 1.413435185207861e-06 0.6025689278491061 1.413435401730486e-06 0.6065904171332736 1.413435651033092e-06 0.6111939272561876 \
1.413435856106534e-06 0.6149609706257601 1.41343610737886e-06 0.6195555361399968 1.413436310600886e-06 0.6232455818254186 1.413436507472791e-06 0.6267987644955494 \
1.413436700764307e-06 0.630267737067843 1.413436955542762e-06 0.6348113783570861 1.413437185753374e-06 0.638887973644319 1.413437403107185e-06 0.6427143472883045 \
1.413437701512907e-06 0.6479268061885751 1.413437916915757e-06 0.6516657345437264 1.413438118139476e-06 0.6551344108237934 1.413438293060983e-06 0.6581323437428509 \
1.413438458126254e-06 0.6609495238976936 1.413438627594774e-06 0.6638251431769452 1.413438779731612e-06 0.666392827642013 1.413438917642298e-06 0.6687037209181631 \
1.413439066478412e-06 0.6711867545200138 1.413439194593014e-06 0.6733159837320549 1.413439337815827e-06 0.6756849429836936 1.413439459090077e-06 0.6776819274526149 \
1.413439596688762e-06 0.6799401191146522 1.413439716069216e-06 0.6818929034138137 1.413439863176962e-06 0.6842914131385206 1.413439980378628e-06 0.6861933934268433 \
1.413440073884205e-06 0.6877071857403232 1.413440164873897e-06 0.6891752279197846 1.413440267615961e-06 0.6908280855439021 1.413440369133525e-06 0.6924555900607121 \
1.413440487516631e-06 0.6943444167618776 1.413440599637217e-06 0.6961264383846065 1.413440717192718e-06 0.6979868779962457 1.413440902343005e-06 0.7008959348649784 \
1.413441033535213e-06 0.7029413755586562 1.413441169703753e-06 0.7050491462541959 1.413441291222456e-06 0.7069171228306749 1.413441431145468e-06 0.7090538254196674 \
1.413441535088117e-06 0.7106315721465845 1.413441646249101e-06 0.712309798010818 1.413441750508965e-06 0.7138759052437967 1.413441880147056e-06 0.7158124745844324 \
1.413441977077769e-06 0.7172526339884565 1.413442116000004e-06 0.7193052800722975 1.413442235549292e-06 0.7210612846995991 1.413442355121865e-06 0.7228080613301419 \
1.413442480897243e-06 0.7246353354365959 1.413442607615586e-06 0.7264656873164689 1.413442729655437e-06 0.728218443613998 1.41344285780388e-06 0.7300486655261287 \
1.413442987872205e-06 0.7318956587421809 1.413443108863227e-06 0.7336041830685722 1.413443249633811e-06 0.7355801168346318 1.41344335060338e-06 0.7369898206659778 \
1.413443452204237e-06 0.7384020079314992 1.413443548224548e-06 0.7397310783624924 1.413443659137403e-06 0.7412570822736337 1.41344374678503e-06 0.7424563811251772 \
1.413443846639401e-06 0.7438154404043728 1.413443981404538e-06 0.7456370856934184 1.413444097699018e-06 0.747198032089633 1.413444201190815e-06 0.7485782798032956 \
1.413444325446263e-06 0.7502239458264747 1.413444470359203e-06 0.7521280942578691 1.413444588339771e-06 0.753666143975803 1.413444707270879e-06 0.7552056331692281 \
1.413444846850418e-06 0.7569980918234445 1.413444991202808e-06 0.7588357421297242 1.413445109263616e-06 0.7603265096672839 1.413445234085335e-06 0.7618908200857619 \
1.413445373916531e-06 0.7636286950759973 1.413445498679428e-06 0.7651662633748356 1.413445642192898e-06 0.7669199865864609 1.413445762878376e-06 0.7683824344671055 \
1.413445883722124e-06 0.7698356273746885 1.413446003367048e-06 0.7712633747646481 1.413446133074687e-06 0.7727989859455529 1.41344624181849e-06 0.7740766298596218 \
1.413446364466226e-06 0.7755070372682662 1.413446474242911e-06 0.7767778749889983 1.413446603267025e-06 0.7782599816788072 1.413446735043344e-06 0.7797610257751375 \
1.41344684835592e-06 0.7810403609326458 1.413446969441862e-06 0.7823954393038701 1.413447073314495e-06 0.7835479431998941 1.413447215597517e-06 0.785111775748914 \
1.413447363800666e-06 0.7867227488076519 1.413447522694201e-06 0.7884297907063792 1.413447642887223e-06 0.7897074707829422 1.41344779245393e-06 0.7912811323018302 \
1.413447916569147e-06 0.7925734175081853 1.413448042273444e-06 0.7938699048627912 1.413448145219011e-06 0.7949224966762399 1.413448259590165e-06 0.7960823495211882 \
1.413448372064409e-06 0.7972131756542409 1.413448462336983e-06 0.7981137961420948 1.413448551677879e-06 0.7989989930139054 1.413448676903817e-06 0.800229513878344 \
1.41344878467518e-06 0.8012785338618679 1.413448914342978e-06 0.8025281307685926 1.413449035722257e-06 0.8036855380110038 1.413449152278057e-06 0.8047859282369955 \
1.413449273083453e-06 0.80591497746663 1.413449405708758e-06 0.8071413435168892 1.413449527502378e-06 0.8082555056211007 1.413449654106103e-06 0.8094015704683005 \
1.413449779719621e-06 0.8105266036187198 1.413449899211046e-06 0.8115857443778658 1.413450037409299e-06 0.8127973981963581 1.413450146908547e-06 0.8137473213416323 \
1.413450231056662e-06 0.8144713378799666 1.41345035186072e-06 0.8155017394983226 1.413450447369557e-06 0.8163089346032877 1.41345058366036e-06 0.8174496006492775 \
1.413450726424414e-06 0.8186303638797883 1.413450860857535e-06 0.8197292014569521 1.413450970729519e-06 0.8206175763825388 1.413451114629136e-06 0.8217677661037901 \
1.41345126795672e-06 0.8229768690765377 1.413451395805574e-06 0.8239722812379519 1.413451536202905e-06 0.8250521595273246 1.413451662107844e-06 0.8260088941474263 \
1.41345181672401e-06 0.8271688948348412 1.413451949079339e-06 0.8281489842609937 1.413452075346168e-06 0.8290730392392056 1.413452193006695e-06 0.8299245984162376 \
1.413452341409092e-06 0.8309852945996649 1.41345250860326e-06 0.8321626230293395 1.413452641380571e-06 0.8330844501529713 1.413452814281769e-06 0.8342675727345584 \
1.413452982699062e-06 0.8354015168591284 1.413453152193536e-06 0.8365246342267009 1.413453333630418e-06 0.8377070668209077 1.413453476186559e-06 0.8386219603417975 \
1.41345359009745e-06 0.8393441765511721 1.413453720973658e-06 0.8401643924869071 1.413453822596633e-06 0.8407940582489307 1.413453939036871e-06 0.8415078269750864 \
1.413454074330057e-06 0.8423269142909066 1.413454271595159e-06 0.8435017451489455 1.413454462114483e-06 0.844614933042255 1.413454672039296e-06 0.8458175693076773 \
1.413454852817827e-06 0.8468334846981137 1.413455050185846e-06 0.8479221976595614 1.41345522404434e-06 0.8488638701886076 1.413455406558583e-06 0.8498353939890455 \
1.413455577902693e-06 0.8507314120859523 1.413455752248258e-06 0.8516272398309612 1.413455927651258e-06 0.8525125793730954 1.413456103896448e-06 0.8533864315694911 \
1.413456293665326e-06 0.8543099749208749 1.413456484423344e-06 0.8552205033559714 1.41345668621255e-06 0.8561646193034282 1.413456878916116e-06 0.8570482883232282 \
1.413457088356793e-06 0.8579892478796384 1.413457318098559e-06 0.8589986827500428 1.413457583567511e-06 0.8601360945383778 1.413457882213855e-06 0.8613786760148464 \
1.413458160601222e-06 0.8625023989005415 1.413458444791177e-06 0.8636161469557806 1.413458719285784e-06 0.8646608622318305 1.41345899137728e-06 0.8656672252055042 \
1.413459261593727e-06 0.8666387059277968 1.413459518761914e-06 0.8675381145236246 1.413459791320979e-06 0.8684653318325959 1.41346006734232e-06 0.8693777905953765 \
1.413460337484171e-06 0.8702455402709716 1.413460637231955e-06 0.8711796653984102 1.413461008105812e-06 0.872294745819888 1.413461303028797e-06 0.8731503023941 \
1.413461557284845e-06 0.8738665406311316 1.413461855515577e-06 0.8746822274488602 1.413462129133901e-06 0.8754080260278182 1.413462365269549e-06 0.8760175227551726 \
1.413462605621406e-06 0.876622281264788 1.413462827963785e-06 0.8771680781109068 1.413463021968128e-06 0.8776338860468618 1.413463351691207e-06 0.8784037109613512 \
1.41346350686397e-06 0.8787567114621292 1.413463824616497e-06 0.879461652496718 1.413464003481858e-06 0.8798480920375044 1.413464345943324e-06 0.8805675499479563 \
1.413464530084847e-06 0.8809434933546246 1.413465004990284e-06 0.8818790560183651 1.413465172384703e-06 0.8821975058309585 1.413465638216128e-06 0.8830540251881659 \
1.413465819040967e-06 0.8833751042472839 1.413466313074347e-06 0.8842212008576973 1.413466454417055e-06 0.884455124402366 1.413467060806836e-06 0.8854193259359495 \
1.413467212878983e-06 0.8856514227360587 1.41346785955747e-06 0.8865980751852495 1.413467987853824e-06 0.8867785329419297 1.413468635979926e-06 0.8876550049536978 \
1.413468765772447e-06 0.8878236738033012 1.413469544034095e-06 0.8887860366092379 1.413469659025973e-06 0.8889208282599539 1.413470514758392e-06 0.8898661633196656 \
1.413470660021537e-06 0.8900169066926564 1.413471645777722e-06 0.8909664261264102 1.413471866882863e-06 0.8911622482549515 1.413473011997306e-06 0.8921020388386462 \
1.413473143207264e-06 0.8922053928944147 1.413474330865799e-06 0.8931033243919096 1.413474484486091e-06 0.8932130731307282 1.413475894522803e-06 0.8941348173026452 \
1.413476117329622e-06 0.8942660193790342 1.41347779802033e-06 0.8951452796684343 1.413478125641509e-06 0.8952966652167414 1.413480355582631e-06 0.8961896554712738 \
1.413480908496592e-06 0.8963788593752812 1.413484476711123e-06 0.8973573335043913 1.413484800223538e-06 0.8974284307984646 1.413491156631826e-06 0.8984120886469452 \
1.413491705534673e-06 0.8984686671268907 1.413544207609024e-06 0.8994658645395698 1.413544850637886e-06 0.8994692460188505 1.413736989308519e-06 0.9004073346715066 \
1.41373719072249e-06 0.9004708280105613 1.413741150500432e-06 0.8995366825576255 1.413741334527229e-06 0.8993953949813248 1.413742651124504e-06 0.8984641879157507 \
1.413742823168359e-06 0.8983566564859006 1.413744719544653e-06 0.8973720929359315 1.413744893250842e-06 0.897304621671452 1.413757467177875e-06 0.8982933655523699 \
1.413757552368112e-06 0.8983081509245614 1.413765819241151e-06 0.8993078551592517 1.413766293960572e-06 0.8993433667976791 1.414259794870011e-06 0.9002974142054325 \
1.414259914349735e-06 0.9003767372269074 1.414260807172786e-06 0.9012336455299185 1.414260953429422e-06 0.901423267690772 1.414261548322101e-06 0.9023325668564308 \
1.414261683292918e-06 0.9025673929107925 1.414262187968707e-06 0.9035294259428087 1.414262320579608e-06 0.9038000271808221 1.414262721206972e-06 0.9046475051114249 \
1.414262865572371e-06 0.9049556543240072 1.41426328869358e-06 0.9058123566484279 1.414263384150638e-06 0.9059850892484415 1.414264808709454e-06 0.9052205906349737 \
1.414264933747309e-06 0.9046352442223391 1.414265060157898e-06 0.9039223775493039 1.414265162806642e-06 0.9032486771507763 1.414265290021932e-06 0.9022944222362175 \
1.414265408867758e-06 0.9012801950564071 1.414265506520237e-06 0.9003603330664713 1.414265588522258e-06 0.8995243596151602 1.414265668185821e-06 0.8986589236008835 \
