2.207060798230234e-07 0.8091594649786741 2.20706210891683e-07 0.8103325925767672 2.207063342120463e-07 0.8114249716726942 2.207064421363105e-07 0.8123719892944993 \
2.207065499317031e-07 0.8133095350680949 2.20706631652631e-07 0.8140147772069938 2.207067485202474e-07 0.815015186305849 2.207068395812563e-07 0.8157880755829442 \
2.207069737498876e-07 0.8169164295805346 2.2070711832076e-07 0.8181184617099191 2.207072518231266e-07 0.8192158725965917 2.207073617890376e-07 0.8201107352847025 \
2.207075056546975e-07 0.8212684563313245 2.207076589602621e-07 0.8224861772268215 2.207077866985553e-07 0.8234883060891934 2.207079273408909e-07 0.8245786478120171 \
2.207080531244556e-07 0.8255423809867173 2.207082077424273e-07 0.8267124309768116 2.207083401541937e-07 0.8277017767197102 2.207084664337982e-07 0.8286345641820314 \
2.207085840641131e-07 0.8294941055817234 2.207087322309758e-07 0.8305638349826423 2.207088993752207e-07 0.8317531470681401 2.207090319938809e-07 0.832683775428688 \
2.20709204938569e-07 0.8338803479528284 2.207093733252244e-07 0.8350269493631071 2.207095428597542e-07 0.8361634673386688 2.207097242289089e-07 0.8373596561587384 \
2.207098668614913e-07 0.8382862741713709 2.207099807973396e-07 0.8390176620397163 2.207101115711344e-07 0.8398476357987267 2.207102132250742e-07 0.8404856735008092 \
2.207103297188026e-07 0.8412091703399448 2.207104652363492e-07 0.8420405885319162 2.20710662580143e-07 0.8432318270427018 2.20710853245141e-07 0.8443612543037786 \
2.207110631019802e-07 0.8455804035625291 2.207112440391043e-07 0.8466117334714958 2.207114413745909e-07 0.8477160230260256 2.207116151614274e-07 0.8486711109012058 \
2.207117977428814e-07 0.8496572451898022 2.207119690624607e-07 0.850566499179887 2.207121434475075e-07 0.8514760798656241 2.207123188310518e-07 0.8523748177975867 \
2.207124950632094e-07 0.8532619682996843 2.207126849014518e-07 0.8542000584728613 2.207128756376655e-07 0.8551245802328369 2.20713077434399e-07 0.856083442102113 \
2.207132701277753e-07 0.8569809170305027 2.207134797560765e-07 0.857937542729613 2.207137091938401e-07 0.8589615588718806 2.207139749904802e-07 0.8601183337444025 \
2.207142735657076e-07 0.8613802063570262 2.207145514672209e-07 0.8625196921548358 2.207148356776949e-07 0.8636511027355716 2.207151100894824e-07 0.8647118800460076 \
2.207153822523641e-07 0.8657341977214618 2.207156524214556e-07 0.8667205537246333 2.207159096161394e-07 0.8676338760342862 2.207161821558105e-07 0.868575115807136 \
2.207164581902909e-07 0.8695013130444248 2.207167283429862e-07 0.8703818891200001 2.207170280497877e-07 0.8713292845176382 2.207173988672582e-07 0.8724597217497643 \
2.207176937859212e-07 0.8733269024855727 2.207179480301993e-07 0.8740525764960509 2.207182462541985e-07 0.8748787854419284 2.207185198789691e-07 0.8756137195941651 \
2.207187560179586e-07 0.8762307200963571 2.207189963736862e-07 0.8768427579093606 2.207192187193381e-07 0.8773949085683344 2.207194127230722e-07 0.877865919014753 \
2.207197424471962e-07 0.878644045115768 2.207198976198553e-07 0.8790007149587372 2.207202153732479e-07 0.879712598742095 2.207203942386052e-07 0.8801026384247937 \
2.207207367000935e-07 0.8808283583858193 2.207209208412927e-07 0.8812073588304842 2.207213957461144e-07 0.8821499412898334 2.207215631406012e-07 0.8824705695712217 \
2.207220289718891e-07 0.8833323038036038 2.207222097967714e-07 0.8836551183393088 2.207227038300282e-07 0.8845051821644966 2.207228451726029e-07 0.8847400410050358 \
2.207234515631179e-07 0.8857071861637142 2.207236036356849e-07 0.8859397703602404 2.207242503137577e-07 0.8868873789663725 2.207243786102467e-07 0.8870678433440622 \
2.207250267232453e-07 0.8879435266410994 2.207251565285235e-07 0.8881118897635528 2.20725934785608e-07 0.8890711781604964 2.207260497804227e-07 0.8892053868933587 \
2.207269055110619e-07 0.8901454611437621 2.207270507776287e-07 0.8902951528450479 2.207280365337324e-07 0.8912364417375994 2.207282576409459e-07 0.8914302300078862 \
2.207294027520271e-07 0.892358484239638 2.207295339601744e-07 0.8924604119362172 2.207308752633695e-07 0.8934531785430913 2.207310266510305e-07 0.8935579568409697 \
2.207325081098674e-07 0.8944876667405802 2.207327469902294e-07 0.894621531696939 2.207345164619859e-07 0.8954958910368339 2.207349055688235e-07 0.8956641700186337 \
2.207372993342323e-07 0.8965498195158238 2.207377748942228e-07 0.8966991754584082 2.207418379503871e-07 0.8976977719002629 2.20742329424408e-07 0.8977905759376156 \
2.207506459514872e-07 0.8987839664765119 2.207515658053769e-07 0.8988472044554419 2.208777709459031e-07 0.8998441026240215 2.20878784754255e-07 0.8998514601858095 \
2.210704973474114e-07 0.8990059056521554 2.210707273489741e-07 0.8988405173838494 2.210723422215349e-07 0.8978439928078279 2.210725199353886e-07 0.8977495532019018 \
2.210892857104286e-07 0.8987316330193963 2.210894216988253e-07 0.8987497732072308 2.211048844279385e-07 0.8997471920221268 2.211051522925305e-07 0.8997526389354535 \
2.215889776197985e-07 0.9006560548284696 2.215890984089986e-07 0.9007687033315858 2.215898861800374e-07 0.9017381658104292 2.215900203187565e-07 0.901943163319478 \
2.215905139335305e-07 0.9027850367016239 2.21590658833145e-07 0.9030569221572713 2.215910546405301e-07 0.9038490360455199 2.215911744361842e-07 0.9041001886668685 \
2.215915586097176e-07 0.9049189780371781 2.215916707313647e-07 0.9051556495331843 2.215921780523356e-07 0.9061253139956988 2.215922720511916e-07 0.90626859229291 \
2.215934307008982e-07 0.9055667778886739 2.215935336638317e-07 0.9051589876696525 2.215936175067007e-07 0.9047707260375384 2.215937512467522e-07 0.9040404158978201 \
2.215938519641334e-07 0.9033957423200318 2.215939595799193e-07 0.9026166239542108 2.215940771531732e-07 0.9016533104038295 2.21594165418223e-07 0.90085556431878 \
2.215942850516912e-07 0.8996698288011099 2.215943823733893e-07 0.8986166602050341 2.215944933908277e-07 0.8973222354192386 2.215945955004155e-07 0.8960407982554908 \
2.21594678931815e-07 0.8949326975987755 2.215947831128827e-07 0.8934749428758865 2.215948741996463e-07 0.8921321265381427 2.215949667404319e-07 0.8907058396397178 \
2.2159506189443e-07 0.8891776325191247 2.215951764494069e-07 0.88725933118288 2.215952652925089e-07 0.8857137884271823 2.215953635316907e-07 0.8839502506198179 \
2.215954489018647e-07 0.8823735982707064 2.215955298021067e-07 0.8808434949738935 2.215956027633997e-07 0.8794355441897157 2.215956697820454e-07 0.8781198554636557 \
2.215957383931237e-07 0.8767515715160701 2.215958218880357e-07 0.8750591081124355 2.215958840153664e-07 0.8737811510706814 2.215959469979638e-07 0.8724704924326797 \
2.215960421537153e-07 0.8704632161180945 2.215961427643535e-07 0.8683077530860182 2.215962226435446e-07 0.8665738309361769 2.215963069058141e-07 0.8647250601592834 \
2.215963860160737e-07 0.8629723295901451 2.215964488315189e-07 0.8615696597604833 2.215965362885537e-07 0.8596016864744445 2.215966021820844e-07 0.8581079708060287 \
2.215966702436265e-07 0.856556281928966 2.215967195561343e-07 0.8554267461646872 2.215967747929236e-07 0.85415654045335 2.215968155325295e-07 0.8532164928603474 \
2.215968618342832e-07 0.8521450198670055 2.21596892048343e-07 0.8514441160591502 2.215969210896253e-07 0.8507691938976955 2.215969517282201e-07 0.8500558939662993 \
2.215970130054097e-07 0.8486254874746039 2.215970660779718e-07 0.8473828229799116 2.215971197331653e-07 0.8461232012188223 2.215971823904472e-07 0.8446482873934593 \
2.215972456733951e-07 0.8431545995644786 2.21597336171269e-07 0.8410121009440262 2.215974331690495e-07 0.8387078554355326 2.215975161465499e-07 0.8367307351423475 \
2.215975981509054e-07 0.8347721678896715 2.215976872193066e-07 0.8326403548070889 2.215977717326432e-07 0.8306135893189693 2.215978625915234e-07 0.8284303722590877 \
2.215979545263781e-07 0.8262176456275642 2.215980569573085e-07 0.8237486178045141 2.215981570753404e-07 0.8213320995840899 2.215982718962233e-07 0.8185572053828121 \
2.215983841027604e-07 0.8158423448209959 2.215985090963053e-07 0.8128151787794674 2.215986403567133e-07 0.8096337870015397 2.215987856277547e-07 0.8061104108175116 \
2.215989401353681e-07 0.8023613213197434 2.215991115759889e-07 0.7981999722344618 2.215992756257814e-07 0.794217661721315 2.215994600412032e-07 0.7897413884478564 \
2.215996665335768e-07 0.7847307375046715 2.215998560274198e-07 0.7801344622909899 2.216000494211826e-07 0.775444374634302 2.216002499880375e-07 0.7705834242206392 \
2.21600397552439e-07 0.7670092004965298 2.216005275638896e-07 0.7638619034739171 2.216006624283032e-07 0.7605987503374771 2.216007689187539e-07 0.7580234999254772 \
2.216009006085467e-07 0.7548403390839162 2.216010070329759e-07 0.7522693550468039 2.21601150211605e-07 0.7488125398635642 2.216013113387162e-07 0.7449250928176189 \
2.216014295655331e-07 0.7420746008290786 2.216015997983541e-07 0.7379721584775248 2.216017657246235e-07 0.7339761998059781 2.216019852669538e-07 0.7286940862104242 \
2.216021784540779e-07 0.724050920820232 2.216023533680413e-07 0.719851304223293 2.216025203151389e-07 0.7158476177432674 2.216027078061003e-07 0.711355754450834 \
2.216028952345367e-07 0.7068709122373377 2.216030635710959e-07 0.7028473835914892 2.216032564016302e-07 0.6982428782038785 2.216033964513775e-07 0.694901318858167 \
2.216035527086664e-07 0.6911769338170629 2.216037468781132e-07 0.6865540563080536 2.216039059846016e-07 0.6827702245679255 2.216040643446318e-07 0.679008548037742 \
2.216042596617402e-07 0.6743756772263459 2.216044700905194e-07 0.6693917663527935 2.216047227926646e-07 0.6634173774538097 2.216049024606155e-07 0.6591769455535931 \
2.216051540374889e-07 0.6532475027332399 2.21605354410306e-07 0.6485340174553987 2.216055260641582e-07 0.6445032789616798 2.216056847562747e-07 0.6407814961122935 \
2.216058239642021e-07 0.637522316374186 2.216059602882518e-07 0.6343349641335875 2.216060875012759e-07 0.6313646237382058 2.216062169938336e-07 0.6283457899522861 \
2.216063449851212e-07 0.6253646753452949 2.216064760596301e-07 0.6223174651643489 2.216066067717051e-07 0.6192830747181834 2.216067493797576e-07 0.6159760732208495 \
2.216068921032356e-07 0.612672916206165 2.216070446510367e-07 0.6091471600588 2.216071891550245e-07 0.6058158037532523 2.216073531732721e-07 0.6020406322262999 \
2.216074906379333e-07 0.5988837056407329 2.21607625454949e-07 0.5957940466067043 2.216077469535923e-07 0.5930134750293682 2.216078858038966e-07 0.5898448108574432 \
2.216079994507128e-07 0.5872554148224447 2.216081508608854e-07 0.5838116422847746 2.216082645795603e-07 0.5812320812748947 2.216083839926513e-07 0.5785269636915771 \
2.216084726731778e-07 0.5765205397309219 2.216085638182694e-07 0.5744630259469776 2.216086291571447e-07 0.5729901393713442 2.216086936268468e-07 0.5715377831648228 \
2.21608744447459e-07 0.5703933076453638 2.216088034223984e-07 0.569066051987989 2.216088708671064e-07 0.5675516747474645 2.216089379592979e-07 0.5660472084764079 \
2.216089908797418e-07 0.5648615894615425 2.216090865272254e-07 0.5627204246953637 2.216091437083616e-07 0.5614413394337 2.216091975109775e-07 0.5602399192081799 \
2.216092592530825e-07 0.5588634520375642 2.216093450862141e-07 0.5569525037715509 2.216094277818617e-07 0.5551133137453282 2.21609553910589e-07 0.552313430559463 \
2.216096890096646e-07 0.5493247407981657 2.21609787329828e-07 0.5471534914294828 2.216098999078898e-07 0.5446716589975775 2.216100024523052e-07 0.5424173856211837 \
2.216101225611309e-07 0.5397821662853191 2.216102242487819e-07 0.5375541863492928 2.216103397527456e-07 0.5350300289250629 2.216104546438614e-07 0.5325260225312031 \
2.216105811211341e-07 0.5297740207092871 2.216107063383297e-07 0.5270565158317848 2.216108531843123e-07 0.5238798967507053 2.216109886424458e-07 0.5209557060405445 \
2.216111462030546e-07 0.5175672114705414 2.216113083572294e-07 0.5140875588169389 2.216114890683071e-07 0.5102248342695275 2.216116813160604e-07 0.5061308236654174 \
2.216118940383231e-07 0.5016182665703952 2.216121259434839e-07 0.4967183500883584 2.216123831371877e-07 0.4913135654247419 2.216126226904984e-07 0.4863004534671564 \
2.216129246203734e-07 0.4800178499336004 2.216132123868145e-07 0.4740665530855001 2.216135251890574e-07 0.4676409412178996 2.216138450208061e-07 0.4611139840073785 \
2.21614184657409e-07 0.4542292677834274 2.216145118732278e-07 0.4476411633207955 2.216148470347968e-07 0.4409363684817221 2.216151642914576e-07 0.4346351592989786 \
2.216154981114363e-07 0.4280489847791872 2.2161584979678e-07 0.4211625252737479 2.21616163864498e-07 0.4150547397555842 2.216164868937019e-07 0.4088175946446666 \
2.216169278730989e-07 0.4003732788922496 2.216172702759421e-07 0.3938810608698495 2.216175707238305e-07 0.3882325136127223 2.216179460534016e-07 0.3812375944419973 \
2.216182761286299e-07 0.3751439175705365 2.216185594064112e-07 0.3699597784791666 2.216188599137726e-07 0.3645020109013299 2.216191395612329e-07 0.3594637112692664 \
2.216193634235237e-07 0.3554634414471464 2.216195752745134e-07 0.35170280677964 2.216197776231135e-07 0.3481338771034005 2.216199787581392e-07 0.3446120049995081 \
2.216201845356566e-07 0.3410324794262659 2.216204455143708e-07 0.3365252478245505 2.216206850045531e-07 0.3324209773202946 2.21620917679624e-07 0.3284665339262754 \
2.216211317612159e-07 0.3248537323113044 2.216213529069831e-07 0.3211475567840967 2.21621553789873e-07 0.3178053707831449 2.216217571810749e-07 0.3144500223650613 \
2.216219548494876e-07 0.3112139453100684 2.216221410931751e-07 0.3081862077816076 2.216223360742573e-07 0.3050391973134606 2.216225395365023e-07 0.3017803754370622 \
2.216227174774077e-07 0.2989521325826759 2.216229532011123e-07 0.2952356640875101 2.216231513339656e-07 0.2921385263640672 2.216233526780327e-07 0.2890160050544278 \
2.216235769672297e-07 0.2855690750291008 2.216237418971288e-07 0.2830551950838826 2.216239195258139e-07 0.2803657404651576 2.216241039249613e-07 0.2775946687427531 \
2.216242877463064e-07 0.2748547260732712 2.216244662029787e-07 0.2722194282383935 2.216246381032459e-07 0.2696976713509589 2.216247986436534e-07 0.2673699088296289 \
2.216249201257116e-07 0.265617282026588 2.216250730472387e-07 0.2634201198254058 2.21625200480934e-07 0.2616085083773952 2.216253046546047e-07 0.2601317890528609 \
2.216254215590816e-07 0.2584775571399547 2.21625536570573e-07 0.2568557450124987 2.216256609328034e-07 0.2551103168403305 2.216257765070866e-07 0.2534925198640895 \
2.216259106146075e-07 0.2516172680784447 2.216260256018485e-07 0.2500177396912131 2.216261793514453e-07 0.2478798443778067 2.216263161546458e-07 0.2459790966208961 \
2.21626450740453e-07 0.2441094379339017 2.216266066045887e-07 0.2419575875351012 2.216267312534115e-07 0.2402378086535915 2.216268704689347e-07 0.2383186229544463 \
2.2162700069296e-07 0.236525770455347 2.216271210458007e-07 0.2348769158236033 2.216272564390845e-07 0.233027137746051 2.216274076440629e-07 0.2309620730808924 \
2.216275424005331e-07 0.2291249940296414 2.216276470867202e-07 0.2277003186426776 2.216277696228612e-07 0.2260366668203369 2.2162790456742e-07 0.2242086518061946 \
2.216279996831675e-07 0.2229209267876512 2.216281149432224e-07 0.2213657311907907 2.216281974762018e-07 0.2202562617028589 2.216282686815329e-07 0.2192992955643472 \
2.216283173890172e-07 0.2186449771734718 2.216283645839733e-07 0.2180112263680214 2.216284111327915e-07 0.2173864029843717 2.216284645213553e-07 0.2166701476649976 \
2.216285018980252e-07 0.2161690444847812 2.216285392831377e-07 0.2156680710113931 2.21628579604508e-07 0.2151283464800275 2.216286508546475e-07 0.2141753141901174 \
2.216286850689041e-07 0.2137180869447317 2.216287314635346e-07 0.2131018213873352 2.216287919072008e-07 0.2122998083652294 2.216288609101202e-07 0.2113853596849882 \
2.216289262050716e-07 0.210520730631805 2.216289941831954e-07 0.2096212333552783 2.21629110629525e-07 0.2080823984153433 2.216292005517136e-07 0.2068957989735914 \
2.216293082176197e-07 0.2054771097790837 2.216294042789353e-07 0.2042146625011118 2.216295076575089e-07 0.2028641889872041 2.216296043425437e-07 0.2016026287683381 \
2.216297071523967e-07 0.2002625524503448 2.216298079123679e-07 0.1989526210414513 2.216299190580346e-07 0.1975116692735505 2.216300260975286e-07 0.1961279675313261 \
2.216301440040638e-07 0.1946083430154048 2.216302521143875e-07 0.1932197128021231 2.216303614129877e-07 0.1918224631760269 2.216304820447392e-07 0.1902849927564414 \
2.216305769453309e-07 0.1890796997295432 2.216307055062502e-07 0.18745262875399 2.216307985410385e-07 0.1862801166370808 2.216309009375946e-07 0.1849947785893032 \
2.216309889048857e-07 0.1838942174288659 2.216310871755573e-07 0.182668828510528 2.216311837761789e-07 0.1814691026470878 2.216312704146924e-07 0.1803971466393716 \
2.216313568237045e-07 0.1793305247657973 2.216314526608142e-07 0.1781527189679156 2.216315573876885e-07 0.1768710765218302 2.216317031999754e-07 0.1750963017969037 \
2.216318191679069e-07 0.1736923427161618 2.216319756317111e-07 0.1718092975148396 2.2163208681163e-07 0.1704786474822015 2.216322270616306e-07 0.1688098560703619 \
2.216323500730353e-07 0.1673544160765056 2.216324565640335e-07 0.1661007559767333 2.216325528894916e-07 0.1649724583647661 2.216326503229586e-07 0.1638357962207703 \
2.216327541762373e-07 0.1626293386330815 2.216328459768101e-07 0.1615673458739011 2.216329443645254e-07 0.1604337426303964 2.216330272831699e-07 0.1594828374885931 \
2.216331226515033e-07 0.1583950132920943 2.216332052138516e-07 0.1574587876231885 2.216333077985372e-07 0.1563016192679324 2.21633384076854e-07 0.1554454316211293 \
2.216334726624788e-07 0.1544557264474612 2.216335448319839e-07 0.1536532700165102 2.216336265414731e-07 0.1527486200895024 2.216337002202809e-07 0.1519363404455653 \
2.216337804404095e-07 0.1510573496788611 2.216338521684844e-07 0.1502755532525617 2.216339204254628e-07 0.149534520573691 2.216340181414224e-07 0.1484788062294206 \
2.216340875916063e-07 0.147731872792437 2.216341703430852e-07 0.1468455801890639 2.216342303799948e-07 0.1462052652532956 2.216343006186586e-07 0.1454587420502366 \
2.216343720461929e-07 0.1447037411390827 2.216344525596948e-07 0.1438588888651768 2.216345158225991e-07 0.1431977449412327 2.216345934965784e-07 0.1423892845091393 \
2.216346828063428e-07 0.141463758692191 2.216347521699289e-07 0.1407479403162204 2.216348501181493e-07 0.1397418416088305 2.216349404626691e-07 0.1388188591118084 \
2.216350262429942e-07 0.1379520826379384 2.21635093896779e-07 0.1372719511642241 2.216351602046294e-07 0.1366075914250998 2.21635238824321e-07 0.1358227655030745 \
2.216353195192302e-07 0.135020537018139 2.21635377921894e-07 0.1344419857224206 2.216354386744168e-07 0.1338420332148588 2.21635532580729e-07 0.1329184183639811 \
2.216355749782324e-07 0.1325029080242558 2.216356542224261e-07 0.1317336600863391 2.216356945925846e-07 0.1313430593815061 2.216357842934634e-07 0.130477658168832 \
2.216358232415503e-07 0.1301029732927899 2.216359188572359e-07 0.1291862249441596 2.216359577410651e-07 0.1288146335111444 2.21636050975841e-07 0.1279263274670414 \
2.2163611931843e-07 0.1272775968534341 2.216361716392852e-07 0.1267823325594629 2.216362537399991e-07 0.1260075984242486 2.216363249033783e-07 0.1253406747583812 \
2.216364028563663e-07 0.1246136378429537 2.216364819761022e-07 0.1238779526756392 2.21636560619333e-07 0.1231489004754178 2.216366406542416e-07 0.122409328367501 \
2.216367023886578e-07 0.1218405706457005 2.216367759836405e-07 0.1211645344030958 2.216368593634578e-07 0.120401093559758 2.216369234601888e-07 0.1198161795466899 \
2.216369928987769e-07 0.119184869057559 2.216370659217156e-07 0.1185234239195788 2.216371507966272e-07 0.1177582144838446 2.216372301594785e-07 0.117046673033812 \
2.216373148931361e-07 0.1162898833629492 2.216374056044255e-07 0.1154830714735263 2.216374811875037e-07 0.1148135241260771 2.216375469154284e-07 0.1142333070693714 \
2.216376069752011e-07 0.1137047561823949 2.216376765809174e-07 0.1130943456353956 2.216377429999685e-07 0.1125141752866663 2.216378224112316e-07 0.1118230150855203 \
2.216379126741612e-07 0.1110406875128299 2.216379817184613e-07 0.1104447270551955 2.216380562735805e-07 0.1098035355921305 2.216381447575013e-07 0.1090456469739195 \
2.216382238656483e-07 0.1083709350695736 2.216382937340289e-07 0.1077773127978274 2.216383747433988e-07 0.1070920034756896 2.216384309482126e-07 0.106618206733547 \
2.216384936074922e-07 0.1060916009495399 2.216385587540976e-07 0.105545887371837 2.216386300897258e-07 0.1049504956797945 2.216387503861013e-07 0.1039516085561449 \
2.216388019396737e-07 0.103525508500865 2.216388570887417e-07 0.1030709598036589 2.216389477859257e-07 0.1023262935955709 2.216390301757782e-07 0.1016530765296615 \
2.216391257555856e-07 0.1008759670630478 2.216392329651519e-07 0.1000092507657299 2.216393366245585e-07 0.09917656019160864 2.216394228321611e-07 0.09848810438956324 \
2.216395090743862e-07 0.09780303991321163 2.216395886154605e-07 0.09717448010577609 2.216396686283335e-07 0.09654538840876434 2.216397599166613e-07 0.09583163072761708 \
2.216398416620796e-07 0.09519620281310773 2.216399305889172e-07 0.09450872319168514 2.216400203662242e-07 0.09381864801001834 2.216400973288722e-07 0.09323024625953365 \
2.216401876536891e-07 0.0925435244861572 2.216402514624153e-07 0.09206084550525626 2.216403239259827e-07 0.09151514907748673 2.216403880546354e-07 0.09103438864950099 \
2.216404663020107e-07 0.09045054736970405 2.216405660032922e-07 0.08971110930136832 2.216406400564437e-07 0.08916512281998501 2.216407266649787e-07 0.08852997392441805 \
2.216408729646849e-07 0.08746544055362569 2.216409836769483e-07 0.08666684197409438 2.216410939866262e-07 0.08587717033461532 2.216412361822689e-07 0.08486839672072237 \
2.216413762347203e-07 0.08388450488753585 2.216415188805343e-07 0.08289222299161547 2.21641667651249e-07 0.08186778387581196 2.216418043639349e-07 0.08093569403044946 \
2.21641946484565e-07 0.07997640434545976 2.21642081061545e-07 0.07907728405019222 2.21642221281423e-07 0.07814997945867638 2.216423690282294e-07 0.07718353387841098 \
2.216425189824149e-07 0.07621348085094087 2.216426836982467e-07 0.07516037195605636 2.216428472843634e-07 0.07412732798506308 2.216430219327157e-07 0.07303837372665309 \
2.216432089864081e-07 0.07188781219077654 2.216434189729257e-07 0.0706159374129187 2.216436370461739e-07 0.06931715807027321 2.216438703663275e-07 0.06795188046253516 \
2.216441248458817e-07 0.0664909822812602 2.2164441780254e-07 0.06484528303377844 2.21644719953089e-07 0.06318745987130532 2.216450576747916e-07 0.06138078634948794 \
2.216454527833931e-07 0.05932807220464856 2.216458202346361e-07 0.05747953410674719 2.216462378424018e-07 0.05544691527644593 2.216465828383762e-07 0.0538196438399016 \
2.216469333806655e-07 0.05221302159193914 2.21647248341029e-07 0.0508087490907442 2.216475475823956e-07 0.049508488261462 2.216478469482477e-07 0.04824029756235761 \
2.216481221909583e-07 0.04710512226277328 2.216484056545246e-07 0.04596497870754415 2.216486672549465e-07 0.04493681260994405 2.216489447070712e-07 0.04387103439794762 \
2.216492207665063e-07 0.04283531238677037 2.21649529036243e-07 0.04170718945545093 2.216497514688635e-07 0.0409114719535993 2.21650039009947e-07 0.03990505631995635 \
2.216502752428796e-07 0.0390969788355163 2.216505937045548e-07 0.03803800466874574 2.21650844115589e-07 0.03722710566490722 2.216511671003914e-07 0.03620720400565681 \
2.216514254364062e-07 0.03541203096995557 2.216517154102847e-07 0.03454066075983582 2.216519452051025e-07 0.0338658635512188 2.216522301004437e-07 0.03304787219836024 \
2.21652469846563e-07 0.03237513696606491 2.216527104811323e-07 0.03171392889024889 2.216529495996188e-07 0.03107212555077287 2.216531855385298e-07 0.03045460689686571 \
2.21653416367391e-07 0.02986254663395104 2.216536313939186e-07 0.02932175456294728 2.216540335597598e-07 0.0283374222946415 2.2165423211788e-07 0.02786401170979088 \
2.216546058190659e-07 0.02699470773596776 2.216547926322608e-07 0.02657042318767052 2.216551386335082e-07 0.02580176906824739 2.216552605769465e-07 0.02553595448027303 \
2.216556434299635e-07 0.02472011952872977 2.216558038641492e-07 0.02438657631284594 2.216562468653031e-07 0.02348572425118655 2.216564174793446e-07 0.02314627247835563 \
2.216567380559406e-07 0.02251902970747987 2.216569383408681e-07 0.0221336684630111 2.216573852788009e-07 0.02128811173678137 2.216575132229166e-07 0.02104854104185888 \
2.21658001100276e-07 0.02014826272243131 2.21658136077553e-07 0.01990454278080647 2.216586183290713e-07 0.0190640092473091 2.216587806551862e-07 0.01879235028057063 \
2.216592670495272e-07 0.01801148170254873 2.216594300771863e-07 0.01776103207540622 2.216601102988766e-07 0.01676849304257711 2.216602493826145e-07 0.01657541006259178 \
2.216609818771477e-07 0.01560782569993242 2.216611407707804e-07 0.01540693214221847 2.216619238518671e-07 0.01445869962397344 2.216620696444218e-07 0.01428952172302696 \
2.216629204257814e-07 0.01334248985256295 2.21663031529053e-07 0.01322388191882306 2.216639648234166e-07 0.0122699293983148 2.216640986614658e-07 0.01213902814618388 \
2.21665057199482e-07 0.01123495036716388 2.216651783165509e-07 0.01112486091825863 2.216663004003486e-07 0.01017270671243764 2.216664059016017e-07 0.01008921053061839 \
2.216677349760139e-07 0.009112307258623473 2.216678551802884e-07 0.009029744095492466 2.21669403542048e-07 0.008036808760534916 2.216694843298185e-07 0.007986285493236449 \
2.216710552093519e-07 0.007024564730313319 2.216711226255509e-07 0.006986095570813155 2.216730433922295e-07 0.006001386377072119 2.216732301941131e-07 0.005914747648762168 \
2.216755456080606e-07 0.0049318160947762 2.216759451349076e-07 0.004777795182599986 2.216785089444083e-07 0.003889929704329555 2.216790078153284e-07 0.003736330440833864 \
2.21682637539317e-07 0.002784984367379526 2.216831882332918e-07 0.002663729254427667 2.216885866736714e-07 0.001711392372544448 2.216888999412434e-07 0.001662511220227468 \
2.216938922337914e-07 0.0006970413096974805 2.216940762528259e-07 0.0006571176749162138 2.243425553956096e-07 -0.0002691198397987355 2.243427114545721e-07 -0.0004551674219448388 \
2.243432594384272e-07 -0.001322174727784445 2.243433723764199e-07 -0.001539785040943742 2.243438016313499e-07 -0.002474302920374066 2.24343907888515e-07 -0.002730173903076456 \
2.243441906906666e-07 -0.003454402452283872 2.243443042852103e-07 -0.003760966378165151 2.243446428397891e-07 -0.004705104513819927 2.243447552637498e-07 -0.005021586953003071 \
2.243450835416507e-07 -0.005887841248467669 2.243451910801718e-07 -0.006130875888161453 2.243460710062032e-07 -0.005789627805322099 2.243462462122502e-07 -0.004910736584223327 \
2.243463630430134e-07 -0.004127745010746014 2.243464899101376e-07 -0.00309221842859156 2.243465914428629e-07 -0.002125750314016509 2.243467128641333e-07 -0.0008095618968406578 \
2.243468030290462e-07 0.0002767910803854594 2.243469002126957e-07 0.001550247908954045 2.243469982869598e-07 0.002938803805678211 2.243471655080454e-07 0.005530627736217106 \
2.243473878133234e-07 0.009378371294171852 2.243475735517141e-07 0.01290572951649239 2.243477976330495e-07 0.01747895571448658 2.243479572777817e-07 0.02091945933227325 \
2.243481217671113e-07 0.02459614091902196 2.243482715915693e-07 0.0280452875125503 2.243484209914613e-07 0.03156498790849799 2.243485705227667e-07 0.03515592969144176 \
2.243487246026614e-07 0.03891669635189081 2.243488867868089e-07 0.0429309674228065 2.24349053210035e-07 0.0470989728378523 2.243492291435082e-07 0.05154884981278444 \
2.24349410271779e-07 0.05616867911875007 2.243496024027047e-07 0.06110225049351239 2.24349810098117e-07 0.0664648391313285 2.243500320181979e-07 0.07222051812179281 \
2.243502672196804e-07 0.07834079218654426 2.243505194059893e-07 0.08491829088081257 2.243507955452241e-07 0.09213111703448683 2.243510966667008e-07 0.1000001933597138 \
2.243514285865622e-07 0.1086702418150647 2.243518059053303e-07 0.1185147411083515 2.243522041953866e-07 0.1288888856248832 2.243526735037065e-07 0.1410822143415975 \
2.243532195292308e-07 0.1552200475789812 2.243538544895379e-07 0.1715918832733369 2.243545538901293e-07 0.1895291194622146 2.243553721290552e-07 0.2103807608661494 \
2.243562778230217e-07 0.2332840710921665 2.243570673340878e-07 0.253091928008631 2.243577710929056e-07 0.2706124241987875 2.243583889437195e-07 0.2858796548825839 \
2.243589545671311e-07 0.2997575097153312 2.243594763024047e-07 0.3124620269501652 2.243599740861211e-07 0.3244932238414255 2.243604577240811e-07 0.3360954048923613 \
2.243609145982154e-07 0.3469667650518959 2.243613874391095e-07 0.3581213589834248 2.243618270524661e-07 0.3684065070151987 2.24362314929562e-07 0.379719432411247 \
2.243628457299846e-07 0.3919028193132517 2.243633436253595e-07 0.4032143644097119 2.24363775002613e-07 0.41292177789323 2.243642618898012e-07 0.4237731225600331 \
2.243647619892433e-07 0.4348012155672935 2.243651066099338e-07 0.4423321287141763 2.243654600037777e-07 0.4500000647748709 2.243658877736169e-07 0.4592134948422093 \
2.243662796346881e-07 0.4675816212925634 2.243665799290445e-07 0.4739471552041949 2.243669218601248e-07 0.4811428413521782 2.243672651945704e-07 0.4883132334011818 \
2.24367525955058e-07 0.4937215836208605 2.243677680115876e-07 0.4987106167174703 2.243680340100557e-07 0.5041617362307154 2.243682934982395e-07 0.5094435946950286 \
2.243684834145397e-07 0.5132872703533161 2.243686986491409e-07 0.5176241792560061 2.243688371999001e-07 0.5204025546691405 2.243689820806791e-07 0.5232962183003332 \
2.243691954947458e-07 0.5275364624051522 2.243693975193605e-07 0.5315382148201082 2.243695902480239e-07 0.5353370730264509 2.243697755034039e-07 0.5389735557287745 \
2.243699525009277e-07 0.5424323215059959 2.243702617642633e-07 0.5484573594957171 2.243705229123106e-07 0.5535233414883098 2.243708247314806e-07 0.5593562770234363 \
2.243710801601219e-07 0.5642781701956761 2.243713725156194e-07 0.5698968483756405 2.243716319698133e-07 0.5748654731717864 2.243719020897901e-07 0.5800301911327002 \
2.243721441003479e-07 0.5846380733684551 2.24372401610146e-07 0.5895273573494454 2.243726280544834e-07 0.5938057549890672 2.243728649429657e-07 0.5982619499065401 \
2.24373074987873e-07 0.6021962733001386 2.243732879185847e-07 0.6061670177072124 2.243735413972821e-07 0.6108668889270118 2.24373744692931e-07 0.6146150465592417 \
2.243739363811142e-07 0.6181346807088086 2.243741250074786e-07 0.6215812235468744 2.243743123254166e-07 0.6249823889551316 2.243745179374062e-07 0.6286953279350977 \
2.243747677606249e-07 0.6331759959753138 2.243749715724035e-07 0.6368063379741715 2.243751792111212e-07 0.6404826298163093 2.24375371862737e-07 0.6438748386876914 \
2.243756164748105e-07 0.6481531432733096 2.243758643733136e-07 0.6524620620600715 2.243760442082188e-07 0.6555644139995785 2.243762349822552e-07 0.6588391718544121 \
2.24376388158437e-07 0.6614554104590837 2.243765598271469e-07 0.6643705886591137 2.243767102939677e-07 0.6669108747194671 2.243768468979714e-07 0.6692010654183506 \
2.243769963383726e-07 0.6716954191563786 2.243771240725235e-07 0.6738189269502312 2.2437726394477e-07 0.6761323074508511 2.24377388021905e-07 0.6781756764962316 \
2.243775193832699e-07 0.6803315871556701 2.243776435547311e-07 0.6823627547057004 2.243777813315919e-07 0.6846081866267727 2.243779015758123e-07 0.6865586181592046 \
2.243780436284175e-07 0.6888545186016138 2.243781438561225e-07 0.6904668682779994 2.243782651601134e-07 0.6924123325129877 2.243783561353879e-07 0.6938641504265992 \
2.243784535186708e-07 0.695411869780077 2.243785506015381e-07 0.6969507228893711 2.243786398841584e-07 0.6983595753378042 2.243787378559428e-07 0.699898781449533 \
2.243788681310304e-07 0.7019319515314388 2.243790215432551e-07 0.7043083163565919 2.243791571090672e-07 0.7063909659299702 2.24379301449562e-07 0.708591461371511 \
2.243794273204452e-07 0.710496752775434 2.243795523478311e-07 0.712376488910674 2.243796666301914e-07 0.7140841686551523 2.243797776133356e-07 0.7157331888171029 \
2.243798773084046e-07 0.7172065512867005 2.243800143526226e-07 0.7192196995505324 2.243801333798347e-07 0.7209572005600779 2.24380253677943e-07 0.7227029412191364 \
2.243803801768634e-07 0.7245276185835638 2.243805041084668e-07 0.7263044524160376 2.243806283948001e-07 0.7280754330070212 2.24380754759953e-07 0.7298652243312684 \
2.243808845716946e-07 0.7316925631262517 2.243810084102138e-07 0.7334254795816325 2.243811411911006e-07 0.735272086289578 2.243812420423058e-07 0.7366670415914529 \
2.243813552339755e-07 0.738224777043618 2.243814420199563e-07 0.7394137384482823 2.243815586452529e-07 0.7410021813026957 2.243816479345105e-07 0.7422110784210975 \
2.243817591113938e-07 0.7437075443329063 2.243818883701577e-07 0.7454347509364776 2.243820022291937e-07 0.7469455276109591 2.243821066334058e-07 0.74832188588007 \
2.243822310004373e-07 0.7499498655229884 2.243823782406159e-07 0.7518616907275563 2.243824985209068e-07 0.753411006437983 2.243826144254459e-07 0.7548933175676444 \
2.243827545012897e-07 0.7566706674475765 2.243828971129601e-07 0.7584645678799224 2.243830150672032e-07 0.7599365027959469 2.243831418837122e-07 0.7615071445339606 \
2.243832827668562e-07 0.7632375905494565 2.243834025603537e-07 0.7646969139886852 2.243835475192107e-07 0.7664484133613445 2.243836690779963e-07 0.7679052725436226 \
2.243837881174897e-07 0.7693214142140735 2.243839097488533e-07 0.7707575700077021 2.243840377178317e-07 0.772256936813787 2.243841469330139e-07 0.7735272422640712 \
2.243842718238923e-07 0.774969549136603 2.24384378939953e-07 0.7761978171588899 2.243845121931473e-07 0.7777146071439789 2.243846392965933e-07 0.7791497354387434 \
2.243847610475684e-07 0.7805132846941326 2.243848776321508e-07 0.7818078758210534 2.24384983459753e-07 0.7829735233300771 2.243851228258954e-07 0.7844949153190801 \
2.243852718976944e-07 0.786105286864636 2.24385419626362e-07 0.7876841235632186 2.243855389322397e-07 0.7889471147195867 2.243856729390521e-07 0.7903527806482344 \
2.243857933652268e-07 0.791604423795974 2.243859349104043e-07 0.7930616786923709 2.243860823364167e-07 0.7945638089648995 2.243862068109252e-07 0.7958198087139573 \
2.243863258549181e-07 0.7970105506108808 2.243864374452017e-07 0.7981174590942314 2.243865426744905e-07 0.7991530841216606 2.243866381855941e-07 0.8000862307887144 \
2.243867742475476e-07 0.8014036057482816 2.243868911236816e-07 0.8025237700417888 2.243870102773537e-07 0.8036549841722296 2.24387132589548e-07 0.8048050501807249 \
2.243872558616218e-07 0.8059526272620129 2.243873823583984e-07 0.8071184350969989 2.243875078610623e-07 0.8082633544790385 2.243876385869669e-07 0.8094437311890262 \
2.243877641549387e-07 0.8105658358439867 2.243878932098036e-07 0.8117072367686948 2.243879990659606e-07 0.8126345588578442 2.243881002348366e-07 0.8135133322873783 \
2.243881948546566e-07 0.8143286754242188 2.243883191357402e-07 0.8153900871385379 2.243884088474262e-07 0.816149614585347 2.243885078849502e-07 0.8169816577628611 \
2.243886456628271e-07 0.8181280288377792 2.243887801986773e-07 0.81923501721715 2.243888886049436e-07 0.8201180631035904 2.243890385184474e-07 0.8213254631869725 \
2.243891890970255e-07 0.8225223201378843 2.243893145921802e-07 0.8235077122548546 2.24389458438707e-07 0.8246238332260477 2.243895830219706e-07 0.8255790649890803 \
2.243897318751914e-07 0.8267066458678887 2.243898680237751e-07 0.827725029289517 2.243899930476024e-07 0.8286494160599757 2.243901107545823e-07 0.8295103773055483 \
2.243902563935805e-07 0.8305630309532103 2.243904227748753e-07 0.8317484146982921 2.243905533585646e-07 0.8326660250626342 2.243907268806749e-07 0.8338683097812621 \
2.243908950025776e-07 0.8350147136930499 2.243910648651803e-07 0.8361549927788252 2.243912457668832e-07 0.8373497079260466 2.243913888761651e-07 0.8382806519784776 \
2.24391502965127e-07 0.839013953006387 2.243916331276036e-07 0.8398410866028793 2.243917349727342e-07 0.8404811280669765 2.243918517989402e-07 0.8412075886390841 \
2.243919886903802e-07 0.8420483852080155 2.24392186497604e-07 0.843243620449199 2.243923781227506e-07 0.8443797466267589 2.24392587554618e-07 0.8455974227529048 \
2.243927695012999e-07 0.8466352798309468 2.243929666301539e-07 0.8477391449715804 2.243931399710144e-07 0.8486924050423899 2.243933229793209e-07 0.8496814535024207 \
2.243934941423557e-07 0.8505903669473519 2.243936687794506e-07 0.851501688465695 2.243938440392814e-07 0.8524001683007644 2.243940201897297e-07 0.8532872510191711 \
2.243942104700295e-07 0.8542278331088334 2.2439440106916e-07 0.8551519386507073 2.243946016923949e-07 0.8561055033533737 2.2439479430095e-07 0.8570028516027762 \
2.243950049816413e-07 0.8579644845832216 2.243952330831089e-07 0.8589827023971403 2.243954988710916e-07 0.860139640227508 2.243957974838522e-07 0.8614018215255795 \
2.243960737724907e-07 0.8625348754565382 2.243963580090103e-07 0.8636666213345715 2.243966322137804e-07 0.8647267940813509 2.243969044486385e-07 0.8657495569722869 \
2.243971746527799e-07 0.8667361702337206 2.243974318083905e-07 0.867649441901348 2.243977043886041e-07 0.8685908808535525 2.2439798037489e-07 0.8695169452638583 \
2.24398250477721e-07 0.870397355937691 2.243985503347982e-07 0.8713451925332844 2.243989213624563e-07 0.8724761722512941 2.243992162997666e-07 0.8733433185969293 \
2.243994705892065e-07 0.8740690226522811 2.243997688459906e-07 0.874895168896023 2.244000424554269e-07 0.8756299040683481 2.244002785839137e-07 0.8762466977562872 \
2.244005189298274e-07 0.8768585021646264 2.244007412634921e-07 0.8774104263690854 2.244009352691695e-07 0.8778812671168952 2.244012649918855e-07 0.8786590883967833 \
2.244014201653189e-07 0.8790156160651978 2.244017379413894e-07 0.8797272612331356 2.244019168030317e-07 0.8801171459162566 2.244022592648612e-07 0.8808425821290963 \
2.244024433930207e-07 0.881221400612852 2.244029182707539e-07 0.8821634994206867 2.244030856669651e-07 0.8824839765989225 2.244035515089056e-07 0.8833452998114757 \
2.244037323309576e-07 0.8836679564577563 2.244042263693833e-07 0.8845176198113115 2.24404367718007e-07 0.8847523712107549 2.244049740520726e-07 0.8857188576377059 \
2.244051261213959e-07 0.8859512996759633 2.244057728095585e-07 0.8868983431897121 2.2440590110417e-07 0.8870786909355212 2.244065492212318e-07 0.8879538337624689 \
2.244066790202949e-07 0.8881220828502663 2.244074572237723e-07 0.8890807033877333 2.24407572278734e-07 0.8892148977954012 2.244084279402065e-07 0.8901543051721961 \
2.244085733010758e-07 0.8903040038307473 2.244095590571273e-07 0.8912446482480114 2.244097801624957e-07 0.8914382978987679 2.244109252894234e-07 0.8923659558950503 \
2.244110565064392e-07 0.8924678262926897 2.244123977150129e-07 0.8934599079028542 2.24412549114272e-07 0.8935646301988298 2.244140305519949e-07 0.8944937559627255 \
2.244142694313731e-07 0.8946275407274444 2.244160387469791e-07 0.8955013787854181 2.244164278981914e-07 0.8956696032899972 2.244188215611418e-07 0.8965547188539188 \
2.244192972701398e-07 0.8967039926079825 2.244233604302104e-07 0.8977020505850396 2.24423851854269e-07 0.8977948037134476 2.24432168453822e-07 0.898787348739254 \
2.244330883529499e-07 0.8988506593152591 2.245765735834803e-07 0.8998476076348748 2.245776920164557e-07 0.8998537475785264 2.247827836359558e-07 0.898985773748599 \
2.247830107254573e-07 0.8988224379910277 2.247846203322555e-07 0.8978282360369357 2.247847977407988e-07 0.8977338482811539 2.248017048890996e-07 0.8987315468430059 \
2.248018143281978e-07 0.8987460089186867 2.248175950494439e-07 0.8997418097871094 2.248178913753395e-07 0.8997476966799167 2.25301325027745e-07 0.9007060148833608 \
2.253014540780854e-07 0.9008313386292994 2.253021042279306e-07 0.9016292186224167 2.253022937236614e-07 0.9019133038041363 2.253027969456399e-07 0.9027675859898705 \
2.253029324182996e-07 0.9030208676018907 2.253033328770163e-07 0.9038195223753869 2.253034648149532e-07 0.9040958310886574 2.253038660300167e-07 0.9049509627747726 \
2.253039642901937e-07 0.9051582028152527 2.253044301640043e-07 0.9060587574877488 2.253045916627274e-07 0.9063060456044927 2.253057356752505e-07 0.9055153668657776 \
2.253058806545959e-07 0.9049059606760256 2.253060592073535e-07 0.9039396653125833 2.253062394026313e-07 0.9027054491383806 2.253063820935606e-07 0.9015369228101149 \
2.253064992531646e-07 0.9004524619440171 2.253065882345255e-07 0.8995505656965809 2.253066798781777e-07 0.8985529714258781 2.253068129901104e-07 0.8969831049011855 \
2.253069067111929e-07 0.8957895978311226 2.253069978500018e-07 0.8945634483845346 2.253071111423133e-07 0.8929516940777753 2.253072142512258e-07 0.8913998138690341 \
2.253073105184064e-07 0.8898830246517148 2.253074296555229e-07 0.8879200664089764 2.253075982407716e-07 0.8849885378698126 2.253077600122728e-07 0.8820195265790133 \
2.253079532313317e-07 0.8782956415026882 2.253081387944432e-07 0.8745571577041361 2.253083490607478e-07 0.8701566079887386 2.253085313097886e-07 0.8662213066841463 \
2.253087161731834e-07 0.8621339172744639 2.253088888583302e-07 0.8582419637438897 2.253090749664034e-07 0.8539816046497358 2.253092527824914e-07 0.849858603441091 \
2.253094334990722e-07 0.8456251963850057 2.253095986373313e-07 0.8417258760277182 2.253097639114333e-07 0.837798995916667 2.253099271590959e-07 0.8339004324287677 \
2.253100857493696e-07 0.8300982805770993 2.253102626737714e-07 0.8258418712800655 2.253104591875839e-07 0.8211009660847696 2.253106267441254e-07 0.8170498602679914 \
2.253107934845439e-07 0.8130123908857781 2.253109679080616e-07 0.8087844286215062 2.253111372776842e-07 0.8046757316210446 2.253113054767786e-07 0.8005936994537799 \
2.25311494325046e-07 0.7960093488074458 2.253116851408819e-07 0.7913773844868103 2.253118935230917e-07 0.7863203192056716 2.25312119942597e-07 0.7808277108969495 \
2.253123091427939e-07 0.7762391340290878 2.253125192894832e-07 0.7711455503222944 2.253126680579875e-07 0.7675418410361046 2.253127990509761e-07 0.7643705172588006 \
2.25312936616212e-07 0.7610417440783073 2.253130423674414e-07 0.7584842184275663 2.253131771410752e-07 0.7552262509102785 2.253132889738005e-07 0.7525244432456109 \
2.253134184089644e-07 0.7493992292091655 2.253135735976883e-07 0.7456545577979357 2.253136852334407e-07 0.7429626190147979 2.253138448080549e-07 0.7391166470929011 \
2.253140201296882e-07 0.7348935218456193 2.253142325051509e-07 0.7297828120356423 2.253144253876789e-07 0.7251458607116523 2.253145820889711e-07 0.7213823872711312 \
2.253147687636618e-07 0.716903961299824 2.253149576500111e-07 0.7123775767926828 2.253151485342027e-07 0.70780884692282 2.253153352821382e-07 0.7033444557767304 \
2.253155183669542e-07 0.698972331957095 2.253156556859354e-07 0.6956951921588121 2.253158089288925e-07 0.6920418367118417 2.253160040575431e-07 0.6873949992893974 \
2.253161613518718e-07 0.6836535194673684 2.25316320746467e-07 0.6798660670227984 2.253165164902601e-07 0.6752219404489795 2.253167086893939e-07 0.6706682621108646 \
2.253169436410222e-07 0.6651105611269369 2.2531713111727e-07 0.6606839627962382 2.253173683544039e-07 0.6550894036851447 2.253175575343661e-07 0.6506361170423679 \
2.253177381501785e-07 0.6463915264929231 2.253179018447415e-07 0.6425504277539856 2.253180463961504e-07 0.6391628119244788 2.2531818686792e-07 0.6358764726647652 \
2.253183139687075e-07 0.6329064225879303 2.253184462761836e-07 0.6298198307262635 2.253185728632297e-07 0.626870110582017 2.253187034434976e-07 0.62383130535404 \
2.253188327128966e-07 0.6208285625908692 2.253189718197929e-07 0.6176004736356133 2.253191203301029e-07 0.6141606483517721 2.253193098786583e-07 0.6097777958748198 \
2.253194555819145e-07 0.6064170107178907 2.253196906324779e-07 0.601007464699683 2.253198736317494e-07 0.5968099615921 2.253200979734226e-07 0.5916778694808832 \
2.253202691466717e-07 0.5877753019413697 2.253204014804909e-07 0.5847634284691802 2.253205332770303e-07 0.5817721407249107 2.253206398209335e-07 0.5793579518205488 \
2.25320735711292e-07 0.5771868999037388 2.25320828211542e-07 0.5750974572268882 2.25320920638905e-07 0.5730134868920421 2.253209930672116e-07 0.5713818265150021 \
2.25321048796317e-07 0.5701269325864891 2.253211099054046e-07 0.5687522410723198 2.2532120667008e-07 0.5665806864277688 2.253212681615946e-07 0.5652027770813386 \
2.253213272142164e-07 0.5638802801505602 2.253214028408818e-07 0.5621878686488651 2.253214698636602e-07 0.5606896577364279 2.253215434607697e-07 0.5590483558003441 \
2.253216110667724e-07 0.5575429304381756 2.253217271358289e-07 0.5549610936632026 2.253218273422345e-07 0.5527359403974305 2.253219393494244e-07 0.5502565947066531 \
2.253220338414751e-07 0.5481686943853854 2.253221549961726e-07 0.5454955387196141 2.253222551839389e-07 0.5432910220514219 2.253223711744508e-07 0.5407443765731218 \
2.253224788782885e-07 0.5383833065966291 2.253225884569768e-07 0.5359861028148916 2.253227005784207e-07 0.5335400310751951 2.253228275156047e-07 0.5307765704644959 \
2.253229496651232e-07 0.5281221248815906 2.253230894260377e-07 0.525095489155881 2.253232265641539e-07 0.522132778766487 2.253233765292442e-07 0.5189020692106626 \
2.253235353022474e-07 0.5154923220538846 2.253237093279044e-07 0.511765695450105 2.25323896158028e-07 0.5077823379664483 2.253241011259936e-07 0.5034264211640872 \
2.253243238349422e-07 0.4987133299464507 2.253245767391391e-07 0.4933874474923696 2.253248116930461e-07 0.4884604410272814 2.253251079613079e-07 0.4822828691822955 \
2.253253977512662e-07 0.4762763831984252 2.253257040870848e-07 0.4699660956099861 2.253260164056119e-07 0.4635767846525711 2.253263549710683e-07 0.4566963260653934 \
2.25326678082485e-07 0.4501741115777416 2.253270164777878e-07 0.4433881855507311 2.253273403090534e-07 0.4369378830387565 2.253276647034741e-07 0.4305204627449936 \
2.253280076377603e-07 0.4237851826852676 2.253283469185779e-07 0.4171698123421442 2.253286863932124e-07 0.4105997181257849 2.253291295050583e-07 0.4020958655332711 \
2.253294915732268e-07 0.3952155038183801 2.253298121249644e-07 0.3891775711374149 2.253301990595345e-07 0.3819561902961204 2.253305269297949e-07 0.3758957719299574 \
2.253308120888516e-07 0.3706704968427373 2.253311304576464e-07 0.3648820026298218 2.253314132885732e-07 0.3597820188690578 2.253316419773369e-07 0.3556924369094372 \
2.253318598701416e-07 0.3518226517641353 2.253320551194862e-07 0.3483769517668343 2.253322620275857e-07 0.344751588202948 2.253324768243417e-07 0.3410137651016431 \
2.253327290508921e-07 0.3366564674340092 2.253329710462048e-07 0.3325077909124976 2.253332018984844e-07 0.3285822460490526 2.253334167466748e-07 0.3249550452085373 \
2.253336371033643e-07 0.3212604562488142 2.253338386742641e-07 0.3179050685021769 2.253340417582106e-07 0.3145531374773136 2.253342396555968e-07 0.3113121771742085 \
2.253344267548364e-07 0.3082694484595072 2.253346206551795e-07 0.3051385396431291 2.253348257035143e-07 0.3018527636900292 2.253350059382659e-07 0.2989872106339772 \
2.253352418362775e-07 0.2952669081535775 2.253354431238275e-07 0.2921198200609627 2.253356445146313e-07 0.2889965001417216 2.253358691637942e-07 0.2855437159941698 \
2.253360345437678e-07 0.2830223598911593 2.253362123481056e-07 0.280330186126118 2.253363960043191e-07 0.277570343839212 2.253365812460764e-07 0.2748090658167894 \
2.253367593914542e-07 0.2721781298892599 2.253369329835173e-07 0.2696316866093095 2.253370933483699e-07 0.267306655456324 2.253372144595526e-07 0.2655585721882695 \
2.253373676543406e-07 0.2633570345323199 2.253374949857892e-07 0.2615475749425888 2.253375983136284e-07 0.2600830587034867 2.25337715638424e-07 0.2584225376281647 \
2.253378334453812e-07 0.2567591557214636 2.253379574091473e-07 0.2550199666844239 2.253380743933138e-07 0.2533821414201824 2.253382051894417e-07 0.2515535495016885 \
2.253383223995523e-07 0.2499173892700276 2.253384756526766e-07 0.2477853623028658 2.253386111831973e-07 0.2459029165157107 2.253387428644058e-07 0.244074199323236 \
2.25338899457317e-07 0.2419017673596028 2.253390246538746e-07 0.2401755227310949 2.253391603715014e-07 0.2383060149301216 2.253392927986628e-07 0.2364844144139329 \
2.253394127723238e-07 0.2348355337769661 2.253395758201609e-07 0.232606585912384 2.253397146272525e-07 0.230713852557009 2.253398531009719e-07 0.2288300961780371 \
2.253399586457212e-07 0.2273962817971701 2.253400870074011e-07 0.2256537837490921 2.253401911350241e-07 0.2242444877898851 2.25340291651026e-07 0.222886569499566 \
2.253403666954022e-07 0.2218745444235658 2.253404440284576e-07 0.2208349692306942 2.253405187916369e-07 0.2198305887827458 2.253405967553143e-07 0.218785487158918 \
2.253406516218243e-07 0.2180503923904892 2.253407081185998e-07 0.2172938400168352 2.253407515721192e-07 0.2167123195211523 2.253407916131654e-07 0.2161767335077376 \
2.253408308521132e-07 0.2156521099473339 2.253408717263501e-07 0.2151058606261434 2.253409258788401e-07 0.2143825797409383 2.253409642959716e-07 0.2138698309421548 \
2.253410035846784e-07 0.2133480458229882 2.253410651213865e-07 0.2125332203444249 2.253411270989155e-07 0.2117131287842428 2.253411835756643e-07 0.2109664019951111 \
2.253412482072545e-07 0.2101124842966758 2.253413437158761e-07 0.2088522205996687 2.253414310316075e-07 0.207701294711168 2.253415276412079e-07 0.2064291756790013 \
2.253416248707623e-07 0.2051510266126755 2.253417257178229e-07 0.2038307158897115 2.253418263175944e-07 0.2025192706911573 2.253419228088913e-07 0.2012627769767186 \
2.253420249910648e-07 0.1999338657614989 2.253421286307215e-07 0.1985898465970496 2.253422384047343e-07 0.1971698847140261 2.253423475797596e-07 0.1957617939809042 \
2.253424676778517e-07 0.1942174441246506 2.253425776973762e-07 0.1928086337505992 2.253426858092848e-07 0.1914295694688549 2.253428088379843e-07 0.1898652723262108 \
2.253428989485537e-07 0.1887234630454603 2.253430063140445e-07 0.1873671680421656 2.253430831253526e-07 0.1864004060894758 2.253431665706207e-07 0.1853535952511875 \
2.253432561024323e-07 0.1842338297700716 2.253433406678985e-07 0.1831790839553313 2.253434203840387e-07 0.1821880912968773 2.253435217092422e-07 0.1809331989518758 \
2.253436300564713e-07 0.1795959386230563 2.253437265321694e-07 0.1784102562612937 2.25343851909986e-07 0.1768766438339704 2.253439846934562e-07 0.1752616821119887 \
2.253441024642794e-07 0.1738362801839788 2.253442481158562e-07 0.1720835746408261 2.253443587130081e-07 0.1707596463148658 2.25344500843447e-07 0.1690680578777541 \
2.253446165530702e-07 0.1676985735146403 2.253447220270832e-07 0.166456424915798 2.253448165437425e-07 0.1653485352650968 2.253449121811146e-07 0.1642320043563913 \
2.253450092529585e-07 0.1631032360400927 2.253451083042124e-07 0.161956192050434 2.253452022277692e-07 0.1608730077890209 2.253452875034443e-07 0.1598934595213354 \
2.253453878832364e-07 0.1587475631033795 2.253454721860728e-07 0.1577906478848196 2.25345574585582e-07 0.1566342854655733 2.253456519798444e-07 0.1557646215197878 \
2.253457443247583e-07 0.154731814591042 2.253458145762303e-07 0.1539498814072817 2.253459107506593e-07 0.1528844393027091 2.253459875753224e-07 0.152038051282755 \
2.253460663454742e-07 0.1511758489440315 2.253461402383946e-07 0.150370438825067 2.253462079361382e-07 0.1496353997608715 2.253463040000261e-07 0.1485973848112393 \
2.25346373572453e-07 0.1478489919002561 2.253464574616254e-07 0.1469503328160803 2.253465185934615e-07 0.146298213254472 2.253465908615431e-07 0.1455309799806117 \
2.253466633001063e-07 0.1447677488542132 2.253467442811468e-07 0.1439178685120187 2.253468103556157e-07 0.1432275520600639 2.253468877561137e-07 0.1424219220725307 \
2.253469771315706e-07 0.1414956876531561 2.253470479922163e-07 0.1407644282175171 2.253471468792833e-07 0.1397487730030469 2.253472241981923e-07 0.1389620820751095 \
2.253473062434185e-07 0.1381330876879582 2.2534739435453e-07 0.1372467208126059 2.25347461981677e-07 0.1365690714953818 2.253475422788589e-07 0.1357674830239305 \
2.253476170628882e-07 0.1350239185327315 2.253476850640654e-07 0.1343502586094245 2.253477317469739e-07 0.1338891847862563 2.253478209985674e-07 0.1330118383700247 \
2.253478592216168e-07 0.1326395291833771 2.253479282135268e-07 0.1319690872918072 2.253479809615963e-07 0.1314578750898332 2.253480639543784e-07 0.1306559489775353 \
2.253481041328288e-07 0.1302688434457458 2.253481966502028e-07 0.1293805059784019 2.253482353685699e-07 0.1290098403727171 2.253483091292851e-07 0.1283055160094505 \
2.253483707572868e-07 0.1277188748199021 2.253484427849764e-07 0.1270353589407805 2.253485109520081e-07 0.1263909833196726 2.253485855741693e-07 0.1256908956540175 \
2.25348667426635e-07 0.1249253613889138 2.253487508807973e-07 0.124147338931438 2.25348823832511e-07 0.1234692772477456 2.253488965594407e-07 0.122795332839617 \
2.253489565494356e-07 0.1222410931008323 2.253490429174471e-07 0.121445549533078 2.253491038861646e-07 0.1208856452315438 2.253491622719555e-07 0.1203507897957366 \
2.253492279066197e-07 0.119751336354628 2.253492872608612e-07 0.1192111367930785 2.253493552926419e-07 0.1185941868697126 2.25349452587012e-07 0.11771710490035 \
2.253495310789918e-07 0.1170124163111649 2.25349621315123e-07 0.1162055395685231 2.253497171618085e-07 0.1153523005684616 2.253497921195047e-07 0.1146878351828532 \
2.253498964789213e-07 0.1137670532163148 2.25349983267518e-07 0.1130053589403202 2.25350092924934e-07 0.1120476726212376 2.253501744789968e-07 0.1113387926087848 \
2.253502700926292e-07 0.1105114393564785 2.253503468048225e-07 0.10985058581598 2.253504417232868e-07 0.1090364400125625 2.253505175463918e-07 0.1083889268999046 \
2.253505952460493e-07 0.1077282965354292 2.253506775775e-07 0.1070311517075373 2.253507371427637e-07 0.1065286079538068 2.253508009005013e-07 0.1059924133642201 \
2.253508619951089e-07 0.1054803128126646 2.253509578588471e-07 0.1046801683739134 2.253510027219416e-07 0.1043071445723913 2.253510859626872e-07 0.1036173314376927 \
2.25351135082509e-07 0.1032117000904133 2.253512441312713e-07 0.1023149933518279 2.253512889673535e-07 0.1019479364619093 2.253513792285848e-07 0.1012117400678687 \
2.25351420105203e-07 0.1008795969612472 2.25351490563617e-07 0.1003088525914566 2.253515768510382e-07 0.09961307626065434 2.253516686285974e-07 0.09887705578174606 \
2.253517381566897e-07 0.09832225024344161 2.25351816683849e-07 0.09769854072774181 2.253519074125254e-07 0.09698178745350861 2.25351983228664e-07 0.09638605854785212 \
2.253520652414071e-07 0.09574500473888557 2.253521469944435e-07 0.09510943278387665 2.253522375022672e-07 0.09440967388330095 2.253523270615646e-07 0.09372126988887708 \
2.253524126713984e-07 0.09306698857649189 2.253525054508965e-07 0.09236212353634379 2.253525863388571e-07 0.0917510971760913 2.253526874678274e-07 0.09099177263830999 \
2.253527679613525e-07 0.09039108594384238 2.253528522042178e-07 0.08976589684797046 2.253529260492652e-07 0.08922077348043934 2.253530028987434e-07 0.08865632925481931 \
2.253530910391125e-07 0.08801255002475737 2.253531711034816e-07 0.08743108261130086 2.253532641396717e-07 0.08675939571108145 2.253533821403849e-07 0.08591369538214398 \
2.253535245136124e-07 0.08490278100234279 2.253536687619621e-07 0.08388867104764453 2.253538110896711e-07 0.08289807427203813 2.253539606674147e-07 0.08186746790234835 \
2.253540969811606e-07 0.08093761126893445 2.253542391015919e-07 0.0799778356000513 2.253543736550197e-07 0.07907840240745091 2.253545140077296e-07 0.07814980287393705 \
2.253546616898023e-07 0.0771833418413561 2.253548118052992e-07 0.07621180464723754 2.253549765257765e-07 0.07515824360926991 2.253551401551281e-07 0.07412455432658185 \
2.25355314933688e-07 0.07303438636984133 2.253555021863042e-07 0.07188220095900363 2.253557122313082e-07 0.07060976590783831 2.253559304415312e-07 0.06930979572898451 \
2.253561638986196e-07 0.06794333957253913 2.25356418744638e-07 0.06648001693367038 2.253567118391949e-07 0.06483321328442151 2.253570141789572e-07 0.06317411115207273 \
2.253573287658326e-07 0.06148945259513613 2.253577250265267e-07 0.05942677493938087 2.253580587436719e-07 0.05774249301432461 2.253584660545012e-07 0.05574994498853819 \
2.253587939392599e-07 0.05419380357502902 2.25359150629899e-07 0.05254809000207299 2.253594638680598e-07 0.05114243792209583 2.253597668351931e-07 0.04981740498512215 \
2.253600643757185e-07 0.04854875663330436 2.253603431552738e-07 0.04739109061078805 2.253606261551693e-07 0.04624570307560639 2.253608878954772e-07 0.04521055793698023 \
2.253611671343699e-07 0.04413130357485813 2.253614392402902e-07 0.0431040186124033 2.253617466070472e-07 0.04197194005652995 2.25361968409948e-07 0.04117329707315532 \
2.253622748704283e-07 0.04009446155587663 2.253625010598812e-07 0.03931650950691581 2.253627399772065e-07 0.03851359500741255 2.253629644010393e-07 0.03777663690506906 \
2.253631666633204e-07 0.03712468825868943 2.253633677059489e-07 0.03648814235703791 2.253637194799833e-07 0.03540095449820539 2.253639697258209e-07 0.03464776841732944 \
2.253642160441008e-07 0.03392252499723709 2.253644973769647e-07 0.03311308780599518 2.253647404679504e-07 0.03242954897046491 2.253649759417007e-07 0.03178112583711486 \
2.25365217601206e-07 0.03113119522156456 2.253654544834836e-07 0.03050988948014832 2.25365685016041e-07 0.02991733361391674 2.253658989845686e-07 0.02937801894285819 \
2.253661049271158e-07 0.02886851641492237 2.253664976516028e-07 0.02792196059063811 2.25366685729283e-07 0.02747992420741849 2.253670611682489e-07 0.02661861215736662 \
2.253672360424775e-07 0.02622659266649364 2.253676593654916e-07 0.02530049759795254 2.253677806148756e-07 0.02504150687334681 2.253682211765283e-07 0.02412433837770948 \
2.253683636746477e-07 0.02383402682615681 2.253686957281575e-07 0.02316883068419595 2.253688786936821e-07 0.02280879143785283 2.25369267997886e-07 0.02205689891561978 \
2.253694363435941e-07 0.02173705378531499 2.253699084579933e-07 0.02085107653961301 2.253700482027269e-07 0.0205916297664938 2.253705437828048e-07 0.01969297428531048 \
2.253706710082374e-07 0.01946923320191776 2.253712389173419e-07 0.01851512288677271 2.253714031712902e-07 0.0182513999453204 2.253720130430286e-07 0.0173209960017622 \
2.253721727282572e-07 0.01708922829277545 2.253726996397978e-07 0.01635462467776483 2.253729041570907e-07 0.01608193551804103 2.253736276344778e-07 0.01515939662837778 \
2.253737930766099e-07 0.01495683325581705 2.253745396363563e-07 0.01408081084911163 2.253746729395689e-07 0.01393008075245666 2.253755331241552e-07 0.01299799962960837 \
2.253756692055701e-07 0.01285670227674402 2.253766097994594e-07 0.01192267652923807 2.253767735725333e-07 0.01176632439256516 2.253777747514646e-07 0.01084959205883911 \
2.253779122291873e-07 0.01072929995296418 2.253790829267985e-07 0.009787962024485789 2.253791753231659e-07 0.009718668544398181 2.253805933990138e-07 0.008725931027897449 \
2.253806803751621e-07 0.00866912727384293 2.253822213707926e-07 0.00770199130002063 2.253823306868068e-07 0.007633428668288294 2.253839739346293e-07 0.006673746291950173 \
2.253841067919082e-07 0.006603544020797993 2.253862011722063e-07 0.005605323336654431 2.253864095769411e-07 0.00551468736035817 2.25388763913366e-07 0.004577307911602986 \
2.253892374721228e-07 0.004407121484391641 2.253921229089796e-07 0.003492041675788492 2.253926525733265e-07 0.00334538389506189 2.253968608005519e-07 0.00237996320858989 \
2.253973742348033e-07 0.002283557532494709 2.254031334854955e-07 0.001325291758975802 2.254033680667129e-07 0.001279502680325907 2.254180358940879e-07 0.0002809017338477542 \
2.2541814896418e-07 0.0002788534805396912 2.280551690439302e-07 -0.0006849217749926401 2.280553352056058e-07 -0.0009443270389602415 2.28055814074993e-07 -0.001850320037528519 \
2.280559067946197e-07 -0.002050462221988249 2.280562720196971e-07 -0.002913187630468476 2.280563636768137e-07 -0.00314709230904735 2.280567297831652e-07 -0.004133001189868674 \
2.280568399302907e-07 -0.004442309109773816 2.280571506685429e-07 -0.005311341427314526 2.280572524071878e-07 -0.005583925258601597 2.280576161113131e-07 -0.00638370916272213 \
2.280577809576365e-07 -0.006585924750287024 2.280583607549566e-07 -0.005792290386912202 2.280585355894154e-07 -0.004916934050781314 2.280586522790152e-07 -0.00413641027497409 \
2.280587787087077e-07 -0.00310656561120747 2.280588807309106e-07 -0.002137079422087956 2.28059000577393e-07 -0.0008406209844352954 2.280590912146293e-07 0.0002489246187367611 \
2.280591896346795e-07 0.001536790859923857 2.280592893583236e-07 0.002948496343048522 2.280594568423325e-07 0.005545701385567424 2.280596754209339e-07 0.009327395936412004 \
2.280598614912559e-07 0.0128572688386996 2.280600828738638e-07 0.01737012273305725 2.280602435339974e-07 0.02082840415615294 2.28060406999647e-07 0.02447866954313523 \
2.280605576351642e-07 0.02794359528291388 2.280607066909169e-07 0.03145289236167962 2.280608561536706e-07 0.03504014479003619 2.280610101846837e-07 0.03879791952579481 \
2.280611723009431e-07 0.04280891157365373 2.280613383304077e-07 0.04696567134311741 2.280615142832281e-07 0.05141478668696391 2.280616949538656e-07 0.05602187592747932 \
2.280618867748118e-07 0.06094655248807559 2.280620938803164e-07 0.06629309753158302 2.280623154520462e-07 0.07203901748582854 2.280625501862155e-07 0.07814662931008168 \
2.280628017257829e-07 0.08470684589377442 2.280630771678493e-07 0.09190125212984442 2.280633773636676e-07 0.09974607960254324 2.280637082958779e-07 0.108390578238945 \
2.280640839626117e-07 0.1181923833971668 2.280644815454798e-07 0.1285487285136021 2.280649483700824e-07 0.1406786766767902 2.280654913626172e-07 0.1547396794802719 \
2.2806612478764e-07 0.1710742296429572 2.280668207276907e-07 0.1889259607126788 2.280676362848005e-07 0.2097135943149445 2.280685463129037e-07 0.2327316641523666 \
2.280693395691243e-07 0.2526372689279454 2.280700450441999e-07 0.2702038474981599 2.280706639884678e-07 0.2855008995781749 2.280712310944079e-07 0.2994177966724069 \
2.280717541744141e-07 0.3121574438576628 2.280722531532068e-07 0.3242197130846058 2.280727371932144e-07 0.3358335658028451 2.280731924200473e-07 0.3466679577370423 \
2.280736669320092e-07 0.3578644504627745 2.280741068407172e-07 0.368158604789619 2.28074592685345e-07 0.3794271463718566 2.280751242881185e-07 0.3916316501999784 \
2.280756269514167e-07 0.4030538969706937 2.280760560236697e-07 0.4127111343288326 2.280765470403382e-07 0.4236561147984291 2.280770484704186e-07 0.434714731975362 \
2.280773950150088e-07 0.442288187401736 2.280777504243856e-07 0.4500000616404133 2.280781776521144e-07 0.4592019891792938 2.28078569851637e-07 0.4675774400278049 \
2.280788702333952e-07 0.4739448723400065 2.280792120451549e-07 0.4811381049525967 2.280795554849688e-07 0.4883107756756314 2.280798162200955e-07 0.4937186470393492 \
2.280800582500486e-07 0.4987071765458648 2.280803241952915e-07 0.5041573145298286 2.280805814645869e-07 0.509394255416739 2.280807715836905e-07 0.5132422368582924 \
2.280809851098511e-07 0.5175451019736222 2.280811248001571e-07 0.5203466115392713 2.280812710004491e-07 0.5232668091041763 2.280814849883502e-07 0.5275186200231483 \
2.280816930046097e-07 0.5316389396023125 2.280818854658791e-07 0.5354321131715788 2.280820705821105e-07 0.5390651926504321 2.280822449555568e-07 0.5424725330931349 \
2.280825494976334e-07 0.5484058192982523 2.280828100565151e-07 0.5534602958276967 2.280831114875446e-07 0.5592859190791987 2.280833658051381e-07 0.5641865993769294 \
2.280836586613278e-07 0.5698153316805189 2.280839178744799e-07 0.5747800306938655 2.280841889508119e-07 0.579963273174682 2.280844307945714e-07 0.5845680738798381 \
2.280846882997289e-07 0.5894577538325241 2.280849150436047e-07 0.5937419314630586 2.280851520444244e-07 0.5982006324572362 2.280853622309863e-07 0.6021379329905048 \
2.280855749915204e-07 0.6061060319396779 2.280858278702861e-07 0.6107954169450593 2.280860315335545e-07 0.6145509252949414 2.280862222509359e-07 0.6180531102377972 \
2.280864095873744e-07 0.6214768531423983 2.28086598465652e-07 0.6249070011644339 2.280868066654474e-07 0.6286671070650327 2.280870509975622e-07 0.6330499453121026 \
2.280872505640949e-07 0.6366057789565548 2.280874547098357e-07 0.6402215701419991 2.2808763934909e-07 0.643474671963314 2.28087908884781e-07 0.6481901084955864 \
2.280881365916373e-07 0.652149230294136 2.280883242633752e-07 0.6553888277830079 2.280885051635202e-07 0.6584949378977958 2.280886647046019e-07 0.661221510907812 \
2.280888351670024e-07 0.6641177016088209 2.280889869184432e-07 0.6666817235716488 2.280891245614551e-07 0.6689905419339194 2.280892735563186e-07 0.6714784915997724 \
2.280894012981823e-07 0.6736028790357499 2.280895442846951e-07 0.675968899142866 2.280896660677513e-07 0.6779749688503388 2.280898023511611e-07 0.6802121872853304 \
2.280899221800626e-07 0.682172759947357 2.280900687756234e-07 0.6845626218370968 2.28090187248565e-07 0.6864845934661837 2.280902831819268e-07 0.6880368302455475 \
2.280903757015115e-07 0.6895284278106264 2.280904807620225e-07 0.6912169000724893 2.280905788439078e-07 0.6927871490736753 2.280907159592253e-07 0.6949707622226827 \
2.28090835157868e-07 0.6968607547931925 2.280909450978383e-07 0.6985951241089645 2.280910825970815e-07 0.7007503743809057 2.280912140269832e-07 0.7027960765825516 \
2.280913462564987e-07 0.7048392108129343 2.280914594338973e-07 0.7065756917706891 2.280916138667517e-07 0.708927873976708 2.280917446467452e-07 0.7109048231498766 \
2.280918673154548e-07 0.7127465601965561 2.280919735837112e-07 0.7143329262278221 2.280920959637349e-07 0.7161490373358268 2.280921978172318e-07 0.7176517022913665 \
2.280923319551315e-07 0.7196190116794019 2.280924526481717e-07 0.7213783352064487 2.280925717899705e-07 0.7231049829175343 2.280926968079846e-07 0.7249059312823601 \
2.280928266477907e-07 0.7267645120560844 2.280929464599617e-07 0.7284691779696002 2.280930754532131e-07 0.730293808329565 2.280932075602774e-07 0.7321507998840678 \
2.280933258660953e-07 0.7338038328985433 2.280934691267862e-07 0.7357927618453034 2.280935715814729e-07 0.7372070005703254 2.280936677883586e-07 0.7385290937783453 \
2.280937728059804e-07 0.7399656334130889 2.280938835775113e-07 0.7414708009413548 2.280939852560522e-07 0.7428439364018735 2.280940882175066e-07 0.7442258341871242 \
2.280942051436606e-07 0.7457850038572696 2.280943339039365e-07 0.747489965072781 2.28094435062908e-07 0.7488201182152049 2.280945839319523e-07 0.7507626302114226 \
2.280947316114891e-07 0.75267249971878 2.280948509768551e-07 0.7542038164026367 2.280949974606996e-07 0.7560679527984652 2.280951206361903e-07 0.7576223900169708 \
2.280952614398646e-07 0.7593848990234215 2.280953980325311e-07 0.7610800595258669 2.280955201903812e-07 0.7625841275516777 2.280956328467787e-07 0.7639610711610054 \
2.280957745729197e-07 0.7656796138775311 2.280959007394198e-07 0.767196844592689 2.280960161567243e-07 0.768574452686535 2.28096146464904e-07 0.7701179991486644 \
2.280962621775718e-07 0.7714782821591826 2.280963850018603e-07 0.7729116492687436 2.280965028461285e-07 0.7742769236963016 2.280966084761186e-07 0.7754922619072108 \
2.280967238495534e-07 0.7768108638983861 2.280968291127158e-07 0.7780056027231214 2.28096940062529e-07 0.7792565499870431 2.280970264670306e-07 0.7802246528436213 \
2.280971305008506e-07 0.7813823422463088 2.28097244396594e-07 0.7826398494046257 2.280973474300136e-07 0.7837684443710583 2.280974555127141e-07 0.7849432998269023 \
2.280975637643697e-07 0.7861107422109641 2.280976991816164e-07 0.7875582910536544 2.280978118557238e-07 0.7887521292973186 2.280979362797841e-07 0.7900592323105087 \
2.28098054252648e-07 0.7912877959129118 2.280981987206026e-07 0.7927781272271259 2.280983163897418e-07 0.7939806363584788 2.280984522695815e-07 0.7953567374150946 \
2.280985870139539e-07 0.7967081403609936 2.280986980849332e-07 0.7978123285366109 2.280987979742732e-07 0.7987978371087655 2.280988996542306e-07 0.7997937268659365 \
2.280990328678971e-07 0.8010867894381996 2.280991512407163e-07 0.8022243628210853 2.280992727817905e-07 0.8033812848148773 2.280993921454424e-07 0.8045065422543012 \
2.280995132768188e-07 0.80563739819571 2.280996449762361e-07 0.8068544426691319 2.280997679845129e-07 0.8079795872959963 2.280998958281203e-07 0.8091371804586788 \
2.281000267346398e-07 0.8103101881504271 2.28100150327798e-07 0.8114062915203997 2.28100257500303e-07 0.8123479140825919 2.281003649295024e-07 0.8132835730547656 \
2.281004475986206e-07 0.8139979974227743 2.281005653103806e-07 0.8150069815425507 2.281006559159858e-07 0.8157770472204025 2.281007865694307e-07 0.8168774959419571 \
2.28100930959301e-07 0.8180800468042847 2.281010641337151e-07 0.8191766687328477 2.281011740251065e-07 0.8200725423139092 2.281013176239916e-07 0.8212302325252553 \
2.281014710146833e-07 0.8224508494407716 2.281015990929081e-07 0.8234574467428303 2.281017388802764e-07 0.8245431382086058 2.281018651298391e-07 0.8255122018650548 \
2.281020197283917e-07 0.8266841987320058 2.281021519393684e-07 0.8276738265999063 2.281022781661507e-07 0.8286078934539939 2.281023959138743e-07 0.8294698388787296 \
2.281025449866676e-07 0.8305480062617677 2.281027123182206e-07 0.8317406852496945 2.281028455394968e-07 0.8326770812274722 2.281030183208196e-07 0.8338744310092966 \
2.281031868261935e-07 0.8350236380668206 2.281033562054924e-07 0.8361608866600232 2.281035378407611e-07 0.8373606451951652 2.281036801740827e-07 0.8382866867625347 \
2.281037940110689e-07 0.8390185116470331 2.28103925192579e-07 0.8398522525089582 2.28104026724794e-07 0.8404903982372576 2.281041430090543e-07 0.8412135669902132 \
2.281042776438078e-07 0.8420406924792603 2.281044746666439e-07 0.8432316292878405 2.281046647721864e-07 0.8443592803112207 2.281048748954986e-07 0.8455816023960827 \
2.281050552136043e-07 0.8466107566581813 2.281052526767048e-07 0.8477171937062282 2.281054267458196e-07 0.8486750118570332 2.281056090652401e-07 0.8496608982186138 \
2.281057804803758e-07 0.8505716849290491 2.281059545936529e-07 0.8514808063694008 2.281061303246211e-07 0.8523822271368225 2.281063064363214e-07 0.8532696099472232 \
2.281064960541732e-07 0.8542074684498208 2.281066868356705e-07 0.8551330189126392 2.28106888431747e-07 0.8560917259710515 2.281070811660049e-07 0.856990088884472 \
2.281072900378257e-07 0.8579439907476532 2.281075207402632e-07 0.8589743400177088 2.281077851832273e-07 0.8601259267840322 2.281080840059149e-07 0.8613896125360476 \
2.281083639602159e-07 0.8625380186322354 2.281086480860817e-07 0.8636694076724545 2.28108922855057e-07 0.8647317823994775 2.281091947122167e-07 0.8657531067718063 \
2.281094650893343e-07 0.8667403371654003 2.281097221678556e-07 0.8676533221001362 2.281099947926866e-07 0.868594905839151 2.281102707598356e-07 0.8695208838709013 \
2.281105408640933e-07 0.8704012674911344 2.281108407401039e-07 0.8713491368600049 2.281112118011625e-07 0.8724801680184872 2.2811150674079e-07 0.8733472453740196 \
2.28111761036548e-07 0.8740729094291386 2.281120592974738e-07 0.8748989982677786 2.281123329040153e-07 0.8756336613858092 2.281125690299577e-07 0.876250392688866 \
2.281128093740557e-07 0.8768621356511911 2.281130317061818e-07 0.8774140071409635 2.28113225712247e-07 0.8778848105679672 2.281135554349973e-07 0.8786625669521169 \
2.281137106085256e-07 0.8790190643519731 2.281140283876062e-07 0.879730644938159 2.281142072488645e-07 0.8801204696806418 2.281145497107611e-07 0.8808457867651537 \
2.281147338373631e-07 0.8812245477320809 2.28115208711942e-07 0.8821665346129511 2.281153761083518e-07 0.8824869809105039 2.281158419518539e-07 0.883348261932613 \
2.281160227735483e-07 0.8836708855253055 2.281165168126507e-07 0.8845204537290557 2.281166581620591e-07 0.8847551796839913 2.281172645001219e-07 0.8857215808967022 \
2.281174165693362e-07 0.8859539944113424 2.28118063256356e-07 0.8869009218298172 2.281181915512387e-07 0.8870812460539503 2.28118839667745e-07 0.8879562712787433 \
2.281189694676407e-07 0.8881245027440973 2.281197476783404e-07 0.8890830197250962 2.281198627254718e-07 0.8892171882189283 2.281207183963142e-07 0.8901564861234483 \
2.281208637440773e-07 0.8903061494816453 2.281218494996487e-07 0.8912466483555094 2.281220706077111e-07 0.8914402669210102 2.281232157277145e-07 0.892367747196105 \
2.281233469391586e-07 0.8924695935232408 2.281246882116238e-07 0.8934615053489913 2.281248396029001e-07 0.8935661991834861 2.281263210551204e-07 0.8944951400107031 \
2.281265599348161e-07 0.8946288932334222 2.281283293566539e-07 0.895502508848118 2.281287184779452e-07 0.895670668133377 2.281311122106538e-07 0.8965556062201232 \
2.281315877505926e-07 0.8967047758494365 2.281356508198176e-07 0.8977025964496719 2.281361422956535e-07 0.8977953148389237 2.281444588927963e-07 0.8987880790885289 \
2.281453787942481e-07 0.8988514070442593 2.282992423701678e-07 0.8998485708192639 2.283028854964575e-07 0.8998628537402877 2.285296142766717e-07 0.8989664306490068 \
2.285298446165833e-07 0.8988008565867064 2.285314595368805e-07 0.897804750401333 2.285316372691665e-07 0.8977103535805105 2.285484036692715e-07 0.8986978311584225 \
2.285485397684025e-07 0.8987160394686986 2.285637106086718e-07 0.8997133888183054 2.285639877135078e-07 0.899719468756186 2.290480289064218e-07 0.9005852143835333 \
2.290482022410388e-07 0.9007408621809421 2.290488627306383e-07 0.9015135064485434 2.290490287958205e-07 0.9017527716291757 2.29049555130528e-07 0.9026184054967997 \
2.290497462444476e-07 0.9029704910143604 2.290501104654996e-07 0.9036902342402512 2.290502896649215e-07 0.9040628043424317 2.290506515515938e-07 0.9048333795345931 \
2.290508466611638e-07 0.9052442844328937 2.290513790595253e-07 0.9062266394381637 2.290515614131638e-07 0.9064623886473868 2.290525533935561e-07 0.905594670761786 \
2.290527149341233e-07 0.9049318860608667 2.290528829265756e-07 0.9040378649110347 2.290530427580612e-07 0.9029782421366458 2.29053180254799e-07 0.9018984154159868 \
2.290533131621115e-07 0.9007052793196499 2.290534395875788e-07 0.8994328447569792 2.290535469868187e-07 0.8982475863895881 2.290536514834769e-07 0.8970047013543965 \
2.290537655331467e-07 0.8955451342423859 2.290538555027343e-07 0.8943225684615312 2.290539603213726e-07 0.8928208677113324 2.290540497696119e-07 0.891473284704788 \
2.290541321453926e-07 0.8901820884368528 2.290542232383926e-07 0.8887006634027688 2.290543605744706e-07 0.8863657732814155 2.290544590674027e-07 0.8846195012157601 \
2.290545711411528e-07 0.8825649218508906 2.290547020241858e-07 0.880080778639088 2.290548384952159e-07 0.8774018563482072 2.290549919493788e-07 0.8742910281085086 \
2.290551510437468e-07 0.8709679977889497 2.290553153276494e-07 0.867445283300377 2.290554719957507e-07 0.8640104344288071 2.290556240865311e-07 0.860615744772629 \
2.290557778002064e-07 0.857132398554192 2.290559373623814e-07 0.853469801378647 2.290560924510829e-07 0.8498714074018293 2.290562661304016e-07 0.8458039138600054 \
2.290564291612694e-07 0.8419559450883216 2.29056590803684e-07 0.8381170660338335 2.290567534504206e-07 0.8342344554797501 2.290569148689274e-07 0.8303657475978833 \
2.29057083463406e-07 0.8263109424305363 2.290572663565043e-07 0.8219002364007665 2.290574341852182e-07 0.8178440888239877 2.290576024710332e-07 0.8137703061148112 \
2.290577732990847e-07 0.8096302849976138 2.290579454736422e-07 0.8054541271740473 2.290581132355611e-07 0.8013830614994394 2.290582968650184e-07 0.7969255463994016 \
2.290584682714963e-07 0.7927646873948894 2.290586537148024e-07 0.7882638003278283 2.290588203854536e-07 0.7842196820467244 2.290589892715848e-07 0.7801233737411432 \
2.290591734278819e-07 0.7756572567105651 2.290593680379105e-07 0.7709405333854473 2.290595152932414e-07 0.7673736106648734 2.29059641923832e-07 0.7643079795643375 \
2.290597837806443e-07 0.7608754495129878 2.290598881844221e-07 0.7583505812556488 2.290600205770739e-07 0.7551502542766809 2.290601301612705e-07 0.7525028097975122 \
2.290602633259231e-07 0.7492875979647342 2.290604195076852e-07 0.7455190770546114 2.290605327371121e-07 0.7427887939149777 2.290606952584764e-07 0.7388718945951063 \
2.290608674392915e-07 0.7347246296492568 2.29061063444044e-07 0.7300078517193382 2.290612278340229e-07 0.7260553905833119 2.290613802307036e-07 0.7223944885043934 \
2.290615439058578e-07 0.718466402706526 2.29061711831558e-07 0.7144406657912139 2.290618916719358e-07 0.7101336212543717 2.290620679658861e-07 0.7059164985576465 \
2.290622390405214e-07 0.7018286413152719 2.29062407358697e-07 0.6978099102718778 2.290625606248287e-07 0.6941537154717222 2.290627225083983e-07 0.6902960245155986 \
2.290629014599385e-07 0.6860364417190952 2.290630356714899e-07 0.6828448068431195 2.290631391777878e-07 0.6803854168085423 2.290632384622005e-07 0.6780286039046017 \
2.290633399166766e-07 0.6756220912380299 2.290634323732757e-07 0.6734303711245889 2.29063516962075e-07 0.6714267031582685 2.290636105394115e-07 0.6692114082407524 \
2.290637270816307e-07 0.6664546942583044 2.290638365591918e-07 0.6638675763958631 2.290639496722031e-07 0.6611971533414394 2.290640727909702e-07 0.6582923426231613 \
2.29064197017283e-07 0.6553636581362478 2.290643677774271e-07 0.6513432847262797 2.290645262260144e-07 0.6476181700514572 2.290646985138371e-07 0.6435738126612673 \
2.290648444919037e-07 0.6401512360303271 2.290649862851197e-07 0.6368325564797357 2.290651178835739e-07 0.6337564355289309 2.290652480468588e-07 0.630718219665797 \
2.290653735717996e-07 0.6277924818644975 2.290655053547071e-07 0.6247239543970449 2.290656352782026e-07 0.6217046839485236 2.290657715867779e-07 0.6185408917806742 \
2.290659162003453e-07 0.615188962872713 2.29066075692536e-07 0.611499189008522 2.290662491526524e-07 0.6074939486938447 2.290664201599544e-07 0.6035554342946753 \
2.290666515285226e-07 0.5982402936372396 2.290668949905284e-07 0.5926661367297537 2.29067069111016e-07 0.5886942528256315 2.290672153830935e-07 0.5853638081576373 \
2.290673497553116e-07 0.58231230528805 2.290674668502067e-07 0.5796585826255305 2.290675626145532e-07 0.5774900935424465 2.290676614610955e-07 0.5752566196463251 \
2.290677454384143e-07 0.5733628024369305 2.290678230524635e-07 0.571614165956722 2.290678843779373e-07 0.5702331258704825 2.290679490585756e-07 0.5687779664863769 \
2.290680303667114e-07 0.5669528575016536 2.290680804367073e-07 0.5658306078972934 2.290681297572688e-07 0.5647256890740617 2.29068191677069e-07 0.5633393552914843 \
2.290682395088943e-07 0.5622690492396486 2.290682900136796e-07 0.5611395143522533 2.290683500757169e-07 0.559799205480933 2.290684093585124e-07 0.5584782058326896 \
2.290684844152261e-07 0.5568072508052372 2.290685540978827e-07 0.5552574373576753 2.290686396864492e-07 0.5533559356568912 2.290687267538207e-07 0.5514265885063823 \
2.290688104163414e-07 0.5495763264044081 2.290688965613662e-07 0.5476734676082877 2.290689922659868e-07 0.5455621222678217 2.290690965509387e-07 0.5432673229847179 \
2.290692112181133e-07 0.5407497407899529 2.290693199365745e-07 0.5383664115638558 2.290694295088142e-07 0.5359693749054023 2.290695418135745e-07 0.5335193270114367 \
2.290696685891956e-07 0.530759392645703 2.290697908664272e-07 0.5281021910076299 2.290699309524049e-07 0.5250685463469849 2.290700679697626e-07 0.5221084647952599 \
2.29070218271135e-07 0.5188705764247719 2.290703771663761e-07 0.5154582091324615 2.290705515002589e-07 0.5117250894133971 2.29070738517481e-07 0.5077378180012799 \
2.290709438354859e-07 0.5033745272871338 2.290711556776788e-07 0.498891131759938 2.29071408479721e-07 0.4935662239713107 2.2907161056737e-07 0.4893264048484654 \
2.290718451606753e-07 0.4844277613141263 2.290720812752722e-07 0.4795194943790256 2.290723344517689e-07 0.474283574581623 2.290726449817317e-07 0.4679020429045382 \
2.290728630397103e-07 0.4634451779596257 2.290730364853444e-07 0.4599153839204358 2.290732129777809e-07 0.4563351808422506 2.290734924595775e-07 0.4506930409909046 \
2.290737247034844e-07 0.4460279192631412 2.290740117970732e-07 0.44029020239849 2.290742296431809e-07 0.435960758243863 2.290744396957687e-07 0.4318042429497612 \
2.290746408936045e-07 0.4278406951573778 2.290748233137656e-07 0.4242617300271556 2.290749972087507e-07 0.4208637793449936 2.290751620728668e-07 0.4176529694331993 \
2.290753208268398e-07 0.4145718140694327 2.290754870737866e-07 0.4113577680628809 2.290756357189934e-07 0.4084923702366076 2.290757880872491e-07 0.4055658186126443 \
2.290759301504318e-07 0.4028468403491589 2.290760995263099e-07 0.3996150665462138 2.290762199082301e-07 0.3973276483660343 2.290763298814939e-07 0.3952449223617059 \
2.290764448068949e-07 0.3930732253581283 2.290765970484751e-07 0.3902080468194818 2.290767092695403e-07 0.3881039677199808 2.290768164620408e-07 0.386098874836553 \
2.290769689902897e-07 0.383254723448244 2.290770971374193e-07 0.380874963946598 2.290772199854117e-07 0.3786015923730871 2.290773990837881e-07 0.375299968600122 \
2.290775481684202e-07 0.3725653942578417 2.290777158758077e-07 0.3695018296724824 2.290778712734425e-07 0.3666748141177644 2.290779954402882e-07 0.3644243980538668 \
2.290781093321555e-07 0.3623666676050148 2.29078230775526e-07 0.3601804966264144 2.290784109272934e-07 0.3569532670533712 2.290785774151136e-07 0.3539878629329621 \
2.29078767834223e-07 0.3506138544217919 2.290789595908186e-07 0.3472380408565978 2.290791426402121e-07 0.344035729794033 2.290792916122767e-07 0.3414435189591631 \
2.290794115521823e-07 0.3393660536257183 2.290795342136651e-07 0.3372483242714233 2.290796572441514e-07 0.3351324902755385 2.29079802148562e-07 0.3326515017845288 \
2.290799054613373e-07 0.3308907757076019 2.290799991908464e-07 0.3292979229163631 2.290800898511484e-07 0.3277620998585528 2.29080200972602e-07 0.3258853746017661 \
2.290803081455789e-07 0.3240820510456246 2.290804064202303e-07 0.3224338250618513 2.290805188247763e-07 0.3205545940512134 2.290806827646764e-07 0.3178277446588927 \
2.290808444025551e-07 0.3151576097143818 2.290809921893013e-07 0.3127316247504084 2.290811544345159e-07 0.3100832165115083 2.290813144650734e-07 0.3074868334344322 \
2.290814667283718e-07 0.3050304870660137 2.290816201002421e-07 0.3025703731928215 2.29081778808771e-07 0.3000411640344692 2.290819432578998e-07 0.297437246442505 \
2.290821104849764e-07 0.2948063590562646 2.290822635965136e-07 0.292412731930112 2.290824466944405e-07 0.2895700146919417 2.290826370021783e-07 0.2866380344427262 \
2.290827859052365e-07 0.2843603072871506 2.290829598425416e-07 0.2817165165722222 2.290831367199302e-07 0.2790484233348025 2.290832843171486e-07 0.2768363681311815 \
2.290834739488487e-07 0.2740172295061162 2.290836239507675e-07 0.2718052906662373 2.290837610609577e-07 0.2697943906627059 2.290839025914008e-07 0.2677397479842996 \
2.290840160502698e-07 0.2661005451260196 2.290841523405965e-07 0.2641384584581135 2.290842824172175e-07 0.2622807416655737 2.290844006714701e-07 0.2606037730704709 \
2.290845185270663e-07 0.2589348966568543 2.290846494208769e-07 0.2570853888657079 2.290847896596348e-07 0.2551145527343576 2.290849051542211e-07 0.2534976852533538 \
2.290850340055979e-07 0.2516957519945816 2.290851491515796e-07 0.2500885525459272 2.290853024625469e-07 0.2479513765689386 2.290854403163083e-07 0.2460367343642474 \
2.290855797779604e-07 0.2441002375748529 2.29085735245815e-07 0.2419427021952501 2.290858600284303e-07 0.2402176526454788 2.290859998933384e-07 0.2382916534360561 \
2.290861285955144e-07 0.2365220787132559 2.290862495543663e-07 0.234860341242685 2.290863665996657e-07 0.2332541163798121 2.290864926007302e-07 0.2315368940272461 \
2.290865893203229e-07 0.2302195772445239 2.290866814091961e-07 0.2289683907689286 2.290867958266674e-07 0.2274152998827935 2.290868941973141e-07 0.2260807986508055 \
2.290870113441077e-07 0.2244933520241092 2.290871144352257e-07 0.2231010305483718 2.290872199499518e-07 0.2216798666278746 2.290873008680117e-07 0.2205933880575098 \
2.290873745391968e-07 0.2196046443759679 2.290874172684338e-07 0.2190314036349237 2.29087460398579e-07 0.2184540235451489 2.290875111960607e-07 0.217774515685755 \
2.290875483709394e-07 0.217277430841393 2.29087589041954e-07 0.2167338127731004 2.290876318337555e-07 0.2161620985357572 2.290876682448971e-07 0.2156758299561118 \
2.290877101698878e-07 0.2151161507306283 2.290877647120985e-07 0.2143884526296278 2.290878031708565e-07 0.2138756926875936 2.290878427976257e-07 0.2133496230586122 \
2.290879046301276e-07 0.212531488259555 2.290879663565787e-07 0.2117156525305126 2.290880224938542e-07 0.210974237875411 2.290880861490837e-07 0.210134110843225 \
2.290881802401172e-07 0.2088936328424611 2.290882670483761e-07 0.2077505933124353 2.290883610050201e-07 0.2065146061917991 2.290884590472537e-07 0.2052266823513323 \
2.290885606346195e-07 0.2038976009052371 2.290886615435679e-07 0.2025832113009377 2.290887582793767e-07 0.2013244528083448 2.290888604043477e-07 0.1999972806373927 \
2.290889637359055e-07 0.1986583046056677 2.29089073618507e-07 0.1972379690671278 2.290891825607647e-07 0.1958337611883887 2.290893023958847e-07 0.1942937175364915 \
2.290894126797513e-07 0.1928822800638286 2.290895205584963e-07 0.191507108810815 2.290896466212543e-07 0.1899051957406391 2.290897364889608e-07 0.1887671190866151 \
2.290898469673e-07 0.1873723090993208 2.290899245002487e-07 0.1863971337376019 2.290900088239919e-07 0.1853400660204312 2.2909009641205e-07 0.1842452710069853 \
2.290901842046442e-07 0.18315095174413 2.290902659245155e-07 0.1821357652581398 2.290903634861928e-07 0.1809282658474054 2.290904701973441e-07 0.1796118512064394 \
2.29090570679026e-07 0.178377576484793 2.290906948502376e-07 0.1768595317522179 2.290908287417608e-07 0.1752320886156309 2.290909476539533e-07 0.1737937102924047 \
2.290910980541469e-07 0.1719851742607024 2.290912088892401e-07 0.1706594030660365 2.290913486559821e-07 0.168997130456427 2.290914671812902e-07 0.1675953052211382 \
2.29091572608521e-07 0.1663548750207849 2.290916673183802e-07 0.1652455210322802 2.290917606281544e-07 0.1641568522804657 2.290918615342705e-07 0.1629842804551663 \
2.290919569521023e-07 0.1618800504313296 2.290920541430255e-07 0.1607598891027116 2.290921357045071e-07 0.1598237474547246 2.290922410209519e-07 0.1586229753023833 \
2.290923245006587e-07 0.1576763029943549 2.290924260299495e-07 0.1565306813704828 2.290925032604858e-07 0.1556635090415242 2.29092594132523e-07 0.154647919213242 \
2.290926634838334e-07 0.1538765336840219 2.290927480678846e-07 0.1529397840535594 2.290928224610911e-07 0.1521208717489242 2.290929018312932e-07 0.151251902275755 \
2.290929764189645e-07 0.1504388356812226 2.290930456405212e-07 0.1496871728711989 2.290931403213281e-07 0.1486640077242138 2.29093210087093e-07 0.1479134441579097 \
2.290932945316558e-07 0.147008717574758 2.290933560970016e-07 0.1463518850554192 2.290934301394933e-07 0.1455673550676988 2.290935035250169e-07 0.1447940960774066 \
2.290935849602586e-07 0.1439395015691976 2.290936544094048e-07 0.1432139999234875 2.290937295111024e-07 0.1424323701137583 2.290938194231735e-07 0.1415006120834361 \
2.290938965067932e-07 0.1407052977810757 2.290939956173774e-07 0.1396885207473417 2.290940651574398e-07 0.138983077430453 2.290941464759156e-07 0.1381612812129989 \
2.290942166443247e-07 0.1374549162714094 2.290942956124378e-07 0.1366629455350578 2.290943745907205e-07 0.1358740351737466 2.290944469125105e-07 0.1351544405911459 \
2.290945162779692e-07 0.1344667589602006 2.290945649819766e-07 0.1339854049281765 2.290946557443483e-07 0.1330945614011112 2.290946877658758e-07 0.1327823711724506 \
2.290947758698441e-07 0.131925672678654 2.290948083638864e-07 0.1316105445757083 2.290949070315436e-07 0.1306564447580443 2.290949506875193e-07 0.130235859061297 \
2.290950286693357e-07 0.1294866595045693 2.290950660002937e-07 0.1291289430202982 2.290951681516938e-07 0.128153223240932 2.290952355956539e-07 0.1275115375392494 \
2.290953007486116e-07 0.1268935577290946 2.290953666546259e-07 0.1262729746041904 2.290954378066093e-07 0.1256052797936485 2.290955207439704e-07 0.1248293808775363 \
2.290956061394508e-07 0.1240331657139879 2.290956822268445e-07 0.1233259817834828 2.290957626875214e-07 0.1225806238777534 2.290958207714622e-07 0.1220441728027253 \
2.29095892104936e-07 0.1213870835332726 2.290959768933693e-07 0.1206085709991845 2.290960380484021e-07 0.1200487744399507 2.290961081348534e-07 0.1194096117168642 \
2.290961706401422e-07 0.1188419501154776 2.290962366450903e-07 0.1182453094891599 2.290963054178569e-07 0.1176255789053269 2.290963748744814e-07 0.1170017375875525 \
2.29096458038731e-07 0.1162574953874909 2.290965311562548e-07 0.1156056107435251 2.29096601870241e-07 0.1149774116339468 2.290966612219237e-07 0.1144518657417393 \
2.290967665191357e-07 0.1135239342411639 2.290968123866298e-07 0.1131212254602471 2.290968993406834e-07 0.1123603821649216 2.290969423544638e-07 0.1119852310621949 \
2.290969872212112e-07 0.1115947726395539 2.29097076954706e-07 0.1108164664143028 2.290971478390574e-07 0.110204256460374 2.290972266925708e-07 0.109525796983828 \
2.290972894703463e-07 0.1089876103666232 2.290973494647019e-07 0.1084750215669379 2.290974604624741e-07 0.1075310013968523 2.2909754121676e-07 0.1068475792877216 \
2.290976536800859e-07 0.1059005796323111 2.290977048246292e-07 0.1054717782906781 2.290977878097979e-07 0.1047785948356612 2.290978459745031e-07 0.1042945647727652 \
2.29097960212503e-07 0.1033482075721767 2.290980101159701e-07 0.1029366076865433 2.290980958575694e-07 0.1022320954501846 2.290981448890196e-07 0.1018307629303728 \
2.290982274554409e-07 0.101157455862875 2.290982983877772e-07 0.1005815064560546 2.290983665381274e-07 0.1000302812267231 2.290984441484433e-07 0.0994053199805509 \
2.290985164918144e-07 0.09882546240595018 2.29098594067778e-07 0.09820656846618626 2.290986827384394e-07 0.09750287271560702 2.290987565532273e-07 0.09692010793638871 \
2.290988381442348e-07 0.09627924899616347 2.290989162827031e-07 0.09566870926115327 2.290990020324936e-07 0.09500229249765579 2.290990897294021e-07 0.09432453920671229 \
2.290991836389668e-07 0.09360304191323381 2.290992800982852e-07 0.09286661217778783 2.290993587289458e-07 0.09226977907248698 2.290994614525456e-07 0.09149473120661993 \
2.290995452801959e-07 0.09086620530027881 2.290996660323777e-07 0.08996702094116031 2.29099795302029e-07 0.08901247130467421 2.290999511904932e-07 0.08787237469953549 \
2.291001062900762e-07 0.08675000010972149 2.291002633058824e-07 0.08562614142917294 2.291004433267348e-07 0.08435280068725284 2.291005938476015e-07 0.08330035525696428 \
2.291007422216238e-07 0.08227363395463329 2.291008798388548e-07 0.08133079092382095 2.291010197585049e-07 0.08038162993974078 2.291011563654934e-07 0.07946425488810546 \
2.291012950927908e-07 0.07854214404995859 2.291014404036529e-07 0.07758663187171365 2.29101588151466e-07 0.07662571164688473 2.291017467483332e-07 0.07560598447141591 \
2.29101911000851e-07 0.07456266320243836 2.291020800179273e-07 0.07350246718885647 2.29102261906921e-07 0.07237646636762114 2.291024625290194e-07 0.07115268999588262 \
2.291026764065622e-07 0.0698691158856425 2.291029040406938e-07 0.0685263410462881 2.291031456262355e-07 0.06712722147996912 2.29103427215414e-07 0.06552977831071743 \
2.291037243695346e-07 0.06388229915275011 2.291040478026115e-07 0.06213267023812474 2.29104438962031e-07 0.0600758559534558 2.29104840456333e-07 0.05803293250078725 \
2.291052173970595e-07 0.05617754872181892 2.291055845107909e-07 0.05442503025024555 2.291059346274713e-07 0.05280240270907886 2.291062539331247e-07 0.05136309724710254 \
2.291065582574072e-07 0.05002640192327024 2.291068551633126e-07 0.04875503464657577 2.291071371636386e-07 0.04757867888787161 2.291074175969433e-07 0.04643900623749339 \
2.291076823205669e-07 0.04538777697325767 2.291079582182789e-07 0.04431704973151576 2.291082326831433e-07 0.04327654260273706 2.291085311024235e-07 0.04217254828989973 \
2.291087576184799e-07 0.04135316230013186 2.291090695313176e-07 0.04025053053625379 2.291092897861088e-07 0.03948972371590862 2.291095070508635e-07 0.03875470657060948 \
2.291097167735126e-07 0.03806113111453101 2.291100269559001e-07 0.03705828856757609 2.291102495537778e-07 0.03635538859683734 2.29110496919279e-07 0.03559019656168042 \
2.291107693256556e-07 0.03476651972027592 2.291109899582094e-07 0.03411384091885184 2.291112742384598e-07 0.03329124852897781 2.291115121517525e-07 0.0326183788879464 \
2.291117502411637e-07 0.03195887699386461 2.291119854964917e-07 0.03132132139405813 2.291122142751987e-07 0.03071728735992773 2.291124470059479e-07 0.03011490821398154 \
2.291126663089891e-07 0.02955843195412813 2.291128702520595e-07 0.02905055018162466 2.291132691617956e-07 0.02808303002558106 2.291134563160508e-07 0.02764052191221165 \
2.29113828521772e-07 0.0267814187683372 2.29114015473295e-07 0.02635997027055515 2.291143848272417e-07 0.02554620807076183 2.291145384804102e-07 0.02521471147941385 \
2.291149546945644e-07 0.02434161493068329 2.291151601823807e-07 0.02392065165079968 2.291154991903413e-07 0.02323955384462723 2.291156818850694e-07 0.02287916718068597 \
2.291161389789784e-07 0.02199597290476789 2.291162687197144e-07 0.02174967209293581 2.291167221401377e-07 0.02089828923199067 2.2911686451243e-07 0.0206336680476187 \
2.291173940791906e-07 0.01967289368906444 2.291175202861975e-07 0.01945139161001456 2.291180825206354e-07 0.01850749734048266 2.29118245259022e-07 0.01824627541187189 \
2.291188094390872e-07 0.01738327200207762 2.291189611831539e-07 0.01716165742474803 2.291196628626383e-07 0.01618760396393164 2.291198329517282e-07 0.01596324388168 \
2.291204880096043e-07 0.01513221026437959 2.291206545239164e-07 0.01492874613340729 2.291213876376758e-07 0.01406966818047924 2.291215209008543e-07 0.01391906482409888 \
2.291223725580289e-07 0.01299647369571925 2.291225105004775e-07 0.01285324185793544 2.291234505599668e-07 0.0119198170026788 2.29123614321604e-07 0.01176347583728811 \
2.291246015550385e-07 0.01085909507266535 2.291247361441145e-07 0.0107410715025141 2.291258775835447e-07 0.009819907073012045 2.291259858224434e-07 0.009738548299709823 \
2.29127309069827e-07 0.00880579379490502 2.291274418155253e-07 0.008718202093769473 2.291289643166501e-07 0.007760835273143199 2.29129076858719e-07 0.007690148685505111 \
2.291307691503061e-07 0.00669558715138598 2.291309094168915e-07 0.00662113250846694 2.291329824261937e-07 0.005629132576249021 2.291331749877106e-07 0.005545002188831318 \
2.291353851975589e-07 0.004656096148610405 2.291357919842319e-07 0.004507219767123045 2.291386137242086e-07 0.003590578528330178 2.291391350199587e-07 0.00344214578404881 \
2.291433471210094e-07 0.002447529662748036 2.291438996838773e-07 0.002340875287107731 2.291497829734169e-07 0.001359168649576994 2.291500322464151e-07 0.001311490127959886 \
2.291631823674654e-07 0.0003136950974005476 2.291632991504353e-07 0.0003112730584132499 2.589900000000113e-07 3.042397160644726e-06 3.027466670270133e-07 -0.0009024818035526668 \
3.027467394426295e-07 -0.001022682652537627 3.027471754673471e-07 -0.001858525046639076 3.027472623617301e-07 -0.002046124893065343 3.027476170650434e-07 -0.00288168582347465 \
3.027477166116442e-07 -0.003135075204051477 3.027479768813486e-07 -0.003828199033013717 3.027481172037501e-07 -0.004216406518003108 3.027483446898323e-07 -0.004856871791621592 \
3.027484818972713e-07 -0.005239031028659006 3.0274886679612e-07 -0.006187559915121 3.027489988933069e-07 -0.006423332025500122 3.027496873363354e-07 -0.005917035979538006 \
3.027498442650689e-07 -0.005202654566481615 3.027499719142314e-07 -0.004414133290428114 3.027500994560215e-07 -0.003433350487145549 3.027502171302335e-07 -0.002355902309038119 \
3.027503162699201e-07 -0.001320627313728655 3.027504216526298e-07 -9.507383675133965e-05 3.027505355599331e-07 0.001369964538583592 3.027506666153286e-07 0.003229572948258866 \
3.027507919785475e-07 0.005172303930030842 3.027509838204114e-07 0.008432154569684791 3.027511274902044e-07 0.01107975669588844 3.027512854720174e-07 0.01417105828876112 \
3.027514340716643e-07 0.01723098336859398 3.02751587122593e-07 0.02051714008521248 3.027517461875693e-07 0.02405720796424875 3.02751899257778e-07 0.02756764950178633 \
3.027520476048421e-07 0.03105219347129199 3.027521967112842e-07 0.03462388853332505 3.027523512757131e-07 0.03838854885099419 3.027525119616768e-07 0.04235886888523473 \
3.027526766408632e-07 0.04647718198980624 3.027528531638066e-07 0.05093664320808645 3.027530321756059e-07 0.05549818742091989 3.027532229484479e-07 0.0603932190016783 \
3.027534277958001e-07 0.06567927942044927 3.027536482930531e-07 0.07139554989571946 3.027538812110213e-07 0.07745499876455469 3.027541304587992e-07 0.08395499695136356 \
3.027544033803266e-07 0.09108394918256098 3.027547001733835e-07 0.09884095133633181 3.027550276098956e-07 0.1073964775374675 3.027553974236946e-07 0.1170487607486894 \
3.027557923699755e-07 0.1273407304921971 3.027562504585284e-07 0.1392499850125259 3.027567825583881e-07 0.1530377249371455 3.027574081103967e-07 0.169180864038255 \
3.027580941024627e-07 0.1867931863309214 3.027588969458782e-07 0.2072766958045763 3.027597962582096e-07 0.2300508264895909 3.027606966983226e-07 0.2526618731709107 \
3.027614985898552e-07 0.2726215666318766 3.027621940969962e-07 0.2897857674353052 3.027628269312821e-07 0.3052728323588638 3.027634223397735e-07 0.3197161646377594 \
3.027639693828152e-07 0.3328722959176427 3.027645031431617e-07 0.3455929446372428 3.027650223825863e-07 0.3578476146335662 3.027655297740487e-07 0.3697097539883151 \
3.027660333952181e-07 0.3813674725871593 3.027665451381145e-07 0.3930934709428262 3.027670522991229e-07 0.404595334768291 3.027675825951367e-07 0.4164962117964878 \
3.027680687086257e-07 0.4272847049163567 3.027685468169473e-07 0.437781779057129 3.027689862490711e-07 0.4473362978389137 3.027691094085349e-07 0.4500002106608159 \
3.027693557274626e-07 0.4553046876287923 3.027696989994585e-07 0.4626558934952216 3.02770010436459e-07 0.4692815017887791 3.027702611477243e-07 0.4745855323881177 \
3.027705319768677e-07 0.480281321066213 3.02770868458777e-07 0.4873122872019196 3.027712244673881e-07 0.4946959640027882 3.027715417375557e-07 0.5012322602315481 \
3.027717806181048e-07 0.506122906570856 3.027720216462867e-07 0.5110269393752048 3.027722735779908e-07 0.5161276795544476 3.027725137318346e-07 0.5209621749612534 \
3.027727364832964e-07 0.5254248476203834 3.027729250409435e-07 0.5291850880529715 3.027731397909867e-07 0.5334523706207774 3.027733543393784e-07 0.5376948565446859 \
3.027736131036701e-07 0.5427871977552768 3.027738639312417e-07 0.5477009885064807 3.027741193501039e-07 0.5526782776843104 3.027744703926295e-07 0.5594898819265107 \
3.027747350009544e-07 0.5645984056527484 3.027750014175097e-07 0.569709962982798 3.027752619318197e-07 0.5746801970751495 3.027755290218824e-07 0.5797469183389945 \
3.027757721599625e-07 0.5843213438768613 3.02776027852189e-07 0.5890994944692448 3.027762556711592e-07 0.5933243819692556 3.027764932159793e-07 0.5976999800355528 \
3.027767046064655e-07 0.6015679915939678 3.027769167472246e-07 0.6054277082074113 3.027771059366022e-07 0.6088479815213901 3.027772370949197e-07 0.6112112531841202 \
3.027773693914781e-07 0.6135871094428261 3.02777554614204e-07 0.6169015645304802 3.027777166365907e-07 0.6197943209800671 3.027778750557552e-07 0.6226100751126036 \
3.027780091676215e-07 0.6249846001944386 3.027781814887287e-07 0.6280247049765127 3.027783104275314e-07 0.6302937061188456 3.027784308050438e-07 0.6324061607157294 \
3.027785713339149e-07 0.634864734791624 3.027787644194074e-07 0.6382321981637986 3.027789142301853e-07 0.6408363654380513 3.027790815377796e-07 0.6437327988167145 \
3.027792625920029e-07 0.6468572757970242 3.027794659184327e-07 0.6503523798695617 3.027796487715879e-07 0.6534819287355287 3.027798193958343e-07 0.6563879501053153 \
3.027799968600742e-07 0.6594029650344411 3.027801628390247e-07 0.6622113135173925 3.027803200758144e-07 0.6648594636266301 3.02780460561866e-07 0.6672075432495704 \
3.027806042919945e-07 0.6695987751186935 3.027807373389854e-07 0.6718055529208897 3.02780879311128e-07 0.6741523780906628 3.027809993716612e-07 0.6761293215200647 \
3.027811443097483e-07 0.6785098354674278 3.027812603067977e-07 0.6804095298668216 3.027813798866854e-07 0.6823647593763783 3.027814788466604e-07 0.68397755359623 \
3.027815973550785e-07 0.6859039329668146 3.027816843993602e-07 0.6873150904607619 3.027818064101795e-07 0.6892866586554622 3.027819053327908e-07 0.6908817703737582 \
3.027819972281661e-07 0.6923536807698466 3.027820971967054e-07 0.6939486118486815 3.02782195442366e-07 0.6955126686751646 3.027822871561283e-07 0.6969676095571918 \
3.027823912890697e-07 0.698613189139943 3.02782527015812e-07 0.7007470979739818 3.027826816242742e-07 0.7031613517373301 3.027828167319862e-07 0.7052558942641604 \
3.027829630685319e-07 0.7075085519458914 3.027830915360735e-07 0.7094732734147607 3.02783215720207e-07 0.7113609898537658 3.027833256245073e-07 0.7130225953369277 \
3.027834422075759e-07 0.7147759898693785 3.027835423854067e-07 0.7162749667021007 3.027836794742156e-07 0.7183149847558421 3.027837994632423e-07 0.7200901405411056 \
3.027839185766902e-07 0.7218426783097279 3.02784045072077e-07 0.723693513465353 3.027841709394491e-07 0.7255245570057045 3.027842935604676e-07 0.7272980597885179 \
3.027844211779915e-07 0.7291334326655684 3.027845514267828e-07 0.7309957624152177 3.02784673019733e-07 0.73272442801297 3.027848117884253e-07 0.7346853525547948 \
3.02784912196869e-07 0.7360963845229137 3.027850155842573e-07 0.7375412410987998 3.027851092446997e-07 0.7388443755773992 3.027852208662967e-07 0.7403895158541485 \
3.027853073348996e-07 0.7415798421827293 3.027854081980104e-07 0.7429609798983192 3.027855402947324e-07 0.7447573558536402 3.027856494960337e-07 0.7462323422761349 \
3.027857540276639e-07 0.747635567415085 3.027858776741446e-07 0.7492836897664436 3.027860263705797e-07 0.7512497161812216 3.027861482512389e-07 0.7528480713857697 \
3.02786261855803e-07 0.7543274008692354 3.027864023754882e-07 0.7561429069656862 3.027865435649301e-07 0.7579511824827749 3.027866613111062e-07 0.7594470562859095 \
3.027867900007657e-07 0.7610693809796742 3.027869325554127e-07 0.7628512182523866 3.027870484119641e-07 0.7642872416835913 3.027871941752297e-07 0.7660789429779771 \
3.02787316007677e-07 0.7675637574673733 3.02787434476374e-07 0.7689965471136999 3.02787557264006e-07 0.7704700089613156 3.027876834168886e-07 0.7719718272910862 \
3.027877937859393e-07 0.7732757954107932 3.02787919217035e-07 0.7747465774777432 3.027880246987464e-07 0.775974259539018 3.027881578651758e-07 0.7775122819577122 \
3.02788280546631e-07 0.7789173428708996 3.027884153096743e-07 0.7804473432620218 3.027885259809625e-07 0.7816923373676121 3.027886353025911e-07 0.7829118427552927 \
3.027887704350256e-07 0.7844048889494442 3.027889212140504e-07 0.7860523747618094 3.027890615829581e-07 0.7875692293014268 3.027891812944828e-07 0.7888502570533434 \
3.027893195488235e-07 0.7903153082715967 3.027894429191593e-07 0.7916096503654788 3.027895880177844e-07 0.7931164937536124 3.027897277580435e-07 0.7945521172774316 \
3.027898549394667e-07 0.7958455533278409 3.027899739792201e-07 0.7970449251022731 3.027900863374111e-07 0.7981670522831598 3.027901905661906e-07 0.79919939674296 \
3.027902859050021e-07 0.8001364844871954 3.027904221931122e-07 0.8014634245741865 3.027905390856557e-07 0.8025894467082511 3.02790658725145e-07 0.8037305025474466 \
3.027907806067166e-07 0.8048811831579785 3.027909029850537e-07 0.8060245537852575 3.027910310137332e-07 0.8072081965553952 3.027911556585317e-07 0.8083483262222385 \
3.027912861572795e-07 0.8095291977395493 3.027914126177069e-07 0.8106611567088965 3.027915397436747e-07 0.8117869190804841 3.027916448611513e-07 0.8127087429624065 \
3.027917501113405e-07 0.8136235164943317 3.027918412515906e-07 0.8144090748259969 3.027919646696249e-07 0.8154632009865571 3.027920517482738e-07 0.8162003374872545 \
3.02792151070959e-07 0.8170344894488412 3.027922959927027e-07 0.8182390501293432 3.027924322612063e-07 0.8193582434421302 3.027925417234847e-07 0.8202477434185359 \
3.027926878435863e-07 0.8214214001843773 3.02792839202198e-07 0.8226208465286928 3.027929650061201e-07 0.8236052915965452 3.027931094167794e-07 0.824721541823094 \
3.027932340177296e-07 0.8256729463037898 3.027933847297913e-07 0.8268094083523665 3.0279352010105e-07 0.8278169867326588 3.027936453039791e-07 0.8287379047458127 \
3.027937629733617e-07 0.829593908450195 3.027939088013387e-07 0.8306418458276996 3.027940752973201e-07 0.8318207857986918 3.027942061544082e-07 0.8327345044534114 \
3.027943796038485e-07 0.833928356718921 3.027945477223224e-07 0.8350667646575466 3.027947175961246e-07 0.8361988603660855 3.027948984507537e-07 0.8373843006762304 \
3.027950416331349e-07 0.8383085120571983 3.027951557464787e-07 0.8390361588138326 3.027952858124697e-07 0.8398559950134801 3.027953876877057e-07 0.8404909448220066 \
3.027955045669982e-07 0.8412116130393378 3.027956416789287e-07 0.8420465258793415 3.027958395595721e-07 0.843231707656198 3.027960313457652e-07 0.8443585547012582 \
3.027962407088286e-07 0.8455646258450146 3.027964228224064e-07 0.846593677725298 3.027966199171782e-07 0.8476867969181797 3.02796793185875e-07 0.8486305714188691 \
3.02796976264561e-07 0.8496104335327738 3.027971474015872e-07 0.8505103231661706 3.027973220804384e-07 0.8514128411730317 3.02797497318728e-07 0.8523022053693007 \
3.027976734583675e-07 0.8531802340241421 3.027978638096238e-07 0.8541115036082744 3.027980543867704e-07 0.855025905954957 3.027982548181929e-07 0.8559685891497206 \
3.027984474106693e-07 0.8568563992305701 3.027986582738064e-07 0.8578086227668252 3.027988861871822e-07 0.8588150784816577 3.027991522177188e-07 0.8599606428795262 \
3.027994507388009e-07 0.8612090806949765 3.027997266924816e-07 0.8623286542354505 3.028000109545961e-07 0.8634483918036945 3.028002851030458e-07 0.8644969441068078 \
3.02800557392313e-07 0.8655088801415273 3.028008275580888e-07 0.8664846790737442 3.028010847361862e-07 0.8673881555543895 3.028013572993529e-07 0.868319368003445 \
3.02801633304697e-07 0.8692355072818493 3.028019034186287e-07 0.870106770567397 3.028022032450018e-07 0.8710447971670072 3.028025742222908e-07 0.8721640818024149 \
3.028028691540118e-07 0.8730224021943973 3.028031234323761e-07 0.873740732376842 3.028034216772072e-07 0.8745584461000401 3.028036952852192e-07 0.8752856917963749 \
3.028039314154438e-07 0.8758961959341748 3.028041717609793e-07 0.8765017794770257 3.028043940971677e-07 0.8770481951318053 3.028045881024505e-07 0.8775144010549708 \
3.028049178237936e-07 0.8782846129827527 3.028050729968195e-07 0.8786376896881318 3.028053907524076e-07 0.8793424631377607 3.028055696169827e-07 0.8797286397841958 \
3.028059120784622e-07 0.8804474051285093 3.028060962178168e-07 0.880822800830328 3.028065711184754e-07 0.881756283451624 3.028067385131538e-07 0.8820737784441692 \
3.028072043462e-07 0.8829272622221894 3.028073851704931e-07 0.8832470363605239 3.028078792047929e-07 0.8840891816604841 3.028080205486687e-07 0.8843218944112644 \
3.028086269405857e-07 0.8852805359894154 3.028087790117662e-07 0.8855111592597558 3.028094256914359e-07 0.8864506941541785 3.028095539876422e-07 0.8866295550025313 \
3.028102021648149e-07 0.8874976172723908 3.028103319236755e-07 0.8876644392549727 3.028111001444974e-07 0.8886037370453904 3.02811229881009e-07 0.8887539063021698 \
3.028120833066544e-07 0.8896836309705964 3.028122265650877e-07 0.8898301468060963 3.02813212785821e-07 0.890764641901611 3.02813434267227e-07 0.8909571971396437 \
3.028145773086277e-07 0.8918770673440963 3.028147072981167e-07 0.8919774876506176 3.028160589233886e-07 0.8929731820841386 3.028162092835701e-07 0.89307657739048 \
3.028176899161688e-07 0.8939986636922405 3.028179288179339e-07 0.8941315911431026 3.028196933116327e-07 0.894999985510941 3.028200009949781e-07 0.8951330875684044 \
3.028225222661808e-07 0.8960612226716312 3.02822959317422e-07 0.8961978289811912 3.028268627296431e-07 0.8971619289239613 3.028271095114498e-07 0.8972094058147089 \
3.028346860012845e-07 0.8981998139535015 3.028348019130314e-07 0.8982099955090975 3.028539004457353e-07 0.8992062631372056 3.028542978885091e-07 0.8992194728667773 \
3.030047133235903e-07 0.9002121614362558 3.03004979381947e-07 0.9002436812458944 3.030102475320153e-07 0.8993470931706574 3.030104539029324e-07 0.899191170936528 \
3.030119320157425e-07 0.8982046351054961 3.030121124663985e-07 0.8981003355419954 3.030143349480612e-07 0.8971299612768925 3.030145410405757e-07 0.897079983173831 \
3.030249493066813e-07 0.8980580240048047 3.03025087164257e-07 0.8980839755683444 3.030318845132984e-07 0.8990685088718567 3.030320700847659e-07 0.8990874390200084 \
3.035282992589679e-07 0.9000706848616691 3.03528359054814e-07 0.9000975977971888 3.035296126054321e-07 0.9010828413531861 3.035297182980354e-07 0.9012097231395001 \
3.035303764287524e-07 0.9021613947651476 3.035305136110213e-07 0.9023918767045529 3.035310366376409e-07 0.9033649777562528 3.035310995012334e-07 0.9034908765919824 \
3.035315720967825e-07 0.904476514442582 3.035316234105955e-07 0.9045863669199017 3.035320893739314e-07 0.9055619780118375 3.035321215783922e-07 0.9056252631670594 \
3.035328386771295e-07 0.9066212416280413 3.035329231134019e-07 0.9066528951765993 3.035335231797814e-07 0.9059679814895146 3.035336430373927e-07 0.9055903401525059 \
3.03533774200172e-07 0.9050640446667092 3.035339090199249e-07 0.9043926011431642 3.035340571549842e-07 0.9034897747335404 3.035341947143354e-07 0.902493211317788 \
3.035343349260954e-07 0.9013135799985507 3.035344335882047e-07 0.9003872218501816 3.035345192720141e-07 0.8995148096066522 3.035346018362134e-07 0.8986166894493001 \
3.035347166188419e-07 0.8972773101170661 3.03534797717086e-07 0.8962642459447687 3.03534877134364e-07 0.8952218112132616 3.035349825888917e-07 0.8937633947192651 \
3.035351052301954e-07 0.8919606744930825 3.035352049542744e-07 0.890414036797163 3.035353751486854e-07 0.8876203405523397 3.035355213337767e-07 0.8850727273800474 \
3.035356895519253e-07 0.8819879035815887 3.035358617130214e-07 0.8786780617039783 3.035360460991142e-07 0.8749807502679057 3.035362306654577e-07 0.8711418063496947 \
3.035364149129437e-07 0.8671917613865908 3.035366002486073e-07 0.8631174608718694 3.035367746363354e-07 0.8592060069639053 3.035369573402717e-07 0.8550405244181323 \
3.035371326873658e-07 0.8509893565349284 3.035373150168772e-07 0.8467313026054767 3.035375053303062e-07 0.8422468264612591 3.035376756604352e-07 0.838204894125699 \
3.035378421840737e-07 0.8342320488410089 3.035380047549371e-07 0.830337741667393 3.035381546161599e-07 0.8267359097041467 3.035383057921791e-07 0.8230937075736249 \
3.035384949376529e-07 0.8185270080344306 3.035386406557074e-07 0.8150026134285653 3.035388156466743e-07 0.8107652770601156 3.035389641182175e-07 0.807166938184282 \
3.035391360056828e-07 0.8029987283123258 3.035393050739223e-07 0.7988973224349885 3.035394692526316e-07 0.7949140139776875 3.035396285801687e-07 0.7910485911592836 \
3.035397890297763e-07 0.7871568543472617 3.035399908491574e-07 0.7822630953020117 3.035401392968917e-07 0.7786646206504594 3.03540293464276e-07 0.77492821376164 \
3.035404305476362e-07 0.7716074476660475 3.035405399330824e-07 0.7689587163513494 3.035406458665383e-07 0.7663946531324515 3.035407728808854e-07 0.7633217481666642 \
3.035408872438541e-07 0.7605561828888391 3.035409900916761e-07 0.7580702160470256 3.035411116819926e-07 0.7551325442760125 3.035412224592673e-07 0.7524575925939972 \
3.035413393080924e-07 0.7496376180588871 3.035414500928178e-07 0.7469652567786068 3.035415684589191e-07 0.7441116745915923 3.035416932860144e-07 0.7411038668912771 \
3.035418458478099e-07 0.7374292753756717 3.035419797447979e-07 0.7342062928952946 3.035421007762374e-07 0.7312947572377408 3.035422649737523e-07 0.7273475399259534 \
3.035424423346988e-07 0.7230877912371642 3.035426245451075e-07 0.7187161681757385 3.035428055423726e-07 0.7143786395952922 3.035429862063158e-07 0.7100537072471783 \
3.035431763578828e-07 0.7055071781827296 3.035433641177769e-07 0.7010230964996226 3.035435646508815e-07 0.696237807975249 3.035437733363431e-07 0.6912646166759551 \
3.035439809799078e-07 0.6863227581165517 3.03544208547776e-07 0.6809140411171237 3.035444008226102e-07 0.6763521085712711 3.035446380878582e-07 0.6707310800019505 \
3.035448313661221e-07 0.6661595641347996 3.035450640988686e-07 0.6606646229758047 3.035452696563363e-07 0.6558174602470968 3.035455020097575e-07 0.6503484594495911 \
3.035456970117276e-07 0.6457674053103037 3.035459002403362e-07 0.6410004262200759 3.035460800928814e-07 0.6367906205544323 3.035462591993119e-07 0.6326052789263827 \
3.035464225765258e-07 0.628795088826817 3.035465946259304e-07 0.6247880828503264 3.035467581187693e-07 0.6209892715878097 3.035469339085876e-07 0.6169100951581823 \
3.035471158475732e-07 0.6126978430086294 3.035473043313055e-07 0.6083422542008314 3.035475107637274e-07 0.6035858951323969 3.035476900783897e-07 0.5994633272559844 \
3.035478872572566e-07 0.5949432360761027 3.035480963453974e-07 0.5901646611556908 3.035483020946604e-07 0.5854760387944159 3.035485426053479e-07 0.5800160304866983 \
3.035487157334496e-07 0.5760958285528379 3.035488806274519e-07 0.5723746772837877 3.035490614880267e-07 0.5683014035092815 3.035492187741233e-07 0.5647722902613652 \
3.035493877569178e-07 0.5609879409349005 3.03549567863379e-07 0.5569709657351898 3.03549720846506e-07 0.5535669615732179 3.035498525609507e-07 0.5506462283231492 \
3.035499999486508e-07 0.5473865746199473 3.035500873742421e-07 0.5454560063082221 3.035501722454816e-07 0.5435860258811447 3.03550270874694e-07 0.5414171943998213 \
3.035503429668553e-07 0.5398340751058975 3.035504400578744e-07 0.5377039800781129 3.035505256482577e-07 0.5358302678688993 3.035505907291341e-07 0.5344081412607664 \
3.03550714329502e-07 0.5317121235594142 3.035508087537724e-07 0.52965475734789 3.035509062769941e-07 0.5275349985745696 3.035510791376451e-07 0.5237893654184622 \
3.035512141331662e-07 0.5208709659121862 3.035513683166277e-07 0.5175498113398643 3.03551542781984e-07 0.5138002600288881 3.035516945879704e-07 0.510550000123414 \
3.03551840818953e-07 0.5074290310664136 3.035519847178261e-07 0.5043644611166801 3.035521277396695e-07 0.5013276181140283 3.035522233495175e-07 0.499301733014788 \
3.035523177934733e-07 0.4973032961550828 3.035524388494141e-07 0.4947494705229025 3.035525337277099e-07 0.4927525559781179 3.035526495585533e-07 0.4903172469328811 \
3.035527368224019e-07 0.4884854516151125 3.035528192528481e-07 0.4867593351188191 3.035529146608016e-07 0.484765406725184 3.035530153710815e-07 0.4826639978995959 \
3.035531122314731e-07 0.4806459052877932 3.035532509612246e-07 0.4777646955734051 3.035533866660861e-07 0.4749532752442271 3.035535871508094e-07 0.4708139964547478 \
3.035538024649621e-07 0.4663911383470885 3.03553984040267e-07 0.462674698484628 3.035541830122363e-07 0.4586189944293299 3.035543535777573e-07 0.455154096457448 \
3.035545279314447e-07 0.4516251957269069 3.035546968646987e-07 0.4482170126441485 3.035548694618603e-07 0.4447467276163349 3.035550520681902e-07 0.4410867902598327 \
3.035552406170555e-07 0.4373240875354826 3.035554340845929e-07 0.4334777823509549 3.035556424052318e-07 0.4293535036700135 3.035558567504624e-07 0.4251286740881063 \
3.035560824557922e-07 0.4207018662297695 3.035563089991605e-07 0.4162771402745992 3.035565711759108e-07 0.4111844468197049 3.035568202097347e-07 0.4063709766754009 \
3.035571213084326e-07 0.4005865607947761 3.035574107292502e-07 0.3950673729298416 3.035577182435291e-07 0.3892455819062323 3.035580404399245e-07 0.3831936848847286 \
3.035583681704072e-07 0.3770882112794804 3.035587006001628e-07 0.3709500980558715 3.035590303291706e-07 0.3649083177186754 3.035593515587582e-07 0.3590729273462687 \
3.03559682375082e-07 0.3531219177045733 3.035600247306453e-07 0.3470224718704957 3.035603243716774e-07 0.3417374346434491 3.035606541592421e-07 0.3359723367088904 \
3.035609810531852e-07 0.3303128110141857 3.03561319032532e-07 0.3245206193888226 3.035616280036957e-07 0.3192755432624759 3.035619528016686e-07 0.31382336954194 \
3.035622684318663e-07 0.3085864885517507 3.035625734190322e-07 0.3035810258414895 3.035628287576776e-07 0.2994330834535801 3.03563093620834e-07 0.295170851203172 \
3.035633807035187e-07 0.2905978071194348 3.035636036732975e-07 0.2870801635277143 3.035638032125666e-07 0.2839591363066187 3.035640128685797e-07 0.2807045410859125 \
3.035641931251209e-07 0.2779290029372279 3.035643554698416e-07 0.2754463208250681 3.035645059048156e-07 0.2731629026725527 3.035646569101242e-07 0.2708866524077067 \
3.035648538007149e-07 0.2679392949564011 3.035649849454786e-07 0.2659970646012914 3.035651096820175e-07 0.2641561221543183 3.035652612740599e-07 0.2619266655689588 \
3.03565357242231e-07 0.2605306204207966 3.035654537935996e-07 0.2591282589302421 3.035655784133887e-07 0.2573209601776467 3.035657209899234e-07 0.255257422470362 \
3.035658799234579e-07 0.25296979123958 3.035660125895253e-07 0.251062957019046 3.03566196158294e-07 0.2484301322588876 3.035663773934597e-07 0.2458327969660818 \
3.035665889075646e-07 0.2428051031600066 3.035667914973991e-07 0.2399069804317323 3.035669580538467e-07 0.2375282895552967 3.03567168273059e-07 0.2345337828133105 \
3.035673416909451e-07 0.2320692345528927 3.035675705336728e-07 0.2288260787734411 3.035677911684244e-07 0.2257162440502939 3.035679668301377e-07 0.2232503232699662 \
3.035681472906433e-07 0.2207258962977968 3.035683180470208e-07 0.2183528725291195 3.035684982432872e-07 0.2158619697278009 3.035686649739047e-07 0.2135675266585953 \
3.035688140953261e-07 0.2115251542210239 3.035689699053442e-07 0.2094125291275523 3.035691050857695e-07 0.2075875692769576 3.035692551671966e-07 0.2055694209972212 \
3.035693876128229e-07 0.2037957203154137 3.035695281573595e-07 0.2019220745191926 3.035696452261239e-07 0.2003748851744883 3.035697749337302e-07 0.1986681706274326 \
3.035698969911991e-07 0.1970700654731777 3.035700195346348e-07 0.1954731161836187 3.035701375539584e-07 0.1939418157697267 3.035702725767313e-07 0.1921981789937757 \
3.03570417201182e-07 0.1903420634523806 3.035705455516813e-07 0.1887049708672087 3.03570669186156e-07 0.1871351133418249 3.035707667362788e-07 0.1859021016257166 \
3.035708818092082e-07 0.1844539912642748 3.035709755078879e-07 0.1832809848801438 3.035710742920116e-07 0.1820493959460708 3.035711972265529e-07 0.1805230483556907 \
3.035712929805559e-07 0.1793400249325384 3.035714220681073e-07 0.177753298391591 3.035715245334772e-07 0.1764993061988986 3.035716227869744e-07 0.1753029542432101 \
3.035717428741866e-07 0.1738483570896001 3.03571845423405e-07 0.1726127298531683 3.035719558810642e-07 0.1712877101305652 3.035720843709282e-07 0.1697552709290656 \
3.035721758557694e-07 0.1686698090598139 3.035722803403581e-07 0.1674358120019214 3.035723552770942e-07 0.1665544493622226 3.03572444845591e-07 0.1655049734124585 \
3.035724954106002e-07 0.164914347906921 3.035725453889764e-07 0.1643318187475747 3.03572610358061e-07 0.163576534137217 3.035726458720287e-07 0.1631646263336159 \
3.035727180712023e-07 0.162329174921529 3.035727852002975e-07 0.1615546732967998 3.035728444300318e-07 0.160873195114598 3.035728881756305e-07 0.1603710314414745 \
3.035729358224586e-07 0.1598254649913795 3.03573006202993e-07 0.1590230739426561 3.03573088541159e-07 0.1580883269013631 3.035731667127594e-07 0.1572048664554128 \
3.035732487657085e-07 0.1562816770844126 3.035733414693307e-07 0.1552436243401225 3.035734642494946e-07 0.153877370231325 3.035735633955882e-07 0.1527810927807017 \
3.035736648959355e-07 0.1516651170047695 3.035737661711265e-07 0.1505582666538253 3.035738626629107e-07 0.1495093242781697 3.035739620809455e-07 0.1484346886615803 \
3.03574046381569e-07 0.1475281828465028 3.035741393202594e-07 0.1465342051547719 3.035742219212e-07 0.1456551508734999 3.035743306872851e-07 0.1445034822456445 \
3.035744363302651e-07 0.1433917535370727 3.035745179898545e-07 0.1425365900703354 3.03574611735024e-07 0.1415598856352903 3.03574705302971e-07 0.1405903867550886 \
3.035747881874616e-07 0.139735765814107 3.035748763466362e-07 0.1388313836440244 3.035749561327222e-07 0.1380170907865772 3.035750497281217e-07 0.1370669869522621 \
3.035751396606459e-07 0.1361590166429519 3.035752102110423e-07 0.1354501541392388 3.035752799712188e-07 0.1347521119166949 3.035753941201259e-07 0.1336164586193709 \
3.035754760987401e-07 0.1328058651355588 3.035755637040425e-07 0.1319440719770354 3.035756632052385e-07 0.1309710196939938 3.035757723852409e-07 0.1299110174488692 \
3.03575874550573e-07 0.1289256009328031 3.035759820107789e-07 0.1278959836800649 3.035761020450569e-07 0.1267549558890445 3.035761962530915e-07 0.1258657925752028 \
3.03576327232195e-07 0.1246390638240933 3.035764266598965e-07 0.1237164070883829 3.035765357815822e-07 0.1227104370444639 3.035766446347502e-07 0.1217138859540913 \
3.035767369441536e-07 0.120874257454373 3.035768497844844e-07 0.1198547128626846 3.035769467965243e-07 0.118986084968971 3.035770510628723e-07 0.1180628196869088 \
3.035771600298026e-07 0.1171053395831002 3.035772595693683e-07 0.1162371554254778 3.035773765620782e-07 0.1152245300989246 3.035774636628686e-07 0.1144761644999183 \
3.035775729545201e-07 0.1135478691973115 3.035776544795827e-07 0.1128618460838699 3.035777542545759e-07 0.1120273350449922 3.03577871679726e-07 0.1110526766231405 \
3.035779734648438e-07 0.1102143708571793 3.035780612037922e-07 0.1094962336869811 3.035781420032999e-07 0.1088432886892514 3.035782289543192e-07 0.1081456845520918 \
3.035783097409448e-07 0.1075007757815706 3.035783999475114e-07 0.1067842832273628 3.03578490898266e-07 0.1060655611559195 3.035785795687901e-07 0.1053685613006139 \
3.035786785836107e-07 0.1045946508745568 3.035787722897869e-07 0.1038723470842792 3.035788661490627e-07 0.1031520741219857 3.035789669765109e-07 0.1023817709659086 \
3.035790716074088e-07 0.1015861061604995 3.035791955701651e-07 0.1006484085638475 3.035792929694782e-07 0.09991551135558702 3.035794132274253e-07 0.09901872452754552 \
3.035795240953005e-07 0.09819831936474602 3.035796285683363e-07 0.09742874659471555 3.035797458050452e-07 0.09656937225591002 3.035798475993662e-07 0.09582695326576983 \
3.035799455749168e-07 0.09511577589263259 3.035800860794065e-07 0.09410164141823299 3.035801911572026e-07 0.09334832721827611 3.035802897700187e-07 0.09264549593674179 \
3.035803824848273e-07 0.09198739948435641 3.035804686832124e-07 0.09137785861853052 3.035805625961876e-07 0.09071637432184691 3.035806596969337e-07 0.09003559055802626 \
3.035807691179881e-07 0.08927317549644689 3.035808701015371e-07 0.08857281843916648 3.035809637594832e-07 0.08792605868920525 3.035810379341552e-07 0.08741581771673042 \
3.03581175834007e-07 0.08647193599618339 3.035812481910108e-07 0.08597917321277694 3.035813835122141e-07 0.08506274029062395 3.035814694238195e-07 0.08448410751389913 \
3.03581614152054e-07 0.08351486081643937 3.035817103826189e-07 0.0828744112740944 3.035817982183981e-07 0.08229260392026354 3.035819140173063e-07 0.08152964121883956 \
3.035820291457576e-07 0.08077575264951149 3.0358214291219e-07 0.08003553900012179 3.035822831696828e-07 0.0791300282244784 3.035824245457162e-07 0.07822490276368012 \
3.035825741817577e-07 0.07727536491519127 3.035827186706132e-07 0.07636690312463701 3.035828698447241e-07 0.07542565384097814 3.035830192155436e-07 0.07450459906593411 \
3.03583168562251e-07 0.0735926433331697 3.035833285177668e-07 0.07262574717347114 3.035834846646777e-07 0.07169171823582712 3.035836591531124e-07 0.07065947636250877 \
3.035838288622191e-07 0.0696671357044583 3.035840140413029e-07 0.0685979885997255 3.035842107623799e-07 0.06747763456279594 3.035844212801998e-07 0.06629631776014881 \
3.03584643312255e-07 0.06507007089066431 3.035848735242764e-07 0.0638195278444372 3.035851160353819e-07 0.06252626147401 3.035853766894672e-07 0.06116236403900636 \
3.035856565885314e-07 0.05972739422233359 3.035859501722554e-07 0.05825544847408989 3.035862651082393e-07 0.05671370145268265 3.035866079141644e-07 0.05507846134953124 \
3.035869573807585e-07 0.0534565727116736 3.035873662849152e-07 0.05161746230842366 3.035877129499425e-07 0.05010669351290297 3.035881003649955e-07 0.04846839895323611 \
3.035884445827877e-07 0.04705645202362623 3.035887680090468e-07 0.04576625679949029 3.035890730548091e-07 0.04458093278443617 3.035893659168059e-07 0.04347099288378908 \
3.035896500577229e-07 0.04242242262004604 3.03589926078015e-07 0.04142902112907627 3.03590192930566e-07 0.04049015932812138 3.035904618227892e-07 0.03956531631184226 \
3.035907378832112e-07 0.03863769040165695 3.035910254787821e-07 0.03769451689421055 3.035912650444083e-07 0.03692662498323904 3.03591554211835e-07 0.03602084344675294 \
3.03591770003438e-07 0.03535960341037672 3.035919577204764e-07 0.03479599077274986 3.035921558495825e-07 0.03421285035004928 3.03592518724446e-07 0.03317032497347058 \
3.03592776866276e-07 0.03244834222605905 3.0359308657919e-07 0.0316030971185694 3.035933520493286e-07 0.03089664771451467 3.035936201684082e-07 0.03019941363307669 \
3.03593899042439e-07 0.02949128999862272 3.035941452288756e-07 0.02888043298519722 3.035943758602853e-07 0.02832033800396738 3.035946141502041e-07 0.02775711540944564 \
3.035948491575685e-07 0.02721270742060762 3.03595076940031e-07 0.02669509678424227 3.035954855523029e-07 0.02579039168486155 3.03595661854632e-07 0.02540904040268441 \
3.03596016332316e-07 0.02465798827491217 3.035962002032883e-07 0.02427641469830137 3.035965351520103e-07 0.02359448510613503 3.035966990607275e-07 0.02326678168937357 \
3.035970913313036e-07 0.02249905491676728 3.035972473220689e-07 0.02220010404946675 3.035976789254264e-07 0.02138321689778962 3.035978163148065e-07 0.0211255367654138 \
3.03598333123589e-07 0.02017559010600388 3.035984586594829e-07 0.01995091418019728 3.035989159010076e-07 0.01915998482559782 3.035990750469891e-07 0.01889493739859509 \
3.035996822854669e-07 0.01793263500095189 3.03599816822955e-07 0.01772934138481063 3.036004800869477e-07 0.01678091027541291 3.036006734103789e-07 0.01651856846389665 \
3.036013410670396e-07 0.01565087920017967 3.03601502655887e-07 0.01544858341705342 3.0360225789114e-07 0.01454101846553843 3.036024074521069e-07 0.01436800730673201 \
3.036032977899311e-07 0.01338293844200974 3.036033964478169e-07 0.01327873262558703 3.03604353121314e-07 0.01230993787860994 3.036044742310216e-07 0.01219243157195396 \
3.036054657237297e-07 0.01126376273051215 3.036056292524602e-07 0.01111855113153209 3.036067591745355e-07 0.01018247077230436 3.036068716217739e-07 0.01009565848301377 \
3.036082494452622e-07 0.009103273453806031 3.036083883905334e-07 0.009009747578659758 3.036099427888684e-07 0.008018073335410726 3.0361005485534e-07 0.00794673960805117 \
3.036116998381698e-07 0.006958154532207958 3.036118070906645e-07 0.006899512253112593 3.036137515841525e-07 0.005937533026687714 3.036139584821097e-07 0.005843834961138424 \
3.036162973698526e-07 0.00487227039639981 3.036167213562637e-07 0.004712306502041247 3.036194935894604e-07 0.003780857497341114 3.036199418985521e-07 0.003647790772321777 \
3.03623582397237e-07 0.00272553831825111 3.036240790530716e-07 0.002619503085887757 3.036298301734959e-07 0.001650572925599863 3.036301169553825e-07 0.001609446887446839 \
3.036354719440668e-07 0.0006353228983793809 3.036356773006917e-07 0.0005920420449145349 3.062827120745074e-07 -0.0002718533828215428 3.062828679501107e-07 -0.0004579010352009555 \
3.062834162652028e-07 -0.001326296959495401 3.062835290488787e-07 -0.001543805653187533 3.062839635410185e-07 -0.002491429791030493 3.062840393661749e-07 -0.002673591589873599 \
3.062843960167732e-07 -0.003590195133438418 3.062845230658532e-07 -0.003936807634339821 3.062848015662471e-07 -0.004716444651655622 3.062849096507305e-07 -0.005020876868076652 \
3.06285253249855e-07 -0.00592430224391268 3.062853602437202e-07 -0.006162325733041658 3.062862596141159e-07 -0.005653094509861465 3.062864380475456e-07 -0.004687598829536962 \
3.062865437709605e-07 -0.003940993102967527 3.062866688337378e-07 -0.002883597584075996 3.062867624178337e-07 -0.001971418478057775 3.062868402573964e-07 -0.001132968824455395 \
3.062869203293945e-07 -0.0001977429743171 3.062870427022047e-07 0.001370578777960296 3.062871609580771e-07 0.003041212838230153 3.062872796071873e-07 0.004860750887681821 \
3.06287393089626e-07 0.006730904986417607 3.062874965327645e-07 0.008536402178002854 3.062876111920181e-07 0.01064190690353853 3.062878017758113e-07 0.0143607330143792 \
3.062879355659492e-07 0.01711819191720031 3.062880858195149e-07 0.02033933849841947 3.062882409887625e-07 0.02378599874269359 3.062883963808114e-07 0.0273434151175349 \
3.062885440880426e-07 0.03080849965087477 3.062886930776679e-07 0.03437359286003162 3.06288848068751e-07 0.03814545786868043 3.062890074393648e-07 0.04208062121327779 \
3.062891723727756e-07 0.04620305710844342 3.062893473191046e-07 0.0506208066052034 3.062895264491763e-07 0.05518387280380205 3.062897162384316e-07 0.06005265756871143 \
3.062899199354002e-07 0.06530840376289772 3.062901397459318e-07 0.07100650943730057 3.062903714973765e-07 0.07703584544314998 3.062906193226736e-07 0.08349927754587044 \
3.062908906436034e-07 0.09058756662233436 3.062911853563813e-07 0.09829181712822582 3.062915106140293e-07 0.106792896697727 3.062918768597349e-07 0.1163551101154179 \
3.062922701564477e-07 0.1266079356677421 3.062927228093435e-07 0.1383809089651769 3.062932485245108e-07 0.1520098384503803 3.062938677380491e-07 0.1679979965193872 \
3.062945484823656e-07 0.1854865650013753 3.062953421573204e-07 0.2057488551561759 3.062962309229534e-07 0.2282732214494322 3.062970443122153e-07 0.2487218262351868 \
3.062977660617924e-07 0.2667261628598245 3.062984017258005e-07 0.282460740414376 3.062989734425617e-07 0.2965101025186013 3.062995089968458e-07 0.3095696210007924 \
3.063000123552588e-07 0.3217495654069301 3.063004886827015e-07 0.3331878525640654 3.063009626063057e-07 0.3444754071334732 3.063014200780245e-07 0.3552759747331513 \
3.06301886058294e-07 0.3661792384270033 3.063023350461038e-07 0.376592601923634 3.063028311526457e-07 0.3879857357798637 3.063033509145082e-07 0.3998002499051578 \
3.063037303191525e-07 0.4083447473225827 3.063041703278757e-07 0.4181679450526055 3.063046400968136e-07 0.4285466970600206 3.063051256177522e-07 0.4391589006481625 \
3.063055650658585e-07 0.4486701556983262 3.063056268188069e-07 0.4500002248264944 3.063057503247038e-07 0.4526540461147197 3.063059973364976e-07 0.4579447795386873 \
3.063062499314088e-07 0.463325462421476 3.063064475025244e-07 0.467511453725808 3.063066730742715e-07 0.4722681264242033 3.06306994642268e-07 0.4790073975813253 \
3.063072634214966e-07 0.4846013351959894 3.063074820729701e-07 0.4891262574467725 3.063076921769364e-07 0.4934547887280634 3.063079185824616e-07 0.4980921872304203 \
3.063081276876522e-07 0.5023516957637455 3.063083170899107e-07 0.5061927337048852 3.06308441251129e-07 0.5086969563931187 3.063085680062259e-07 0.5112441466129884 \
3.06308728004704e-07 0.5144514110933732 3.063089756476561e-07 0.5193914248715521 3.063091542341148e-07 0.5229351592435862 3.063093251876918e-07 0.5263079149198099 \
3.063095865372878e-07 0.5314455197962068 3.063098126088702e-07 0.5358634945234868 3.063100157405374e-07 0.5398188128751134 3.063101809712675e-07 0.5430252218652345 \
3.063103377582878e-07 0.5460612552756139 3.063105269149053e-07 0.5497137532216215 3.063107287826585e-07 0.5535976061995346 3.063109529339811e-07 0.5578986282275192 \
3.063111913163462e-07 0.5624617013850463 3.06311426077985e-07 0.566941985223824 3.063116563486904e-07 0.5713275351537204 3.063118621413239e-07 0.5752375533958141 \
3.063120671255381e-07 0.5791255875933676 3.063123099407797e-07 0.5837094709690289 3.063125646983618e-07 0.588493349632063 3.063127929267933e-07 0.5927514274590796 \
3.063130307656652e-07 0.5971656109489694 3.063132430431008e-07 0.6010807441713891 3.063134548365055e-07 0.6049674646600495 3.06313708720774e-07 0.6095919957414236 \
3.063139133143013e-07 0.6132953190650409 3.063141650376543e-07 0.6178178328453598 3.063143528271744e-07 0.6211736970442716 3.063146057002513e-07 0.6256587164710262 \
3.063148041096133e-07 0.6291560967673944 3.06314983842284e-07 0.6323071487074056 3.063152541130913e-07 0.6370161336915187 3.063154713968567e-07 0.6407803561788556 \
3.063156519232363e-07 0.6438916924996977 3.063158530841308e-07 0.6473460740030906 3.063160216675126e-07 0.650231451944099 3.063162260257198e-07 0.6537144072723954 \
3.063163716887783e-07 0.6561873372238678 3.063165362473771e-07 0.6589728476742622 3.063167057165935e-07 0.6618316558839334 3.063168592566751e-07 0.664412775690417 \
3.06317000490202e-07 0.6667750288922751 3.063171440660136e-07 0.6691685747430841 3.06317277296139e-07 0.6713840140331436 3.063174191964594e-07 0.6737368819239464 \
3.063175394300862e-07 0.6757233098298149 3.063176840811384e-07 0.6781085120392751 3.063178002998436e-07 0.6800197521569988 3.063179193821632e-07 0.6819757159594566 \
3.063180179604767e-07 0.6835903813535821 3.063181355581833e-07 0.6855122399681081 3.063182229941461e-07 0.6869376986921233 3.063183477402322e-07 0.6889650632873403 \
3.063184475472963e-07 0.6905825000046129 3.063185400370926e-07 0.6920753042469043 3.063186413211772e-07 0.6937043390836264 3.063187391142832e-07 0.695273833970533 \
3.063188303850746e-07 0.6967333967490603 3.063189328429049e-07 0.6983656370917724 3.063190657521356e-07 0.7004728611232253 3.063192207675414e-07 0.7029137789397926 \
3.063193556492269e-07 0.7050222373350452 3.063195011450183e-07 0.7072806469370021 3.063196289996853e-07 0.709252249158637 3.063197534579806e-07 0.7111597484283609 \
3.063198647836849e-07 0.7128563623504806 3.063199788137127e-07 0.7145852226468989 3.063200793249296e-07 0.7161013069709498 3.063202165260769e-07 0.7181590832501857 \
3.063203364719788e-07 0.7199473375636642 3.06320455641778e-07 0.7217141075019444 3.063205825867917e-07 0.7235855504531626 3.063207073542094e-07 0.7254141264975077 \
3.063208308495973e-07 0.7272133847865295 3.063209576308702e-07 0.7290498056238117 3.063210882203554e-07 0.730930225429108 3.063212104322583e-07 0.7326797786847141 \
3.063213474902716e-07 0.7346298644824388 3.063214487056265e-07 0.7360619656663578 3.063215536745619e-07 0.7375401619041119 3.063216451659951e-07 0.7388229997694907 \
3.06321758241356e-07 0.7404001534680551 3.063218455422403e-07 0.7416107338190071 3.063219500055706e-07 0.7430512000342341 3.063220807687029e-07 0.7448411286358657 \
3.063221906822003e-07 0.7463352048609909 3.063222953419585e-07 0.7477488743938407 3.0632241917362e-07 0.7494094725133206 3.063225679269713e-07 0.751387874302702 \
3.06322689842132e-07 0.7529958494242643 3.063228036963925e-07 0.7544867042370438 3.0632294419585e-07 0.7563117925204224 3.063230855193645e-07 0.7581313010100689 \
3.063232032989716e-07 0.7596352654099263 3.063233316974594e-07 0.7612620174900669 3.06323474021161e-07 0.7630496612437514 3.063235904103157e-07 0.7644991888858087 \
3.063237361339775e-07 0.7662987831554334 3.063238579138671e-07 0.7677897310961733 3.06323976478797e-07 0.7692300520321635 3.063240990922458e-07 0.7707078417740018 \
3.063242255436292e-07 0.77221964326554 3.06324335666584e-07 0.7735261258099556 3.063244611887263e-07 0.7750039859681491 3.06324566849672e-07 0.7762386743660952 \
3.063247020268293e-07 0.7778058706872942 3.063248256373457e-07 0.7792267957652825 3.06324955634725e-07 0.7807078764205345 3.06325068606223e-07 0.7819831642610904 \
3.063251765001111e-07 0.7831908181350914 3.063253130307933e-07 0.7847046126527283 3.063254631517019e-07 0.7863508260127218 3.063256054160057e-07 0.7878933964149381 \
3.063257249975189e-07 0.7891771019825847 3.06325861808649e-07 0.7906313890246753 3.063259843124129e-07 0.7919206245676671 3.063261289843411e-07 0.7934276941869095 \
3.063262697694143e-07 0.794878360380241 3.063263965852094e-07 0.796171745508174 3.063265156326018e-07 0.7973744708066829 3.063266278955628e-07 0.7984986270115709 \
3.063267322833333e-07 0.7995352562746869 3.063268275603949e-07 0.8004739840425704 3.063269639028913e-07 0.8018044219089175 3.063270807679598e-07 0.8029326473252685 \
3.063272003644895e-07 0.8040757482679398 3.063273222502994e-07 0.8052288531124292 3.063274448385593e-07 0.8063765489401953 3.06327572579618e-07 0.8075599074701925 \
3.06327697362526e-07 0.8087035441861687 3.063278278629006e-07 0.8098867241643505 3.063279542295969e-07 0.8110199871086299 3.06328081578389e-07 0.8121498004723215 \
3.063281867911793e-07 0.8130740322933268 3.063282914951838e-07 0.8139855427426806 3.063283830253901e-07 0.8147757515715357 3.063285063983601e-07 0.8158311616195392 \
3.063285933524084e-07 0.8165684017534872 3.063286922082447e-07 0.8173999442793862 3.063288367108844e-07 0.8186029267949408 3.063289730365726e-07 0.8197243345631372 \
3.063290824450085e-07 0.8206145128367788 3.06329228461948e-07 0.821788834531623 3.063293802030074e-07 0.8229927727264784 3.063295061195854e-07 0.8239792970156907 \
3.063296505686489e-07 0.8250971468990039 3.063297752648172e-07 0.8260503472050121 3.063299258788342e-07 0.8271873005969326 3.063300612493023e-07 0.8281959289694237 \
3.063301864729373e-07 0.8291179217777711 3.063303041288969e-07 0.8299746468143927 3.063304499105104e-07 0.8310230722388168 3.063306163942599e-07 0.8322027532553667 \
3.063307472150236e-07 0.8331167337813133 3.063309206750455e-07 0.834311196379941 3.063310887878414e-07 0.8354501125721271 3.063312586689692e-07 0.8365827385393307 \
3.063314395126276e-07 0.8377685497174457 3.063315827046921e-07 0.8386931238161603 3.063316968221893e-07 0.8394210074154138 3.063318268737995e-07 0.8402408682651782 \
3.063319287535162e-07 0.8408758513273116 3.063320456411389e-07 0.841596551294542 3.063321827868591e-07 0.8424315815669623 3.063323806960722e-07 0.8436167827761205 \
3.063325725154114e-07 0.8447436440637145 3.063327818661576e-07 0.8459494874145237 3.06332964017768e-07 0.8469786287449077 3.063331611039906e-07 0.8480715276019779 \
3.063333343567189e-07 0.8490148531186206 3.063335174509634e-07 0.8499943787178993 3.063336885824299e-07 0.8508936588199895 3.063338632702719e-07 0.8517955326875627 \
3.063340385042873e-07 0.8526841769874772 3.063342146411542e-07 0.8535614892404448 3.063344050084938e-07 0.8544920815553035 3.063345955808447e-07 0.8554057038167108 \
3.063347959768378e-07 0.8563474066245403 3.063349885664635e-07 0.8572344253714166 3.06335199466375e-07 0.858185963363946 3.063354273418618e-07 0.8591913103610016 \
3.063356934247181e-07 0.8603357477151101 3.063359919268544e-07 0.8615822374427254 3.063362678163234e-07 0.8627000332972231 3.063365520834927e-07 0.8638181192989086 \
3.063368262214432e-07 0.8648650323418529 3.06337098522366e-07 0.8658754039994767 3.063373686785625e-07 0.8668495780678541 3.063376258626989e-07 0.8677515347235455 \
3.063378984216134e-07 0.8686810999091764 3.063381744693316e-07 0.8695957110915412 3.063384445895985e-07 0.8704649939918846 3.063387444494889e-07 0.8714007440816277 \
3.063391154301144e-07 0.8725171209518352 3.063394103525362e-07 0.8733732402027278 3.063396646282709e-07 0.8740897163373675 3.06339962841735e-07 0.8749052413925265 \
3.063402364113466e-07 0.8756305047096297 3.063404725347486e-07 0.8762394088953867 3.063407128598864e-07 0.8768433401198644 3.063409351938211e-07 0.8773882060838187 \
3.063411292002539e-07 0.8778530214284207 3.063414589096812e-07 0.8786208714695904 3.063416140810901e-07 0.87897283049042 3.063419317234907e-07 0.8796750328643211 \
3.063421106040349e-07 0.8800599154915705 3.063424530647979e-07 0.8807759898408113 3.063426372672098e-07 0.8811501695110489 3.063431122965131e-07 0.8820806183873429 \
3.06343279683462e-07 0.8823969901232691 3.063437454598435e-07 0.8832471741583867 3.063439262991872e-07 0.8835657112976044 3.063444203088053e-07 0.8844044135654346 \
3.063445616237109e-07 0.8846360992458032 3.063451678673266e-07 0.8855901496945974 3.063453199425258e-07 0.8858196526512701 3.06345966662599e-07 0.8867549368993356 \
3.063460949492666e-07 0.8869330782847171 3.063467431586864e-07 0.8877977435561634 3.06346872882985e-07 0.8879638504720397 3.063476413020527e-07 0.8888993076310558 \
3.063477710739033e-07 0.8890488273083775 3.063486247365088e-07 0.8899738047157748 3.063487677615613e-07 0.8901192131187072 3.06349754067048e-07 0.8910487927319016 \
3.063499755535999e-07 0.8912403904783051 3.063511183781385e-07 0.8921548233216382 3.063512482580762e-07 0.8922544308366913 3.063526007584981e-07 0.8932425879319322 \
3.063527510414313e-07 0.8933452769452155 3.063542315756977e-07 0.8942627870546499 3.063544704854918e-07 0.8943950258099049 3.063562525184327e-07 0.8952625983306248 \
3.063566382658602e-07 0.895426813549116 3.063590404240788e-07 0.8963023915260389 3.063595153600487e-07 0.8964490046842035 3.063634332871647e-07 0.8974035634625627 \
3.063639032474093e-07 0.8974927205890085 3.063722720353868e-07 0.8984807567386782 3.063724925457144e-07 0.8984960697096243 3.064170720742927e-07 0.8994905034760702 \
3.064182734601916e-07 0.8995076493514624 3.065540832686943e-07 0.9004821828323031 3.065542622454192e-07 0.9005421539807538 3.065577071203374e-07 0.8996085030263692 \
3.065578799041918e-07 0.8994755022453073 3.065592062238996e-07 0.8985168769831137 3.06559392989208e-07 0.8983970610744239 3.065611771942332e-07 0.8974304740967198 \
3.065613893245152e-07 0.8973403978332656 3.065747300202991e-07 0.8983331062395279 3.065748433081446e-07 0.8983517458922662 3.065835466612414e-07 0.8993273409280406 \
3.0658409447182e-07 0.8993637478389299 3.070766218437148e-07 0.9003542216796759 3.070767175825666e-07 0.9004233209197793 3.070776601319424e-07 0.9014023545001312 \
3.070778225852538e-07 0.9016297223302431 3.070783892915005e-07 0.9025464066367429 3.070784964622122e-07 0.9027401250447874 3.07078889770564e-07 0.9035002370985188 \
3.07079022567928e-07 0.9037710185404622 3.070794021690344e-07 0.9045728679206633 3.070795323837805e-07 0.9048512534150681 3.070799937900729e-07 0.9057878278182891 \
3.070801130371311e-07 0.9060008176934132 3.070815426461655e-07 0.9050557440230738 3.070816263162926e-07 0.9046580283931719 3.070817516221221e-07 0.9039622140338933 \
3.070818594362906e-07 0.9032622438705011 3.070819784306371e-07 0.9023800387125585 3.070820938028541e-07 0.9014106868475621 3.070821838997509e-07 0.900578017289966 \
3.070822953474549e-07 0.8994526603282017 3.070823814266029e-07 0.8985125975436928 3.070824873922515e-07 0.8972736935213672 3.070825871606176e-07 0.8960214106762436 \
3.070826681562277e-07 0.8949470092681954 3.070827778041954e-07 0.8934133399212493 3.070828633916057e-07 0.8921520042367302 3.070829555142149e-07 0.8907345325087322 \
3.07083043733598e-07 0.8893220116766375 3.070831525083507e-07 0.8875100775672261 3.070832354013856e-07 0.8860780350921965 3.070833439750574e-07 0.8841400608632336 \
3.070834362012525e-07 0.8824412727986957 3.070835208217502e-07 0.8808423775446282 3.0708360666218e-07 0.8791839877465467 3.0708368587706e-07 0.8776224824828824 \
3.070837619650304e-07 0.8760960492665846 3.070838543013988e-07 0.874210837196514 3.070839141777347e-07 0.8729702140710593 3.070839715660192e-07 0.8717685933706794 \
3.070840335611921e-07 0.8704574090763495 3.070840968400435e-07 0.8691057216070059 3.070841469113811e-07 0.8680269866686803 3.070841963535335e-07 0.8669542389500936 \
3.070842600232402e-07 0.8655623656543436 3.070843359706592e-07 0.8638877358586781 3.070843848016709e-07 0.8628032002737418 3.070844333256242e-07 0.8617197496806845 \
3.07084509037347e-07 0.8600184098866027 3.070845762461248e-07 0.8584975010852487 3.070846189526312e-07 0.8575263577286506 3.070846628552044e-07 0.8565244243916033 \
3.070847506603509e-07 0.8545103166059256 3.070848135135196e-07 0.8530605771626394 3.070848721831768e-07 0.8517018597088126 3.070849083617785e-07 0.8508614974547222 \
3.070849431802581e-07 0.8500510151036469 3.070849782062432e-07 0.8492340038666518 3.070850482582133e-07 0.8475953578585981 3.07085096728698e-07 0.8464581214772323 \
3.070851406734992e-07 0.8454248116355969 3.070851861912554e-07 0.8443523575543517 3.070852500921664e-07 0.8428433081697474 3.070853162185396e-07 0.8412777165526386 \
3.07085421348608e-07 0.8387809254526315 3.070855092832832e-07 0.8366857089760468 3.070855882285649e-07 0.834800137446173 3.070856763936023e-07 0.8326899670047023 \
3.070857632095989e-07 0.8306078985741704 3.070858511012833e-07 0.8284959280419055 3.070859423503732e-07 0.8262996967350639 3.070860451122409e-07 0.8238226494465998 \
3.070861436157165e-07 0.8214450402687625 3.070862559486315e-07 0.8187302447322098 3.070863689227678e-07 0.8159967029774419 3.070864902106627e-07 0.8130591602364435 \
3.070866207178167e-07 0.8098958628758253 3.070867497637196e-07 0.8067658935936169 3.070869032393199e-07 0.8030416153605923 3.070870685235405e-07 0.799029304640783 \
3.070872362647447e-07 0.7949567682299736 3.070874327883338e-07 0.7901857478752816 3.07087637550659e-07 0.7852160332972318 3.070878502277154e-07 0.7800563994093253 \
3.070880508476619e-07 0.7751902022758907 3.070882517063895e-07 0.7703212856706637 3.070884017284074e-07 0.766686939713112 3.070885322635739e-07 0.7635264252913375 \
3.070886666810141e-07 0.7602735436595947 3.070887728765446e-07 0.7577048602246427 3.070889061828774e-07 0.754482067181252 3.070890132158029e-07 0.7518959494812111 \
3.070891562917044e-07 0.7484409822837247 3.07089320797846e-07 0.7444713482725677 3.070894416150925e-07 0.74155777711076 3.070896127217565e-07 0.7374334100931738 \
3.070897736123089e-07 0.733558046396253 3.070899902049297e-07 0.7283457217000903 3.070901834606309e-07 0.7236999380850822 3.07090362395765e-07 0.7194029726762079 \
3.070905292123874e-07 0.7154015770462002 3.070907154183522e-07 0.7109395231330657 3.070909033515935e-07 0.7064416825495208 3.070910692736986e-07 0.7024749886985119 \
3.07091261631787e-07 0.6978803202016938 3.07091402988682e-07 0.6945068232011449 3.070915599964439e-07 0.6907636199298515 3.07091755976089e-07 0.6860965106368763 \
3.070919184101942e-07 0.6822325558671515 3.070920795863762e-07 0.6784034260021697 3.070922718945739e-07 0.6738409413562468 3.070924895564538e-07 0.6686845685784016 \
3.070927375777557e-07 0.6628199086538362 3.07092915635219e-07 0.6586162961343578 3.070931641790282e-07 0.6527567611811057 3.070933667862709e-07 0.6479896840619462 \
3.070935365969381e-07 0.6440011601507294 3.07093695213124e-07 0.6402799599229552 3.070938337435587e-07 0.637035894415233 3.070939699513215e-07 0.6338503464729111 \
3.070940962626978e-07 0.6309003762865483 3.070942257219331e-07 0.6278810604265532 3.070943540536725e-07 0.6248911458464299 3.070944853836027e-07 0.6218374290191309 \
3.070946174102147e-07 0.6187713222160208 3.070947615700952e-07 0.6154276788919771 3.070949057786871e-07 0.6120888358645944 3.070950534337911e-07 0.6086753592300279 \
3.070952004901491e-07 0.6052842859263143 3.070953583041757e-07 0.6016504852589418 3.070954909098278e-07 0.5986039825107707 3.070956223747947e-07 0.5955897059985247 \
3.070957418045935e-07 0.5928552647156846 3.070958778732863e-07 0.5897484304797134 3.070959928015483e-07 0.5871283594046445 3.070961439122689e-07 0.5836892419704927 \
3.070962585613368e-07 0.5810871834776226 3.070963764990064e-07 0.5784138884735546 3.070964662802944e-07 0.576381560286313 3.070965565996887e-07 0.5743415774978985 \
3.070966232905592e-07 0.5728373329037385 3.070966888523724e-07 0.5713590910263378 3.070967398944957e-07 0.5702089751121119 3.070968015962151e-07 0.5688198806440578 \
3.070968646860707e-07 0.5674025889664359 3.070969290444246e-07 0.5659586381304559 3.070969824382236e-07 0.5647616504486359 3.070970750808062e-07 0.5626864159088959 \
3.070971516880785e-07 0.5609719030357503 3.070972075131406e-07 0.5597256439368602 3.070972765672667e-07 0.5581857825097393 3.070973834553926e-07 0.5558054549196561 \
3.070974611990176e-07 0.5540764009223496 3.070975620491174e-07 0.5518382286767042 3.070976877299716e-07 0.5490568313009737 3.070977879716568e-07 0.5468419758621708 \
3.070978998893402e-07 0.5443739014182352 3.070980031552469e-07 0.5421024366463116 3.070981229045887e-07 0.5394737463112931 3.07098224637469e-07 0.5372436950013484 \
3.070983401572132e-07 0.5347185748314579 3.070984551922987e-07 0.5322102907975605 3.07098581673211e-07 0.529456475824718 3.070987070470086e-07 0.5267350629320526 \
3.070988538629319e-07 0.5235577714138258 3.070989894263807e-07 0.5206304261698983 3.070991471246342e-07 0.5172373565578411 3.070993094436886e-07 0.5137528589513558 \
3.070994902675847e-07 0.5098871206809381 3.070996827159054e-07 0.5057874350093188 3.070998956212086e-07 0.5012700264709963 3.071001278026081e-07 0.4963634062180514 \
3.071003850931867e-07 0.4909555076455908 3.071006247190101e-07 0.4859407514401474 3.071009264344461e-07 0.479662588092526 3.071012143537997e-07 0.4737079198104491 \
3.071015272426189e-07 0.4672821326282255 3.071018469808238e-07 0.4607585360408045 3.071021865759847e-07 0.4538766993710576 3.071025134784829e-07 0.4472977926730654 \
3.071028490368641e-07 0.4405887635920606 3.071031661327868e-07 0.4342949501181722 3.071035003705415e-07 0.4277061431972559 3.071038518016635e-07 0.4208322784122511 \
3.071041663278176e-07 0.4147233751108969 3.07104489505308e-07 0.4084912998479469 3.071049306200656e-07 0.400057814108821 3.071052727361035e-07 0.3935812134363078 \
3.071055726806328e-07 0.3879522399691127 3.071059478116385e-07 0.3809760137481454 3.071062775558777e-07 0.3749002425561211 3.071065607988036e-07 0.3697269896098562 \
3.071068609450588e-07 0.3642865787664632 3.071071405472531e-07 0.3592589179584539 3.071073643233647e-07 0.3552676761685443 3.071075761036954e-07 0.3515151294490645 \
3.071077785371594e-07 0.3479514629380864 3.071079796284271e-07 0.3444362246481504 3.071081853428453e-07 0.3408632458568372 3.071084529657171e-07 0.3362478643926977 \
3.071086918970113e-07 0.3321601360780691 3.07108925403074e-07 0.3281974319442653 3.071091388684736e-07 0.3246000376975314 3.071093602460465e-07 0.3208952602338652 \
3.071095602096931e-07 0.3175728982722026 3.071097644820061e-07 0.3142073831356898 3.071099618288778e-07 0.3109812293225088 3.071101472014048e-07 0.3079732989686547 \
3.071103433077958e-07 0.3048147723336881 3.071105455849362e-07 0.3015820927993307 3.071107212432327e-07 0.2988007390096292 3.0711090711339e-07 0.295878328903569 \
3.071111140927825e-07 0.2926488196724605 3.071112994143739e-07 0.2897857719971084 3.071114946411816e-07 0.2867989994419413 3.07111650415531e-07 0.28443329608414 \
3.071118291723129e-07 0.2817356906084737 3.071120102032329e-07 0.2790344478478936 3.071121601003467e-07 0.2768142575519123 3.071123611437744e-07 0.273859574769726 \
3.071125102589039e-07 0.2716833853889438 3.071126487983335e-07 0.2696726034832688 3.071128006734089e-07 0.2674956304896134 3.071129151475376e-07 0.2658586287383957 \
3.071130466774683e-07 0.2639823142040156 3.071131724359563e-07 0.2622048582339201 3.071132767763623e-07 0.2607341604582348 3.071133897557217e-07 0.2591418073851619 \
3.071135060842464e-07 0.2575033437579446 3.071136490116675e-07 0.2554974228347739 3.071137622731725e-07 0.2539102348881249 3.071138964299053e-07 0.2520298733123076 \
3.071140069027097e-07 0.2504818583075984 3.071141623352847e-07 0.2483006006477398 3.071143032203835e-07 0.2463217957442577 3.071144546129539e-07 0.2441928603691365 \
3.071146097750346e-07 0.2420086586735095 3.071147391842834e-07 0.2401849910837116 3.071148738963765e-07 0.2382868210192302 3.071150115942015e-07 0.2363478190565156 \
3.071151293462172e-07 0.2346905900295477 3.071152886704099e-07 0.2324499447852502 3.071154259326364e-07 0.2305210708572645 3.071155666789934e-07 0.2285488733964877 \
3.071156724701667e-07 0.2270688194984586 3.071158024115646e-07 0.2252532503786337 3.071159029480282e-07 0.2238506847401111 3.071160052817357e-07 0.2224250970611539 \
3.071160790103172e-07 0.2214012665004395 3.071161582442603e-07 0.2203047212273054 3.071162292155075e-07 0.2193236206014474 3.071162806785351e-07 0.218612902325451 \
3.071163336269882e-07 0.2178825126218075 3.071164127819908e-07 0.2167921001391954 3.071164550546259e-07 0.2162104926182252 3.071164948991708e-07 0.2156628374086678 \
3.071165381228204e-07 0.2150692779925967 3.071165790298225e-07 0.2145080585354088 3.071166491522843e-07 0.2135474129702876 3.071166828372557e-07 0.2130867492099046 \
3.071167276666377e-07 0.212477723463 3.071167865237998e-07 0.2116792343136102 3.071168513092605e-07 0.2108017053965978 3.071169087900245e-07 0.2100241135398916 \
3.071169692190328e-07 0.209207737948094 3.071170662554631e-07 0.2078991976528634 3.07117150945123e-07 0.2067595417901527 3.071172598558851e-07 0.2052972881712416 \
3.071173562566921e-07 0.2040065614180294 3.071174512733294e-07 0.2027428333585779 3.071175547051275e-07 0.2013717100485363 3.071176496344728e-07 0.2001158751783069 \
3.071177526548994e-07 0.198757993281026 3.071178577373321e-07 0.1973779917312911 3.071179670461462e-07 0.1959482000350934 3.071180774896281e-07 0.1945091075764383 \
3.071181937799036e-07 0.1929996650696684 3.071183037098964e-07 0.1915811184357085 3.071184133723204e-07 0.1901717999899754 3.071185150889654e-07 0.1888694322720079 \
3.071186080436791e-07 0.1876837490531375 3.07118700772569e-07 0.1865049219968967 3.07118774458125e-07 0.1855719169757668 3.071188572993399e-07 0.1845269810791141 \
3.071189318853365e-07 0.1835895008849975 3.071190016086783e-07 0.1827150226754214 3.071190683270854e-07 0.1818808699270075 3.071191641704113e-07 0.1806871657728035 \
3.071192468771839e-07 0.1796611249561687 3.071193404410076e-07 0.1785035608809835 3.07119435337095e-07 0.1773351434884491 3.071195467074053e-07 0.1759704596301353 \
3.071196883497589e-07 0.1742450478777388 3.071198035966122e-07 0.1728486436789435 3.071199481442513e-07 0.1711076225712051 3.071200597399285e-07 0.1697708811114609 \
3.071202009589021e-07 0.1680898955975501 3.071203166961755e-07 0.1667201145354908 3.071204226568608e-07 0.1654722325850081 3.071205214164775e-07 0.164314417410061 \
3.071206177596498e-07 0.1631901152369615 3.071207064174022e-07 0.1621596955203892 3.071208317516728e-07 0.1607099933926625 3.071209262770884e-07 0.1596224416957933 \
3.071210240160401e-07 0.1585042187118262 3.071211321109172e-07 0.1572745454417887 3.071212267786047e-07 0.1562036643369483 3.071213342264514e-07 0.1549951394274829 \
3.071214253154951e-07 0.1539767092330788 3.071215320872068e-07 0.1527896463435911 3.071216354804728e-07 0.1516469620792683 3.071217465609577e-07 0.1504267727114754 \
3.071218357869395e-07 0.1494522115900035 3.071219212668682e-07 0.1485231035185812 3.071220051920549e-07 0.1476157397758405 3.071220748986192e-07 0.1468658175993407 \
3.071221535366968e-07 0.1460232248551682 3.071222318479542e-07 0.1451880611912267 3.071223024838273e-07 0.1444378248611795 3.071223879746948e-07 0.1435337156153706 \
3.071224753636722e-07 0.1426139614481139 3.071225569511858e-07 0.1417594571206545 3.071226542701372e-07 0.1407454482154784 3.071227349596596e-07 0.139910090776864 \
3.071228257446906e-07 0.1389752404035735 3.07122947088963e-07 0.1377336220260025 3.071230361386038e-07 0.13682812281983 3.07123134655454e-07 0.1358318692385875 \
3.071232217417229e-07 0.1349560640726983 3.071233321526109e-07 0.1338550874529322 3.071234206114333e-07 0.1329791517134813 3.071235213400266e-07 0.1319874611681985 \
3.071236261295802e-07 0.1309622419763913 3.071237205198131e-07 0.1300442429014473 3.07123817024605e-07 0.1291112112475518 3.071239165112583e-07 0.1281591654439075 \
3.071240029124292e-07 0.1273384721630967 3.071240978925599e-07 0.1264411177628728 3.071242020813879e-07 0.1254629331099751 3.071243112001386e-07 0.124445178694 \
3.071244055505945e-07 0.1235704029653004 3.07124517846343e-07 0.1225411084520107 3.071246133096967e-07 0.1216733466577494 3.071247175205873e-07 0.1207311846737792 \
3.071248068659445e-07 0.1199276649878674 3.071248772532175e-07 0.1192980345746366 3.071249526392512e-07 0.1186268760051257 3.071250287714207e-07 0.1179522201461119 \
3.071250977489184e-07 0.1173458504859956 3.071251802680909e-07 0.1166263596898966 3.071252522115779e-07 0.1160015972854393 3.071253342903043e-07 0.1152916772467617 \
3.071254186247801e-07 0.1145654108773922 3.07125496418619e-07 0.113898375935255 3.071255891835211e-07 0.1131065723182637 3.071257047873425e-07 0.1121254933399327 \
3.071258106929114e-07 0.1112341778178403 3.071258883498312e-07 0.1105854195321705 3.071259766463023e-07 0.1098504899494786 3.071260567033545e-07 0.1091866403929743 \
3.071261536294793e-07 0.1083861389179563 3.07126248864964e-07 0.1076031391441806 3.071263374361587e-07 0.1068780200140514 3.071264387442599e-07 0.1060523297458165 \
3.071265442899473e-07 0.1051963702337609 3.071266534843119e-07 0.1043160928234657 3.071267616019328e-07 0.1034503663302994 3.071268815196938e-07 0.1024949450012773 \
3.071269828815214e-07 0.1016914181115986 3.071270888911509e-07 0.100855068690839 3.071272146827803e-07 0.09986840123414902 3.071273442400857e-07 0.09885896724496235 \
3.071274799154405e-07 0.09780904711780367 3.071276559873037e-07 0.09645781830037269 3.071278197878238e-07 0.09521257997344186 3.071279826125652e-07 0.09398642071914091 \
3.071280677512003e-07 0.09334985726464029 3.07128137589223e-07 0.09282999162688726 3.071282070848284e-07 0.09231474740697931 3.071282810434879e-07 0.09176875214326782 \
3.071283771983755e-07 0.09106241641841166 3.071284516137408e-07 0.09051841344162129 3.071285296033096e-07 0.08995079828656057 3.071286060521396e-07 0.08939693755534793 \
3.071286935462239e-07 0.08876614459792892 3.071287957229341e-07 0.08803382885421264 3.071288842873223e-07 0.08740269463919083 3.071289939528099e-07 0.08662585268124241 \
3.071291100092175e-07 0.08580942306245626 3.07129251558034e-07 0.0848216759818637 3.071293844270176e-07 0.08390253510334872 3.071295251873282e-07 0.08293727564630923 \
3.071296748969478e-07 0.08192024575105315 3.071298106088348e-07 0.08100683753927941 3.071299521257171e-07 0.08006309454860433 3.071300872475907e-07 0.07917070961097784 \
3.071302285200282e-07 0.07824718349428782 3.071303756129204e-07 0.07729532867436953 3.07130527122786e-07 0.07632524417621221 3.071306924984999e-07 0.07527819040792309 \
3.071308562596902e-07 0.07425356708383206 3.071310323896319e-07 0.07316505371836476 3.071312215286099e-07 0.07201151367936541 3.071314322022337e-07 0.07074528708793332 \
3.071316517688556e-07 0.06944624562626683 3.071318865352622e-07 0.06808094281860989 3.071321449277003e-07 0.06660616301228137 3.071324395923605e-07 0.06496103773121734 \
3.071327436716829e-07 0.06330286177969326 3.071331045821629e-07 0.06138472526627536 3.071334404990352e-07 0.05964719353945821 3.071338806764061e-07 0.05743991201668189 \
3.071342590438092e-07 0.05560437501227136 3.071347015027716e-07 0.05352996728430704 3.071350555229165e-07 0.05192508193542229 3.071354420396718e-07 0.05022502935509546 \
3.07135786643729e-07 0.04875485597254389 3.071361086186649e-07 0.04741934964807833 3.07136412152492e-07 0.04619304551845941 3.071367070734883e-07 0.04503122626702559 \
3.071369895557667e-07 0.04394770877170886 3.071372666361775e-07 0.04291147062934708 3.071375323636684e-07 0.04194013461971725 3.071378035943552e-07 0.0409708748276704 \
3.071380798533722e-07 0.04000619535229137 3.071383697525942e-07 0.03901828782233653 3.071385981289875e-07 0.03825741181922668 3.071389030130544e-07 0.03726495139513845 \
3.071391196849105e-07 0.03657573971894532 3.071393110416374e-07 0.03597943984071691 3.071395096361558e-07 0.03537298232318693 3.071398395514967e-07 0.03438820140908775 \
3.071400814971701e-07 0.03368375433354889 3.071403968092223e-07 0.03278771666975258 3.071406669292072e-07 0.03203957074185158 3.071409233008807e-07 0.03134567005659093 \
3.071412033128806e-07 0.03060515313352298 3.071414489686567e-07 0.02997014710356035 3.071416817043018e-07 0.02938120249260199 3.07141924434299e-07 0.02878348292867495 \
3.071421611615635e-07 0.02821317433052753 3.071423898079744e-07 0.0276732289298247 3.071428070936345e-07 0.02671456010533928 3.071430022743284e-07 0.02627749693639509 \
3.071433834414109e-07 0.02544369227895442 3.071435606942329e-07 0.02506446942885681 3.071439031456878e-07 0.02434654114125227 3.071440564141201e-07 0.02403127656358269 \
3.071444314325841e-07 0.02327616399748992 3.071445690667252e-07 0.02300530455388665 3.071450533333593e-07 0.02207084195640928 3.071451729527604e-07 0.02184403312078184 \
3.071455899915636e-07 0.02106026682208277 3.07145733393791e-07 0.02079332360769017 3.071462546051726e-07 0.01984598817089831 3.071463823790427e-07 0.0196205814374062 \
3.071469667914167e-07 0.01863359713481367 3.071471392268229e-07 0.01835589372257288 3.071477433235728e-07 0.01743644241612937 3.071479047552142e-07 0.01720262545858322 \
3.071485447014338e-07 0.01631831686205014 3.071487230176005e-07 0.016083210242981 3.071493710016487e-07 0.01526127675881721 3.071495362552397e-07 0.01505930898173208 \
3.071502725571753e-07 0.01419381259610907 3.071504068332255e-07 0.01404154276213586 3.071512039327433e-07 0.01317592498067951 3.071513445303545e-07 0.01302934089458718 \
3.071523098735771e-07 0.0120661300044765 3.071524742123827e-07 0.01190857475316222 3.071534749435119e-07 0.01099048917119646 3.07153612213369e-07 0.01087009009405628 \
3.071547509078863e-07 0.009949273443646761 3.071548650857872e-07 0.009863136028526375 3.071562457306217e-07 0.008889755784408603 3.071564000878327e-07 0.00878832203975914 \
3.071579465820612e-07 0.00781340401000951 3.071580309437644e-07 0.007760176032106158 3.071597163710821e-07 0.006770348169342283 3.071598398995725e-07 0.00670487246831437 \
3.071618897141387e-07 0.005720970231232756 3.071620861142965e-07 0.005634691917282852 3.071644047936537e-07 0.004698942116576918 3.071648654079885e-07 0.004530544077955615 \
3.071676055035305e-07 0.003639937533647344 3.071681236485673e-07 0.00349159181499799 3.071722742898753e-07 0.002502201117031859 3.071728121398825e-07 0.002396807933581942 \
3.0717889437533e-07 0.001421603691354927 3.071791533557405e-07 0.001378272220758726 3.071844761190904e-07 0.0003814093765652445 3.071845892761344e-07 0.0003711807182531981 \
3.098307063923701e-07 -0.0004615907568095335 3.098308688313385e-07 -0.0006852153244161934 3.098313698328069e-07 -0.001554404032531494 3.098314540153697e-07 -0.001725199767551738 \
3.098318555381938e-07 -0.002626792336557519 3.098319448731607e-07 -0.002845673237760077 3.098322314649697e-07 -0.0035898660494722 3.098323590334993e-07 -0.003937855927128601 \
3.098326777451613e-07 -0.004830400105952924 3.098327919463135e-07 -0.00515011308870196 3.098330743466382e-07 -0.005887653497963378 3.098332045728569e-07 -0.006177415671381139 \
3.098341829257541e-07 -0.005220113099403402 3.098343702332871e-07 -0.004004368716724641 3.098345016776888e-07 -0.002901539130564616 3.098346071052425e-07 -0.001869327786897239 \
3.098346928227261e-07 -0.0009323217369615201 3.098347747492128e-07 4.151965372454519e-05 3.098348957860361e-07 0.001618129410352471 3.098349947146829e-07 0.003024565667809575 \
3.098351531113568e-07 0.005482561958548801 3.098353705585867e-07 0.00923691162542661 3.098355517808096e-07 0.0126653356758144 3.098357638749061e-07 0.01697021734206094 \
3.098359268985627e-07 0.02046388365739064 3.098360875209785e-07 0.02403759527126768 3.09836241061221e-07 0.02755862871109176 3.098363891179022e-07 0.031036270750196 \
3.098365381988111e-07 0.03460722192241437 3.098366927287225e-07 0.03837091703902212 3.098368533795379e-07 0.04234026030123839 3.098370180342186e-07 0.04645786783841532 \
3.098371945751169e-07 0.05091770581196236 3.098373735379688e-07 0.05547793877747508 3.098375642811338e-07 0.0603721650098247 3.09837769062163e-07 0.06565647483694508 \
3.098379895344492e-07 0.07137203566208646 3.098382223941741e-07 0.0774299331224613 3.098384715816505e-07 0.08392829098722057 3.098387444237776e-07 0.09105513637423955 \
3.098390411275777e-07 0.09880974921055499 3.098393684539683e-07 0.1073623706929605 3.098397381053549e-07 0.11701033799881 3.09840132977169e-07 0.1273002725707723 \
3.098405908154097e-07 0.1392030195235975 3.098411226222497e-07 0.1529832553757746 3.09841747860046e-07 0.1691182447448397 3.098424336075175e-07 0.1867241161332086 \
3.098432360033912e-07 0.2071957342970069 3.09844134802183e-07 0.2299563735557614 3.098449404156324e-07 0.2501946571168963 3.098456541669658e-07 0.2679877251922811 \
3.098462837288478e-07 0.2835633151515627 3.098468540922982e-07 0.2975737963344939 3.098473850476804e-07 0.3105173405876944 3.098478868351306e-07 0.3226580892822354 \
3.098483661296844e-07 0.3341673054699896 3.098488316851033e-07 0.3452566901045974 3.098492954815109e-07 0.3562094254686541 3.098497512295407e-07 0.3668794056881832 \
3.098502114496752e-07 0.3775613305945491 3.098507497336462e-07 0.3899285626759094 3.098512505841796e-07 0.4013172511919189 3.098516508068632e-07 0.4103337945930838 \
3.098521576676441e-07 0.421642452039157 3.098526436338564e-07 0.4323669409017459 3.098530431485677e-07 0.4410997362599856 3.098534537606271e-07 0.4500002277813482 \
3.098538826870602e-07 0.4592207708982954 3.098542842014423e-07 0.4677760623951868 3.098545915918887e-07 0.4742753916877908 3.098549418336473e-07 0.4816249679276425 \
3.098552950738506e-07 0.4889795533930016 3.0985554824443e-07 0.4942125642332652 3.098557811883199e-07 0.4989990073547648 3.098560228316108e-07 0.5039392821429431 \
3.098562478222295e-07 0.5085102868389438 3.098564398583375e-07 0.5123881070394828 3.098566246700343e-07 0.5161059569497825 3.098568469603498e-07 0.5205538992744256 \
3.098570136717574e-07 0.5238726938135662 3.098572308883525e-07 0.5281726418673847 3.098574339672442e-07 0.5321820613122353 3.098576113786994e-07 0.5356681922482178 \
3.098577994510863e-07 0.5393528234657015 3.098580354832656e-07 0.5439555888699217 3.098583013652896e-07 0.5491186112539347 3.098585231271783e-07 0.5534070305875756 \
3.098588031850331e-07 0.5588091140818973 3.098590461848179e-07 0.5634839438879177 3.09859321538161e-07 0.5687575845994758 3.098595665335016e-07 0.5734440561015828 \
3.098598068277205e-07 0.5780305526007354 3.098600478670234e-07 0.5826153106864888 3.09860305457841e-07 0.5874946531182738 3.098605408246178e-07 0.5919209497705462 \
3.09860772126727e-07 0.5962518282209535 3.098609946534482e-07 0.6003950532231523 3.098612030130559e-07 0.6042587207462122 3.098614408548706e-07 0.6086392006348278 \
3.098616517150854e-07 0.612499186772883 3.09861907322267e-07 0.617151767543529 3.098621060500327e-07 0.620751700070918 3.098623816826772e-07 0.6257066023742009 \
3.098626044387981e-07 0.6296824120643636 3.098628978099216e-07 0.6348814180513288 3.098631305799232e-07 0.6389753720667986 3.098633507813092e-07 0.6428252659334456 \
3.098635520519211e-07 0.6463216644290061 3.098637693407936e-07 0.6500784077528632 3.098639440567036e-07 0.6530842133917786 3.098641303213334e-07 0.6562672470877895 \
3.098643090603859e-07 0.6593113758161715 3.098644717643993e-07 0.6620700940033843 3.098646370334099e-07 0.6648583661366954 3.098647803012238e-07 0.6672607123132118 \
3.09864919531648e-07 0.669583864918244 3.098650593322146e-07 0.6719085596965743 3.098651941074223e-07 0.6741424479378803 3.098653216016633e-07 0.6762463034350935 \
3.098654545557747e-07 0.6784344250006583 3.098655761601249e-07 0.680430207161383 3.098657045733663e-07 0.6825336955632141 3.098658203404209e-07 0.6844241240890321 \
3.098659183815937e-07 0.686020684362688 3.098660190776997e-07 0.687656981754083 3.098661288314626e-07 0.689434454762776 3.098662455994179e-07 0.6913211166705923 \
3.098663368261916e-07 0.6927889453402305 3.098664460316049e-07 0.6945396927028351 3.098665471403262e-07 0.6961566646470493 3.098666425406182e-07 0.6976767415743361 \
3.098667520226426e-07 0.6994136821864276 3.098668864742773e-07 0.7015344809028976 3.098670354932137e-07 0.7038694457768003 3.098671644232324e-07 0.7058755144243859 \
3.09867311083691e-07 0.7081418729260142 3.098674378680718e-07 0.7100885084081828 3.098675624659611e-07 0.7119899232102255 3.098676743197281e-07 0.7136874821928206 \
3.098677872756922e-07 0.7153928249203609 3.098678878290893e-07 0.716903336497302 3.098680251105924e-07 0.7189542886859326 3.098681449794518e-07 0.7207346491296758 \
3.09868264162204e-07 0.7224952472954583 3.098683911643136e-07 0.7243608783177121 3.098685157126648e-07 0.726179956024653 3.098686393836757e-07 0.7279757435764195 \
3.09868765971953e-07 0.7298035010246171 3.098688965411881e-07 0.7316777339938921 3.098690190562223e-07 0.7334262671520465 3.098691552997129e-07 0.7353588786631546 \
3.098692567424861e-07 0.7367901064855561 3.09869362765969e-07 0.7382789144707947 3.098694532971524e-07 0.7395446819117977 3.098695671233782e-07 0.7411267287627761 \
3.098696547849604e-07 0.742338113895605 3.098697606802377e-07 0.7437932991468792 3.098698910335325e-07 0.7455718205320391 3.098700016011403e-07 0.7470699275523445 \
3.098701062716115e-07 0.7484790865773925 3.09870230233143e-07 0.7501360792234356 3.09870378790597e-07 0.752105598322839 3.098705004731933e-07 0.7537054667443914 \
3.098706145848825e-07 0.7551949470168074 3.098707550054835e-07 0.7570132059451244 3.098708965335436e-07 0.7588296197226846 3.098710143228134e-07 0.7603289862386273 \
3.098711425226351e-07 0.7619481626911874 3.098712845904683e-07 0.7637269294216019 3.098714014655762e-07 0.7651780119234867 3.098715471393621e-07 0.7669714049983392 \
3.098716688778096e-07 0.7684572223066155 3.098717875183015e-07 0.7698939375992205 3.098719099845946e-07 0.7713653733660819 3.098720367016846e-07 0.7728756341192486 \
3.098721466036788e-07 0.7741754302862822 3.098722722190223e-07 0.7756497674172792 3.098723780294307e-07 0.7768823528242577 3.098725141995534e-07 0.7784559787239111 \
3.098726385466015e-07 0.7798807766277074 3.098727659718769e-07 0.7813271999647126 3.098728805279564e-07 0.7826155184370988 3.098729872082259e-07 0.7838050786084815 \
3.098731251508229e-07 0.785328674235108 3.098732746003193e-07 0.7869612315653352 3.098734194525364e-07 0.7885256944569791 3.098735388882871e-07 0.7898026796320731 \
3.0987367431316e-07 0.7912364721526877 3.09873795807481e-07 0.7925100718437531 3.098739391665555e-07 0.7939977458315933 3.09874082600237e-07 0.7954699260458764 \
3.098742084112467e-07 0.7967479640295563 3.098743274579285e-07 0.7979459892863545 3.098744394715731e-07 0.7990632136113104 3.098745442634543e-07 0.8000996927221937 \
3.098746394563032e-07 0.8010335634530776 3.098747758668286e-07 0.8023587211299719 3.098748926790049e-07 0.8034813603122919 3.098750121402484e-07 0.8046180202255495 \
3.098751341806002e-07 0.8057672874017472 3.098752570806969e-07 0.8069126780167393 3.098753842000533e-07 0.8080849010520604 3.098755093419151e-07 0.8092265787736463 \
3.098756398931422e-07 0.8104047139317369 3.09875765969389e-07 0.811530109085512 3.098758939660489e-07 0.8126603425876329 3.098759994272971e-07 0.8135823118114501 \
3.098761026965977e-07 0.814477091043954 3.098761953499458e-07 0.8152732203909091 3.098763190441811e-07 0.8163262937528154 3.098764066640956e-07 0.8170655553659417 \
3.098765053301514e-07 0.8178914289762149 3.098766488771539e-07 0.819080619224994 3.098767844633066e-07 0.8201904093102529 3.098768936532881e-07 0.8210742465492874 \
3.098770411027471e-07 0.8222539401850584 3.09877191506449e-07 0.8234410273756358 3.098773169754118e-07 0.8244188977545531 3.098774611413952e-07 0.8255287290252299 \
3.098775854299599e-07 0.8264738611628292 3.098777359002563e-07 0.8276038147969816 3.098778715066145e-07 0.8286089145501508 3.09877996601616e-07 0.8295251220930787 \
3.098781143174533e-07 0.8303776282987162 3.098782602030521e-07 0.8314210189912619 3.098784266961482e-07 0.8325942517713072 3.098785575628508e-07 0.833503494447128 \
3.098787310074617e-07 0.8346911703335461 3.098788991402022e-07 0.8358239212093587 3.098790689939496e-07 0.8369500705213252 3.098792498869552e-07 0.838129582835239 \
3.098793930212163e-07 0.8390486258646698 3.098795071191619e-07 0.8397723391454259 3.098796372463218e-07 0.8405879656882547 3.098797391021787e-07 0.8412191375388212 \
3.098798559475988e-07 0.8419354178465567 3.098799929193963e-07 0.84276453896487 3.098801907591422e-07 0.843942473808897 3.098803824446297e-07 0.8450620046306492 \
3.09880591850993e-07 0.8462610422160779 3.098807738618767e-07 0.8472832413425977 3.098809709773334e-07 0.8483697584184032 3.098811442904469e-07 0.8493077402131245 \
3.098813273256562e-07 0.8502809338042043 3.098814984787832e-07 0.8511747489972419 3.098816731317363e-07 0.8520708361396651 3.098818483828913e-07 0.8529540285731302 \
3.098820245303913e-07 0.8538259128238825 3.098822148367787e-07 0.8547503816925358 3.098824054277479e-07 0.8556583881771193 3.098826059797908e-07 0.8565949481971697 \
3.098827985825885e-07 0.8574764650234362 3.098830093312883e-07 0.8584213553684483 3.098832373621857e-07 0.8594210644592908 3.098835032419522e-07 0.8605573106989262 \
3.098838018200941e-07 0.8617960322792503 3.098840779837292e-07 0.8629075153790151 3.098843622302292e-07 0.8640180616030438 3.098846364142308e-07 0.8650581816846495 \
3.098849086694401e-07 0.8660616517296992 3.098851788589146e-07 0.8670295451208139 3.098854360232381e-07 0.8679256252637404 3.098857085969722e-07 0.8688492356117473 \
3.098859846024351e-07 0.8697577927663542 3.09886254710518e-07 0.8706213441784563 3.098865545689379e-07 0.8715508809746347 3.098869255828164e-07 0.8726599440782473 \
3.098872205155291e-07 0.873510245983525 3.098874748008955e-07 0.8742218447789023 3.098877730441708e-07 0.8750318897722944 3.098880466409288e-07 0.8757523113099853 \
3.098882827679075e-07 0.8763571312809064 3.098885231072055e-07 0.876957042728428 3.098887454408612e-07 0.8774982514557473 3.098889394467937e-07 0.8779599514934209 \
3.098892691652286e-07 0.8787226653583874 3.098894243380191e-07 0.8790722725343518 3.098897420714095e-07 0.8797700114458387 3.098899209390604e-07 0.880152324917399 \
3.09890263400534e-07 0.8808637455080008 3.098904475523683e-07 0.8812353200296749 3.098909224784184e-07 0.8821594045029107 3.098910898716537e-07 0.8824737723885729 \
3.098915556929605e-07 0.8833186808430151 3.098917365204472e-07 0.883635209600208 3.098922305497857e-07 0.8844687288968743 3.098923718877729e-07 0.8846990198924604 \
3.098929782491027e-07 0.8856473543416146 3.098931303209552e-07 0.8858754372639542 3.098937770089477e-07 0.8868048391838264 3.098939053031091e-07 0.8869818633102416 \
3.098945534965822e-07 0.8878410756373726 3.098946832451334e-07 0.8880061989117775 3.09895451498601e-07 0.8889361126992519 3.098955812406254e-07 0.8890847997417872 \
3.098964346975575e-07 0.8900046759307325 3.098965779246734e-07 0.8901495209380393 3.098975641580769e-07 0.8910738355210844 3.09897785636141e-07 0.8912643084423501 \
3.098989286536885e-07 0.8921737958641509 3.098990586319894e-07 0.8922730011388891 3.099004103389882e-07 0.8932565980587214 3.099005606923423e-07 0.8933589605607284 \
3.09902041315768e-07 0.8942730372387374 3.0990228021907e-07 0.8944047337041336 3.099040613442277e-07 0.8952702388217941 3.099044473255946e-07 0.8954343910560414 \
3.099068488716345e-07 0.896309305076933 3.099073238084202e-07 0.8964562995603377 3.099111419701395e-07 0.8973944547681553 3.099116244593365e-07 0.897487269196476 \
3.099195104748494e-07 0.898471373493449 3.099201266375397e-07 0.8985180228791175 3.100152826123789e-07 0.899508178894561 3.100167732145567e-07 0.8995204306067698 \
3.101280612887407e-07 0.9005118233983579 3.101282376257435e-07 0.9005706457326812 3.10131860757067e-07 0.8996048713171836 3.101320419550936e-07 0.8994654179496379 \
3.101333530765704e-07 0.8985275682722235 3.101335349539762e-07 0.8984123497545736 3.101353579441702e-07 0.8974436520388238 3.101355178574244e-07 0.8973766233009967 \
3.101486686887231e-07 0.8983720910457982 3.101487796702765e-07 0.8983905835035384 3.101576012543832e-07 0.8993863063850064 3.101581480238467e-07 0.8994226481040219 \
3.106507199766805e-07 0.9003987622903815 3.106507897691656e-07 0.9004496773542636 3.106516224219291e-07 0.9012853800543292 3.106517484680941e-07 0.9014513953152168 \
3.106523289889575e-07 0.9023435091985418 3.106524699532118e-07 0.9025895326188698 3.106528690912908e-07 0.9033428289365844 3.106530192408316e-07 0.9036449200440446 \
3.106534623221535e-07 0.9045762589490434 3.106536194942562e-07 0.9049121924877023 3.106540651209874e-07 0.9058152254958243 3.106541635773263e-07 0.9059929146639856 \
3.106555802587204e-07 0.9052304871087643 3.10655711415865e-07 0.904616184869324 3.106558804230411e-07 0.9036290332250884 3.106560457149166e-07 0.9024406226812831 \
3.106561519806978e-07 0.9015554774641358 3.106562554175281e-07 0.9006052096506509 3.106563411842469e-07 0.8997486040545581 3.106564306782332e-07 0.8987887485205278 \
3.106565549226324e-07 0.8973492764100613 3.106566730035805e-07 0.8958624931586439 3.106567602196721e-07 0.8946938835082598 3.106568845267161e-07 0.8929289312882503 \
3.106569915106439e-07 0.8913158670103165 3.106570913423478e-07 0.8897378501708729 3.106572176331742e-07 0.8876466417139378 3.106573858217853e-07 0.884705368138502 \
3.106575415215381e-07 0.8818365157686672 3.106577381263672e-07 0.8780362649814708 3.106579217476167e-07 0.8743271923380105 3.106581332550105e-07 0.8698916163736473 \
3.106583140648106e-07 0.8659808238081558 3.106584986458582e-07 0.8618945354625286 3.106586716498537e-07 0.8579913311618118 3.106588570505038e-07 0.8537436868396935 \
3.106590361336512e-07 0.8495884889292737 3.106592197227131e-07 0.8452850234109005 3.106593864844183e-07 0.8413449312544377 3.10659554574996e-07 0.8373487193315756 \
3.10659717684167e-07 0.8334514816705533 3.106598728704027e-07 0.829729402178684 3.10660045969282e-07 0.8255639501984255 3.106602319597377e-07 0.8210763864673301 \
3.106603965802216e-07 0.8170961425007568 3.106605614501323e-07 0.8131038678717658 3.106607367821645e-07 0.8088537582860886 3.106609012086681e-07 0.8048648186953292 \
3.106610698442787e-07 0.8007719922541914 3.106612606476452e-07 0.7961398815555145 3.106614461718184e-07 0.7916360074082958 3.106616551006281e-07 0.7865651471012967 \
3.10661879917618e-07 0.7811107659751856 3.106620697327054e-07 0.77650678233121 3.106622715901883e-07 0.7716133355283564 3.106624158608269e-07 0.76811790639139 \
3.106625575043926e-07 0.7646880872338248 3.106626852021022e-07 0.7615975116975136 3.106627962479435e-07 0.7589113686396982 3.106629248105796e-07 0.7558028559024855 \
3.10663057376087e-07 0.7525995467138866 3.106631706977832e-07 0.7498629233610832 3.106633070324095e-07 0.7465723252212872 3.106634134316607e-07 0.7440058350410135 \
3.106635726504468e-07 0.7401674766516904 3.106637450281421e-07 0.7360137588823189 3.10663907275386e-07 0.7321074183421575 3.106640796243437e-07 0.7279612819449855 \
3.106642390105271e-07 0.7241302920521341 3.106644468157139e-07 0.7191408067115369 3.106646073553789e-07 0.7152908836069264 3.106647998447152e-07 0.7106793324906435 \
3.10664985361064e-07 0.7062404417184839 3.106651552371093e-07 0.7021802791355866 3.106653471069473e-07 0.6975984806629684 3.106654933309623e-07 0.6941099299715526 \
3.106656536173094e-07 0.6902897983225644 3.10665856006145e-07 0.6854719661536142 3.10666037294609e-07 0.681161582477689 3.106662061160357e-07 0.6771536053116509 \
3.106663919619109e-07 0.6727470762459599 3.106665978927512e-07 0.6678715161770782 3.10666765819558e-07 0.6639016226084196 3.106669260812615e-07 0.6601182542089066 \
3.106671649337354e-07 0.65448589698252 3.106673326948486e-07 0.6505369020837752 3.106675137682881e-07 0.6462813620835641 3.106676749231988e-07 0.642499550819208 \
3.106678211904597e-07 0.6390715923276049 3.106679598785689e-07 0.6358268652274862 3.106680892356149e-07 0.6328040340451749 3.106682186201702e-07 0.6297855584526113 \
3.106683469414899e-07 0.6267952385336898 3.106684771436295e-07 0.6237652412672913 3.106686061600736e-07 0.6207683673242944 3.106687447356331e-07 0.6175525629501428 \
3.106688928112201e-07 0.6141227553162802 3.106690791385052e-07 0.60981438109949 3.106692268222044e-07 0.6064079319686639 3.106694619864099e-07 0.600995965122186 \
3.106696544341406e-07 0.5965821560879089 3.106698950039548e-07 0.5910808370261941 3.106700640513256e-07 0.587228367631822 3.106702017177501e-07 0.5840969866928536 \
3.106703298227265e-07 0.581191110277254 3.10670443409422e-07 0.5786182870235701 3.106705347742257e-07 0.5765512826027382 3.106706241961132e-07 0.5745328691003393 \
3.106706914578463e-07 0.573016830490748 3.106707574780489e-07 0.5715297341779608 3.106708095317241e-07 0.5703577032508095 3.106708737705932e-07 0.5689124506700958 \
3.106709353071159e-07 0.5675311492520995 3.106709995886598e-07 0.5660899724818867 3.106710527797555e-07 0.5648985048860162 3.106711451255398e-07 0.5628316153148989 \
3.106712217014409e-07 0.5611191615154557 3.106712775450911e-07 0.5598732849310241 3.106713468881998e-07 0.5583285932816697 3.106714527394756e-07 0.5559733466166974 \
3.1067153043128e-07 0.5542469170533902 3.106716310298676e-07 0.5520159549745236 3.106717590630782e-07 0.5491849411292137 3.106718585604598e-07 0.5469885705929382 \
3.106719711258113e-07 0.544508366501287 3.106720741701315e-07 0.5422442603473754 3.106721942190172e-07 0.5396115972585003 3.106722958334261e-07 0.5373863339265779 \
3.10672411457693e-07 0.5348611538529422 3.106725265738742e-07 0.5323536236546169 3.106726530109181e-07 0.529604142030661 3.106727785251858e-07 0.5268822104345234 \
3.106729252048618e-07 0.5237112381511962 3.106730608755698e-07 0.5207845659358002 3.106732186414087e-07 0.5173942078023266 3.106733810633495e-07 0.5139116507621072 \
3.106735619718178e-07 0.5100482739823553 3.106737545639722e-07 0.5059503908118104 3.106739675557428e-07 0.5014368974673542 3.106741999884595e-07 0.4965308659362653 \
3.106744575093732e-07 0.49112491222925 3.106746974735513e-07 0.4861095397820235 3.106749986779057e-07 0.4798501326413723 3.106752869755342e-07 0.4738957353990632 \
3.106756000618611e-07 0.4674739717793394 3.106759195881407e-07 0.4609631488871989 3.106762590854062e-07 0.4540919149088484 3.106765852755184e-07 0.4475353831519197 \
3.106769217567802e-07 0.4408159131180407 3.106772384675873e-07 0.4345373385230166 3.106775725526604e-07 0.4279587671099637 3.106779242615287e-07 0.4210864038135054 \
3.106782387463783e-07 0.4149846225409808 3.106785621928357e-07 0.4087533091618546 3.106790031209485e-07 0.400331870031168 3.106793449160247e-07 0.3938679283557566 \
3.106796443500686e-07 0.3882534014213259 3.10680018872672e-07 0.3812944595528024 3.106803482503896e-07 0.375233915169682 3.10680631354694e-07 0.3700684563936956 \
3.106809310997049e-07 0.3646408765157301 3.106812105955488e-07 0.3596219010422631 3.10681434267487e-07 0.3556377385586224 3.106816459791946e-07 0.3518907610576284 \
3.106818484819268e-07 0.3483292724130969 3.10682049543475e-07 0.3448190020587957 3.106822552213837e-07 0.3412518188287665 3.106824735968598e-07 0.3374887625241871 \
3.106827173592566e-07 0.3333167726275162 3.106829441158294e-07 0.3294678078423895 3.106831640268007e-07 0.3257615367192951 3.106833824514083e-07 0.3221060038181086 \
3.106835864764178e-07 0.318715141566024 3.106837883342076e-07 0.3153870758963987 3.106839886575955e-07 0.3121102802474151 3.106841752715021e-07 0.309079115007194 \
3.106843725731086e-07 0.3058982938882217 3.10684581156335e-07 0.3025606704206737 3.106847867910569e-07 0.2992974534031506 3.106850115231368e-07 0.2957609785165763 \
3.106852284189794e-07 0.2923771984023277 3.106854360983307e-07 0.2891642611511841 3.106856671491776e-07 0.2856239464683982 3.10685841949429e-07 0.2829684481899911 \
3.10686021147604e-07 0.2802647299798244 3.106861900221201e-07 0.2777348429135014 3.106864183453934e-07 0.274348458173166 3.106865950826614e-07 0.2717528218126659 \
3.106867633653918e-07 0.2693020894036587 3.106869358321621e-07 0.2668230333489093 3.106870699344411e-07 0.264903804409765 3.10687215894446e-07 0.2628277003548514 \
3.106873545899465e-07 0.2608803500812688 3.106874768715512e-07 0.2591684246570544 3.106876109903814e-07 0.2572942758553639 3.106877400914859e-07 0.2554978336754472 \
3.106878595252204e-07 0.2538430842138498 3.106879863604196e-07 0.2520939183506197 3.106881060014414e-07 0.2504447954274527 3.106882556176353e-07 0.2483797066042054 \
3.106883904811462e-07 0.2465170278296022 3.106885200385602e-07 0.2447289494531232 3.10688677103379e-07 0.2425624627506451 3.106888010990138e-07 0.2408491463446025 \
3.106889412471492e-07 0.2389135279283614 3.106890711400503e-07 0.2371200701944942 3.106891917576705e-07 0.2354534357320198 3.106893542306008e-07 0.2332087289724075 \
3.106895002846996e-07 0.2311905595759856 3.106896386054839e-07 0.2292825126447264 3.106897465327019e-07 0.2277949627009887 3.106898773176093e-07 0.225993474229161 \
3.106899758236256e-07 0.22463752857886 3.106900799069717e-07 0.2232056532573264 3.106901527838364e-07 0.2222046546567725 3.10690234937313e-07 0.2210804129356655 \
3.10690302346398e-07 0.2201585377209549 3.106903490506606e-07 0.2195201149856669 3.106903984680203e-07 0.2188449488487562 3.10690489422163e-07 0.2176035744446363 \
3.106905558165761e-07 0.2166983392055156 3.106906027798693e-07 0.2160586379972232 3.106906530910749e-07 0.2153737902794619 3.106907122404248e-07 0.2145693142997165 \
3.106907550863284e-07 0.2139870779821451 3.10690798893629e-07 0.2133941263688522 3.106908684238941e-07 0.2124566309962414 3.106909553407082e-07 0.2112864027023158 \
3.106910365295633e-07 0.2101949018929156 3.106911224290264e-07 0.2090416531541652 3.106912165752074e-07 0.2077796428137634 3.106913083290811e-07 0.2065517647617813 \
3.106914036255171e-07 0.2052788208685862 3.106915001042083e-07 0.2039945431316728 3.106916009294901e-07 0.2026602783061639 3.106916968855022e-07 0.2013924147365721 \
3.10691799571213e-07 0.2000377255165624 3.106919026075665e-07 0.1986831378210229 3.10692012697906e-07 0.1972405340748948 3.106921214497938e-07 0.1958206085628783 \
3.106922411717489e-07 0.1942631948714586 3.106923516146512e-07 0.1928328887741874 3.106924596174588e-07 0.1914411844406488 3.10692584973803e-07 0.1898318066870429 \
3.106926779079788e-07 0.1886434908940876 3.106927562787551e-07 0.1876443873000938 3.10692832918829e-07 0.1866698667869858 3.106929154301432e-07 0.1856249297118943 \
3.106929849397592e-07 0.1847473639743596 3.106930508953873e-07 0.1839166514106665 3.106931151627221e-07 0.1831089953192083 3.106932271462069e-07 0.1817072258029639 \
3.106933212001737e-07 0.1805353135896268 3.106934288419354e-07 0.1791985758407087 3.106935353149934e-07 0.1778827552324552 3.106936553069199e-07 0.1764073736674057 \
3.106937933595456e-07 0.174720142305475 3.106939095201005e-07 0.1733081217455876 3.106940716169029e-07 0.1713503924599185 3.106941867054196e-07 0.1699688234017716 \
3.106943266910192e-07 0.1682987764548305 3.106944438970947e-07 0.1669083002780509 3.106945548164474e-07 0.1655990025649634 3.106946524449328e-07 0.1644521190704843 \
3.106947472954813e-07 0.1633427224865242 3.106948633498935e-07 0.161991523106341 3.106949548984438e-07 0.1609305136382055 3.106950510074198e-07 0.1598214181625073 \
3.106951452255534e-07 0.1587403933520305 3.106952387261563e-07 0.1576732160104884 3.106953323234783e-07 0.1566104070550305 3.106954280050165e-07 0.1555300824433628 \
3.106955185929212e-07 0.1545132165873678 3.106956096060781e-07 0.1534969984004868 3.106957051545556e-07 0.1524358767948732 3.106957958202681e-07 0.1514342506187442 \
3.106958988926308e-07 0.1503020548964867 3.106959713440797e-07 0.1495100717445464 3.106960504448726e-07 0.148649146151682 3.106961249930915e-07 0.1478424742503694 \
3.106961960245005e-07 0.1470770917224498 3.106962687889816e-07 0.1462962409077327 3.106963434061567e-07 0.1454990959398698 3.106964133891184e-07 0.1447543557055888 \
3.106964875500381e-07 0.143968261688537 3.106965412953772e-07 0.1434005634796054 3.106965945789319e-07 0.1428396203849428 3.106966597746903e-07 0.1421555039833398 \
3.106967310807313e-07 0.141411576573238 3.106967954507931e-07 0.1407432786314442 3.106968688027537e-07 0.1399847409254479 3.106969294203207e-07 0.1393607073002494 \
3.106970154538046e-07 0.1384787080092832 3.106970914048206e-07 0.1377037134581418 3.106971813727262e-07 0.1367902106004182 3.106972630996836e-07 0.1359645165492482 \
3.106973457896615e-07 0.1351360437760365 3.106974283459693e-07 0.1343145513298757 3.106975339081247e-07 0.1332698421778018 3.106976157754082e-07 0.1324642397250402 \
3.106977131428679e-07 0.1315110876582503 3.106978031437286e-07 0.130634908321232 3.106978911139876e-07 0.1297829978838479 3.106979740438426e-07 0.1289892226181523 \
3.106980482809344e-07 0.1282822873521282 3.106981479319927e-07 0.1273377645104763 3.106982436870518e-07 0.1264350619688987 3.106983305344566e-07 0.1256206895242312 \
3.106984205359939e-07 0.1247808744623497 3.106985008686745e-07 0.1240346855852102 3.106985875627031e-07 0.1232365419604467 3.106986863930319e-07 0.1223331159004786 \
3.106987764751698e-07 0.1215131568528167 3.106988867184272e-07 0.1205141992263624 3.106989739498662e-07 0.1197275966302077 3.106990425230003e-07 0.1191120727131645 \
3.106991271853926e-07 0.1183553887582162 3.106991936928737e-07 0.1177634990399222 3.106992651487993e-07 0.1171309945267847 3.106993348226041e-07 0.1165184920865242 \
3.106994121596921e-07 0.1158409171037389 3.106995079029745e-07 0.1150054407698888 3.10699579157887e-07 0.1143861389207103 3.106996465274204e-07 0.1138025718558601 \
3.106997149641909e-07 0.113211685696446 3.106997905545423e-07 0.1125613765304429 3.106998812963886e-07 0.1117840233035959 3.106999640001163e-07 0.1110788257213999 \
3.107000775991873e-07 0.1101151050704521 3.107001874748992e-07 0.1091895325357105 3.107002796742132e-07 0.1084169374841771 3.107004036235445e-07 0.1073835127717347 \
3.107004919878672e-07 0.1066505015902263 3.107006314468373e-07 0.1055001025916527 3.107007307435382e-07 0.1046863788921388 3.107008233935897e-07 0.1039306459201802 \
3.10700933598102e-07 0.1030359883605075 3.107010188925422e-07 0.1023467905686673 3.107011037933452e-07 0.101663637589173 3.107011867443086e-07 0.1009989740617136 \
3.107013092542103e-07 0.1000225794851696 3.107014311960626e-07 0.09905761200121259 3.10701557818349e-07 0.09806258992746317 3.107016706304718e-07 0.09718220909187772 \
3.107018152059564e-07 0.09606278874246346 3.107019529198845e-07 0.09500564015228773 3.107020696106743e-07 0.09411672853020667 3.107021973542416e-07 0.0931507147971556 \
3.107022970187578e-07 0.09240236948627445 3.107023764526375e-07 0.09180921593916676 3.107024751879354e-07 0.09107599640376031 3.10702553063239e-07 0.09050081472416407 \
3.107026345291548e-07 0.08990210528957472 3.107027092464628e-07 0.0893557072655629 3.107027897762006e-07 0.08876971652456604 3.107029086085259e-07 0.08791061481419053 \
3.107029982690622e-07 0.08726673116015753 3.107031031831091e-07 0.08651800316437093 3.107032346576667e-07 0.08558693768262025 3.107033957658019e-07 0.08445695903909305 \
3.107035359474973e-07 0.08348350561263763 3.107036844501031e-07 0.08246223579158835 3.10703821170292e-07 0.08153124812726546 3.107039611820024e-07 0.08058696725890066 \
3.10704098179202e-07 0.07967195061625794 3.107042367898133e-07 0.07875532825288725 3.107043812626999e-07 0.07780967510081127 3.107045288089374e-07 0.07685421131041187 \
3.107046863126477e-07 0.07584560580436887 3.107048507078841e-07 0.07480523464991846 3.107050187999819e-07 0.07375451744755303 3.10705199799341e-07 0.07263751640721161 \
3.107053985126234e-07 0.07142823309373261 3.10705611921415e-07 0.07014922396308329 3.107058380853001e-07 0.06881630383186611 3.107060786456226e-07 0.06742468841361035 \
3.107063562065355e-07 0.06585179211508728 3.107066534109385e-07 0.06420523370201831 3.107069717116618e-07 0.06248365192299224 3.10707361695962e-07 0.06043183534616462 \
3.107077605227481e-07 0.05839861031494715 3.10708202994687e-07 0.05621846258761681 3.107085879755898e-07 0.05438828987170503 3.107090000221824e-07 0.05249218901100536 \
3.10709351759698e-07 0.05092353490091287 3.107096872643497e-07 0.04946969867921969 3.107099977632446e-07 0.04816021644386199 3.107102917000643e-07 0.04695194805701195 \
3.107105844309969e-07 0.04577883625507727 3.107108592742044e-07 0.04470700909733757 3.107111331179271e-07 0.04366353526031765 3.107113988076876e-07 0.04267398813878486 \
3.107116741167033e-07 0.04167180388267511 3.107119586736207e-07 0.04066026046469497 3.107122549717362e-07 0.03963283340811159 3.107125138471216e-07 0.03875659098599576 \
3.107127418035276e-07 0.03800131046948733 3.107129605287219e-07 0.03729095380188759 3.107131803834489e-07 0.03659437723507575 3.107135212495136e-07 0.03554043311314246 \
3.107137972903943e-07 0.03470953269536187 3.107140907211692e-07 0.03384790442147732 3.107143732890922e-07 0.03303898052111545 3.107146281985287e-07 0.03232625790162248 \
3.107149088829884e-07 0.03155947796597136 3.107151547163818e-07 0.03090318379665042 3.107153868776701e-07 0.03029616297556957 3.10715627215008e-07 0.02968398395812225 \
3.107158628518432e-07 0.02909722707395018 3.107160910630208e-07 0.0285403787496557 3.107165078357495e-07 0.02755138287878544 3.10716702361127e-07 0.02710176794309662 \
3.107170886015322e-07 0.02623051698020805 3.10717267770925e-07 0.0258356865503758 3.107176189981086e-07 0.02507792837274256 3.107177869041566e-07 0.0247229612172224 \
3.107181711668123e-07 0.02392944198669211 3.107182864485406e-07 0.02369675911063252 3.107187284963783e-07 0.02282172072611499 3.107189503116517e-07 0.02239223679446916 \
3.107194739313108e-07 0.02139838041889957 3.107196292938196e-07 0.02110714647916685 3.107201469998876e-07 0.02015295207761772 3.10720272033152e-07 0.01992792118872039 \
3.10720796234659e-07 0.01901759738223179 3.107209324540342e-07 0.01879045572456909 3.107215387304897e-07 0.01783210191617334 3.107217057396231e-07 0.01758082406519646 \
3.107223489472666e-07 0.01666064795441237 3.107225280915353e-07 0.0164167113061686 3.107232182502689e-07 0.01551958953683085 3.107233818701531e-07 0.01531511209162885 \
3.107241423508398e-07 0.01440332854054019 3.107242893929629e-07 0.01423371673427115 3.107251072646214e-07 0.01333087949608782 3.107252268131343e-07 0.01320411419549955 \
3.107261426746556e-07 0.01227329163592313 3.107262840275722e-07 0.01213544173166964 3.107272325031483e-07 0.01124488043697059 3.107273911425863e-07 0.01110230805801717 \
3.1072857354363e-07 0.01011356759191894 3.107286716440201e-07 0.01003725601038859 3.1072993325548e-07 0.009120360285939955 3.107300676693304e-07 0.009028655389366201 \
3.107316082406548e-07 0.008043892937307966 3.107316892739987e-07 0.007992925041580451 3.107332778679313e-07 0.007023242357651564 3.10733410759078e-07 0.006948518507451114 \
3.107353874624203e-07 0.005952856104192286 3.107355692005682e-07 0.005869662958407677 3.107376715542283e-07 0.004980929874643355 3.107381123459968e-07 0.004810448874467742 \
3.107407675608552e-07 0.003892108290451164 3.107412441403943e-07 0.003745909362026665 3.107448822226149e-07 0.00279447349697209 3.107454077460605e-07 0.002678838783887205 \
3.107510138108453e-07 0.001700248310874221 3.107513248985468e-07 0.001653333728976835 3.107564592262458e-07 0.0006858192122199529 3.107566532060193e-07 0.0006440832883579712 \
3.134045769148618e-07 -0.0002037173203380238 3.134047411152831e-07 -0.0003889174928863678 3.134053144580912e-07 -0.001270938904608877 3.134053893922784e-07 -0.001411855863724778 \
3.134058499760551e-07 -0.002393592696522268 3.134059619168068e-07 -0.002660411672198376 3.134062151887948e-07 -0.003300974950034667 3.134063815720996e-07 -0.003745951779090856 \
3.134066765678696e-07 -0.004566571567208835 3.134067880554425e-07 -0.00488071790655901 3.134070674282164e-07 -0.005641221413069743 3.134071883865554e-07 -0.005938820066262044 \
3.134082823393885e-07 -0.005180465225493313 3.13408406471631e-07 -0.004410796826645887 3.134085308790492e-07 -0.003456122327429311 3.134086504354286e-07 -0.002364170815481491 \
3.13408748579805e-07 -0.001341064316055312 3.13408855004127e-07 -0.0001052154991983786 3.134089672399721e-07 0.001336046702817826 3.134091021958209e-07 0.003249882807978809 \
3.134092247823306e-07 0.005149402351921401 3.134094136442457e-07 0.008353592055059769 3.134095548265785e-07 0.01094873860302964 3.134097081879224e-07 0.01393943619118621 \
3.134098515614267e-07 0.01687898420971235 3.13410005752867e-07 0.02017576688295359 3.134101618928252e-07 0.02363796584892512 3.134103176188778e-07 0.02719811802828209 \
3.134104651125568e-07 0.03065407560139007 3.134106137843234e-07 0.03420778369279751 3.134107691144076e-07 0.03798436241030867 3.134109277402875e-07 0.04189786275883118 \
3.134110926734479e-07 0.0460171220807938 3.134112670963364e-07 0.05041857973200652 3.134114460857363e-07 0.05497510627343041 3.134116353855968e-07 0.05982852266675163 \
3.134118383936028e-07 0.06506368941101938 3.134120578706689e-07 0.07075025585284363 3.134122889353305e-07 0.07675903373893865 3.134125359956494e-07 0.08319974270080552 \
3.134128064206373e-07 0.0902619122132732 3.134130999843244e-07 0.09793335781011638 3.13413424033306e-07 0.1064001814721126 3.134137882548562e-07 0.1159066558703892 \
3.134141808063258e-07 0.1261372395632307 3.134146303042508e-07 0.1378252442462487 3.134151530964837e-07 0.1513754922073403 3.134157666942192e-07 0.1672157090591849 \
3.134164444550933e-07 0.184625848284817 3.134172327202124e-07 0.2047487967247964 3.134181155530716e-07 0.22712469896725 3.134189338390288e-07 0.2476994923478653 \
3.13419661268608e-07 0.2658503723959502 3.134203013816358e-07 0.2817009601644404 3.134208756853502e-07 0.2958213763442377 3.134214132513172e-07 0.3089396094373287 \
3.134219172487762e-07 0.3211464104224903 3.1342239337143e-07 0.3325930942309646 3.134228712594449e-07 0.3439912352478621 3.134233245925507e-07 0.3547121966731367 \
3.134237958852587e-07 0.3657614311162562 3.134242385610847e-07 0.3760518588326446 3.13424757059872e-07 0.3879885572071845 3.134252842219919e-07 0.3999987293386327 \
3.134256631316234e-07 0.4085537955782026 3.134261930471663e-07 0.4204060347738258 3.13426622963746e-07 0.429919877745455 3.134270766645209e-07 0.4398653393542544 \
3.134275433780368e-07 0.4500002271552926 3.134279810592672e-07 0.4594210430579985 3.134283890215308e-07 0.468120704286539 3.134287084545646e-07 0.4748816926501604 \
3.134290805898366e-07 0.4826992142337162 3.134293155719776e-07 0.4876010339127531 3.13429549178225e-07 0.4924491904621348 3.134297971906479e-07 0.4975647713404599 \
3.134300955920778e-07 0.5036796627825791 3.134303519484798e-07 0.5088948470128004 3.134305642417897e-07 0.5131878547336713 3.134307582598616e-07 0.5170959594548015 \
3.134309052463942e-07 0.5200432695146362 3.134310592244046e-07 0.523118600542271 3.134312771061538e-07 0.5274469616807909 3.134315302104803e-07 0.5324525256580425 \
3.134317400493245e-07 0.5365797337241586 3.134319515026335e-07 0.5407247601751553 3.134322337095338e-07 0.5462280430697679 3.134324632548168e-07 0.5506821559930507 \
3.134326791510236e-07 0.5548604062613707 3.134329613725408e-07 0.560308769190463 3.134332126802682e-07 0.5651538146135803 3.134335103411598e-07 0.5708625224168123 \
3.134337605680607e-07 0.5756519166658941 3.134340169315557e-07 0.5805516059354519 3.134342573415699e-07 0.585116682128892 3.134345155213862e-07 0.5900038400537884 \
3.134347391135916e-07 0.5942175703762435 3.134349776231628e-07 0.5986919452581434 3.134351852078615e-07 0.6025689278491061 3.134354017304866e-07 0.6065904171332736 \
3.134356510330919e-07 0.6111939272561876 3.134358561065347e-07 0.6149609706257601 3.134361073788606e-07 0.6195555361399968 3.13436310600886e-07 0.6232455818254186 \
3.134365074727914e-07 0.6267987644955494 3.134367007643072e-07 0.630267737067843 3.134369555427623e-07 0.6348113783570861 3.13437185753374e-07 0.638887973644319 \
3.134374031071848e-07 0.6427143472883045 3.134377015129076e-07 0.6479268061885751 3.134379169157571e-07 0.6516657345437264 3.134381181394757e-07 0.6551344108237934 \
3.134382930609835e-07 0.6581323437428509 3.13438458126254e-07 0.6609495238976936 3.134386275947746e-07 0.6638251431769452 3.134387797316125e-07 0.666392827642013 \
3.134389176422984e-07 0.6687037209181631 3.134390664784122e-07 0.6711867545200138 3.134391945930143e-07 0.6733159837320549 3.134393378158276e-07 0.6756849429836936 \
3.134394590900776e-07 0.6776819274526149 3.134395966887617e-07 0.6799401191146522 3.134397160692161e-07 0.6818929034138137 3.134398631769624e-07 0.6842914131385206 \
3.134399803786278e-07 0.6861933934268433 3.13440073884205e-07 0.6877071857403232 3.13440164873897e-07 0.6891752279197846 3.134402676159613e-07 0.6908280855439021 \
3.134403691335249e-07 0.6924555900607121 3.134404875166309e-07 0.6943444167618776 3.134405996372169e-07 0.6961264383846065 3.134407171927181e-07 0.6979868779962457 \
3.134409023430049e-07 0.7008959348649784 3.134410335352131e-07 0.7029413755586562 3.134411697037528e-07 0.7050491462541959 3.134412912224561e-07 0.7069171228306749 \
3.134414311454679e-07 0.7090538254196674 3.134415350881169e-07 0.7106315721465845 3.134416462491007e-07 0.712309798010818 3.134417505089649e-07 0.7138759052437967 \
3.134418801470564e-07 0.7158124745844324 3.134419770777692e-07 0.7172526339884565 3.134421160000042e-07 0.7193052800722975 3.134422355492927e-07 0.7210612846995991 \
3.134423551218654e-07 0.7228080613301419 3.134424808972429e-07 0.7246353354365959 3.134426076155857e-07 0.7264656873164689 3.134427296554369e-07 0.728218443613998 \
3.134428578038805e-07 0.7300486655261287 3.13442987872205e-07 0.7318956587421809 3.134431088632273e-07 0.7336041830685722 3.134432496338107e-07 0.7355801168346318 \
3.1344335060338e-07 0.7369898206659778 3.134434522042367e-07 0.7384020079314992 3.13443548224548e-07 0.7397310783624924 3.134436591374029e-07 0.7412570822736337 \
3.134437467850298e-07 0.7424563811251772 3.134438466394007e-07 0.7438154404043728 3.134439814045385e-07 0.7456370856934184 3.13444097699018e-07 0.747198032089633 \
3.13444201190815e-07 0.7485782798032956 3.134443254462628e-07 0.7502239458264747 3.13444470359203e-07 0.7521280942578691 3.134445883397714e-07 0.753666143975803 \
3.134447072708787e-07 0.7552056331692281 3.134448468504184e-07 0.7569980918234445 3.134449912028081e-07 0.7588357421297242 3.134451092636163e-07 0.7603265096672839 \
3.134452340853355e-07 0.7618908200857619 3.134453739165311e-07 0.7636286950759973 3.134454986794279e-07 0.7651662633748356 3.134456421928987e-07 0.7669199865864609 \
3.134457628783765e-07 0.7683824344671055 3.13445883722124e-07 0.7698356273746885 3.134460033670484e-07 0.7712633747646481 3.134461330746874e-07 0.7727989859455529 \
3.134462418184901e-07 0.7740766298596218 3.134463644662266e-07 0.7755070372682662 3.134464742429112e-07 0.7767778749889983 3.13446603267025e-07 0.7782599816788072 \
3.134467350433437e-07 0.7797610257751375 3.134468483559198e-07 0.7810403609326458 3.134469694418617e-07 0.7823954393038701 3.134470733144949e-07 0.7835479431998941 \
3.134472155975174e-07 0.785111775748914 3.134473638006659e-07 0.7867227488076519 3.134475226942012e-07 0.7884297907063792 3.134476428872234e-07 0.7897074707829422 \
3.134477924539297e-07 0.7912811323018302 3.134479165691468e-07 0.7925734175081853 3.134480422734439e-07 0.7938699048627912 3.134481452190109e-07 0.7949224966762399 \
3.134482595901654e-07 0.7960823495211882 3.134483720644089e-07 0.7972131756542409 3.134484623369833e-07 0.7981137961420948 3.134485516778793e-07 0.7989989930139054 \
3.134486769038167e-07 0.800229513878344 3.134487846751798e-07 0.8012785338618679 3.134489143429785e-07 0.8025281307685926 3.134490357222573e-07 0.8036855380110038 \
3.134491522780568e-07 0.8047859282369955 3.134492730834528e-07 0.80591497746663 3.134494057087579e-07 0.8071413435168892 3.134495275023783e-07 0.8082555056211007 \
3.13449654106103e-07 0.8094015704683005 3.134497797196214e-07 0.8105266036187198 3.13449899211046e-07 0.8115857443778658 3.134500374092988e-07 0.8127973981963581 \
3.134501469085475e-07 0.8137473213416323 3.134502310566626e-07 0.8144713378799666 3.134503518607202e-07 0.8155017394983226 3.134504473695572e-07 0.8163089346032877 \
3.134505836603603e-07 0.8174496006492775 3.13450726424414e-07 0.8186303638797883 3.13450860857535e-07 0.8197292014569521 3.134509707295191e-07 0.8206175763825388 \
3.134511146291367e-07 0.8217677661037901 3.134512679567201e-07 0.8229768690765377 3.134513958055741e-07 0.8239722812379519 3.134515362029048e-07 0.8250521595273246 \
3.13451662107844e-07 0.8260088941474263 3.134518167240102e-07 0.8271688948348412 3.134519490793395e-07 0.8281489842609937 3.134520753461681e-07 0.8290730392392056 \
3.134521930066954e-07 0.8299245984162376 3.134523414090921e-07 0.8309852945996649 3.134525086032604e-07 0.8321626230293395 3.134526413805716e-07 0.8330844501529713 \
3.134528142817687e-07 0.8342675727345584 3.134529826990627e-07 0.8354015168591284 3.134531521935363e-07 0.8365246342267009 3.134533336304179e-07 0.8377070668209077 \
3.134534761865593e-07 0.8386219603417975 3.134535900974499e-07 0.8393441765511721 3.134537209736586e-07 0.8401643924869071 3.134538225966329e-07 0.8407940582489307 \
3.134539390368715e-07 0.8415078269750864 3.134540743300576e-07 0.8423269142909066 3.134542715951592e-07 0.8435017451489455 3.134544621144827e-07 0.844614933042255 \
3.13454672039296e-07 0.8458175693076773 3.134548528178267e-07 0.8468334846981137 3.134550501858462e-07 0.8479221976595614 3.134552240443405e-07 0.8488638701886076 \
3.134554065585834e-07 0.8498353939890455 3.134555779026936e-07 0.8507314120859523 3.13455752248258e-07 0.8516272398309612 3.134559276512583e-07 0.8525125793730954 \
3.134561038964483e-07 0.8533864315694911 3.134562936653265e-07 0.8543099749208749 3.134564844233442e-07 0.8552205033559714 3.134566862125501e-07 0.8561646193034282 \
3.134568789161161e-07 0.8570482883232282 3.134570883567927e-07 0.8579892478796384 3.134573180985592e-07 0.8589986827500428 3.134575835675109e-07 0.8601360945383778 \
3.134578822138556e-07 0.8613786760148464 3.134581606012222e-07 0.8625023989005415 3.134584447911769e-07 0.8636161469557806 3.13458719285784e-07 0.8646608622318305 \
3.134589913772806e-07 0.8656672252055042 3.134592615937268e-07 0.8666387059277968 3.134595187619146e-07 0.8675381145236246 3.134597913209795e-07 0.8684653318325959 \
3.1346006734232e-07 0.8693777905953765 3.13460337484171e-07 0.8702455402709716 3.134606372319547e-07 0.8711796653984102 3.134610081058124e-07 0.872294745819888 \
3.134613030287967e-07 0.8731503023941 3.134615572848448e-07 0.8738665406311316 3.134618555155772e-07 0.8746822274488602 3.134621291339016e-07 0.8754080260278182 \
3.134623652695491e-07 0.8760175227551726 3.134626056214059e-07 0.876622281264788 3.134628279637853e-07 0.8771680781109068 3.134630219681285e-07 0.8776338860468618 \
3.134633516912075e-07 0.8784037109613512 3.1346350686397e-07 0.8787567114621292 3.134638246164967e-07 0.879461652496718 3.134640034818579e-07 0.8798480920375044 \
3.134643459433238e-07 0.8805675499479563 3.134645300848474e-07 0.8809434933546246 3.134650049902839e-07 0.8818790560183651 3.134651723847029e-07 0.8821975058309585 \
3.134656382161285e-07 0.8830540251881659 3.134658190409674e-07 0.8833751042472839 3.134663130743469e-07 0.8842212008576973 3.134664544170557e-07 0.884455124402366 \
3.13467060806836e-07 0.8854193259359495 3.134672128789829e-07 0.8856514227360587 3.134678595574705e-07 0.8865980751852495 3.134679878538246e-07 0.8867785329419297 \
3.134686359799261e-07 0.8876550049536978 3.134687657724472e-07 0.8878236738033012 3.134695440340947e-07 0.8887860366092379 3.134696590259732e-07 0.8889208282599539 \
3.134705147583919e-07 0.8898661633196656 3.134706600215368e-07 0.8900169066926564 3.134716457777221e-07 0.8909664261264102 3.134718668828627e-07 0.8911622482549515 \
3.134730119973067e-07 0.8921020388386462 3.134731432072641e-07 0.8922053928944147 3.134743308657994e-07 0.8931033243919096 3.134744844860915e-07 0.8932130731307282 \
3.13475894522803e-07 0.8941348173026452 3.13476117329622e-07 0.8942660193790342 3.134777980203304e-07 0.8951452796684343 3.134781256415096e-07 0.8952966652167414 \
3.134803555826309e-07 0.8961896554712738 3.134809084965924e-07 0.8963788593752812 3.134844767111233e-07 0.8973573335043913 3.134848002235382e-07 0.8974284307984646 \
3.134911566318259e-07 0.8984120886469452 3.134917055346727e-07 0.8984686671268907 3.13544207609024e-07 0.8994658645395698 3.135448506378865e-07 0.8994692460188505 \
3.137369893085195e-07 0.9004073346715066 3.137371907224907e-07 0.9004708280105613 3.137411505004318e-07 0.8995366825576255 3.137413345272296e-07 0.8993953949813248 \
3.137426511245044e-07 0.8984641879157507 3.137428231683587e-07 0.8983566564859006 3.137447195446537e-07 0.8973720929359315 3.137448932508418e-07 0.897304621671452 \
3.137574671778748e-07 0.8982933655523699 3.137575523681118e-07 0.8983081509245614 3.137658192411513e-07 0.8993078551592517 3.137662939605718e-07 0.8993433667976791 \
3.142597948700116e-07 0.9002974142054325 3.142599143497356e-07 0.9003767372269074 3.142608071727864e-07 0.9012336455299185 3.142609534294226e-07 0.901423267690772 \
3.142615483221009e-07 0.9023325668564308 3.142616832929176e-07 0.9025673929107925 3.14262187968707e-07 0.9035294259428087 3.142623205796079e-07 0.9038000271808221 \
3.142627212069726e-07 0.9046475051114249 3.142628655723708e-07 0.9049556543240072 3.142632886935802e-07 0.9058123566484279 3.142633841506385e-07 0.9059850892484415 \
3.142648087094547e-07 0.9052205906349737 3.142649337473088e-07 0.9046352442223391 3.142650601578981e-07 0.9039223775493039 3.142651628066418e-07 0.9032486771507763 \
3.142652900219319e-07 0.9022944222362175 3.142654088677579e-07 0.9012801950564071 3.142655065202371e-07 0.9003603330664713 3.142655885222584e-07 0.8995243596151602 \
3.142656681858213e-07 0.8986589236008835 3.142657789639895e-07 0.8973708307079206 3.142658801400036e-07 0.8961049472956977 3.142659630844751e-07 0.8950067229086057 \
3.142660715298925e-07 0.8934921260891034 3.142661799938501e-07 0.8918872687155874 3.14266275049989e-07 0.8904106867557802 3.142663959226416e-07 0.8884444419111864 \
3.14266516699262e-07 0.8863849482818795 3.142666297444327e-07 0.8843763393508186 3.142667329151817e-07 0.8824794505619851 3.142668185153382e-07 0.8808620855018965 \
3.142668929893991e-07 0.8794251273161163 3.142669873129417e-07 0.8775673968166831 3.142670757738577e-07 0.8757888800524039 3.142671548468696e-07 0.8741711975775893 \
3.142672488342247e-07 0.872216793437976 3.142673301795293e-07 0.8704993514258973 3.14267425093555e-07 0.8684673705816817 3.14267518136275e-07 0.8664480751909672 \
3.142676149220692e-07 0.8643215060814092 3.142677382174414e-07 0.8615778533848952 3.142678516644525e-07 0.859022019682563 3.142679775164913e-07 0.8561558571929792 \
3.142681008446355e-07 0.8533196845306243 3.142682300229265e-07 0.850323637950593 3.142683706197831e-07 0.8470370034914 3.142684793995045e-07 0.8444782910716596 \
3.142686144592575e-07 0.8412850455921466 3.14268724119566e-07 0.8386804253780991 3.142688532993454e-07 0.8356002443501571 3.14268979483175e-07 0.8325812421138936 \
3.142691065735304e-07 0.8295317031556502 3.142692355958039e-07 0.826427745883674 3.142693446760448e-07 0.8237985689995477 3.142694845267009e-07 0.8204223029647078 \
3.142696239548932e-07 0.8170507778356514 3.142697567085239e-07 0.8138366863616762 3.142698867771992e-07 0.8106848159989707 3.142700104726457e-07 0.8076853837479523 \
3.142701474270357e-07 0.8043627031572629 3.142702611388824e-07 0.8016030849198694 3.142703886159226e-07 0.7985086235398901 3.142704994169941e-07 0.7958187897651571 \
3.142706186034522e-07 0.7929254985494992 3.142707319825085e-07 0.7901733724735396 3.142708662929012e-07 0.7869138859547327 3.142709733871687e-07 0.7843152933129034 \
3.142710894043117e-07 0.7815009627552112 3.142712185952754e-07 0.778367508739124 3.142713162077106e-07 0.7760002683782802 3.142714217871509e-07 0.773440790716327 \
3.142715304693199e-07 0.7708069008430674 3.142716328855832e-07 0.7683258101021144 3.142717262792412e-07 0.7660641808432364 3.142718458350171e-07 0.7631702213567544 \
3.142719383073787e-07 0.7609327305817616 3.14272030945494e-07 0.7586922094322426 3.142721293703097e-07 0.7563124992069843 3.142722373479617e-07 0.7537030947613649 \
3.142723336164742e-07 0.7513778334636231 3.142724198728768e-07 0.7492952979736797 3.142725227366661e-07 0.7468128004450286 3.14272601580994e-07 0.744910856519283 \
3.142727023870358e-07 0.7424801602439853 3.142728369152764e-07 0.7392377693660663 3.142729741401358e-07 0.7359316755186537 3.142731176199873e-07 0.7324773442723981 \
3.142732660441767e-07 0.7289066083419234 3.142734093054719e-07 0.7254625447335662 3.142735493824514e-07 0.7220977259655398 3.142737058083174e-07 0.7183435968963056 \
3.142738302100673e-07 0.715360858370426 3.14273951271848e-07 0.7124600029613375 3.1427410478411e-07 0.7087850045121084 3.142742395660554e-07 0.7055614325718365 \
3.142743656650877e-07 0.7025479112911024 3.142745088393713e-07 0.6991289103945657 3.142746289211628e-07 0.6962626602560111 3.142747581554914e-07 0.6931807499479741 \
3.142748646405391e-07 0.6906432840523983 3.142749769163615e-07 0.6879696524977363 3.142750732516477e-07 0.6856773754336868 3.142751760613402e-07 0.683232326200841 \
3.14275270865193e-07 0.6809792012818872 3.142753761871231e-07 0.6784784437814733 3.14275484625777e-07 0.6759058899658261 3.142755836350576e-07 0.673558569590366 \
3.142757003916503e-07 0.6707929011939652 3.142758084769278e-07 0.6682347329991606 3.142759184831366e-07 0.6656332609774134 3.142760045709787e-07 0.6635992664604092 \
3.142761341661182e-07 0.6605400273835189 3.142762267673659e-07 0.6583552307294462 3.142763225550924e-07 0.6560965362104854 3.142764075070784e-07 0.6540950852804182 \
3.142765268016021e-07 0.6512869789851043 3.142766140715399e-07 0.6492343850333612 3.142767047785614e-07 0.6471030993779646 3.14276805943536e-07 0.6447280068361273 \
3.142768857743593e-07 0.6428551652550211 3.142769745601937e-07 0.6407732405330839 3.142770522504205e-07 0.6389536101386547 3.142771140193684e-07 0.6375081226244841 \
3.142771777840134e-07 0.6360167668935747 3.142772410182332e-07 0.634538653569437 3.142772802588059e-07 0.6336218002627473 3.142773208978281e-07 0.6326726453797233 \
3.142774009823624e-07 0.6308039353694699 3.142774708865426e-07 0.6291742390428672 3.142775215232567e-07 0.6279942052995945 3.142775602728994e-07 0.6270914175114127 \
3.142775992678787e-07 0.6261832343283663 3.142776438826267e-07 0.6251445623164014 3.142776867390832e-07 0.6241478292286105 3.142777370536867e-07 0.6229782634938205 \
3.142777889908641e-07 0.6217719122409077 3.142778740584487e-07 0.6197972300178722 3.142779340388659e-07 0.6184052992407258 3.142780238260749e-07 0.61632338076978 \
3.142781002901565e-07 0.6145529519516876 3.142781798544472e-07 0.6127119801362371 3.142782608910593e-07 0.6108383709630588 3.142783501053817e-07 0.6087775861620425 \
3.142784409653938e-07 0.6066826282541496 3.142785281841023e-07 0.6046739453334793 3.142786219572931e-07 0.6025158549334848 3.142787236427565e-07 0.6001788642681311 \
3.142788232408485e-07 0.5978941858483342 3.142789350958888e-07 0.5953317151711254 3.14279051129026e-07 0.5926772450523136 3.142791727501318e-07 0.5899020947998995 \
3.142792771339459e-07 0.5875236635596754 3.142794219241658e-07 0.5842296531729801 3.142795345841267e-07 0.5816734289694181 3.14279643596094e-07 0.5792035939892568 \
3.142797360755373e-07 0.5771100174076607 3.142798295261766e-07 0.5749994714793375 3.142799218520404e-07 0.5729181236728181 3.142799944387413e-07 0.571283073141143 \
3.142800503929671e-07 0.5700232888304386 3.142801114612485e-07 0.5686498830286455 3.142802099507645e-07 0.5664400707212188 3.142802731622084e-07 0.5650238531380825 \
3.14280333588177e-07 0.5636708824310654 3.142804105365601e-07 0.5619492451093103 3.142804736951014e-07 0.5605380106414651 3.142805620087099e-07 0.558569506627369 \
3.14280633210033e-07 0.5569845302974165 3.14280719745787e-07 0.555060151797141 3.142808410985601e-07 0.5523665438352664 3.142809690278082e-07 0.5495364947125975 \
3.142810671584392e-07 0.5473694328713704 3.142811802824346e-07 0.5448752016832871 3.14281282350254e-07 0.5426314425864434 3.142814012991245e-07 0.5400217272291628 \
3.142815043868322e-07 0.5377630705755105 3.142816185939865e-07 0.5352670017334624 3.142817320096582e-07 0.532794946211756 3.14281859080713e-07 0.5300302694710822 \
3.14281982900802e-07 0.5273426867079006 3.142821276896071e-07 0.5242103332418484 3.142822635131097e-07 0.5212782585303676 3.142824185679684e-07 0.5179428401013338 \
3.142825794198528e-07 0.5144913885072363 3.142827581493005e-07 0.5106699876709851 3.1428294832834e-07 0.5066200804011861 3.142831582303623e-07 0.5021665212646098 \
3.142833869363468e-07 0.4973332357952056 3.142836408642853e-07 0.4919960258408594 3.142838817977506e-07 0.4869529241725989 3.142841779602358e-07 0.4807889695952298 \
3.142844679576231e-07 0.4747910561470179 3.142847742009558e-07 0.4684976697011882 3.142850948768875e-07 0.4619520863481486 3.142854227440541e-07 0.4553041925245184 \
3.142857629891091e-07 0.4484521981997251 3.142860884146545e-07 0.4419418052309769 3.142864103218022e-07 0.4355465312739703 3.142867405359073e-07 0.4290298934287748 \
3.142870965284996e-07 0.4220583188787752 3.142874154069286e-07 0.4158579595363656 3.14287752858691e-07 0.4093433989943853 3.142881807254075e-07 0.4011531841887147 \
3.142885294373556e-07 0.3945419525178304 3.142888370733194e-07 0.388759214407489 3.142892168998106e-07 0.3816861832573664 3.142895480893721e-07 0.3755780492082042 \
3.142898316974524e-07 0.370391509977049 3.142901425163967e-07 0.3647512908748707 3.142904218330045e-07 0.3597258263082204 3.142906483291526e-07 0.3556836811642302 \
3.142908640115379e-07 0.3518598964090484 3.142910612955428e-07 0.3483842179544538 3.142912662800023e-07 0.3447988491770444 3.142914785019664e-07 0.3411119200457455 \
3.142917338071541e-07 0.33670771290924 3.142919753294027e-07 0.3325734463267218 3.14292206706731e-07 0.3286464933807047 3.142924215592308e-07 0.3250253651850565 \
3.142926421183882e-07 0.3213332986541765 3.142928435443551e-07 0.3179852906236645 3.142930466126061e-07 0.3146379646143546 3.142932445082156e-07 0.3114011111455273 \
3.142934314693022e-07 0.3083651674074345 3.142936252695217e-07 0.3052406640298299 3.142938291861339e-07 0.3019773030815858 3.142940082554678e-07 0.2991336297844484 \
3.142942438463241e-07 0.2954229173226265 3.142944446504233e-07 0.2922868215109002 3.142946458293147e-07 0.2891696385850206 3.142948696390574e-07 0.2857334090862961 \
3.142950342018033e-07 0.2832271910241367 3.142952111291889e-07 0.2805503385691353 3.14295396922194e-07 0.2777610713150803 3.142955787376702e-07 0.2750538970423583 \
3.142957577624632e-07 0.2724132377985424 3.142959251076164e-07 0.2699606650006489 3.142960855365337e-07 0.2676371805838822 3.142962081102854e-07 0.2658719571410424 \
3.14296357874814e-07 0.2637236906090554 3.142964855719403e-07 0.2619099339733745 3.142965928803121e-07 0.2603957336038235 3.142967088809744e-07 0.2587625259947361 \
3.142968191895705e-07 0.2572125806747212 3.142969450687671e-07 0.2554509781935611 3.142970605506183e-07 0.2538402638894013 3.142971951315211e-07 0.2519757335310172 \
3.142973071947753e-07 0.2504255755821768 3.142974575341346e-07 0.2483447107137444 3.142975971599893e-07 0.2464124269747185 3.142977430518096e-07 0.2444035064209518 \
3.142978760124476e-07 0.2425734862730615 3.14297999574161e-07 0.2408709992523319 3.142981467838532e-07 0.2388417729476062 3.142982633706824e-07 0.2372355665500016 \
3.142984028258316e-07 0.23532008003217 3.142985370003013e-07 0.2334768281602104 3.142986629767575e-07 0.2317465561243653 3.142987823761605e-07 0.2301094434087779 \
3.142988772305854e-07 0.2288105340759602 3.142989903681845e-07 0.2272617792622066 3.142990706846421e-07 0.2261626001158484 3.142991582496986e-07 0.2249657246820506 \
3.142992837868356e-07 0.2232507767215072 3.142993894805428e-07 0.2218101326756785 3.142994791350539e-07 0.2205921574607158 3.14299549986253e-07 0.2196300825522397 \
3.142995930147827e-07 0.2190460135436258 3.142996353053263e-07 0.2184724035808872 3.142996776470424e-07 0.2178984240735344 3.142997498424616e-07 0.2169203674089526 \
3.142997922358174e-07 0.2163464205126744 3.14299827490656e-07 0.2158693585303403 3.142998716822395e-07 0.2152716287340076 3.142999412904665e-07 0.2143309212991285 \
3.142999756337965e-07 0.2138672544767182 3.143000200933248e-07 0.2132698436071631 3.143000877718062e-07 0.2123628126304402 3.143001741990649e-07 0.2112058698236149 \
3.143002488356675e-07 0.2102078598594563 3.143003301376756e-07 0.2091219706754807 3.143004270150594e-07 0.2078300362310651 3.143005529985482e-07 0.2061528795789772 \
3.143006555333841e-07 0.2047906894256944 3.143007570169014e-07 0.2034500128132261 3.143008580825969e-07 0.202119416354989 3.143009546968166e-07 0.2008491615811921 \
3.143010566612396e-07 0.1995112314821507 3.143011633834836e-07 0.1981153840927639 3.143012717886237e-07 0.1967018790395962 3.143013837827796e-07 0.1952465002768531 \
3.14301496249907e-07 0.1937897263683151 3.143016083232463e-07 0.1923454332378671 3.143017162157206e-07 0.1909603537828802 3.143018175986494e-07 0.1896629368444172 \
3.143019092360985e-07 0.1884941330679491 3.143020032117073e-07 0.1872990757663449 3.143020744780721e-07 0.1863957871745983 3.1430215115336e-07 0.1854271890400033 \
3.143022548124749e-07 0.184122202819407 3.143023284795955e-07 0.1831974022686171 3.143024018254956e-07 0.1822796569444652 3.143025152158449e-07 0.1808667181969195 \
3.143026030744852e-07 0.1797760932362061 3.143026869231622e-07 0.1787387947787487 3.143028158855897e-07 0.1771515524267008 3.143029177720844e-07 0.1759040172436072 \
3.143030234727908e-07 0.1746156056808686 3.143031251208657e-07 0.1733818993219825 3.143032559825841e-07 0.1718019019596718 3.143033631792215e-07 0.1705140034701537 \
3.14303492508118e-07 0.168969083715685 3.143036042046102e-07 0.167642098072289 3.143037045351887e-07 0.1664555496840579 3.143038003357432e-07 0.1653276075899142 \
3.143039111480153e-07 0.1640289617085985 3.143039985482962e-07 0.1630090521997956 3.143041098694134e-07 0.1617156184952586 3.143042028212722e-07 0.1606409001560029 \
3.143042903941502e-07 0.1596330843918451 3.143043920250233e-07 0.1584700928658864 3.143044764790781e-07 0.1575086241734052 3.143045515834575e-07 0.1566573095634876 \
3.143046294056999e-07 0.1557789554714152 3.143047097635688e-07 0.1548759612316424 3.143048108183989e-07 0.1537464547857493 3.143048932519626e-07 0.1528311848879565 \
3.143049855565143e-07 0.1518114053368895 3.143050624909871e-07 0.150965812476358 3.143051454135576e-07 0.1500585909391909 3.143052169442981e-07 0.1492793026301012 \
3.143053133277974e-07 0.1482344968214558 3.143053835562832e-07 0.1474766665551334 3.143054665365612e-07 0.1465853655470201 3.143055279788246e-07 0.1459298106834085 \
3.143055996612094e-07 0.1451677491870439 3.14305668289752e-07 0.1444408762699853 3.143057185582615e-07 0.1439102090153988 3.143057661380673e-07 0.143409423336876 \
3.14305820187418e-07 0.1428423132663369 3.143058795295158e-07 0.1422216078256897 3.143059475649228e-07 0.1415124633834424 3.14306023828345e-07 0.1407207186008814 \
3.143060921081446e-07 0.1400161356079559 3.143061868943229e-07 0.1390460813732662 3.143062764481352e-07 0.1381341561933974 3.143063481336088e-07 0.1374075731330657 \
3.143064320850176e-07 0.1365606113096345 3.143064973974727e-07 0.1359045398875483 3.143065588405982e-07 0.1352895588344758 3.143066331170967e-07 0.1345490408254265 \
3.143066953273574e-07 0.1339328028964004 3.143067632983657e-07 0.133265236037424 3.143068225054055e-07 0.1326856657519672 3.143068951778785e-07 0.1319767402814105 \
3.143069701979877e-07 0.1312477270463112 3.143070556514107e-07 0.1304208267333309 3.143071417517503e-07 0.1295914604616623 3.143072418772051e-07 0.1286317929389105 \
3.143073231668748e-07 0.127857435971709 3.143074249342228e-07 0.1268981149578782 3.143075091821821e-07 0.1261072369695883 3.143076079989111e-07 0.1251836587365037 \
3.143076808394557e-07 0.1245055382686853 3.143077608655429e-07 0.1237631876254407 3.14307831351338e-07 0.1231117958237987 3.143079038817606e-07 0.1224439308288319 \
3.143079813507563e-07 0.1217331219782777 3.143080887021039e-07 0.1207554316575004 3.143081893401196e-07 0.1198442997624752 3.143082619276736e-07 0.1191899427853172 \
3.143083307595138e-07 0.1185715582611356 3.143083965463339e-07 0.1179824683205609 3.143084661751317e-07 0.1173610347366148 3.143085365588769e-07 0.1167350538439435 \
3.143086117372496e-07 0.1160688810594495 3.143087159914846e-07 0.1151493019715505 3.143087911261386e-07 0.114489769343061 3.143088600412231e-07 0.1138870655592168 \
3.143089232460945e-07 0.1133369146236164 3.143089927874599e-07 0.1127339156958381 3.14309050088964e-07 0.1122385190692166 3.14309121730019e-07 0.1116210355509516 \
3.143091795650925e-07 0.1111240709857579 3.143092516865272e-07 0.1105063809580559 3.1430931410261e-07 0.1099736279351742 3.143093984241316e-07 0.1092565349771765 \
3.143094660201e-07 0.1086842173446869 3.143095748160323e-07 0.1077671916889585 3.143096791265639e-07 0.1068924975608609 3.14309758614772e-07 0.1062289053282379 \
3.143098461831825e-07 0.1055008617114655 3.143099096395349e-07 0.1049752776433979 3.143099713506517e-07 0.10446579874651 3.14310075190416e-07 0.103612238268202 \
3.143101578711175e-07 0.1029362225408096 3.143102563391439e-07 0.1021348761715451 3.14310340785582e-07 0.101450818648051 3.143104572630618e-07 0.1005121841703865 \
3.143105919965077e-07 0.09943411943161744 3.143107280660444e-07 0.0983541971400249 3.143108423854515e-07 0.09745369041838402 3.143109278525961e-07 0.09678457778867394 \
3.143110381342688e-07 0.09592640631053104 3.143111189226223e-07 0.09530159220710262 3.143112184734934e-07 0.09453592511176086 3.143113084215428e-07 0.09384821103094763 \
3.14311380924943e-07 0.09329669945188329 3.143114626670093e-07 0.09267796846073476 3.143115907872446e-07 0.09171467366828615 3.143116721993079e-07 0.09110674702409056 \
3.143117466312153e-07 0.09055373306570065 3.143118216050993e-07 0.08999936228352182 3.143119010240745e-07 0.08941505746347288 3.143120096849318e-07 0.08862052380504259 \
3.143121040449035e-07 0.08793517800096999 3.143121934400264e-07 0.08728987318634121 3.143123002057426e-07 0.086524181682867 3.143124187081826e-07 0.08568073755029131 \
3.143125602332527e-07 0.08468224831562859 3.143126933716762e-07 0.08375174214918565 3.143128342170073e-07 0.08277682112810406 3.143129832689884e-07 0.08175525972387458 \
3.143131190667176e-07 0.08083369778093191 3.143132605232322e-07 0.0798830809748103 3.143133957831475e-07 0.07898330517332906 3.143135371649882e-07 0.07805242629322809 \
3.143136842327613e-07 0.07709434677344783 3.143138359609018e-07 0.07611680364043326 3.143140013092032e-07 0.07506403321855706 3.143141651767209e-07 0.07403332863189842 \
3.143143414906487e-07 0.07293832728335037 3.143145309257506e-07 0.07177777688466977 3.143147416924551e-07 0.07050569389938771 3.143149614649522e-07 0.06920150027616521 \
3.143151964331044e-07 0.06783224552442871 3.14315455333654e-07 0.06635227408830123 3.14315750264117e-07 0.06470266364809808 3.143160546101784e-07 0.06304001691994518 \
3.143164165564573e-07 0.06111393619706453 3.143167326842125e-07 0.05947639552636011 3.143171740066774e-07 0.0572596911373907 3.143174875727196e-07 0.05573556853365672 \
3.14317911072189e-07 0.0537382660685313 3.143182550240426e-07 0.05216649213267931 3.143185952653102e-07 0.05065508790922631 3.143189061028998e-07 0.04931137323461653 \
3.143192005748017e-07 0.04807062469528345 3.143194942742994e-07 0.04686392507224969 3.143197691455356e-07 0.04576537019482012 3.143200446857014e-07 0.04468949010490332 \
3.143203097762298e-07 0.04367785045825667 3.143205865333108e-07 0.04264571401740119 3.143208698014357e-07 0.04161414314527601 3.143211677947347e-07 0.04055545327485047 \
3.143214272801311e-07 0.03965542606183669 3.143216573035691e-07 0.03887446236327848 3.143218769951559e-07 0.03814321686473518 3.14322101935296e-07 0.0374128399305801 \
3.1432242218897e-07 0.0363978329183388 3.143227099868201e-07 0.03550963653148703 3.143229863821537e-07 0.03467738358988744 3.143232702012828e-07 0.03384352473043348 \
3.143235083105866e-07 0.03315996078327022 3.143237926213707e-07 0.03236211345273886 3.143240345332207e-07 0.03169864947531036 3.143242696733945e-07 0.03106710921041438 \
3.143245113809233e-07 0.03043352335444016 3.143247483338566e-07 0.02982731501219571 3.14324978676274e-07 0.02925002048968134 3.143251924268523e-07 0.02872465224286764 \
3.143253982738151e-07 0.02822791768061097 3.143257906108381e-07 0.02730524204782691 3.143259790028487e-07 0.02687312495148303 3.143263546143073e-07 0.02603163971789 \
3.143265290810819e-07 0.02564950258131362 3.143269530155409e-07 0.02474274850847508 3.14327073769958e-07 0.02449086781212801 3.143275440207215e-07 0.02353384026002922 \
3.143276932357865e-07 0.02323677291035493 3.143280868679981e-07 0.02246740853134286 3.143282578943424e-07 0.02213909006726131 3.143287451732745e-07 0.02121869533024997 \
3.143288872209832e-07 0.02095326544309953 3.143294202372519e-07 0.01997576278857772 3.14329542401289e-07 0.01975737097014436 3.143300645590335e-07 0.01885981776906158 \
3.143302351373363e-07 0.01857989792133653 3.143307224503994e-07 0.01781360777737795 3.143308939733227e-07 0.01755501440977742 3.143315137600803e-07 0.01666567753024489 \
3.143316846844061e-07 0.0164316648397145 3.143323902353964e-07 0.01551160061118263 3.14332552852409e-07 0.01530799450170666 3.143333097458994e-07 0.01439879525764199 \
3.143334506625442e-07 0.01423641007536438 3.143343506613842e-07 0.01324361033368418 3.143344380106346e-07 0.01315122959105692 3.14335342363989e-07 0.01223321097894121 \
3.14335479555938e-07 0.01209984223734439 3.14336450212214e-07 0.01118944790767422 3.14336578130092e-07 0.01107451071402888 3.143377285400387e-07 0.01011008206277823 \
3.143378223420747e-07 0.01003687265682024 3.143390783878875e-07 0.009120584045805383 3.143392159292007e-07 0.009026502753623255 3.14340774683602e-07 0.008029670037698805 \
3.143408584862873e-07 0.007977066150721189 3.143424638651059e-07 0.00699828665725172 3.143425747634502e-07 0.006935886594503895 3.143445070098238e-07 0.005959177461785255 \
3.143446867147596e-07 0.005876661013304485 3.143467985058761e-07 0.004981749118765498 3.143471412910116e-07 0.004848482978762325 3.143496544570453e-07 0.003966891390423618 \
3.143501241787149e-07 0.003819799497680527 3.143537644949897e-07 0.002847564273158896 3.143542802321751e-07 0.002731633924241866 3.143596220620139e-07 0.001773027297371861 \
3.14359907382299e-07 0.001729522787584184 3.143651360301289e-07 0.0007540451492352357 3.143653101766958e-07 0.0007162692714263865 3.170136987690021e-07 -0.0001123232525192561 \
3.170138717942903e-07 -0.0002901710972538241 3.170144915460445e-07 -0.001202022686018724 3.170145801152216e-07 -0.001365806793032466 3.170149410863549e-07 -0.002110727959526865 \
3.1701506578065e-07 -0.002395793696299351 3.170154296225314e-07 -0.003299857180474864 3.170156008981996e-07 -0.003758114451912169 3.170158948960377e-07 -0.004576312838821549 \
3.170160051044431e-07 -0.004886880824040592 3.170162833584409e-07 -0.005643955697619643 3.1701640463225e-07 -0.00594200199557267 3.17017498254348e-07 -0.00517389603226481 \
3.170176213582281e-07 -0.004409713243767066 3.170177448263029e-07 -0.003462788751204457 3.170178649920999e-07 -0.002366010162083454 3.170179628537677e-07 -0.001346276287748183 \
3.170180695561039e-07 -0.0001076498664581183 3.170181813974884e-07 0.001328007358939307 3.170183173718548e-07 0.003256083960376262 3.170184394010113e-07 0.00514709866632534 \
3.170186278172891e-07 0.008343062029134115 3.170187688058191e-07 0.01093380316938193 3.170189215775226e-07 0.01391176330477175 3.170190642801506e-07 0.01683596409946878 \
3.170192186323876e-07 0.02013443377634912 3.170193744260432e-07 0.02358734537610087 3.170195304833402e-07 0.02715365164079262 3.170196778877403e-07 0.03060642997674319 \
3.170198265044852e-07 0.03415780069914553 3.170199819257017e-07 0.03793559522944389 3.170201403115322e-07 0.04184227512730877 3.170203052511541e-07 0.04596085539464361 \
3.170204795004229e-07 0.05035714787605008 3.170206584435392e-07 0.05491177248689325 3.170208475830321e-07 0.0597604232635115 3.170210503636104e-07 0.06498910043066243 \
3.170212697356369e-07 0.07067233091134768 3.170215005721334e-07 0.07667464705993039 3.170217473839693e-07 0.0831083675499642 3.1702201751608e-07 0.09016243555275107 \
3.170223107041881e-07 0.0978236474935409 3.170226343596258e-07 0.1062798466079799 3.170229979269121e-07 0.1157689210849182 3.170233902204302e-07 0.1259925151671456 \
3.170238386999148e-07 0.1376538644086695 3.170243603994004e-07 0.1511757390224034 3.170249727720439e-07 0.1669844191341421 3.170256494173592e-07 0.1843663871188266 \
3.170264363276496e-07 0.2044554566749352 3.170273175487439e-07 0.2267919980918504 3.170281372923844e-07 0.2474048556006221 3.170288657453285e-07 0.2655829647002126 \
3.17029507221317e-07 0.2814688958417333 3.170300831444854e-07 0.2956305456066151 3.170306204013019e-07 0.3087428400511723 3.17031124292597e-07 0.3209487846516751 \
3.17031601896145e-07 0.3324328152479784 3.170320800193789e-07 0.343838772307344 3.170325321182285e-07 0.3545331600964184 3.170330038845194e-07 0.365596737404158 \
3.170334475813599e-07 0.3759140547845509 3.170339695498976e-07 0.3879344734281669 3.170344970878305e-07 0.399956933836353 3.170348766025744e-07 0.4085271910771138 \
3.170354055641746e-07 0.4203606102508351 3.170358748832554e-07 0.4307444005277802 3.170363100387911e-07 0.4402814026247405 3.170367575161174e-07 0.4500002273945978 \
3.170371975395924e-07 0.4594737646471725 3.170376008413354e-07 0.4680814138276727 3.170379192411013e-07 0.4748254127722248 3.170382892190148e-07 0.4826007100982719 \
3.17038525472097e-07 0.4875314737878706 3.170387605434932e-07 0.4924129045770672 3.170390118828312e-07 0.4975994385012801 3.170393182698655e-07 0.5038799449729535 \
3.170395752283189e-07 0.5091120301871851 3.170397837026154e-07 0.5133309170973237 3.170399840849048e-07 0.5173683849445317 3.170401264786059e-07 0.5202244049244739 \
3.170402754030717e-07 0.5231993726577677 3.170404869493287e-07 0.5274019882470222 3.170407130069516e-07 0.5318780389403845 3.170409075493335e-07 0.5357103559602913 \
3.170410966812289e-07 0.539423417888626 3.170413261282768e-07 0.5439012399750046 3.170415086340828e-07 0.5474563135343053 3.170417459969519e-07 0.5520623276458133 \
3.170420149912601e-07 0.5572695987004129 3.170422639017101e-07 0.5620706638085723 3.170425079185314e-07 0.5667633705755619 3.170427802737438e-07 0.5719926523718327 \
3.170430416698736e-07 0.5769928369418796 3.170432993012793e-07 0.5819084237686675 3.17043546144628e-07 0.586601202059797 3.170437918903539e-07 0.5912552023551558 \
3.170440184678743e-07 0.5955288021520931 3.170442496200641e-07 0.5998646534936181 3.170444559004441e-07 0.6037202012184053 3.170446840212041e-07 0.6079592993751251 \
3.170449064011853e-07 0.6120725203834017 3.17045133377667e-07 0.6162454422471376 3.170453484306168e-07 0.6201823359462864 3.170455778001903e-07 0.6243500782103125 \
3.170458468230649e-07 0.6292041961704016 3.170460698367118e-07 0.6331993632081415 3.170462820912892e-07 0.6369772451758789 3.170464934888789e-07 0.6407176358819484 \
3.17046693558109e-07 0.644236566349866 3.170469231519586e-07 0.6482486956559365 3.170471639888863e-07 0.6524328529570182 3.170473457382733e-07 0.6555667906748446 \
3.170475342865e-07 0.6588018260593631 3.170476873661394e-07 0.6614154033769962 3.170478593744213e-07 0.6643352515471471 3.170480095472396e-07 0.6668697017322168 \
3.170481460645294e-07 0.6691578850264722 3.170482956937163e-07 0.6716547631652277 3.170484234340851e-07 0.673777752640997 3.170485630202226e-07 0.6760856948620949 \
3.170486872589102e-07 0.6781310478824312 3.170488184087496e-07 0.6802827752320969 3.170489428500932e-07 0.6823179209931315 3.170490800809157e-07 0.6845542421253382 \
3.170492003290863e-07 0.6865048414796368 3.170493416605295e-07 0.6887891282595083 3.170494419916407e-07 0.6904033553735033 3.170495631093427e-07 0.6923460943304175 \
3.170496538868777e-07 0.6937948943079848 3.170497511453436e-07 0.6953408241330762 3.170498473532237e-07 0.6968660703265798 3.170499359670681e-07 0.6982647859968389 \
3.170500332550912e-07 0.6997938110311075 3.170501657237294e-07 0.7018622871835729 3.170503209139279e-07 0.7042674555997347 3.170504587918793e-07 0.7063866855441746 \
3.170506036461533e-07 0.7085960165693863 3.170507307079098e-07 0.7105202221428537 3.170508553934701e-07 0.7123960184768648 3.170509680988463e-07 0.7140814553427599 \
3.170510798891907e-07 0.7157437310299281 3.170511806678399e-07 0.7172341607972841 3.170513179462954e-07 0.7192525454101454 3.170514376303672e-07 0.7210013704967912 \
3.170515570598379e-07 0.7227365757678518 3.170516839430602e-07 0.7245692610776365 3.170518083607121e-07 0.7263556789600311 3.170519320935366e-07 0.728121726658988 \
3.170520586890634e-07 0.7299181396522603 3.170521890744641e-07 0.7317573312219798 3.170523118842844e-07 0.7334798522758219 3.170524473200596e-07 0.7353678990088863 \
3.170525486098379e-07 0.7367723836293941 3.170526562323338e-07 0.7382576460517265 3.170527457604157e-07 0.7394878879617913 3.170528603087849e-07 0.7410528648863303 \
3.170529483370413e-07 0.7422487366778059 3.170530554151068e-07 0.7436953530868765 3.170531854801004e-07 0.7454403311053276 3.170532967597954e-07 0.7469230742113165 \
3.170534013783548e-07 0.7483084058091373 3.170535254613402e-07 0.7499400420429273 3.170536737621685e-07 0.7518749696944975 3.170537951620328e-07 0.7534462209622173 \
3.170539096027802e-07 0.7549170836379747 3.170540499400977e-07 0.7567069362027918 3.170541917029811e-07 0.7584995177563068 3.170543095039188e-07 0.759977341175643 \
3.170544374807853e-07 0.761570846386187 3.170545791832092e-07 0.7633205808366864 3.170546966945227e-07 0.7647599110190483 3.170548422997917e-07 0.7665289162262866 \
3.170549639940994e-07 0.7679951561698679 3.170550827247088e-07 0.7694149786178283 3.170552050113037e-07 0.7708662727382939 3.170553320558197e-07 0.77236234268503 \
3.170554416997921e-07 0.7736439866494906 3.170555673867047e-07 0.7751025186690397 3.170556734018052e-07 0.776323977486031 3.170558089877718e-07 0.7778743028704433 \
3.170559339507686e-07 0.7792913979962601 3.17056059856921e-07 0.7807070123991936 3.17056175124167e-07 0.7819915514687489 3.170562814286401e-07 0.7831664991275713 \
3.17056419833432e-07 0.7846822315516878 3.170565691298821e-07 0.7862997378875561 3.170567146373276e-07 0.7878588534534761 3.170568340418389e-07 0.7891257303126159 \
3.170569691346634e-07 0.7905455128963393 3.170570903878263e-07 0.7918076974797237 3.170572333811048e-07 0.7932816011184505 3.170573775854105e-07 0.7947523458802197 \
3.170575031222391e-07 0.7960199014141693 3.170576221686118e-07 0.7972110037065316 3.170577341044954e-07 0.7983213107123885 3.170578389760474e-07 0.7993531099923881 \
3.170579342264591e-07 0.8002831901653534 3.170580705697047e-07 0.8016020813281191 3.170581873938354e-07 0.8027203407102198 3.170583067984452e-07 0.803852171037294 \
3.170584289052493e-07 0.8049980820693966 3.170585518602505e-07 0.8061401395390313 3.17058678828951e-07 0.8073073595000361 3.170588040685604e-07 0.8084467645495962 \
3.17058934640955e-07 0.8096220968518901 3.170590606314733e-07 0.8107441738369082 3.170591888173857e-07 0.8118738099374113 3.170592943471138e-07 0.8127947795787664 \
3.170593972188869e-07 0.8136847278655364 3.17059490214057e-07 0.8144826950388273 3.170596140106596e-07 0.8155354283166244 3.170597019789174e-07 0.8162769513478326 \
3.170598007099885e-07 0.8171027376706747 3.170599439751418e-07 0.8182889948057973 3.170600792538271e-07 0.8193962136425846 3.170601883684495e-07 0.8202800249700468 \
3.17060336451758e-07 0.8214657808291811 3.170604862226849e-07 0.8226492530953341 3.170606114572855e-07 0.8236267526687548 3.170607554487032e-07 0.8247372275730155 \
3.170608795047738e-07 0.8256825756473101 3.170610299680322e-07 0.8268152483647575 3.17061165678884e-07 0.8278240064655301 3.170612906973921e-07 0.828742521381556 \
3.170614084523219e-07 0.8295983347934622 3.170615544291349e-07 0.8306466023667578 3.170617209384522e-07 0.8318251482734692 3.170618518610282e-07 0.8327390940956469 \
3.170620252884658e-07 0.8339327615268647 3.170621934353481e-07 0.8350717495747054 3.170623632702773e-07 0.8362042975620877 3.170625441950479e-07 0.8373912937861997 \
3.170626872933069e-07 0.8383160748488641 3.170628013791983e-07 0.8390446117604563 3.170629315531841e-07 0.8398665237782376 3.170630333942664e-07 0.8405024977857931 \
3.170631502136154e-07 0.8412243379523001 3.170632870780449e-07 0.8420597162999857 3.170634848766686e-07 0.8432475311273343 3.170636764807398e-07 0.8443767279905872 \
3.170638859212216e-07 0.8455874169714939 3.170640678468519e-07 0.8466193100105236 3.170642649799575e-07 0.8477171434207121 3.170644383298479e-07 0.8486653666163242 \
3.170646213292318e-07 0.8496493024239481 3.17064792495495e-07 0.8505537352954988 3.170649671272818e-07 0.8514606693963016 3.170651423896692e-07 0.8523550102558151 \
3.170653185417845e-07 0.8532381479010797 3.170655088128238e-07 0.8541746551565574 3.170656994147745e-07 0.85509499218684 3.170659000624008e-07 0.8560449689899254 \
3.170660926729659e-07 0.8569390259424264 3.170663033306522e-07 0.8578972157030333 3.170665314560509e-07 0.8589122247267402 3.170667972133685e-07 0.8600655879592763 \
3.17067095837813e-07 0.8613244245924475 3.170673721693318e-07 0.862454900702886 3.170676564023905e-07 0.8635842083919951 3.17067930614306e-07 0.8646423892283146 \
3.170682028423722e-07 0.8656634505877856 3.170684730511913e-07 0.8666487272755322 3.170687302040671e-07 0.8675609437488442 3.170690027863351e-07 0.868501515423508 \
3.170692787713349e-07 0.8694269133137555 3.170695488729115e-07 0.8703069289141475 3.170698487348628e-07 0.8712546000783432 3.170702197689933e-07 0.8723856543073821 \
3.170705147067536e-07 0.8732530157608677 3.170707689975357e-07 0.8739790309043101 3.170710672549513e-07 0.8748056771600844 3.170713408634847e-07 0.8755409825400007 \
3.170715769915496e-07 0.8761583495732972 3.170718173369303e-07 0.876770807053994 3.170720396702121e-07 0.8773233906735478 3.170722336759598e-07 0.8777948466981503 \
3.17072563398506e-07 0.8785737911727464 3.170727185719444e-07 0.8789308835864816 3.17073036347473e-07 0.8796437246174529 3.170732152091701e-07 0.8800342982281311 \
3.170735576710472e-07 0.8807611334253193 3.170737417995192e-07 0.8811407335605206 3.170742166778565e-07 0.8820849466541889 3.170743840740528e-07 0.8824061830950772 \
3.170748499154564e-07 0.8832696475595492 3.170750307376651e-07 0.8835931319180218 3.170755247759143e-07 0.8844450822729043 3.170756661243274e-07 0.8846804878101884 \
3.170762724573853e-07 0.8856498028150036 3.170764245267248e-07 0.8858829444029697 3.170770712152002e-07 0.8868329272509302 3.170771995097231e-07 0.8870138524519416 \
3.170778476269279e-07 0.8878919388991984 3.170779774257916e-07 0.8880607713689423 3.17078755627481e-07 0.8890227771434612 3.170788706844142e-07 0.8891574578072456 \
3.170797263428482e-07 0.8901003239091128 3.170798717076157e-07 0.8902505899439886 3.1708085746403e-07 0.8911948786459364 3.170810785690402e-07 0.8913892999646706 \
3.170822236960192e-07 0.8923206810037944 3.170823549126186e-07 0.892422953350996 3.170836961242674e-07 0.8934189515818408 3.170838475232108e-07 0.8935240845833778 \
3.170853289614591e-07 0.8944568913393511 3.170855678408922e-07 0.8945912088657246 3.170873371610739e-07 0.8954685138428928 3.170877263108405e-07 0.895637400736999 \
3.170901199766276e-07 0.896526474291006 3.170905956894499e-07 0.8966764365754722 3.17094011699057e-07 0.8975478548673914 3.170946588490717e-07 0.8976786076740833 \
3.171021370136781e-07 0.8986646932675814 3.171028095907965e-07 0.8987192862546014 3.171952539953667e-07 0.8997188196574962 3.171959172280509e-07 0.8997241906476866 \
3.17385126389945e-07 0.900686595210158 3.173852884627892e-07 0.9007292695325627 3.173879339836764e-07 0.8998161167154269 3.173881025331539e-07 0.8996881690130656 \
3.173893792855451e-07 0.8987393243250013 3.173895814518808e-07 0.8986030018074492 3.173911895612674e-07 0.8976721249252815 3.173913816671926e-07 0.8975774045828077 \
3.174064950498388e-07 0.8985726115129884 3.174066831087563e-07 0.8986004060702872 3.174179880377677e-07 0.8995874924221801 3.174183614235164e-07 0.8996034751727418 \
3.17907373786698e-07 0.9005892719715856 3.179074845548976e-07 0.9006868984798269 3.179082372272589e-07 0.9015617873136611 3.179083390219455e-07 0.9017086238768567 \
3.179088744204902e-07 0.9025814930725723 3.179089769296628e-07 0.9027670217776843 3.179093691484817e-07 0.9035254014384071 3.17909509991429e-07 0.9038129158713877 \
3.179099510288813e-07 0.9047472953155866 3.179101365144842e-07 0.9051402477015744 3.179106528276013e-07 0.9061269394579334 3.17910737502694e-07 0.9062564181617988 \
3.179119721747438e-07 0.9053011091537977 3.179121293881559e-07 0.9045688862145235 3.179123212048176e-07 0.9034162411061901 3.179124880453484e-07 0.9021712267446264 \
3.179126350037463e-07 0.9008824031243315 3.179127491199425e-07 0.8997575350477262 3.179128789920323e-07 0.8983446880789033 3.179129901095502e-07 0.8970273815442567 \
3.179130829140294e-07 0.8958483937359277 3.17913171236719e-07 0.8946639786015808 3.179132744174779e-07 0.8932058048613533 3.179133666254135e-07 0.8918333298588224 \
3.179134541956103e-07 0.8904732289418564 3.179135681890766e-07 0.8886245408236838 3.179137299935004e-07 0.8858564722885236 3.179139149921176e-07 0.8825005184224666 \
3.179141071517853e-07 0.8788219124347386 3.179143085991386e-07 0.874780227084481 3.179145150097281e-07 0.8704697801294994 3.179147001816807e-07 0.8664790122147591 \
3.179148846894051e-07 0.862405115500708 3.179150578412964e-07 0.8585071391690239 3.179152428873213e-07 0.8542751393552932 3.179154202615245e-07 0.8501657390392787 \
3.179155970079552e-07 0.8460284987362284 3.179157631666058e-07 0.8421077870518131 3.179159252110445e-07 0.8382599993991456 3.179160917839251e-07 0.8342839555277276 \
3.179162504376618e-07 0.8304816347052207 3.179164413136869e-07 0.8258903812682129 3.179166162972586e-07 0.8216694867670907 3.179167862433926e-07 0.8175615830390965 \
3.179169514195676e-07 0.8135626411663678 3.179171246116744e-07 0.8093650119631921 3.179172956738769e-07 0.8052155696745213 3.179174637749139e-07 0.801136095357175 \
3.179176541098628e-07 0.7965156511928794 3.179178376918066e-07 0.7920591698039 3.179180456827317e-07 0.7870113041480956 3.179182682592422e-07 0.7816114142545842 \
3.17918457674258e-07 0.7770174196885687 3.17918650984654e-07 0.7723312127316435 3.179187944302406e-07 0.7688556734481145 3.179189438535907e-07 0.7652374066097742 \
3.179190630060629e-07 0.7623536300085233 3.179191757225445e-07 0.7596269484184472 3.179192849974512e-07 0.7569846861296079 3.179194210272094e-07 0.753697254849378 \
3.179195338230239e-07 0.750972995067179 3.179196560209801e-07 0.7480232093637929 3.179197676057526e-07 0.7453311011793381 3.179198923122156e-07 0.7423241425761796 \
3.179200466941669e-07 0.7386034578119585 3.179202134782327e-07 0.7345862494782525 3.179204306429213e-07 0.7293605768817599 3.179206252035101e-07 0.7246835946359503 \
3.179207855343955e-07 0.7208333202545074 3.179209609599985e-07 0.7166251500492028 3.179211507235729e-07 0.7120779400724765 3.179213394518974e-07 0.7075610435995559 \
3.179215212732644e-07 0.7032145396962334 3.179217058706759e-07 0.6988062725207448 3.179218429538112e-07 0.6955348514212173 3.179219962420495e-07 0.6918805091472418 \
3.179221916137951e-07 0.6872279990818534 3.179223477705467e-07 0.6835136309588888 3.179225057227664e-07 0.6797605476340507 3.179227039740297e-07 0.6750570282453686 \
3.179228973199279e-07 0.6704763548785364 3.17923133825274e-07 0.6648822204491218 3.179233200303777e-07 0.6604858901039825 3.179235576526979e-07 0.6548824851665868 \
3.179237444514522e-07 0.6504854738275335 3.179239250092116e-07 0.6462424706993735 3.179240880851561e-07 0.6424159959781919 3.179242326967206e-07 0.6390271817202816 \
3.179243732990706e-07 0.6357379642635244 3.179245001086569e-07 0.632774906490579 3.179246322451931e-07 0.6296924762754078 3.179247584891446e-07 0.6267508340255646 \
3.179248897527744e-07 0.6236963630311418 3.179250188505141e-07 0.6206978048938425 3.179251582761788e-07 0.6174624210713571 3.179253066461711e-07 0.6140261568477932 \
3.179255012030603e-07 0.6095278574984737 3.179256446489368e-07 0.6062198040692683 3.179258791091827e-07 0.6008245134060309 3.179260510074948e-07 0.5968818013610552 \
3.179262639280334e-07 0.5920102583789468 3.179264363946513e-07 0.5880775912131976 3.179265667191976e-07 0.5851108450968721 3.179266982755174e-07 0.5821241897920357 \
3.179268085055992e-07 0.5796262478458715 3.179269041598466e-07 0.5774603558442819 3.179270033938061e-07 0.5752182923213994 3.179270863119075e-07 0.5733484809858778 \
3.179271652275343e-07 0.5715706040143225 3.179272281563093e-07 0.5701535626562365 3.179272936647862e-07 0.5686800671140783 3.179273741508387e-07 0.5668736364148982 \
3.179274240168465e-07 0.5657560592102344 3.179274732056154e-07 0.5646541775062763 3.179275346754008e-07 0.5632780399140616 3.179275825969294e-07 0.5622058085646952 \
3.179276334416479e-07 0.5610687758404553 3.179276925419032e-07 0.5597501790023616 3.1792775115623e-07 0.5584442118409422 3.179278267823233e-07 0.5567607189607793 \
3.17927897341035e-07 0.5551915720267918 3.17927986471042e-07 0.5532116467156011 3.1792807569462e-07 0.5512351177508077 3.179281609982305e-07 0.5493490637975145 \
3.17928248625197e-07 0.5474138635528197 3.179283456271202e-07 0.545274424894262 3.179284499728913e-07 0.5429792414815097 3.179285662643155e-07 0.5404269323775457 \
3.17928672601932e-07 0.5380963700835184 3.179287843108152e-07 0.5356536306660374 3.179288966052949e-07 0.5332047801427824 3.179290238028543e-07 0.5304364255197962 \
3.17929146572528e-07 0.5277698476303582 3.179292887969246e-07 0.5246912237717902 3.179294251600566e-07 0.5217463069543907 3.179295773811234e-07 0.5184691491721333 \
3.179297370173294e-07 0.5150420887864461 3.179299129925215e-07 0.5112761258030903 3.179301015011087e-07 0.5072591542828934 3.179303085676898e-07 0.5028616940969075 \
3.179305335096624e-07 0.4981043078903621 3.179307849056189e-07 0.4928144328841237 3.179310213311851e-07 0.4878598554762091 3.179313184949192e-07 0.4816683149127979 \
3.179316091722113e-07 0.4756487143466775 3.17931917027196e-07 0.469313240945046 3.179322308529534e-07 0.4628991126846517 3.179325599943131e-07 0.4562163541974347 \
3.179328933724197e-07 0.4494927613461197 3.179332249990283e-07 0.4428490490857003 3.179335465484253e-07 0.4364504708187015 3.179338742242378e-07 0.4299742838549845 \
3.179342218438604e-07 0.4231546934710667 3.179345550651743e-07 0.4166645133789623 3.179349009744022e-07 0.4099771621835854 3.179353463882216e-07 0.4014400148089548 \
3.179357041780923e-07 0.3946500490499754 3.179360183349117e-07 0.3887397205534429 3.179364027453916e-07 0.3815756289527631 3.179367327200365e-07 0.3754830843203271 \
3.179370179301253e-07 0.3702633801070484 3.179373262203822e-07 0.3646649204592909 3.179376060174434e-07 0.3596257204303125 3.179378320117929e-07 0.3555880084110294 \
3.179380468497475e-07 0.3517755993421203 3.179382452848198e-07 0.3482769933469286 3.179384492243371e-07 0.3447071465415313 3.179386597603963e-07 0.3410461989361561 \
3.179389167345215e-07 0.3366091000429626 3.179391579951288e-07 0.3324763702393667 3.179393895688451e-07 0.3285420159269506 3.179396042222912e-07 0.3249208057821749 \
3.17939825046275e-07 0.3212218866489027 3.179400262928671e-07 0.3178749657716667 3.179402293821204e-07 0.3145250552959265 3.179404272269915e-07 0.3112865758726304 \
3.179406140799367e-07 0.3082497660855442 3.179408080166626e-07 0.3051208532403978 3.179410117613171e-07 0.30185834615803 3.179411904885829e-07 0.2990186060348319 \
3.179414281343783e-07 0.2952727068736475 3.179416278966111e-07 0.2921508861588616 3.179418295254275e-07 0.2890253490052915 3.179420549918856e-07 0.285561995332 \
3.17942221086285e-07 0.2830312764183137 3.179423997053871e-07 0.2803277612349699 3.179425814095885e-07 0.2775983111934518 3.179427700433049e-07 0.2747882307029562 \
3.17942947466508e-07 0.2721695222189568 3.179431246596456e-07 0.2695724116247911 3.179432847315606e-07 0.2672552081803913 3.179434051322386e-07 0.2655193337608355 \
3.179435529583031e-07 0.2633957862580221 3.179436815880755e-07 0.2615692882062232 3.179437837936585e-07 0.2601227034409412 3.179439020289393e-07 0.2584516051170885 \
3.179440224822997e-07 0.2567534139348401 3.179441461906177e-07 0.2550183706610066 3.179442644426428e-07 0.2533694204037282 3.179443922957733e-07 0.2515887492000971 \
3.179445125816039e-07 0.249915736161692 3.179446652612099e-07 0.2477917697339537 3.179448001739884e-07 0.2459264316518071 3.1794492881341e-07 0.2441493177932957 \
3.17945086528788e-07 0.2419705448111171 3.179452132100908e-07 0.2402201997919771 3.179453485361585e-07 0.2383592392624043 3.179454874487268e-07 0.2364550510890953 \
3.179456052210313e-07 0.2348405558720491 3.179457644918496e-07 0.2326580599570062 3.179459010137043e-07 0.2307878375452989 3.179460422456504e-07 0.2288626996658652 \
3.179461480586929e-07 0.2274220928889542 3.179462784016402e-07 0.2256484734765637 3.17946378112453e-07 0.2242944442559471 3.179464809338881e-07 0.2228991027388591 \
3.179465543495424e-07 0.2219046249368765 3.179466341811041e-07 0.2208265149641777 3.179467042283352e-07 0.2198809561195558 3.179467546314264e-07 0.2192009305305119 \
3.179468068832254e-07 0.2184966408607167 3.179468861207429e-07 0.2174292050927151 3.179469279646958e-07 0.2168658036437602 3.179469673046481e-07 0.216336351877609 \
3.179470103400575e-07 0.2157575332679269 3.179470545074838e-07 0.2151638767852215 3.179471282732236e-07 0.2141731338947761 3.179471637852207e-07 0.2136967174286463 \
3.179472115000211e-07 0.2130606706933813 3.17947272229561e-07 0.2122518321687151 3.179473404867867e-07 0.2113438957752176 3.179474130085659e-07 0.2103801801047663 \
3.179474856831929e-07 0.2094152724966429 3.179475939991808e-07 0.2079788886429202 3.179476916703231e-07 0.20668564243436 3.179478032218192e-07 0.2052110974836689 \
3.179479017572532e-07 0.2039136008387587 3.179480052503929e-07 0.2025572972554956 3.179481011521277e-07 0.2013021587886929 3.17948203780057e-07 0.1999606878451601 \
3.179483066031699e-07 0.1986207062101238 3.179484167227972e-07 0.1971897063011611 3.179485254183531e-07 0.1957815523781236 3.179486450955818e-07 0.1942360962608612 \
3.179487553732606e-07 0.192818053470401 3.179488634364806e-07 0.1914343471929882 3.179489885351485e-07 0.1898375077741012 3.179490785049817e-07 0.1886931806549971 \
3.179491571919347e-07 0.1876950225942949 3.17949234476806e-07 0.1867173468865102 3.179493209853825e-07 0.1856271834369256 3.179494199345929e-07 0.1843848109964498 \
3.179494904434582e-07 0.1835017733581451 3.179495618945114e-07 0.1826096997732476 3.179496670398458e-07 0.1813018727451555 3.179497462794755e-07 0.1803200401832796 \
3.179498273633695e-07 0.1793174195483187 3.179499208553101e-07 0.1781663090788374 3.179500216312847e-07 0.1769308188703378 3.179501713433884e-07 0.175105380089017 \
3.179502871327037e-07 0.1737009932372819 3.179504381380806e-07 0.1718807311127691 3.179505492465001e-07 0.1705485445502526 3.179506913729584e-07 0.168854666407182 \
3.179508090313791e-07 0.167460358327668 3.179509139359749e-07 0.1662230887079887 3.179510089985733e-07 0.1651069099307241 3.179511024298279e-07 0.1640147999883682 \
3.179512034764903e-07 0.1628388413495604 3.179512998233979e-07 0.1617223204899406 3.179513969756437e-07 0.1606011553546776 3.179514800242163e-07 0.1596469772300165 \
3.179515900618698e-07 0.1583897228513109 3.179516723644316e-07 0.1574542248873526 3.179517773641412e-07 0.156267858580057 3.179518550602102e-07 0.1553950893374849 \
3.179519378796887e-07 0.1544690878994293 3.179520195415937e-07 0.1535604570452941 3.179521088908844e-07 0.152571060794856 3.1795218460332e-07 0.1517364980793458 \
3.179522671659343e-07 0.1508307726525361 3.179523437473671e-07 0.1499942554682341 3.179524120352535e-07 0.1492531084507001 3.179525054022655e-07 0.1482449401818621 \
3.179525745556768e-07 0.1475015570698688 3.179526501800083e-07 0.1466917482325688 3.179527117291286e-07 0.1460354497178591 3.179527789778923e-07 0.1453208357145237 \
3.179528500398917e-07 0.1445684785944268 3.179529255373203e-07 0.143772322008306 3.179529844488598e-07 0.1431546944759192 3.179530611224699e-07 0.1423563022825049 \
3.179531414432115e-07 0.1415233898163201 3.179532145945195e-07 0.1407682091691316 3.179533087509408e-07 0.139800669784813 3.179533803551248e-07 0.1390684367429364 \
3.179534538159005e-07 0.1383201464810226 3.179535373276515e-07 0.1374732033664194 3.179536268067954e-07 0.1365744208092838 3.179536918717003e-07 0.1359252211013016 \
3.179538039977229e-07 0.1348115665849295 3.179538691838635e-07 0.1341670699454539 3.179539392221084e-07 0.1334770515823289 3.179539995271633e-07 0.1328849371768329 \
3.179540545379868e-07 0.1323464455745446 3.17954142654965e-07 0.1314871014507438 3.179541834412595e-07 0.131090685705856 3.179542871440105e-07 0.1300923774523848 \
3.179543304565801e-07 0.1296773144713907 3.17954391675178e-07 0.1290920262082728 3.179544365118974e-07 0.1286643765206081 3.179545241079233e-07 0.127831527987147 \
3.179545656618794e-07 0.1274377589706847 3.179546255233895e-07 0.1268718307679372 3.179546973671149e-07 0.1261946708524367 3.179547535798413e-07 0.1256664967939027 \
3.179548160673402e-07 0.125081039250218 3.179548902953232e-07 0.1243877959456236 3.179549649763284e-07 0.1236954937854857 3.179550521595408e-07 0.1228905551604285 \
3.179551205580918e-07 0.1222610287411191 3.17955201128775e-07 0.1215216597888775 3.179552824242559e-07 0.120778012781285 3.179553493407808e-07 0.1201677797529914 \
3.179554321577256e-07 0.1194156054679852 3.179554913464481e-07 0.1188799972037829 3.179555572674477e-07 0.1182853617472536 3.179556371414917e-07 0.1175675408705869 \
3.179557136372899e-07 0.1168828806096336 3.179557950994005e-07 0.1161574242846086 3.179558935702815e-07 0.1152852106851665 3.179559686806303e-07 0.114622623867465 \
3.179560716684202e-07 0.1137180076826871 3.179561458523715e-07 0.1130691786503039 3.179562434718251e-07 0.1122190343868764 3.179563392827804e-07 0.1113890351962442 \
3.179564351312053e-07 0.110562946039519 3.179565160694118e-07 0.1098685209805978 3.179566044526832e-07 0.1091134439098378 3.179567030526616e-07 0.108274944429282 \
3.179567758368656e-07 0.1076586405352824 3.17956865109775e-07 0.1069058608836731 3.179569270917884e-07 0.1063852406583179 3.179569896849557e-07 0.1058613310701875 \
3.179570749071042e-07 0.105150777260444 3.179571803694782e-07 0.1042758147594986 3.179572601999606e-07 0.1036167065755082 3.179573409142144e-07 0.1029530974056021 \
3.179574235279495e-07 0.1022768941101355 3.179574939725617e-07 0.1017026162492672 3.179575972319282e-07 0.1008648142128753 3.179576700720535e-07 0.1002767039768694 \
3.179577557123351e-07 0.09958839426015198 3.179578745140727e-07 0.09863954321822334 3.179579421518979e-07 0.09810250133474645 3.179580119020204e-07 0.09755100310752296 \
3.17958089237e-07 0.09694230106952094 3.179581816572539e-07 0.09621870517595056 3.17958253354782e-07 0.09566033062548993 3.179583391719417e-07 0.09499542738017568 \
3.17958441597192e-07 0.09420660575030523 3.17958534892083e-07 0.09349264652734962 3.179586312085565e-07 0.09276005482712441 3.179587081108176e-07 0.09217843893134048 \
3.179588015908053e-07 0.09147541043939374 3.179588808332317e-07 0.09088281005358793 3.17958995455426e-07 0.0900310686188453 3.179591250636858e-07 0.08907580221142102 \
3.179592583208766e-07 0.08810234090122065 3.179594023507657e-07 0.08705990691030199 3.179595595189096e-07 0.08593388720602639 3.179597092953871e-07 0.08487214151476249 \
3.179598717629786e-07 0.08373303262435308 3.179600149429843e-07 0.08273971668837025 3.17960167622107e-07 0.0816913199659166 3.179603018918778e-07 0.08077856892457436 \
3.179604436441555e-07 0.07982444400446118 3.179605786438163e-07 0.07892500874648442 3.179607206012136e-07 0.07798882638923543 3.179608674486441e-07 0.07703088995320664 \
3.17961019894053e-07 0.07604750978240994 3.179611851127758e-07 0.07499422991502351 3.179613492506213e-07 0.07396067809208305 3.17961526112024e-07 0.07286119333145537 \
3.179617164535802e-07 0.07169407515132428 3.179619274100931e-07 0.07042030845332216 3.179621478192316e-07 0.0691121699798517 3.17962383344393e-07 0.06773900533435212 \
3.179626437937674e-07 0.0662496528900723 3.179629394591772e-07 0.06459579389282195 3.179632445814628e-07 0.06292902455725519 3.179636095760241e-07 0.06098725515092194 \
3.179640044568393e-07 0.05894944116461652 3.179644108474933e-07 0.05692211719668253 3.179648265730353e-07 0.05491854459141238 3.179651893793582e-07 0.0532251207245777 \
3.179655339806477e-07 0.05166301626031383 3.179658491605098e-07 0.05027284652491828 3.179661446898748e-07 0.04900240867073854 3.179664426703825e-07 0.04775344010203557 \
3.179667184691725e-07 0.04662857640242725 3.179669972437684e-07 0.04551884372531381 3.179672611786382e-07 0.04449205559535935 3.179675372013766e-07 0.04344260531795661 \
3.179678161576298e-07 0.04240676967887352 3.179681298509633e-07 0.04127097799875453 3.179683658512502e-07 0.04043636567030678 3.179686216459875e-07 0.03955075129286261 \
3.17968881769487e-07 0.03867033103466553 3.179691519047594e-07 0.03778142289416799 3.179694311247467e-07 0.03688501536902895 3.179697129633963e-07 0.03600226561751176 \
3.17969989839066e-07 0.03515600409566183 3.179702689326649e-07 0.03432349610146775 3.179705018102725e-07 0.03364444121149882 3.179707856469894e-07 0.03283527291840588 \
3.179710257519236e-07 0.03216626441466421 3.179712655507464e-07 0.0315119836023277 3.179715048279204e-07 0.03087436846876356 3.179717400849421e-07 0.03026290129608995 \
3.17971971011964e-07 0.02967475842909434 3.17972186001007e-07 0.02913788335257221 3.179725881554596e-07 0.02816043724496065 3.179727868782784e-07 0.02768988489927659 \
3.179731605612946e-07 0.0268265706552881 3.179733473596173e-07 0.02640514011949098 3.179736949193039e-07 0.02563810810034544 3.179738168487671e-07 0.0253740445387235 \
3.179741993202075e-07 0.02456430406701914 3.179743700282368e-07 0.02421180751242828 3.179748271256211e-07 0.02328894863848502 3.179750127580069e-07 0.0229225623309489 \
3.179753762152598e-07 0.02221803970155307 3.179755965826125e-07 0.02179832126591805 3.179760543089696e-07 0.02093867417890744 3.179761897285988e-07 0.02068687731869814 \
3.179767196240474e-07 0.01972418011126781 3.17976838945017e-07 0.01951377505543128 3.179774047306961e-07 0.01856069823426573 3.17977569110437e-07 0.0182962226476828 \
3.179781876557339e-07 0.01735107502432094 3.179783577099333e-07 0.01710418363667701 3.179788898421661e-07 0.01636278834442301 3.179790869261418e-07 0.01610013864443424 \
3.179798100452149e-07 0.01517806887136661 3.179799746753809e-07 0.01497647803580381 3.179807238007678e-07 0.01409711804523418 3.179808571001203e-07 0.01394643716836554 \
3.179817173537587e-07 0.01301449210748497 3.179818524573794e-07 0.01287422877142914 3.179827950348197e-07 0.01193816285908547 3.179829586305738e-07 0.01178202925388569 \
3.179839599872008e-07 0.0108653384673985 3.179840975299883e-07 0.01074500730514941 3.179853196363713e-07 0.009765086624518643 3.179854265890839e-07 0.00968516078425012 \
3.179868307805774e-07 0.008707372520026449 3.179869356112841e-07 0.008639312158696611 3.179884704482461e-07 0.00767719340797631 3.179885657315476e-07 0.007617466071856052 \
3.179901745288685e-07 0.006680264535635283 3.179903086056077e-07 0.006609506832171614 3.179924056185594e-07 0.005610918814474722 3.179926361631908e-07 0.005510783990371394 \
3.179949591584347e-07 0.004586584533412417 3.179954404886379e-07 0.004413562233393853 3.179982780502688e-07 0.003511943147855551 3.179988229699549e-07 0.003360532104877318 \
3.180029471783516e-07 0.002408309874554541 3.180034909020111e-07 0.002305347543005144 3.180093621912368e-07 0.001333291345955189 3.180096050564212e-07 0.001286469439319215 \
3.180239329487719e-07 0.0002880570268237783 3.180240775074142e-07 0.0002853642807229123 3.206613564285128e-07 -0.0006859155495331031 3.206614959836499e-07 -0.000901903561740745 \
3.206620050775826e-07 -0.001859438188174024 3.206620945650851e-07 -0.002052812934985279 3.206624579599451e-07 -0.00291126965001638 3.206625489820155e-07 -0.003143482006111167 \
3.206629144200523e-07 -0.004127275145644371 3.206630246806195e-07 -0.004436819103926468 3.206633367277739e-07 -0.005309594399865315 3.206634394426211e-07 -0.005584800160857357 \
3.206638032904768e-07 -0.006384516484886619 3.206639680812086e-07 -0.006586298968823262 3.206645476774082e-07 -0.005791490933239759 3.206647227875511e-07 -0.004914057272375438 \
3.206648394794853e-07 -0.004132845175365214 3.206649660640906e-07 -0.003100877896798674 3.206650678730126e-07 -0.002132773363901063 3.206651883617228e-07 -0.0008283127610571584 \
3.206652788087988e-07 0.0002599396317828252 3.206653766989305e-07 0.001541559978017447 3.206654757632395e-07 0.002943971508909197 3.206656465705158e-07 0.005594911825788154 \
3.206658683385388e-07 0.00944046646559993 3.206660642423845e-07 0.01317281463966807 3.206662231237664e-07 0.01639870563256729 3.206663875522633e-07 0.01989779506365397 \
3.206665419182936e-07 0.02331070396473752 3.20666700690818e-07 0.02693200463312963 3.20666847428777e-07 0.03036422445567413 3.206669960527481e-07 0.0339113704936035 \
3.20667151667245e-07 0.03768995713197771 3.206673089092589e-07 0.04156499463828727 3.206674738020577e-07 0.04567927910670353 3.206676472215784e-07 0.05005184210758699 \
3.20667825915293e-07 0.05459761989277153 3.206680145311307e-07 0.05943075613080645 3.206682154312736e-07 0.06460909294799391 3.206684348880646e-07 0.0702927970720964 \
3.206686644343515e-07 0.07626037976612585 3.20668910133291e-07 0.08266408948881369 3.206691786982297e-07 0.08967663153997742 3.206694700401445e-07 0.09728936802005522 \
3.206697917081718e-07 0.1056939239977524 3.20670152022263e-07 0.1150987971742611 3.206705430017012e-07 0.1252892839303718 3.206709864165172e-07 0.1368209045172546 \
3.206715027296046e-07 0.1502062239570841 3.206721089348208e-07 0.16586000516691 3.206727801918478e-07 0.1831102247110778 3.206735596915048e-07 0.20301830483439 \
3.206744320013886e-07 0.2251413938832897 3.206752623367137e-07 0.2460320778586349 3.206759936670634e-07 0.264292249712138 3.206766416128433e-07 0.280346965484095 \
3.206772249233171e-07 0.29469740877147 3.20677760655584e-07 0.3077798509628869 3.20678263914169e-07 0.3199778888071559 3.2067874911767e-07 0.3316516836183861 \
3.206792280403756e-07 0.3430829066939081 3.20679674471008e-07 0.3536501814456421 3.206801488007181e-07 0.3647819492304352 3.206805979917124e-07 0.3752331958288908 \
3.206810884639696e-07 0.3865396207984229 3.206816170367226e-07 0.3985997842463301 3.206819881810625e-07 0.4069920784971888 3.206825159354181e-07 0.4188173133762567 \
3.206829782921778e-07 0.4290642331729484 3.206834506243179e-07 0.4394285229343968 3.206839324090407e-07 0.4498981261869666 3.206839654481592e-07 0.4506126593745911 \
3.206840032071518e-07 0.45142837879914 3.20684078725137e-07 0.4530572051633331 3.206842297611073e-07 0.4563088938659436 3.206844372803726e-07 0.460764549126051 \
3.206846253191843e-07 0.4647825567212808 3.206848443283984e-07 0.469441659996985 3.206850871594094e-07 0.4745824626509371 3.206853869350375e-07 0.4808894567257585 \
3.206856247281872e-07 0.4858624696070272 3.206858879495879e-07 0.4913374535260851 3.206861488471327e-07 0.4967277906005185 3.206863784012197e-07 0.5014431429135263 \
3.206866014614136e-07 0.506003872007333 3.206868030374043e-07 0.5100983586086808 3.206869518674631e-07 0.51310967141356 3.206871961785157e-07 0.5180317772556589 \
3.206873287837491e-07 0.5206893064287169 3.206874681403308e-07 0.5234717264876519 3.206876791057242e-07 0.5276623644271943 3.206878539796058e-07 0.5311266030493931 \
3.206881220278524e-07 0.5364094032095129 3.206883170535098e-07 0.5402319029111832 3.206884966150174e-07 0.5437361368949839 3.206887475711459e-07 0.5486228351952749 \
3.20689024979257e-07 0.5540035987981641 3.20689308928559e-07 0.5594901708581531 3.206895645658505e-07 0.5644152233389156 3.206898555480696e-07 0.570006772487656 \
3.20690115853754e-07 0.5749917787111524 3.206903842978737e-07 0.5801232573974072 3.206906270630043e-07 0.5847450403362237 3.206908835942051e-07 0.5896146675871002 \
3.206911097576483e-07 0.59388771440121 3.206913470991427e-07 0.5983512154742827 3.206915564878602e-07 0.6022720321566808 3.206917702606284e-07 0.6062574570422776 \
3.206920237134688e-07 0.6109557890491497 3.206922265678164e-07 0.6146943332140289 3.206924193723378e-07 0.6182333111593361 3.206926096773651e-07 0.6217090173923294 \
3.206928003358541e-07 0.6251694921350958 3.206930029137797e-07 0.6288260100903066 3.206932656625422e-07 0.6335359534764116 3.206934946302321e-07 0.6376100987349322 \
3.206937145778672e-07 0.6414991146358265 3.206939402625401e-07 0.6454625140719233 3.206941491499662e-07 0.6491091855837361 3.206943708035853e-07 0.652957810138281 \
3.206945556930106e-07 0.6561429680377227 3.206947457075645e-07 0.6594017273991298 3.206948958626861e-07 0.6619630641908443 3.206950707405929e-07 0.6649292185271485 \
3.206952164613095e-07 0.6673855496832628 3.206953524938417e-07 0.6696641287411549 3.206955008561211e-07 0.672138295335571 3.206956303038336e-07 0.6742883907026684 \
3.206957641695307e-07 0.6764996355878535 3.206958925139303e-07 0.6786115243545502 3.206960179020585e-07 0.6806677490053815 3.20696147367755e-07 0.6827843190971332 \
3.206962783489702e-07 0.6849171426143115 3.206964267220724e-07 0.6873221141612875 3.206965347848267e-07 0.6890667486235877 3.206966633164996e-07 0.6911333958680312 \
3.206967987562836e-07 0.6933004139195943 3.206969236906072e-07 0.6952876996714908 3.206970494478751e-07 0.6972799977491608 3.206971559637663e-07 0.6989584331773744 \
3.20697273081655e-07 0.7007929859467624 3.206973916214008e-07 0.7026383448210159 3.206975149247975e-07 0.704545102273978 3.206976180976957e-07 0.7061304255463237 \
3.206977690688591e-07 0.7084341141567283 3.206978853230653e-07 0.7101955266062138 3.206980158834539e-07 0.7121605601685687 3.206981344459821e-07 0.7139335830373704 \
3.206982405198518e-07 0.7155108922888329 3.206983405447916e-07 0.716990346352101 3.206984778700066e-07 0.719009255813789 3.206985965313623e-07 0.7207429633399333 \
3.20698718230586e-07 0.7225107522614664 3.206988434131515e-07 0.7243181860083944 3.206989654329653e-07 0.7260693242762759 3.206990934647187e-07 0.7278954552757622 \
3.20699217946458e-07 0.7296603419865877 3.206993462457807e-07 0.7314685590147565 3.206994733395841e-07 0.7332489547570846 3.206995993644231e-07 0.7350034830462163 \
3.2069970210311e-07 0.7364262918236342 3.206998167758557e-07 0.7380063527755659 3.206998981819179e-07 0.7391232259175492 3.207000173814378e-07 0.7407496908814458 \
3.207001100237781e-07 0.7420059782745783 3.207002481828348e-07 0.7438668850244906 3.207003792383344e-07 0.7456179978167152 3.207005093705019e-07 0.7473439783685625 \
3.207006143445769e-07 0.7487266533969134 3.207007534844189e-07 0.7505456565005918 3.207009074287187e-07 0.7525407731682957 3.207010293729987e-07 0.7541080835708853 \
3.207011769193594e-07 0.7559892974429111 3.20701298924537e-07 0.7575320275232224 3.207014476244666e-07 0.7593968175435225 3.207015816710922e-07 0.7610632318338031 \
3.207017039243472e-07 0.7625711443351471 3.207018167902567e-07 0.763953046884334 3.207019596412247e-07 0.7656882893306027 3.207020863641194e-07 0.7672149413549471 \
3.207022021689945e-07 0.7685995877768005 3.207023319108228e-07 0.7701390587657672 3.207024476492106e-07 0.7715019052061673 3.207025706016372e-07 0.7729391548276606 \
3.20702688317297e-07 0.7743051053122872 3.207027942872733e-07 0.7755262985206828 3.207029106984675e-07 0.7768586864857919 3.207030173164004e-07 0.7780703956921795 \
3.207031295151206e-07 0.7793369495935717 3.207032161836897e-07 0.7803089322889447 3.207033195691813e-07 0.7814603789665585 3.207034327334326e-07 0.7827108149434853 \
3.207035383807156e-07 0.783868819044773 3.207036477202729e-07 0.7850578567336689 3.207037548972878e-07 0.786214126597127 3.20703884303365e-07 0.7875981444497275 \
3.207039967207506e-07 0.7887899291890393 3.207041201084898e-07 0.7900869036018625 3.207042375588255e-07 0.7913106402786101 3.207043810857437e-07 0.7927918312347375 \
3.20704496005322e-07 0.7939667362870242 3.207046347277352e-07 0.7953719780830618 3.207047727598755e-07 0.7967562205547866 3.207048822530295e-07 0.7978444364842524 \
3.207049832714595e-07 0.7988406866985471 3.207050843594198e-07 0.7998302780396641 3.207052167466158e-07 0.8011146558616069 3.207053354720369e-07 0.8022550163876687 \
3.207054572565424e-07 0.8034134048507504 3.20705576346336e-07 0.8045351524060473 3.207056975508533e-07 0.8056657048884367 3.207058291946645e-07 0.8068811249615274 \
3.207059522127029e-07 0.8080052413861453 3.207060798230234e-07 0.8091594649786741 3.20706210891683e-07 0.8103325925767672 3.207063342120463e-07 0.8114249716726942 \
3.207064421363105e-07 0.8123719892944993 3.207065499317031e-07 0.8133095350680949 3.20706631652631e-07 0.8140147772069938 3.207067485202474e-07 0.815015186305849 \
3.207068395812563e-07 0.8157880755829442 3.207069737498876e-07 0.8169164295805346 3.2070711832076e-07 0.8181184617099191 3.207072518231266e-07 0.8192158725965917 \
3.207073617890376e-07 0.8201107352847025 3.207075056546975e-07 0.8212684563313245 3.207076589602621e-07 0.8224861772268215 3.207077866985553e-07 0.8234883060891934 \
3.207079273408909e-07 0.8245786478120171 3.207080531244556e-07 0.8255423809867173 3.207082077424273e-07 0.8267124309768116 3.207083401541937e-07 0.8277017767197102 \
3.207084664337982e-07 0.8286345641820314 3.207085840641131e-07 0.8294941055817234 3.207087322309758e-07 0.8305638349826423 3.207088993752207e-07 0.8317531470681401 \
3.207090319938809e-07 0.832683775428688 3.20709204938569e-07 0.8338803479528284 3.207093733252244e-07 0.8350269493631071 3.207095428597542e-07 0.8361634673386688 \
3.207097242289089e-07 0.8373596561587384 3.207098668614913e-07 0.8382862741713709 3.207099807973396e-07 0.8390176620397163 3.207101115711344e-07 0.8398476357987267 \
3.207102132250742e-07 0.8404856735008092 3.207103297188026e-07 0.8412091703399448 3.207104652363492e-07 0.8420405885319162 3.20710662580143e-07 0.8432318270427018 \
3.20710853245141e-07 0.8443612543037786 3.207110631019802e-07 0.8455804035625291 3.207112440391043e-07 0.8466117334714958 3.207114413745909e-07 0.8477160230260256 \
3.207116151614274e-07 0.8486711109012058 3.207117977428814e-07 0.8496572451898022 3.207119690624607e-07 0.850566499179887 3.207121434475075e-07 0.8514760798656241 \
3.207123188310518e-07 0.8523748177975867 3.207124950632094e-07 0.8532619682996843 3.207126849014518e-07 0.8542000584728613 3.207128756376655e-07 0.8551245802328369 \
3.20713077434399e-07 0.856083442102113 3.207132701277753e-07 0.8569809170305027 3.207134797560765e-07 0.857937542729613 3.207137091938401e-07 0.8589615588718806 \
3.207139749904802e-07 0.8601183337444025 3.207142735657076e-07 0.8613802063570262 3.207145514672209e-07 0.8625196921548358 3.207148356776949e-07 0.8636511027355716 \
3.207151100894824e-07 0.8647118800460076 3.207153822523641e-07 0.8657341977214618 3.207156524214556e-07 0.8667205537246333 3.207159096161394e-07 0.8676338760342862 \
3.207161821558105e-07 0.868575115807136 3.207164581902909e-07 0.8695013130444248 3.207167283429862e-07 0.8703818891200001 3.207170280497877e-07 0.8713292845176382 \
3.207173988672582e-07 0.8724597217497643 3.207176937859212e-07 0.8733269024855727 3.207179480301993e-07 0.8740525764960509 3.207182462541985e-07 0.8748787854419284 \
3.207185198789691e-07 0.8756137195941651 3.207187560179586e-07 0.8762307200963571 3.207189963736862e-07 0.8768427579093606 3.207192187193381e-07 0.8773949085683344 \
3.207194127230722e-07 0.877865919014753 3.207197424471962e-07 0.878644045115768 3.207198976198553e-07 0.8790007149587372 3.207202153732479e-07 0.879712598742095 \
3.207203942386052e-07 0.8801026384247937 3.207207367000935e-07 0.8808283583858193 3.207209208412927e-07 0.8812073588304842 3.207213957461144e-07 0.8821499412898334 \
3.207215631406012e-07 0.8824705695712217 3.207220289718891e-07 0.8833323038036038 3.207222097967714e-07 0.8836551183393088 3.207227038300282e-07 0.8845051821644966 \
3.207228451726029e-07 0.8847400410050358 3.207234515631179e-07 0.8857071861637142 3.207236036356849e-07 0.8859397703602404 3.207242503137577e-07 0.8868873789663725 \
3.207243786102467e-07 0.8870678433440622 3.207250267232453e-07 0.8879435266410994 3.207251565285235e-07 0.8881118897635528 3.20725934785608e-07 0.8890711781604964 \
3.207260497804227e-07 0.8892053868933587 3.207269055110619e-07 0.8901454611437621 3.207270507776287e-07 0.8902951528450479 3.207280365337324e-07 0.8912364417375994 \
3.207282576409459e-07 0.8914302300078862 3.207294027520271e-07 0.892358484239638 3.207295339601744e-07 0.8924604119362172 3.207308752633695e-07 0.8934531785430913 \
3.207310266510305e-07 0.8935579568409697 3.207325081098674e-07 0.8944876667405802 3.207327469902294e-07 0.894621531696939 3.207345164619859e-07 0.8954958910368339 \
3.207349055688235e-07 0.8956641700186337 3.207372993342323e-07 0.8965498195158238 3.207377748942228e-07 0.8966991754584082 3.207418379503871e-07 0.8976977719002629 \
3.20742329424408e-07 0.8977905759376156 3.207506459514872e-07 0.8987839664765119 3.207515658053769e-07 0.8988472044554419 3.208777709459031e-07 0.8998441026240215 \
3.20878784754255e-07 0.8998514601858095 3.210704973474114e-07 0.8990059056521554 3.210707273489741e-07 0.8988405173838494 3.210723422215349e-07 0.8978439928078279 \
3.210725199353886e-07 0.8977495532019018 3.210892857104286e-07 0.8987316330193963 3.210894216988253e-07 0.8987497732072308 3.211048844279385e-07 0.8997471920221268 \
3.211051522925305e-07 0.8997526389354535 3.215889776197985e-07 0.9006560548284696 3.215890984089986e-07 0.9007687033315858 3.215898861800374e-07 0.9017381658104292 \
3.215900203187565e-07 0.901943163319478 3.215905139335305e-07 0.9027850367016239 3.21590658833145e-07 0.9030569221572713 3.215910546405301e-07 0.9038490360455199 \
3.215911744361842e-07 0.9041001886668685 3.215915586097176e-07 0.9049189780371781 3.215916707313647e-07 0.9051556495331843 3.215921780523356e-07 0.9061253139956988 \
3.215922720511916e-07 0.90626859229291 3.215934307008982e-07 0.9055667778886739 3.215935336638317e-07 0.9051589876696525 3.215936175067007e-07 0.9047707260375384 \
3.215937512467522e-07 0.9040404158978201 3.215938519641334e-07 0.9033957423200318 3.215939595799193e-07 0.9026166239542108 3.215940771531732e-07 0.9016533104038295 \
3.21594165418223e-07 0.90085556431878 3.215942850516912e-07 0.8996698288011099 3.215943823733893e-07 0.8986166602050341 3.215944933908277e-07 0.8973222354192386 \
3.215945955004155e-07 0.8960407982554908 3.21594678931815e-07 0.8949326975987755 3.215947831128827e-07 0.8934749428758865 3.215948741996463e-07 0.8921321265381427 \
3.215949667404319e-07 0.8907058396397178 3.2159506189443e-07 0.8891776325191247 3.215951764494069e-07 0.88725933118288 3.215952652925089e-07 0.8857137884271823 \
3.215953635316907e-07 0.8839502506198179 3.215954489018647e-07 0.8823735982707064 3.215955298021067e-07 0.8808434949738935 3.215956027633997e-07 0.8794355441897157 \
3.215956697820454e-07 0.8781198554636557 3.215957383931237e-07 0.8767515715160701 3.215958218880357e-07 0.8750591081124355 3.215958840153664e-07 0.8737811510706814 \
3.215959469979638e-07 0.8724704924326797 3.215960421537153e-07 0.8704632161180945 3.215961427643535e-07 0.8683077530860182 3.215962226435446e-07 0.8665738309361769 \
3.215963069058141e-07 0.8647250601592834 3.215963860160737e-07 0.8629723295901451 3.215964488315189e-07 0.8615696597604833 3.215965362885537e-07 0.8596016864744445 \
3.215966021820844e-07 0.8581079708060287 3.215966702436265e-07 0.856556281928966 3.215967195561343e-07 0.8554267461646872 3.215967747929236e-07 0.85415654045335 \
3.215968155325295e-07 0.8532164928603474 3.215968618342832e-07 0.8521450198670055 3.21596892048343e-07 0.8514441160591502 3.215969210896253e-07 0.8507691938976955 \
3.215969517282201e-07 0.8500558939662993 3.215970130054097e-07 0.8486254874746039 3.215970660779718e-07 0.8473828229799116 3.215971197331653e-07 0.8461232012188223 \
3.215971823904472e-07 0.8446482873934593 3.215972456733951e-07 0.8431545995644786 3.21597336171269e-07 0.8410121009440262 3.215974331690495e-07 0.8387078554355326 \
3.215975161465499e-07 0.8367307351423475 3.215975981509054e-07 0.8347721678896715 3.215976872193066e-07 0.8326403548070889 3.215977717326432e-07 0.8306135893189693 \
3.215978625915234e-07 0.8284303722590877 3.215979545263781e-07 0.8262176456275642 3.215980569573085e-07 0.8237486178045141 3.215981570753404e-07 0.8213320995840899 \
3.215982718962233e-07 0.8185572053828121 3.215983841027604e-07 0.8158423448209959 3.215985090963053e-07 0.8128151787794674 3.215986403567133e-07 0.8096337870015397 \
3.215987856277547e-07 0.8061104108175116 3.215989401353681e-07 0.8023613213197434 3.215991115759889e-07 0.7981999722344618 3.215992756257814e-07 0.794217661721315 \
3.215994600412032e-07 0.7897413884478564 3.215996665335768e-07 0.7847307375046715 3.215998560274198e-07 0.7801344622909899 3.216000494211826e-07 0.775444374634302 \
3.216002499880375e-07 0.7705834242206392 3.21600397552439e-07 0.7670092004965298 3.216005275638896e-07 0.7638619034739171 3.216006624283032e-07 0.7605987503374771 \
3.216007689187539e-07 0.7580234999254772 3.216009006085467e-07 0.7548403390839162 3.216010070329759e-07 0.7522693550468039 3.21601150211605e-07 0.7488125398635642 \
3.216013113387162e-07 0.7449250928176189 3.216014295655331e-07 0.7420746008290786 3.216015997983541e-07 0.7379721584775248 3.216017657246235e-07 0.7339761998059781 \
3.216019852669538e-07 0.7286940862104242 3.216021784540779e-07 0.724050920820232 3.216023533680413e-07 0.719851304223293 3.216025203151389e-07 0.7158476177432674 \
3.216027078061003e-07 0.711355754450834 3.216028952345367e-07 0.7068709122373377 3.216030635710959e-07 0.7028473835914892 3.216032564016302e-07 0.6982428782038785 \
3.216033964513775e-07 0.694901318858167 3.216035527086664e-07 0.6911769338170629 3.216037468781132e-07 0.6865540563080536 3.216039059846016e-07 0.6827702245679255 \
3.216040643446318e-07 0.679008548037742 3.216042596617402e-07 0.6743756772263459 3.216044700905194e-07 0.6693917663527935 3.216047227926646e-07 0.6634173774538097 \
3.216049024606155e-07 0.6591769455535931 3.216051540374889e-07 0.6532475027332399 3.21605354410306e-07 0.6485340174553987 3.216055260641582e-07 0.6445032789616798 \
3.216056847562747e-07 0.6407814961122935 3.216058239642021e-07 0.637522316374186 3.216059602882518e-07 0.6343349641335875 3.216060875012759e-07 0.6313646237382058 \
3.216062169938336e-07 0.6283457899522861 3.216063449851212e-07 0.6253646753452949 3.216064760596301e-07 0.6223174651643489 3.216066067717051e-07 0.6192830747181834 \
3.216067493797576e-07 0.6159760732208495 3.216068921032356e-07 0.612672916206165 3.216070446510367e-07 0.6091471600588 3.216071891550245e-07 0.6058158037532523 \
3.216073531732721e-07 0.6020406322262999 3.216074906379333e-07 0.5988837056407329 3.21607625454949e-07 0.5957940466067043 3.216077469535923e-07 0.5930134750293682 \
3.216078858038966e-07 0.5898448108574432 3.216079994507128e-07 0.5872554148224447 3.216081508608854e-07 0.5838116422847746 3.216082645795603e-07 0.5812320812748947 \
3.216083839926513e-07 0.5785269636915771 3.216084726731778e-07 0.5765205397309219 3.216085638182694e-07 0.5744630259469776 3.216086291571447e-07 0.5729901393713442 \
3.216086936268468e-07 0.5715377831648228 3.21608744447459e-07 0.5703933076453638 3.216088034223984e-07 0.569066051987989 3.216088708671064e-07 0.5675516747474645 \
3.216089379592979e-07 0.5660472084764079 3.216089908797418e-07 0.5648615894615425 3.216090865272254e-07 0.5627204246953637 3.216091437083616e-07 0.5614413394337 \
3.216091975109775e-07 0.5602399192081799 3.216092592530825e-07 0.5588634520375642 3.216093450862141e-07 0.5569525037715509 3.216094277818617e-07 0.5551133137453282 \
3.21609553910589e-07 0.552313430559463 3.216096890096646e-07 0.5493247407981657 3.21609787329828e-07 0.5471534914294828 3.216098999078898e-07 0.5446716589975775 \
3.216100024523052e-07 0.5424173856211837 3.216101225611309e-07 0.5397821662853191 3.216102242487819e-07 0.5375541863492928 3.216103397527456e-07 0.5350300289250629 \
3.216104546438614e-07 0.5325260225312031 3.216105811211341e-07 0.5297740207092871 3.216107063383297e-07 0.5270565158317848 3.216108531843123e-07 0.5238798967507053 \
3.216109886424458e-07 0.5209557060405445 3.216111462030546e-07 0.5175672114705414 3.216113083572294e-07 0.5140875588169389 3.216114890683071e-07 0.5102248342695275 \
3.216116813160604e-07 0.5061308236654174 3.216118940383231e-07 0.5016182665703952 3.216121259434839e-07 0.4967183500883584 3.216123831371877e-07 0.4913135654247419 \
3.216126226904984e-07 0.4863004534671564 3.216129246203734e-07 0.4800178499336004 3.216132123868145e-07 0.4740665530855001 3.216135251890574e-07 0.4676409412178996 \
3.216138450208061e-07 0.4611139840073785 3.21614184657409e-07 0.4542292677834274 3.216145118732278e-07 0.4476411633207955 3.216148470347968e-07 0.4409363684817221 \
3.216151642914576e-07 0.4346351592989786 3.216154981114363e-07 0.4280489847791872 3.2161584979678e-07 0.4211625252737479 3.21616163864498e-07 0.4150547397555842 \
3.216164868937019e-07 0.4088175946446666 3.216169278730989e-07 0.4003732788922496 3.216172702759421e-07 0.3938810608698495 3.216175707238305e-07 0.3882325136127223 \
3.216179460534016e-07 0.3812375944419973 3.216182761286299e-07 0.3751439175705365 3.216185594064112e-07 0.3699597784791666 3.216188599137726e-07 0.3645020109013299 \
3.216191395612329e-07 0.3594637112692664 3.216193634235237e-07 0.3554634414471464 3.216195752745134e-07 0.35170280677964 3.216197776231135e-07 0.3481338771034005 \
3.216199787581392e-07 0.3446120049995081 3.216201845356566e-07 0.3410324794262659 3.216204455143708e-07 0.3365252478245505 3.216206850045531e-07 0.3324209773202946 \
3.21620917679624e-07 0.3284665339262754 3.216211317612159e-07 0.3248537323113044 3.216213529069831e-07 0.3211475567840967 3.21621553789873e-07 0.3178053707831449 \
3.216217571810749e-07 0.3144500223650613 3.216219548494876e-07 0.3112139453100684 3.216221410931751e-07 0.3081862077816076 3.216223360742573e-07 0.3050391973134606 \
3.216225395365023e-07 0.3017803754370622 3.216227174774077e-07 0.2989521325826759 3.216229532011123e-07 0.2952356640875101 3.216231513339656e-07 0.2921385263640672 \
3.216233526780327e-07 0.2890160050544278 3.216235769672297e-07 0.2855690750291008 3.216237418971288e-07 0.2830551950838826 3.216239195258139e-07 0.2803657404651576 \
3.216241039249613e-07 0.2775946687427531 3.216242877463064e-07 0.2748547260732712 3.216244662029787e-07 0.2722194282383935 3.216246381032459e-07 0.2696976713509589 \
3.216247986436534e-07 0.2673699088296289 3.216249201257116e-07 0.265617282026588 3.216250730472387e-07 0.2634201198254058 3.21625200480934e-07 0.2616085083773952 \
3.216253046546047e-07 0.2601317890528609 3.216254215590816e-07 0.2584775571399547 3.21625536570573e-07 0.2568557450124987 3.216256609328034e-07 0.2551103168403305 \
3.216257765070866e-07 0.2534925198640895 3.216259106146075e-07 0.2516172680784447 3.216260256018485e-07 0.2500177396912131 3.216261793514453e-07 0.2478798443778067 \
3.216263161546458e-07 0.2459790966208961 3.21626450740453e-07 0.2441094379339017 3.216266066045887e-07 0.2419575875351012 3.216267312534115e-07 0.2402378086535915 \
3.216268704689347e-07 0.2383186229544463 3.2162700069296e-07 0.236525770455347 3.216271210458007e-07 0.2348769158236033 3.216272564390845e-07 0.233027137746051 \
3.216274076440629e-07 0.2309620730808924 3.216275424005331e-07 0.2291249940296414 3.216276470867202e-07 0.2277003186426776 3.216277696228612e-07 0.2260366668203369 \
3.2162790456742e-07 0.2242086518061946 3.216279996831675e-07 0.2229209267876512 3.216281149432224e-07 0.2213657311907907 3.216281974762018e-07 0.2202562617028589 \
3.216282686815329e-07 0.2192992955643472 3.216283173890172e-07 0.2186449771734718 3.216283645839733e-07 0.2180112263680214 3.216284111327915e-07 0.2173864029843717 \
3.216284645213553e-07 0.2166701476649976 3.216285018980252e-07 0.2161690444847812 3.216285392831377e-07 0.2156680710113931 3.21628579604508e-07 0.2151283464800275 \
3.216286508546475e-07 0.2141753141901174 3.216286850689041e-07 0.2137180869447317 3.216287314635346e-07 0.2131018213873352 3.216287919072008e-07 0.2122998083652294 \
3.216288609101202e-07 0.2113853596849882 3.216289262050716e-07 0.210520730631805 3.216289941831954e-07 0.2096212333552783 3.21629110629525e-07 0.2080823984153433 \
3.216292005517136e-07 0.2068957989735914 3.216293082176197e-07 0.2054771097790837 3.216294042789353e-07 0.2042146625011118 3.216295076575089e-07 0.2028641889872041 \
3.216296043425437e-07 0.2016026287683381 3.216297071523967e-07 0.2002625524503448 3.216298079123679e-07 0.1989526210414513 3.216299190580346e-07 0.1975116692735505 \
3.216300260975286e-07 0.1961279675313261 3.216301440040638e-07 0.1946083430154048 3.216302521143875e-07 0.1932197128021231 3.216303614129877e-07 0.1918224631760269 \
3.216304820447392e-07 0.1902849927564414 3.216305769453309e-07 0.1890796997295432 3.216307055062502e-07 0.18745262875399 3.216307985410385e-07 0.1862801166370808 \
3.216309009375946e-07 0.1849947785893032 3.216309889048857e-07 0.1838942174288659 3.216310871755573e-07 0.182668828510528 3.216311837761789e-07 0.1814691026470878 \
3.216312704146924e-07 0.1803971466393716 3.216313568237045e-07 0.1793305247657973 3.216314526608142e-07 0.1781527189679156 3.216315573876885e-07 0.1768710765218302 \
3.216317031999754e-07 0.1750963017969037 3.216318191679069e-07 0.1736923427161618 3.216319756317111e-07 0.1718092975148396 3.2163208681163e-07 0.1704786474822015 \
3.216322270616306e-07 0.1688098560703619 3.216323500730353e-07 0.1673544160765056 3.216324565640335e-07 0.1661007559767333 3.216325528894916e-07 0.1649724583647661 \
3.216326503229586e-07 0.1638357962207703 3.216327541762373e-07 0.1626293386330815 3.216328459768101e-07 0.1615673458739011 3.216329443645254e-07 0.1604337426303964 \
3.216330272831699e-07 0.1594828374885931 3.216331226515033e-07 0.1583950132920943 3.216332052138516e-07 0.1574587876231885 3.216333077985372e-07 0.1563016192679324 \
3.21633384076854e-07 0.1554454316211293 3.216334726624788e-07 0.1544557264474612 3.216335448319839e-07 0.1536532700165102 3.216336265414731e-07 0.1527486200895024 \
3.216337002202809e-07 0.1519363404455653 3.216337804404095e-07 0.1510573496788611 3.216338521684844e-07 0.1502755532525617 3.216339204254628e-07 0.149534520573691 \
3.216340181414224e-07 0.1484788062294206 3.216340875916063e-07 0.147731872792437 3.216341703430852e-07 0.1468455801890639 3.216342303799948e-07 0.1462052652532956 \
3.216343006186586e-07 0.1454587420502366 3.216343720461929e-07 0.1447037411390827 3.216344525596948e-07 0.1438588888651768 3.216345158225991e-07 0.1431977449412327 \
3.216345934965784e-07 0.1423892845091393 3.216346828063428e-07 0.141463758692191 3.216347521699289e-07 0.1407479403162204 3.216348501181493e-07 0.1397418416088305 \
3.216349404626691e-07 0.1388188591118084 3.216350262429942e-07 0.1379520826379384 3.21635093896779e-07 0.1372719511642241 3.216351602046294e-07 0.1366075914250998 \
3.21635238824321e-07 0.1358227655030745 3.216353195192302e-07 0.135020537018139 3.21635377921894e-07 0.1344419857224206 3.216354386744168e-07 0.1338420332148588 \
3.21635532580729e-07 0.1329184183639811 3.216355749782324e-07 0.1325029080242558 3.216356542224261e-07 0.1317336600863391 3.216356945925846e-07 0.1313430593815061 \
3.216357842934634e-07 0.130477658168832 3.216358232415503e-07 0.1301029732927899 3.216359188572359e-07 0.1291862249441596 3.216359577410651e-07 0.1288146335111444 \
3.21636050975841e-07 0.1279263274670414 3.2163611931843e-07 0.1272775968534341 3.216361716392852e-07 0.1267823325594629 3.216362537399991e-07 0.1260075984242486 \
3.216363249033783e-07 0.1253406747583812 3.216364028563663e-07 0.1246136378429537 3.216364819761022e-07 0.1238779526756392 3.21636560619333e-07 0.1231489004754178 \
3.216366406542416e-07 0.122409328367501 3.216367023886578e-07 0.1218405706457005 3.216367759836405e-07 0.1211645344030958 3.216368593634578e-07 0.120401093559758 \
3.216369234601888e-07 0.1198161795466899 3.216369928987769e-07 0.119184869057559 3.216370659217156e-07 0.1185234239195788 3.216371507966272e-07 0.1177582144838446 \
3.216372301594785e-07 0.117046673033812 3.216373148931361e-07 0.1162898833629492 3.216374056044255e-07 0.1154830714735263 3.216374811875037e-07 0.1148135241260771 \
3.216375469154284e-07 0.1142333070693714 3.216376069752011e-07 0.1137047561823949 3.216376765809174e-07 0.1130943456353956 3.216377429999685e-07 0.1125141752866663 \
3.216378224112316e-07 0.1118230150855203 3.216379126741612e-07 0.1110406875128299 3.216379817184613e-07 0.1104447270551955 3.216380562735805e-07 0.1098035355921305 \
3.216381447575013e-07 0.1090456469739195 3.216382238656483e-07 0.1083709350695736 3.216382937340289e-07 0.1077773127978274 3.216383747433988e-07 0.1070920034756896 \
3.216384309482126e-07 0.106618206733547 3.216384936074922e-07 0.1060916009495399 3.216385587540976e-07 0.105545887371837 3.216386300897258e-07 0.1049504956797945 \
3.216387503861013e-07 0.1039516085561449 3.216388019396737e-07 0.103525508500865 3.216388570887417e-07 0.1030709598036589 3.216389477859257e-07 0.1023262935955709 \
3.216390301757782e-07 0.1016530765296615 3.216391257555856e-07 0.1008759670630478 3.216392329651519e-07 0.1000092507657299 3.216393366245585e-07 0.09917656019160864 \
3.216394228321611e-07 0.09848810438956324 3.216395090743862e-07 0.09780303991321163 3.216395886154605e-07 0.09717448010577609 3.216396686283335e-07 0.09654538840876434 \
3.216397599166613e-07 0.09583163072761708 3.216398416620796e-07 0.09519620281310773 3.216399305889172e-07 0.09450872319168514 3.216400203662242e-07 0.09381864801001834 \
3.216400973288722e-07 0.09323024625953365 3.216401876536891e-07 0.0925435244861572 3.216402514624153e-07 0.09206084550525626 3.216403239259827e-07 0.09151514907748673 \
3.216403880546354e-07 0.09103438864950099 3.216404663020107e-07 0.09045054736970405 3.216405660032922e-07 0.08971110930136832 3.216406400564437e-07 0.08916512281998501 \
3.216407266649787e-07 0.08852997392441805 3.216408729646849e-07 0.08746544055362569 3.216409836769483e-07 0.08666684197409438 3.216410939866262e-07 0.08587717033461532 \
3.216412361822689e-07 0.08486839672072237 3.216413762347203e-07 0.08388450488753585 3.216415188805343e-07 0.08289222299161547 3.21641667651249e-07 0.08186778387581196 \
3.216418043639349e-07 0.08093569403044946 3.21641946484565e-07 0.07997640434545976 3.21642081061545e-07 0.07907728405019222 3.21642221281423e-07 0.07814997945867638 \
3.216423690282294e-07 0.07718353387841098 3.216425189824149e-07 0.07621348085094087 3.216426836982467e-07 0.07516037195605636 3.216428472843634e-07 0.07412732798506308 \
3.216430219327157e-07 0.07303837372665309 3.216432089864081e-07 0.07188781219077654 3.216434189729257e-07 0.0706159374129187 3.216436370461739e-07 0.06931715807027321 \
3.216438703663275e-07 0.06795188046253516 3.216441248458817e-07 0.0664909822812602 3.2164441780254e-07 0.06484528303377844 3.21644719953089e-07 0.06318745987130532 \
3.216450576747916e-07 0.06138078634948794 3.216454527833931e-07 0.05932807220464856 3.216458202346361e-07 0.05747953410674719 3.216462378424018e-07 0.05544691527644593 \
3.216465828383762e-07 0.0538196438399016 3.216469333806655e-07 0.05221302159193914 3.21647248341029e-07 0.0508087490907442 3.216475475823956e-07 0.049508488261462 \
3.216478469482477e-07 0.04824029756235761 3.216481221909583e-07 0.04710512226277328 3.216484056545246e-07 0.04596497870754415 3.216486672549465e-07 0.04493681260994405 \
3.216489447070712e-07 0.04387103439794762 3.216492207665063e-07 0.04283531238677037 3.21649529036243e-07 0.04170718945545093 3.216497514688635e-07 0.0409114719535993 \
3.21650039009947e-07 0.03990505631995635 3.216502752428796e-07 0.0390969788355163 3.216505937045548e-07 0.03803800466874574 3.21650844115589e-07 0.03722710566490722 \
3.216511671003914e-07 0.03620720400565681 3.216514254364062e-07 0.03541203096995557 3.216517154102847e-07 0.03454066075983582 3.216519452051025e-07 0.0338658635512188 \
3.216522301004437e-07 0.03304787219836024 3.21652469846563e-07 0.03237513696606491 3.216527104811323e-07 0.03171392889024889 3.216529495996188e-07 0.03107212555077287 \
3.216531855385298e-07 0.03045460689686571 3.21653416367391e-07 0.02986254663395104 3.216536313939186e-07 0.02932175456294728 3.216540335597598e-07 0.0283374222946415 \
3.2165423211788e-07 0.02786401170979088 3.216546058190659e-07 0.02699470773596776 3.216547926322608e-07 0.02657042318767052 3.216551386335082e-07 0.02580176906824739 \
3.216552605769465e-07 0.02553595448027303 3.216556434299635e-07 0.02472011952872977 3.216558038641492e-07 0.02438657631284594 3.216562468653031e-07 0.02348572425118655 \
3.216564174793446e-07 0.02314627247835563 3.216567380559406e-07 0.02251902970747987 3.216569383408681e-07 0.0221336684630111 3.216573852788009e-07 0.02128811173678137 \
3.216575132229166e-07 0.02104854104185888 3.21658001100276e-07 0.02014826272243131 3.21658136077553e-07 0.01990454278080647 3.216586183290713e-07 0.0190640092473091 \
3.216587806551862e-07 0.01879235028057063 3.216592670495272e-07 0.01801148170254873 3.216594300771863e-07 0.01776103207540622 3.216601102988766e-07 0.01676849304257711 \
3.216602493826145e-07 0.01657541006259178 3.216609818771477e-07 0.01560782569993242 3.216611407707804e-07 0.01540693214221847 3.216619238518671e-07 0.01445869962397344 \
3.216620696444218e-07 0.01428952172302696 3.216629204257814e-07 0.01334248985256295 3.21663031529053e-07 0.01322388191882306 3.216639648234166e-07 0.0122699293983148 \
3.216640986614658e-07 0.01213902814618388 3.21665057199482e-07 0.01123495036716388 3.216651783165509e-07 0.01112486091825863 3.216663004003486e-07 0.01017270671243764 \
3.216664059016017e-07 0.01008921053061839 3.216677349760139e-07 0.009112307258623473 3.216678551802884e-07 0.009029744095492466 3.21669403542048e-07 0.008036808760534916 \
3.216694843298185e-07 0.007986285493236449 3.216710552093519e-07 0.007024564730313319 3.216711226255509e-07 0.006986095570813155 3.216730433922295e-07 0.006001386377072119 \
3.216732301941131e-07 0.005914747648762168 3.216755456080606e-07 0.0049318160947762 3.216759451349076e-07 0.004777795182599986 3.216785089444083e-07 0.003889929704329555 \
3.216790078153284e-07 0.003736330440833864 3.21682637539317e-07 0.002784984367379526 3.216831882332918e-07 0.002663729254427667 3.216885866736714e-07 0.001711392372544448 \
3.216888999412434e-07 0.001662511220227468 3.216938922337914e-07 0.0006970413096974805 3.216940762528259e-07 0.0006571176749162138 3.243425553956096e-07 -0.0002691198397987355 \
3.243427114545721e-07 -0.0004551674219448388 3.243432594384272e-07 -0.001322174727784445 3.243433723764199e-07 -0.001539785040943742 3.243438016313499e-07 -0.002474302920374066 \
3.24343907888515e-07 -0.002730173903076456 3.243441906906666e-07 -0.003454402452283872 3.243443042852103e-07 -0.003760966378165151 3.243446428397891e-07 -0.004705104513819927 \
3.243447552637498e-07 -0.005021586953003071 3.243450835416507e-07 -0.005887841248467669 3.243451910801718e-07 -0.006130875888161453 3.243460710062032e-07 -0.005789627805322099 \
3.243462462122502e-07 -0.004910736584223327 3.243463630430134e-07 -0.004127745010746014 3.243464899101376e-07 -0.00309221842859156 3.243465914428629e-07 -0.002125750314016509 \
3.243467128641333e-07 -0.0008095618968406578 3.243468030290462e-07 0.0002767910803854594 3.243469002126957e-07 0.001550247908954045 3.243469982869598e-07 0.002938803805678211 \
3.243471655080454e-07 0.005530627736217106 3.243473878133234e-07 0.009378371294171852 3.243475735517141e-07 0.01290572951649239 3.243477976330495e-07 0.01747895571448658 \
3.243479572777817e-07 0.02091945933227325 3.243481217671113e-07 0.02459614091902196 3.243482715915693e-07 0.0280452875125503 3.243484209914613e-07 0.03156498790849799 \
3.243485705227667e-07 0.03515592969144176 3.243487246026614e-07 0.03891669635189081 3.243488867868089e-07 0.0429309674228065 3.24349053210035e-07 0.0470989728378523 \
3.243492291435082e-07 0.05154884981278444 3.24349410271779e-07 0.05616867911875007 3.243496024027047e-07 0.06110225049351239 3.24349810098117e-07 0.0664648391313285 \
3.243500320181979e-07 0.07222051812179281 3.243502672196804e-07 0.07834079218654426 3.243505194059893e-07 0.08491829088081257 3.243507955452241e-07 0.09213111703448683 \
3.243510966667008e-07 0.1000001933597138 3.243514285865622e-07 0.1086702418150647 3.243518059053303e-07 0.1185147411083515 3.243522041953866e-07 0.1288888856248832 \
3.243526735037065e-07 0.1410822143415975 3.243532195292308e-07 0.1552200475789812 3.243538544895379e-07 0.1715918832733369 3.243545538901293e-07 0.1895291194622146 \
3.243553721290552e-07 0.2103807608661494 3.243562778230217e-07 0.2332840710921665 3.243570673340878e-07 0.253091928008631 3.243577710929056e-07 0.2706124241987875 \
3.243583889437195e-07 0.2858796548825839 3.243589545671311e-07 0.2997575097153312 3.243594763024047e-07 0.3124620269501652 3.243599740861211e-07 0.3244932238414255 \
3.243604577240811e-07 0.3360954048923613 3.243609145982154e-07 0.3469667650518959 3.243613874391095e-07 0.3581213589834248 3.243618270524661e-07 0.3684065070151987 \
3.24362314929562e-07 0.379719432411247 3.243628457299846e-07 0.3919028193132517 3.243633436253595e-07 0.4032143644097119 3.24363775002613e-07 0.41292177789323 \
3.243642618898012e-07 0.4237731225600331 3.243647619892433e-07 0.4348012155672935 3.243651066099338e-07 0.4423321287141763 3.243654600037777e-07 0.4500000647748709 \
3.243658877736169e-07 0.4592134948422093 3.243662796346881e-07 0.4675816212925634 3.243665799290445e-07 0.4739471552041949 3.243669218601248e-07 0.4811428413521782 \
3.243672651945704e-07 0.4883132334011818 3.24367525955058e-07 0.4937215836208605 3.243677680115876e-07 0.4987106167174703 3.243680340100557e-07 0.5041617362307154 \
3.243682934982395e-07 0.5094435946950286 3.243684834145397e-07 0.5132872703533161 3.243686986491409e-07 0.5176241792560061 3.243688371999001e-07 0.5204025546691405 \
3.243689820806791e-07 0.5232962183003332 3.243691954947458e-07 0.5275364624051522 3.243693975193605e-07 0.5315382148201082 3.243695902480239e-07 0.5353370730264509 \
3.243697755034039e-07 0.5389735557287745 3.243699525009277e-07 0.5424323215059959 3.243702617642633e-07 0.5484573594957171 3.243705229123106e-07 0.5535233414883098 \
3.243708247314806e-07 0.5593562770234363 3.243710801601219e-07 0.5642781701956761 3.243713725156194e-07 0.5698968483756405 3.243716319698133e-07 0.5748654731717864 \
3.243719020897901e-07 0.5800301911327002 3.243721441003479e-07 0.5846380733684551 3.24372401610146e-07 0.5895273573494454 3.243726280544834e-07 0.5938057549890672 \
3.243728649429657e-07 0.5982619499065401 3.24373074987873e-07 0.6021962733001386 3.243732879185847e-07 0.6061670177072124 3.243735413972821e-07 0.6108668889270118 \
3.24373744692931e-07 0.6146150465592417 3.243739363811142e-07 0.6181346807088086 3.243741250074786e-07 0.6215812235468744 3.243743123254166e-07 0.6249823889551316 \
3.243745179374062e-07 0.6286953279350977 3.243747677606249e-07 0.6331759959753138 3.243749715724035e-07 0.6368063379741715 3.243751792111212e-07 0.6404826298163093 \
3.24375371862737e-07 0.6438748386876914 3.243756164748105e-07 0.6481531432733096 3.243758643733136e-07 0.6524620620600715 3.243760442082188e-07 0.6555644139995785 \
3.243762349822552e-07 0.6588391718544121 3.24376388158437e-07 0.6614554104590837 3.243765598271469e-07 0.6643705886591137 3.243767102939677e-07 0.6669108747194671 \
3.243768468979714e-07 0.6692010654183506 3.243769963383726e-07 0.6716954191563786 3.243771240725235e-07 0.6738189269502312 3.2437726394477e-07 0.6761323074508511 \
3.24377388021905e-07 0.6781756764962316 3.243775193832699e-07 0.6803315871556701 3.243776435547311e-07 0.6823627547057004 3.243777813315919e-07 0.6846081866267727 \
3.243779015758123e-07 0.6865586181592046 3.243780436284175e-07 0.6888545186016138 3.243781438561225e-07 0.6904668682779994 3.243782651601134e-07 0.6924123325129877 \
3.243783561353879e-07 0.6938641504265992 3.243784535186708e-07 0.695411869780077 3.243785506015381e-07 0.6969507228893711 3.243786398841584e-07 0.6983595753378042 \
3.243787378559428e-07 0.699898781449533 3.243788681310304e-07 0.7019319515314388 3.243790215432551e-07 0.7043083163565919 3.243791571090672e-07 0.7063909659299702 \
3.24379301449562e-07 0.708591461371511 3.243794273204452e-07 0.710496752775434 3.243795523478311e-07 0.712376488910674 3.243796666301914e-07 0.7140841686551523 \
3.243797776133356e-07 0.7157331888171029 3.243798773084046e-07 0.7172065512867005 3.243800143526226e-07 0.7192196995505324 3.243801333798347e-07 0.7209572005600779 \
3.24380253677943e-07 0.7227029412191364 3.243803801768634e-07 0.7245276185835638 3.243805041084668e-07 0.7263044524160376 3.243806283948001e-07 0.7280754330070212 \
3.24380754759953e-07 0.7298652243312684 3.243808845716946e-07 0.7316925631262517 3.243810084102138e-07 0.7334254795816325 3.243811411911006e-07 0.735272086289578 \
3.243812420423058e-07 0.7366670415914529 3.243813552339755e-07 0.738224777043618 3.243814420199563e-07 0.7394137384482823 3.243815586452529e-07 0.7410021813026957 \
3.243816479345105e-07 0.7422110784210975 3.243817591113938e-07 0.7437075443329063 3.243818883701577e-07 0.7454347509364776 3.243820022291937e-07 0.7469455276109591 \
3.243821066334058e-07 0.74832188588007 3.243822310004373e-07 0.7499498655229884 3.243823782406159e-07 0.7518616907275563 3.243824985209068e-07 0.753411006437983 \
3.243826144254459e-07 0.7548933175676444 3.243827545012897e-07 0.7566706674475765 3.243828971129601e-07 0.7584645678799224 3.243830150672032e-07 0.7599365027959469 \
3.243831418837122e-07 0.7615071445339606 3.243832827668562e-07 0.7632375905494565 3.243834025603537e-07 0.7646969139886852 3.243835475192107e-07 0.7664484133613445 \
3.243836690779963e-07 0.7679052725436226 3.243837881174897e-07 0.7693214142140735 3.243839097488533e-07 0.7707575700077021 3.243840377178317e-07 0.772256936813787 \
3.243841469330139e-07 0.7735272422640712 3.243842718238923e-07 0.774969549136603 3.24384378939953e-07 0.7761978171588899 3.243845121931473e-07 0.7777146071439789 \
3.243846392965933e-07 0.7791497354387434 3.243847610475684e-07 0.7805132846941326 3.243848776321508e-07 0.7818078758210534 3.24384983459753e-07 0.7829735233300771 \
3.243851228258954e-07 0.7844949153190801 3.243852718976944e-07 0.786105286864636 3.24385419626362e-07 0.7876841235632186 3.243855389322397e-07 0.7889471147195867 \
3.243856729390521e-07 0.7903527806482344 3.243857933652268e-07 0.791604423795974 3.243859349104043e-07 0.7930616786923709 3.243860823364167e-07 0.7945638089648995 \
3.243862068109252e-07 0.7958198087139573 3.243863258549181e-07 0.7970105506108808 3.243864374452017e-07 0.7981174590942314 3.243865426744905e-07 0.7991530841216606 \
3.243866381855941e-07 0.8000862307887144 3.243867742475476e-07 0.8014036057482816 3.243868911236816e-07 0.8025237700417888 3.243870102773537e-07 0.8036549841722296 \
3.24387132589548e-07 0.8048050501807249 3.243872558616218e-07 0.8059526272620129 3.243873823583984e-07 0.8071184350969989 3.243875078610623e-07 0.8082633544790385 \
3.243876385869669e-07 0.8094437311890262 3.243877641549387e-07 0.8105658358439867 3.243878932098036e-07 0.8117072367686948 3.243879990659606e-07 0.8126345588578442 \
3.243881002348366e-07 0.8135133322873783 3.243881948546566e-07 0.8143286754242188 3.243883191357402e-07 0.8153900871385379 3.243884088474262e-07 0.816149614585347 \
3.243885078849502e-07 0.8169816577628611 3.243886456628271e-07 0.8181280288377792 3.243887801986773e-07 0.81923501721715 3.243888886049436e-07 0.8201180631035904 \
3.243890385184474e-07 0.8213254631869725 3.243891890970255e-07 0.8225223201378843 3.243893145921802e-07 0.8235077122548546 3.24389458438707e-07 0.8246238332260477 \
3.243895830219706e-07 0.8255790649890803 3.243897318751914e-07 0.8267066458678887 3.243898680237751e-07 0.827725029289517 3.243899930476024e-07 0.8286494160599757 \
3.243901107545823e-07 0.8295103773055483 3.243902563935805e-07 0.8305630309532103 3.243904227748753e-07 0.8317484146982921 3.243905533585646e-07 0.8326660250626342 \
3.243907268806749e-07 0.8338683097812621 3.243908950025776e-07 0.8350147136930499 3.243910648651803e-07 0.8361549927788252 3.243912457668832e-07 0.8373497079260466 \
3.243913888761651e-07 0.8382806519784776 3.24391502965127e-07 0.839013953006387 3.243916331276036e-07 0.8398410866028793 3.243917349727342e-07 0.8404811280669765 \
3.243918517989402e-07 0.8412075886390841 3.243919886903802e-07 0.8420483852080155 3.24392186497604e-07 0.843243620449199 3.243923781227506e-07 0.8443797466267589 \
3.24392587554618e-07 0.8455974227529048 3.243927695012999e-07 0.8466352798309468 3.243929666301539e-07 0.8477391449715804 3.243931399710144e-07 0.8486924050423899 \
3.243933229793209e-07 0.8496814535024207 3.243934941423557e-07 0.8505903669473519 3.243936687794506e-07 0.851501688465695 3.243938440392814e-07 0.8524001683007644 \
3.243940201897297e-07 0.8532872510191711 3.243942104700295e-07 0.8542278331088334 3.2439440106916e-07 0.8551519386507073 3.243946016923949e-07 0.8561055033533737 \
3.2439479430095e-07 0.8570028516027762 3.243950049816413e-07 0.8579644845832216 3.243952330831089e-07 0.8589827023971403 3.243954988710916e-07 0.860139640227508 \
3.243957974838522e-07 0.8614018215255795 3.243960737724907e-07 0.8625348754565382 3.243963580090103e-07 0.8636666213345715 3.243966322137804e-07 0.8647267940813509 \
3.243969044486385e-07 0.8657495569722869 3.243971746527799e-07 0.8667361702337206 3.243974318083905e-07 0.867649441901348 3.243977043886041e-07 0.8685908808535525 \
3.2439798037489e-07 0.8695169452638583 3.24398250477721e-07 0.870397355937691 3.243985503347982e-07 0.8713451925332844 3.243989213624563e-07 0.8724761722512941 \
3.243992162997666e-07 0.8733433185969293 3.243994705892065e-07 0.8740690226522811 3.243997688459906e-07 0.874895168896023 3.244000424554269e-07 0.8756299040683481 \
3.244002785839137e-07 0.8762466977562872 3.244005189298274e-07 0.8768585021646264 3.244007412634921e-07 0.8774104263690854 3.244009352691695e-07 0.8778812671168952 \
3.244012649918855e-07 0.8786590883967833 3.244014201653189e-07 0.8790156160651978 3.244017379413894e-07 0.8797272612331356 3.244019168030317e-07 0.8801171459162566 \
3.244022592648612e-07 0.8808425821290963 3.244024433930207e-07 0.881221400612852 3.244029182707539e-07 0.8821634994206867 3.244030856669651e-07 0.8824839765989225 \
3.244035515089056e-07 0.8833452998114757 3.244037323309576e-07 0.8836679564577563 3.244042263693833e-07 0.8845176198113115 3.24404367718007e-07 0.8847523712107549 \
3.244049740520726e-07 0.8857188576377059 3.244051261213959e-07 0.8859512996759633 3.244057728095585e-07 0.8868983431897121 3.2440590110417e-07 0.8870786909355212 \
3.244065492212318e-07 0.8879538337624689 3.244066790202949e-07 0.8881220828502663 3.244074572237723e-07 0.8890807033877333 3.24407572278734e-07 0.8892148977954012 \
3.244084279402065e-07 0.8901543051721961 3.244085733010758e-07 0.8903040038307473 3.244095590571273e-07 0.8912446482480114 3.244097801624957e-07 0.8914382978987679 \
3.244109252894234e-07 0.8923659558950503 3.244110565064392e-07 0.8924678262926897 3.244123977150129e-07 0.8934599079028542 3.24412549114272e-07 0.8935646301988298 \
3.244140305519949e-07 0.8944937559627255 3.244142694313731e-07 0.8946275407274444 3.244160387469791e-07 0.8955013787854181 3.244164278981914e-07 0.8956696032899972 \
3.244188215611418e-07 0.8965547188539188 3.244192972701398e-07 0.8967039926079825 3.244233604302104e-07 0.8977020505850396 3.24423851854269e-07 0.8977948037134476 \
3.24432168453822e-07 0.898787348739254 3.244330883529499e-07 0.8988506593152591 3.245765735834803e-07 0.8998476076348748 3.245776920164557e-07 0.8998537475785264 \
3.247827836359558e-07 0.898985773748599 3.247830107254573e-07 0.8988224379910277 3.247846203322555e-07 0.8978282360369357 3.247847977407988e-07 0.8977338482811539 \
3.248017048890996e-07 0.8987315468430059 3.248018143281978e-07 0.8987460089186867 3.248175950494439e-07 0.8997418097871094 3.248178913753395e-07 0.8997476966799167 \
3.25301325027745e-07 0.9007060148833608 3.253014540780854e-07 0.9008313386292994 3.253021042279306e-07 0.9016292186224167 3.253022937236614e-07 0.9019133038041363 \
3.253027969456399e-07 0.9027675859898705 3.253029324182996e-07 0.9030208676018907 3.253033328770163e-07 0.9038195223753869 3.253034648149532e-07 0.9040958310886574 \
3.253038660300167e-07 0.9049509627747726 3.253039642901937e-07 0.9051582028152527 3.253044301640043e-07 0.9060587574877488 3.253045916627274e-07 0.9063060456044927 \
3.253057356752505e-07 0.9055153668657776 3.253058806545959e-07 0.9049059606760256 3.253060592073535e-07 0.9039396653125833 3.253062394026313e-07 0.9027054491383806 \
3.253063820935606e-07 0.9015369228101149 3.253064992531646e-07 0.9004524619440171 3.253065882345255e-07 0.8995505656965809 3.253066798781777e-07 0.8985529714258781 \
3.253068129901104e-07 0.8969831049011855 3.253069067111929e-07 0.8957895978311226 3.253069978500018e-07 0.8945634483845346 3.253071111423133e-07 0.8929516940777753 \
3.253072142512258e-07 0.8913998138690341 3.253073105184064e-07 0.8898830246517148 3.253074296555229e-07 0.8879200664089764 3.253075982407716e-07 0.8849885378698126 \
3.253077600122728e-07 0.8820195265790133 3.253079532313317e-07 0.8782956415026882 3.253081387944432e-07 0.8745571577041361 3.253083490607478e-07 0.8701566079887386 \
3.253085313097886e-07 0.8662213066841463 3.253087161731834e-07 0.8621339172744639 3.253088888583302e-07 0.8582419637438897 3.253090749664034e-07 0.8539816046497358 \
3.253092527824914e-07 0.849858603441091 3.253094334990722e-07 0.8456251963850057 3.253095986373313e-07 0.8417258760277182 3.253097639114333e-07 0.837798995916667 \
3.253099271590959e-07 0.8339004324287677 3.253100857493696e-07 0.8300982805770993 3.253102626737714e-07 0.8258418712800655 3.253104591875839e-07 0.8211009660847696 \
3.253106267441254e-07 0.8170498602679914 3.253107934845439e-07 0.8130123908857781 3.253109679080616e-07 0.8087844286215062 3.253111372776842e-07 0.8046757316210446 \
3.253113054767786e-07 0.8005936994537799 3.25311494325046e-07 0.7960093488074458 3.253116851408819e-07 0.7913773844868103 3.253118935230917e-07 0.7863203192056716 \
3.25312119942597e-07 0.7808277108969495 3.253123091427939e-07 0.7762391340290878 3.253125192894832e-07 0.7711455503222944 3.253126680579875e-07 0.7675418410361046 \
3.253127990509761e-07 0.7643705172588006 3.25312936616212e-07 0.7610417440783073 3.253130423674414e-07 0.7584842184275663 3.253131771410752e-07 0.7552262509102785 \
3.253132889738005e-07 0.7525244432456109 3.253134184089644e-07 0.7493992292091655 3.253135735976883e-07 0.7456545577979357 3.253136852334407e-07 0.7429626190147979 \
3.253138448080549e-07 0.7391166470929011 3.253140201296882e-07 0.7348935218456193 3.253142325051509e-07 0.7297828120356423 3.253144253876789e-07 0.7251458607116523 \
3.253145820889711e-07 0.7213823872711312 3.253147687636618e-07 0.716903961299824 3.253149576500111e-07 0.7123775767926828 3.253151485342027e-07 0.70780884692282 \
3.253153352821382e-07 0.7033444557767304 3.253155183669542e-07 0.698972331957095 3.253156556859354e-07 0.6956951921588121 3.253158089288925e-07 0.6920418367118417 \
3.253160040575431e-07 0.6873949992893974 3.253161613518718e-07 0.6836535194673684 3.25316320746467e-07 0.6798660670227984 3.253165164902601e-07 0.6752219404489795 \
3.253167086893939e-07 0.6706682621108646 3.253169436410222e-07 0.6651105611269369 3.2531713111727e-07 0.6606839627962382 3.253173683544039e-07 0.6550894036851447 \
3.253175575343661e-07 0.6506361170423679 3.253177381501785e-07 0.6463915264929231 3.253179018447415e-07 0.6425504277539856 3.253180463961504e-07 0.6391628119244788 \
3.2531818686792e-07 0.6358764726647652 3.253183139687075e-07 0.6329064225879303 3.253184462761836e-07 0.6298198307262635 3.253185728632297e-07 0.626870110582017 \
3.253187034434976e-07 0.62383130535404 3.253188327128966e-07 0.6208285625908692 3.253189718197929e-07 0.6176004736356133 3.253191203301029e-07 0.6141606483517721 \
3.253193098786583e-07 0.6097777958748198 3.253194555819145e-07 0.6064170107178907 3.253196906324779e-07 0.601007464699683 3.253198736317494e-07 0.5968099615921 \
3.253200979734226e-07 0.5916778694808832 3.253202691466717e-07 0.5877753019413697 3.253204014804909e-07 0.5847634284691802 3.253205332770303e-07 0.5817721407249107 \
3.253206398209335e-07 0.5793579518205488 3.25320735711292e-07 0.5771868999037388 3.25320828211542e-07 0.5750974572268882 3.25320920638905e-07 0.5730134868920421 \
3.253209930672116e-07 0.5713818265150021 3.25321048796317e-07 0.5701269325864891 3.253211099054046e-07 0.5687522410723198 3.2532120667008e-07 0.5665806864277688 \
3.253212681615946e-07 0.5652027770813386 3.253213272142164e-07 0.5638802801505602 3.253214028408818e-07 0.5621878686488651 3.253214698636602e-07 0.5606896577364279 \
3.253215434607697e-07 0.5590483558003441 3.253216110667724e-07 0.5575429304381756 3.253217271358289e-07 0.5549610936632026 3.253218273422345e-07 0.5527359403974305 \
3.253219393494244e-07 0.5502565947066531 3.253220338414751e-07 0.5481686943853854 3.253221549961726e-07 0.5454955387196141 3.253222551839389e-07 0.5432910220514219 \
3.253223711744508e-07 0.5407443765731218 3.253224788782885e-07 0.5383833065966291 3.253225884569768e-07 0.5359861028148916 3.253227005784207e-07 0.5335400310751951 \
3.253228275156047e-07 0.5307765704644959 3.253229496651232e-07 0.5281221248815906 3.253230894260377e-07 0.525095489155881 3.253232265641539e-07 0.522132778766487 \
3.253233765292442e-07 0.5189020692106626 3.253235353022474e-07 0.5154923220538846 3.253237093279044e-07 0.511765695450105 3.25323896158028e-07 0.5077823379664483 \
3.253241011259936e-07 0.5034264211640872 3.253243238349422e-07 0.4987133299464507 3.253245767391391e-07 0.4933874474923696 3.253248116930461e-07 0.4884604410272814 \
3.253251079613079e-07 0.4822828691822955 3.253253977512662e-07 0.4762763831984252 3.253257040870848e-07 0.4699660956099861 3.253260164056119e-07 0.4635767846525711 \
3.253263549710683e-07 0.4566963260653934 3.25326678082485e-07 0.4501741115777416 3.253270164777878e-07 0.4433881855507311 3.253273403090534e-07 0.4369378830387565 \
3.253276647034741e-07 0.4305204627449936 3.253280076377603e-07 0.4237851826852676 3.253283469185779e-07 0.4171698123421442 3.253286863932124e-07 0.4105997181257849 \
3.253291295050583e-07 0.4020958655332711 3.253294915732268e-07 0.3952155038183801 3.253298121249644e-07 0.3891775711374149 3.253301990595345e-07 0.3819561902961204 \
3.253305269297949e-07 0.3758957719299574 3.253308120888516e-07 0.3706704968427373 3.253311304576464e-07 0.3648820026298218 3.253314132885732e-07 0.3597820188690578 \
3.253316419773369e-07 0.3556924369094372 3.253318598701416e-07 0.3518226517641353 3.253320551194862e-07 0.3483769517668343 3.253322620275857e-07 0.344751588202948 \
3.253324768243417e-07 0.3410137651016431 3.253327290508921e-07 0.3366564674340092 3.253329710462048e-07 0.3325077909124976 3.253332018984844e-07 0.3285822460490526 \
3.253334167466748e-07 0.3249550452085373 3.253336371033643e-07 0.3212604562488142 3.253338386742641e-07 0.3179050685021769 3.253340417582106e-07 0.3145531374773136 \
3.253342396555968e-07 0.3113121771742085 3.253344267548364e-07 0.3082694484595072 3.253346206551795e-07 0.3051385396431291 3.253348257035143e-07 0.3018527636900292 \
3.253350059382659e-07 0.2989872106339772 3.253352418362775e-07 0.2952669081535775 3.253354431238275e-07 0.2921198200609627 3.253356445146313e-07 0.2889965001417216 \
3.253358691637942e-07 0.2855437159941698 3.253360345437678e-07 0.2830223598911593 3.253362123481056e-07 0.280330186126118 3.253363960043191e-07 0.277570343839212 \
3.253365812460764e-07 0.2748090658167894 3.253367593914542e-07 0.2721781298892599 3.253369329835173e-07 0.2696316866093095 3.253370933483699e-07 0.267306655456324 \
3.253372144595526e-07 0.2655585721882695 3.253373676543406e-07 0.2633570345323199 3.253374949857892e-07 0.2615475749425888 3.253375983136284e-07 0.2600830587034867 \
3.25337715638424e-07 0.2584225376281647 3.253378334453812e-07 0.2567591557214636 3.253379574091473e-07 0.2550199666844239 3.253380743933138e-07 0.2533821414201824 \
3.253382051894417e-07 0.2515535495016885 3.253383223995523e-07 0.2499173892700276 3.253384756526766e-07 0.2477853623028658 3.253386111831973e-07 0.2459029165157107 \
3.253387428644058e-07 0.244074199323236 3.25338899457317e-07 0.2419017673596028 3.253390246538746e-07 0.2401755227310949 3.253391603715014e-07 0.2383060149301216 \
3.253392927986628e-07 0.2364844144139329 3.253394127723238e-07 0.2348355337769661 3.253395758201609e-07 0.232606585912384 3.253397146272525e-07 0.230713852557009 \
3.253398531009719e-07 0.2288300961780371 3.253399586457212e-07 0.2273962817971701 3.253400870074011e-07 0.2256537837490921 3.253401911350241e-07 0.2242444877898851 \
3.25340291651026e-07 0.222886569499566 3.253403666954022e-07 0.2218745444235658 3.253404440284576e-07 0.2208349692306942 3.253405187916369e-07 0.2198305887827458 \
3.253405967553143e-07 0.218785487158918 3.253406516218243e-07 0.2180503923904892 3.253407081185998e-07 0.2172938400168352 3.253407515721192e-07 0.2167123195211523 \
3.253407916131654e-07 0.2161767335077376 3.253408308521132e-07 0.2156521099473339 3.253408717263501e-07 0.2151058606261434 3.253409258788401e-07 0.2143825797409383 \
3.253409642959716e-07 0.2138698309421548 3.253410035846784e-07 0.2133480458229882 3.253410651213865e-07 0.2125332203444249 3.253411270989155e-07 0.2117131287842428 \
3.253411835756643e-07 0.2109664019951111 3.253412482072545e-07 0.2101124842966758 3.253413437158761e-07 0.2088522205996687 3.253414310316075e-07 0.207701294711168 \
3.253415276412079e-07 0.2064291756790013 3.253416248707623e-07 0.2051510266126755 3.253417257178229e-07 0.2038307158897115 3.253418263175944e-07 0.2025192706911573 \
3.253419228088913e-07 0.2012627769767186 3.253420249910648e-07 0.1999338657614989 3.253421286307215e-07 0.1985898465970496 3.253422384047343e-07 0.1971698847140261 \
3.253423475797596e-07 0.1957617939809042 3.253424676778517e-07 0.1942174441246506 3.253425776973762e-07 0.1928086337505992 3.253426858092848e-07 0.1914295694688549 \
3.253428088379843e-07 0.1898652723262108 3.253428989485537e-07 0.1887234630454603 3.253430063140445e-07 0.1873671680421656 3.253430831253526e-07 0.1864004060894758 \
3.253431665706207e-07 0.1853535952511875 3.253432561024323e-07 0.1842338297700716 3.253433406678985e-07 0.1831790839553313 3.253434203840387e-07 0.1821880912968773 \
3.253435217092422e-07 0.1809331989518758 3.253436300564713e-07 0.1795959386230563 3.253437265321694e-07 0.1784102562612937 3.25343851909986e-07 0.1768766438339704 \
3.253439846934562e-07 0.1752616821119887 3.253441024642794e-07 0.1738362801839788 3.253442481158562e-07 0.1720835746408261 3.253443587130081e-07 0.1707596463148658 \
3.25344500843447e-07 0.1690680578777541 3.253446165530702e-07 0.1676985735146403 3.253447220270832e-07 0.166456424915798 3.253448165437425e-07 0.1653485352650968 \
3.253449121811146e-07 0.1642320043563913 3.253450092529585e-07 0.1631032360400927 3.253451083042124e-07 0.161956192050434 3.253452022277692e-07 0.1608730077890209 \
3.253452875034443e-07 0.1598934595213354 3.253453878832364e-07 0.1587475631033795 3.253454721860728e-07 0.1577906478848196 3.25345574585582e-07 0.1566342854655733 \
3.253456519798444e-07 0.1557646215197878 3.253457443247583e-07 0.154731814591042 3.253458145762303e-07 0.1539498814072817 3.253459107506593e-07 0.1528844393027091 \
3.253459875753224e-07 0.152038051282755 3.253460663454742e-07 0.1511758489440315 3.253461402383946e-07 0.150370438825067 3.253462079361382e-07 0.1496353997608715 \
3.253463040000261e-07 0.1485973848112393 3.25346373572453e-07 0.1478489919002561 3.253464574616254e-07 0.1469503328160803 3.253465185934615e-07 0.146298213254472 \
3.253465908615431e-07 0.1455309799806117 3.253466633001063e-07 0.1447677488542132 3.253467442811468e-07 0.1439178685120187 3.253468103556157e-07 0.1432275520600639 \
3.253468877561137e-07 0.1424219220725307 3.253469771315706e-07 0.1414956876531561 3.253470479922163e-07 0.1407644282175171 3.253471468792833e-07 0.1397487730030469 \
3.253472241981923e-07 0.1389620820751095 3.253473062434185e-07 0.1381330876879582 3.2534739435453e-07 0.1372467208126059 3.25347461981677e-07 0.1365690714953818 \
3.253475422788589e-07 0.1357674830239305 3.253476170628882e-07 0.1350239185327315 3.253476850640654e-07 0.1343502586094245 3.253477317469739e-07 0.1338891847862563 \
3.253478209985674e-07 0.1330118383700247 3.253478592216168e-07 0.1326395291833771 3.253479282135268e-07 0.1319690872918072 3.253479809615963e-07 0.1314578750898332 \
3.253480639543784e-07 0.1306559489775353 3.253481041328288e-07 0.1302688434457458 3.253481966502028e-07 0.1293805059784019 3.253482353685699e-07 0.1290098403727171 \
3.253483091292851e-07 0.1283055160094505 3.253483707572868e-07 0.1277188748199021 3.253484427849764e-07 0.1270353589407805 3.253485109520081e-07 0.1263909833196726 \
3.253485855741693e-07 0.1256908956540175 3.25348667426635e-07 0.1249253613889138 3.253487508807973e-07 0.124147338931438 3.25348823832511e-07 0.1234692772477456 \
3.253488965594407e-07 0.122795332839617 3.253489565494356e-07 0.1222410931008323 3.253490429174471e-07 0.121445549533078 3.253491038861646e-07 0.1208856452315438 \
3.253491622719555e-07 0.1203507897957366 3.253492279066197e-07 0.119751336354628 3.253492872608612e-07 0.1192111367930785 3.253493552926419e-07 0.1185941868697126 \
3.25349452587012e-07 0.11771710490035 3.253495310789918e-07 0.1170124163111649 3.25349621315123e-07 0.1162055395685231 3.253497171618085e-07 0.1153523005684616 \
3.253497921195047e-07 0.1146878351828532 3.253498964789213e-07 0.1137670532163148 3.25349983267518e-07 0.1130053589403202 3.25350092924934e-07 0.1120476726212376 \
3.253501744789968e-07 0.1113387926087848 3.253502700926292e-07 0.1105114393564785 3.253503468048225e-07 0.10985058581598 3.253504417232868e-07 0.1090364400125625 \
3.253505175463918e-07 0.1083889268999046 3.253505952460493e-07 0.1077282965354292 3.253506775775e-07 0.1070311517075373 3.253507371427637e-07 0.1065286079538068 \
3.253508009005013e-07 0.1059924133642201 3.253508619951089e-07 0.1054803128126646 3.253509578588471e-07 0.1046801683739134 3.253510027219416e-07 0.1043071445723913 \
3.253510859626872e-07 0.1036173314376927 3.25351135082509e-07 0.1032117000904133 3.253512441312713e-07 0.1023149933518279 3.253512889673535e-07 0.1019479364619093 \
3.253513792285848e-07 0.1012117400678687 3.25351420105203e-07 0.1008795969612472 3.25351490563617e-07 0.1003088525914566 3.253515768510382e-07 0.09961307626065434 \
3.253516686285974e-07 0.09887705578174606 3.253517381566897e-07 0.09832225024344161 3.25351816683849e-07 0.09769854072774181 3.253519074125254e-07 0.09698178745350861 \
3.25351983228664e-07 0.09638605854785212 3.253520652414071e-07 0.09574500473888557 3.253521469944435e-07 0.09510943278387665 3.253522375022672e-07 0.09440967388330095 \
3.253523270615646e-07 0.09372126988887708 3.253524126713984e-07 0.09306698857649189 3.253525054508965e-07 0.09236212353634379 3.253525863388571e-07 0.0917510971760913 \
3.253526874678274e-07 0.09099177263830999 3.253527679613525e-07 0.09039108594384238 3.253528522042178e-07 0.08976589684797046 3.253529260492652e-07 0.08922077348043934 \
3.253530028987434e-07 0.08865632925481931 3.253530910391125e-07 0.08801255002475737 3.253531711034816e-07 0.08743108261130086 3.253532641396717e-07 0.08675939571108145 \
3.253533821403849e-07 0.08591369538214398 3.253535245136124e-07 0.08490278100234279 3.253536687619621e-07 0.08388867104764453 3.253538110896711e-07 0.08289807427203813 \
3.253539606674147e-07 0.08186746790234835 3.253540969811606e-07 0.08093761126893445 3.253542391015919e-07 0.0799778356000513 3.253543736550197e-07 0.07907840240745091 \
3.253545140077296e-07 0.07814980287393705 3.253546616898023e-07 0.0771833418413561 3.253548118052992e-07 0.07621180464723754 3.253549765257765e-07 0.07515824360926991 \
3.253551401551281e-07 0.07412455432658185 3.25355314933688e-07 0.07303438636984133 3.253555021863042e-07 0.07188220095900363 3.253557122313082e-07 0.07060976590783831 \
3.253559304415312e-07 0.06930979572898451 3.253561638986196e-07 0.06794333957253913 3.25356418744638e-07 0.06648001693367038 3.253567118391949e-07 0.06483321328442151 \
3.253570141789572e-07 0.06317411115207273 3.253573287658326e-07 0.06148945259513613 3.253577250265267e-07 0.05942677493938087 3.253580587436719e-07 0.05774249301432461 \
3.253584660545012e-07 0.05574994498853819 3.253587939392599e-07 0.05419380357502902 3.25359150629899e-07 0.05254809000207299 3.253594638680598e-07 0.05114243792209583 \
3.253597668351931e-07 0.04981740498512215 3.253600643757185e-07 0.04854875663330436 3.253603431552738e-07 0.04739109061078805 3.253606261551693e-07 0.04624570307560639 \
3.253608878954772e-07 0.04521055793698023 3.253611671343699e-07 0.04413130357485813 3.253614392402902e-07 0.0431040186124033 3.253617466070472e-07 0.04197194005652995 \
3.25361968409948e-07 0.04117329707315532 3.253622748704283e-07 0.04009446155587663 3.253625010598812e-07 0.03931650950691581 3.253627399772065e-07 0.03851359500741255 \
3.253629644010393e-07 0.03777663690506906 3.253631666633204e-07 0.03712468825868943 3.253633677059489e-07 0.03648814235703791 3.253637194799833e-07 0.03540095449820539 \
3.253639697258209e-07 0.03464776841732944 3.253642160441008e-07 0.03392252499723709 3.253644973769647e-07 0.03311308780599518 3.253647404679504e-07 0.03242954897046491 \
3.253649759417007e-07 0.03178112583711486 3.25365217601206e-07 0.03113119522156456 3.253654544834836e-07 0.03050988948014832 3.25365685016041e-07 0.02991733361391674 \
3.253658989845686e-07 0.02937801894285819 3.253661049271158e-07 0.02886851641492237 3.253664976516028e-07 0.02792196059063811 3.25366685729283e-07 0.02747992420741849 \
3.253670611682489e-07 0.02661861215736662 3.253672360424775e-07 0.02622659266649364 3.253676593654916e-07 0.02530049759795254 3.253677806148756e-07 0.02504150687334681 \
3.253682211765283e-07 0.02412433837770948 3.253683636746477e-07 0.02383402682615681 3.253686957281575e-07 0.02316883068419595 3.253688786936821e-07 0.02280879143785283 \
3.25369267997886e-07 0.02205689891561978 3.253694363435941e-07 0.02173705378531499 3.253699084579933e-07 0.02085107653961301 3.253700482027269e-07 0.0205916297664938 \
3.253705437828048e-07 0.01969297428531048 3.253706710082374e-07 0.01946923320191776 3.253712389173419e-07 0.01851512288677271 3.253714031712902e-07 0.0182513999453204 \
3.253720130430286e-07 0.0173209960017622 3.253721727282572e-07 0.01708922829277545 3.253726996397978e-07 0.01635462467776483 3.253729041570907e-07 0.01608193551804103 \
3.253736276344778e-07 0.01515939662837778 3.253737930766099e-07 0.01495683325581705 3.253745396363563e-07 0.01408081084911163 3.253746729395689e-07 0.01393008075245666 \
3.253755331241552e-07 0.01299799962960837 3.253756692055701e-07 0.01285670227674402 3.253766097994594e-07 0.01192267652923807 3.253767735725333e-07 0.01176632439256516 \
3.253777747514646e-07 0.01084959205883911 3.253779122291873e-07 0.01072929995296418 3.253790829267985e-07 0.009787962024485789 3.253791753231659e-07 0.009718668544398181 \
3.253805933990138e-07 0.008725931027897449 3.253806803751621e-07 0.00866912727384293 3.253822213707926e-07 0.00770199130002063 3.253823306868068e-07 0.007633428668288294 \
3.253839739346293e-07 0.006673746291950173 3.253841067919082e-07 0.006603544020797993 3.253862011722063e-07 0.005605323336654431 3.253864095769411e-07 0.00551468736035817 \
3.25388763913366e-07 0.004577307911602986 3.253892374721228e-07 0.004407121484391641 3.253921229089796e-07 0.003492041675788492 3.253926525733265e-07 0.00334538389506189 \
3.253968608005519e-07 0.00237996320858989 3.253973742348033e-07 0.002283557532494709 3.254031334854955e-07 0.001325291758975802 3.254033680667129e-07 0.001279502680325907 \
3.254180358940879e-07 0.0002809017338477542 3.2541814896418e-07 0.0002788534805396912 3.280551690439302e-07 -0.0006849217749926401 3.280553352056058e-07 -0.0009443270389602415 \
3.28055814074993e-07 -0.001850320037528519 3.280559067946197e-07 -0.002050462221988249 3.280562720196971e-07 -0.002913187630468476 3.280563636768137e-07 -0.00314709230904735 \
3.280567297831652e-07 -0.004133001189868674 3.280568399302907e-07 -0.004442309109773816 3.280571506685429e-07 -0.005311341427314526 3.280572524071878e-07 -0.005583925258601597 \
3.280576161113131e-07 -0.00638370916272213 3.280577809576365e-07 -0.006585924750287024 3.280583607549566e-07 -0.005792290386912202 3.280585355894154e-07 -0.004916934050781314 \
3.280586522790152e-07 -0.00413641027497409 3.280587787087077e-07 -0.00310656561120747 3.280588807309106e-07 -0.002137079422087956 3.28059000577393e-07 -0.0008406209844352954 \
3.280590912146293e-07 0.0002489246187367611 3.280591896346795e-07 0.001536790859923857 3.280592893583236e-07 0.002948496343048522 3.280594568423325e-07 0.005545701385567424 \
3.280596754209339e-07 0.009327395936412004 3.280598614912559e-07 0.0128572688386996 3.280600828738638e-07 0.01737012273305725 3.280602435339974e-07 0.02082840415615294 \
3.28060406999647e-07 0.02447866954313523 3.280605576351642e-07 0.02794359528291388 3.280607066909169e-07 0.03145289236167962 3.280608561536706e-07 0.03504014479003619 \
3.280610101846837e-07 0.03879791952579481 3.280611723009431e-07 0.04280891157365373 3.280613383304077e-07 0.04696567134311741 3.280615142832281e-07 0.05141478668696391 \
3.280616949538656e-07 0.05602187592747932 3.280618867748118e-07 0.06094655248807559 3.280620938803164e-07 0.06629309753158302 3.280623154520462e-07 0.07203901748582854 \
3.280625501862155e-07 0.07814662931008168 3.280628017257829e-07 0.08470684589377442 3.280630771678493e-07 0.09190125212984442 3.280633773636676e-07 0.09974607960254324 \
3.280637082958779e-07 0.108390578238945 3.280640839626117e-07 0.1181923833971668 3.280644815454798e-07 0.1285487285136021 3.280649483700824e-07 0.1406786766767902 \
3.280654913626172e-07 0.1547396794802719 3.2806612478764e-07 0.1710742296429572 3.280668207276907e-07 0.1889259607126788 3.280676362848005e-07 0.2097135943149445 \
3.280685463129037e-07 0.2327316641523666 3.280693395691243e-07 0.2526372689279454 3.280700450441999e-07 0.2702038474981599 3.280706639884678e-07 0.2855008995781749 \
3.280712310944079e-07 0.2994177966724069 3.280717541744141e-07 0.3121574438576628 3.280722531532068e-07 0.3242197130846058 3.280727371932144e-07 0.3358335658028451 \
3.280731924200473e-07 0.3466679577370423 3.280736669320092e-07 0.3578644504627745 3.280741068407172e-07 0.368158604789619 3.28074592685345e-07 0.3794271463718566 \
3.280751242881185e-07 0.3916316501999784 3.280756269514167e-07 0.4030538969706937 3.280760560236697e-07 0.4127111343288326 3.280765470403382e-07 0.4236561147984291 \
3.280770484704186e-07 0.434714731975362 3.280773950150088e-07 0.442288187401736 3.280777504243856e-07 0.4500000616404133 3.280781776521144e-07 0.4592019891792938 \
3.28078569851637e-07 0.4675774400278049 3.280788702333952e-07 0.4739448723400065 3.280792120451549e-07 0.4811381049525967 3.280795554849688e-07 0.4883107756756314 \
3.280798162200955e-07 0.4937186470393492 3.280800582500486e-07 0.4987071765458648 3.280803241952915e-07 0.5041573145298286 3.280805814645869e-07 0.509394255416739 \
3.280807715836905e-07 0.5132422368582924 3.280809851098511e-07 0.5175451019736222 3.280811248001571e-07 0.5203466115392713 3.280812710004491e-07 0.5232668091041763 \
3.280814849883502e-07 0.5275186200231483 3.280816930046097e-07 0.5316389396023125 3.280818854658791e-07 0.5354321131715788 3.280820705821105e-07 0.5390651926504321 \
3.280822449555568e-07 0.5424725330931349 3.280825494976334e-07 0.5484058192982523 3.280828100565151e-07 0.5534602958276967 3.280831114875446e-07 0.5592859190791987 \
3.280833658051381e-07 0.5641865993769294 3.280836586613278e-07 0.5698153316805189 3.280839178744799e-07 0.5747800306938655 3.280841889508119e-07 0.579963273174682 \
3.280844307945714e-07 0.5845680738798381 3.280846882997289e-07 0.5894577538325241 3.280849150436047e-07 0.5937419314630586 3.280851520444244e-07 0.5982006324572362 \
3.280853622309863e-07 0.6021379329905048 3.280855749915204e-07 0.6061060319396779 3.280858278702861e-07 0.6107954169450593 3.280860315335545e-07 0.6145509252949414 \
3.280862222509359e-07 0.6180531102377972 3.280864095873744e-07 0.6214768531423983 3.28086598465652e-07 0.6249070011644339 3.280868066654474e-07 0.6286671070650327 \
3.280870509975622e-07 0.6330499453121026 3.280872505640949e-07 0.6366057789565548 3.280874547098357e-07 0.6402215701419991 3.2808763934909e-07 0.643474671963314 \
3.28087908884781e-07 0.6481901084955864 3.280881365916373e-07 0.652149230294136 3.280883242633752e-07 0.6553888277830079 3.280885051635202e-07 0.6584949378977958 \
3.280886647046019e-07 0.661221510907812 3.280888351670024e-07 0.6641177016088209 3.280889869184432e-07 0.6666817235716488 3.280891245614551e-07 0.6689905419339194 \
3.280892735563186e-07 0.6714784915997724 3.280894012981823e-07 0.6736028790357499 3.280895442846951e-07 0.675968899142866 3.280896660677513e-07 0.6779749688503388 \
3.280898023511611e-07 0.6802121872853304 3.280899221800626e-07 0.682172759947357 3.280900687756234e-07 0.6845626218370968 3.28090187248565e-07 0.6864845934661837 \
3.280902831819268e-07 0.6880368302455475 3.280903757015115e-07 0.6895284278106264 3.280904807620225e-07 0.6912169000724893 3.280905788439078e-07 0.6927871490736753 \
3.280907159592253e-07 0.6949707622226827 3.28090835157868e-07 0.6968607547931925 3.280909450978383e-07 0.6985951241089645 3.280910825970815e-07 0.7007503743809057 \
3.280912140269832e-07 0.7027960765825516 3.280913462564987e-07 0.7048392108129343 3.280914594338973e-07 0.7065756917706891 3.280916138667517e-07 0.708927873976708 \
3.280917446467452e-07 0.7109048231498766 3.280918673154548e-07 0.7127465601965561 3.280919735837112e-07 0.7143329262278221 3.280920959637349e-07 0.7161490373358268 \
3.280921978172318e-07 0.7176517022913665 3.280923319551315e-07 0.7196190116794019 3.280924526481717e-07 0.7213783352064487 3.280925717899705e-07 0.7231049829175343 \
3.280926968079846e-07 0.7249059312823601 3.280928266477907e-07 0.7267645120560844 3.280929464599617e-07 0.7284691779696002 3.280930754532131e-07 0.730293808329565 \
3.280932075602774e-07 0.7321507998840678 3.280933258660953e-07 0.7338038328985433 3.280934691267862e-07 0.7357927618453034 3.280935715814729e-07 0.7372070005703254 \
3.280936677883586e-07 0.7385290937783453 3.280937728059804e-07 0.7399656334130889 3.280938835775113e-07 0.7414708009413548 3.280939852560522e-07 0.7428439364018735 \
3.280940882175066e-07 0.7442258341871242 3.280942051436606e-07 0.7457850038572696 3.280943339039365e-07 0.747489965072781 3.28094435062908e-07 0.7488201182152049 \
3.280945839319523e-07 0.7507626302114226 3.280947316114891e-07 0.75267249971878 3.280948509768551e-07 0.7542038164026367 3.280949974606996e-07 0.7560679527984652 \
3.280951206361903e-07 0.7576223900169708 3.280952614398646e-07 0.7593848990234215 3.280953980325311e-07 0.7610800595258669 3.280955201903812e-07 0.7625841275516777 \
3.280956328467787e-07 0.7639610711610054 3.280957745729197e-07 0.7656796138775311 3.280959007394198e-07 0.767196844592689 3.280960161567243e-07 0.768574452686535 \
3.28096146464904e-07 0.7701179991486644 3.280962621775718e-07 0.7714782821591826 3.280963850018603e-07 0.7729116492687436 3.280965028461285e-07 0.7742769236963016 \
3.280966084761186e-07 0.7754922619072108 3.280967238495534e-07 0.7768108638983861 3.280968291127158e-07 0.7780056027231214 3.28096940062529e-07 0.7792565499870431 \
3.280970264670306e-07 0.7802246528436213 3.280971305008506e-07 0.7813823422463088 3.28097244396594e-07 0.7826398494046257 3.280973474300136e-07 0.7837684443710583 \
3.280974555127141e-07 0.7849432998269023 3.280975637643697e-07 0.7861107422109641 3.280976991816164e-07 0.7875582910536544 3.280978118557238e-07 0.7887521292973186 \
3.280979362797841e-07 0.7900592323105087 3.28098054252648e-07 0.7912877959129118 3.280981987206026e-07 0.7927781272271259 3.280983163897418e-07 0.7939806363584788 \
3.280984522695815e-07 0.7953567374150946 3.280985870139539e-07 0.7967081403609936 3.280986980849332e-07 0.7978123285366109 3.280987979742732e-07 0.7987978371087655 \
3.280988996542306e-07 0.7997937268659365 3.280990328678971e-07 0.8010867894381996 3.280991512407163e-07 0.8022243628210853 3.280992727817905e-07 0.8033812848148773 \
3.280993921454424e-07 0.8045065422543012 3.280995132768188e-07 0.80563739819571 3.280996449762361e-07 0.8068544426691319 3.280997679845129e-07 0.8079795872959963 \
3.280998958281203e-07 0.8091371804586788 3.281000267346398e-07 0.8103101881504271 3.28100150327798e-07 0.8114062915203997 3.28100257500303e-07 0.8123479140825919 \
3.281003649295024e-07 0.8132835730547656 3.281004475986206e-07 0.8139979974227743 3.281005653103806e-07 0.8150069815425507 3.281006559159858e-07 0.8157770472204025 \
3.281007865694307e-07 0.8168774959419571 3.28100930959301e-07 0.8180800468042847 3.281010641337151e-07 0.8191766687328477 3.281011740251065e-07 0.8200725423139092 \
3.281013176239916e-07 0.8212302325252553 3.281014710146833e-07 0.8224508494407716 3.281015990929081e-07 0.8234574467428303 3.281017388802764e-07 0.8245431382086058 \
3.281018651298391e-07 0.8255122018650548 3.281020197283917e-07 0.8266841987320058 3.281021519393684e-07 0.8276738265999063 3.281022781661507e-07 0.8286078934539939 \
3.281023959138743e-07 0.8294698388787296 3.281025449866676e-07 0.8305480062617677 3.281027123182206e-07 0.8317406852496945 3.281028455394968e-07 0.8326770812274722 \
3.281030183208196e-07 0.8338744310092966 3.281031868261935e-07 0.8350236380668206 3.281033562054924e-07 0.8361608866600232 3.281035378407611e-07 0.8373606451951652 \
3.281036801740827e-07 0.8382866867625347 3.281037940110689e-07 0.8390185116470331 3.28103925192579e-07 0.8398522525089582 3.28104026724794e-07 0.8404903982372576 \
3.281041430090543e-07 0.8412135669902132 3.281042776438078e-07 0.8420406924792603 3.281044746666439e-07 0.8432316292878405 3.281046647721864e-07 0.8443592803112207 \
3.281048748954986e-07 0.8455816023960827 3.281050552136043e-07 0.8466107566581813 3.281052526767048e-07 0.8477171937062282 3.281054267458196e-07 0.8486750118570332 \
3.281056090652401e-07 0.8496608982186138 3.281057804803758e-07 0.8505716849290491 3.281059545936529e-07 0.8514808063694008 3.281061303246211e-07 0.8523822271368225 \
3.281063064363214e-07 0.8532696099472232 3.281064960541732e-07 0.8542074684498208 3.281066868356705e-07 0.8551330189126392 3.28106888431747e-07 0.8560917259710515 \
3.281070811660049e-07 0.856990088884472 3.281072900378257e-07 0.8579439907476532 3.281075207402632e-07 0.8589743400177088 3.281077851832273e-07 0.8601259267840322 \
3.281080840059149e-07 0.8613896125360476 3.281083639602159e-07 0.8625380186322354 3.281086480860817e-07 0.8636694076724545 3.28108922855057e-07 0.8647317823994775 \
3.281091947122167e-07 0.8657531067718063 3.281094650893343e-07 0.8667403371654003 3.281097221678556e-07 0.8676533221001362 3.281099947926866e-07 0.868594905839151 \
3.281102707598356e-07 0.8695208838709013 3.281105408640933e-07 0.8704012674911344 3.281108407401039e-07 0.8713491368600049 3.281112118011625e-07 0.8724801680184872 \
3.2811150674079e-07 0.8733472453740196 3.28111761036548e-07 0.8740729094291386 3.281120592974738e-07 0.8748989982677786 3.281123329040153e-07 0.8756336613858092 \
3.281125690299577e-07 0.876250392688866 3.281128093740557e-07 0.8768621356511911 3.281130317061818e-07 0.8774140071409635 3.28113225712247e-07 0.8778848105679672 \
3.281135554349973e-07 0.8786625669521169 3.281137106085256e-07 0.8790190643519731 3.281140283876062e-07 0.879730644938159 3.281142072488645e-07 0.8801204696806418 \
3.281145497107611e-07 0.8808457867651537 3.281147338373631e-07 0.8812245477320809 3.28115208711942e-07 0.8821665346129511 3.281153761083518e-07 0.8824869809105039 \
3.281158419518539e-07 0.883348261932613 3.281160227735483e-07 0.8836708855253055 3.281165168126507e-07 0.8845204537290557 3.281166581620591e-07 0.8847551796839913 \
3.281172645001219e-07 0.8857215808967022 3.281174165693362e-07 0.8859539944113424 3.28118063256356e-07 0.8869009218298172 3.281181915512387e-07 0.8870812460539503 \
3.28118839667745e-07 0.8879562712787433 3.281189694676407e-07 0.8881245027440973 3.281197476783404e-07 0.8890830197250962 3.281198627254718e-07 0.8892171882189283 \
3.281207183963142e-07 0.8901564861234483 3.281208637440773e-07 0.8903061494816453 3.281218494996487e-07 0.8912466483555094 3.281220706077111e-07 0.8914402669210102 \
3.281232157277145e-07 0.892367747196105 3.281233469391586e-07 0.8924695935232408 3.281246882116238e-07 0.8934615053489913 3.281248396029001e-07 0.8935661991834861 \
3.281263210551204e-07 0.8944951400107031 3.281265599348161e-07 0.8946288932334222 3.281283293566539e-07 0.895502508848118 3.281287184779452e-07 0.895670668133377 \
3.281311122106538e-07 0.8965556062201232 3.281315877505926e-07 0.8967047758494365 3.281356508198176e-07 0.8977025964496719 3.281361422956535e-07 0.8977953148389237 \
3.281444588927963e-07 0.8987880790885289 3.281453787942481e-07 0.8988514070442593 3.282992423701678e-07 0.8998485708192639 3.283028854964575e-07 0.8998628537402877 \
3.285296142766717e-07 0.8989664306490068 3.285298446165833e-07 0.8988008565867064 3.285314595368805e-07 0.897804750401333 3.285316372691665e-07 0.8977103535805105 \
3.285484036692715e-07 0.8986978311584225 3.285485397684025e-07 0.8987160394686986 3.285637106086718e-07 0.8997133888183054 3.285639877135078e-07 0.899719468756186 \
3.290480289064218e-07 0.9005852143835333 3.290482022410388e-07 0.9007408621809421 3.290488627306383e-07 0.9015135064485434 3.290490287958205e-07 0.9017527716291757 \
3.29049555130528e-07 0.9026184054967997 3.290497462444476e-07 0.9029704910143604 3.290501104654996e-07 0.9036902342402512 3.290502896649215e-07 0.9040628043424317 \
3.290506515515938e-07 0.9048333795345931 3.290508466611638e-07 0.9052442844328937 3.290513790595253e-07 0.9062266394381637 3.290515614131638e-07 0.9064623886473868 \
3.290525533935561e-07 0.905594670761786 3.290527149341233e-07 0.9049318860608667 3.290528829265756e-07 0.9040378649110347 3.290530427580612e-07 0.9029782421366458 \
3.29053180254799e-07 0.9018984154159868 3.290533131621115e-07 0.9007052793196499 3.290534395875788e-07 0.8994328447569792 3.290535469868187e-07 0.8982475863895881 \
3.290536514834769e-07 0.8970047013543965 3.290537655331467e-07 0.8955451342423859 3.290538555027343e-07 0.8943225684615312 3.290539603213726e-07 0.8928208677113324 \
3.290540497696119e-07 0.891473284704788 3.290541321453926e-07 0.8901820884368528 3.290542232383926e-07 0.8887006634027688 3.290543605744706e-07 0.8863657732814155 \
3.290544590674027e-07 0.8846195012157601 3.290545711411528e-07 0.8825649218508906 3.290547020241858e-07 0.880080778639088 3.290548384952159e-07 0.8774018563482072 \
3.290549919493788e-07 0.8742910281085086 3.290551510437468e-07 0.8709679977889497 3.290553153276494e-07 0.867445283300377 3.290554719957507e-07 0.8640104344288071 \
3.290556240865311e-07 0.860615744772629 3.290557778002064e-07 0.857132398554192 3.290559373623814e-07 0.853469801378647 3.290560924510829e-07 0.8498714074018293 \
3.290562661304016e-07 0.8458039138600054 3.290564291612694e-07 0.8419559450883216 3.29056590803684e-07 0.8381170660338335 3.290567534504206e-07 0.8342344554797501 \
3.290569148689274e-07 0.8303657475978833 3.29057083463406e-07 0.8263109424305363 3.290572663565043e-07 0.8219002364007665 3.290574341852182e-07 0.8178440888239877 \
3.290576024710332e-07 0.8137703061148112 3.290577732990847e-07 0.8096302849976138 3.290579454736422e-07 0.8054541271740473 3.290581132355611e-07 0.8013830614994394 \
3.290582968650184e-07 0.7969255463994016 3.290584682714963e-07 0.7927646873948894 3.290586537148024e-07 0.7882638003278283 3.290588203854536e-07 0.7842196820467244 \
3.290589892715848e-07 0.7801233737411432 3.290591734278819e-07 0.7756572567105651 3.290593680379105e-07 0.7709405333854473 3.290595152932414e-07 0.7673736106648734 \
3.29059641923832e-07 0.7643079795643375 3.290597837806443e-07 0.7608754495129878 3.290598881844221e-07 0.7583505812556488 3.290600205770739e-07 0.7551502542766809 \
3.290601301612705e-07 0.7525028097975122 3.290602633259231e-07 0.7492875979647342 3.290604195076852e-07 0.7455190770546114 3.290605327371121e-07 0.7427887939149777 \
3.290606952584764e-07 0.7388718945951063 3.290608674392915e-07 0.7347246296492568 3.29061063444044e-07 0.7300078517193382 3.290612278340229e-07 0.7260553905833119 \
3.290613802307036e-07 0.7223944885043934 3.290615439058578e-07 0.718466402706526 3.29061711831558e-07 0.7144406657912139 3.290618916719358e-07 0.7101336212543717 \
3.290620679658861e-07 0.7059164985576465 3.290622390405214e-07 0.7018286413152719 3.29062407358697e-07 0.6978099102718778 3.290625606248287e-07 0.6941537154717222 \
3.290627225083983e-07 0.6902960245155986 3.290629014599385e-07 0.6860364417190952 3.290630356714899e-07 0.6828448068431195 3.290631391777878e-07 0.6803854168085423 \
3.290632384622005e-07 0.6780286039046017 3.290633399166766e-07 0.6756220912380299 3.290634323732757e-07 0.6734303711245889 3.29063516962075e-07 0.6714267031582685 \
3.290636105394115e-07 0.6692114082407524 3.290637270816307e-07 0.6664546942583044 3.290638365591918e-07 0.6638675763958631 3.290639496722031e-07 0.6611971533414394 \
3.290640727909702e-07 0.6582923426231613 3.29064197017283e-07 0.6553636581362478 3.290643677774271e-07 0.6513432847262797 3.290645262260144e-07 0.6476181700514572 \
3.290646985138371e-07 0.6435738126612673 3.290648444919037e-07 0.6401512360303271 3.290649862851197e-07 0.6368325564797357 3.290651178835739e-07 0.6337564355289309 \
3.290652480468588e-07 0.630718219665797 3.290653735717996e-07 0.6277924818644975 3.290655053547071e-07 0.6247239543970449 3.290656352782026e-07 0.6217046839485236 \
3.290657715867779e-07 0.6185408917806742 3.290659162003453e-07 0.615188962872713 3.29066075692536e-07 0.611499189008522 3.290662491526524e-07 0.6074939486938447 \
3.290664201599544e-07 0.6035554342946753 3.290666515285226e-07 0.5982402936372396 3.290668949905284e-07 0.5926661367297537 3.29067069111016e-07 0.5886942528256315 \
3.290672153830935e-07 0.5853638081576373 3.290673497553116e-07 0.58231230528805 3.290674668502067e-07 0.5796585826255305 3.290675626145532e-07 0.5774900935424465 \
3.290676614610955e-07 0.5752566196463251 3.290677454384143e-07 0.5733628024369305 3.290678230524635e-07 0.571614165956722 3.290678843779373e-07 0.5702331258704825 \
3.290679490585756e-07 0.5687779664863769 3.290680303667114e-07 0.5669528575016536 3.290680804367073e-07 0.5658306078972934 3.290681297572688e-07 0.5647256890740617 \
3.29068191677069e-07 0.5633393552914843 3.290682395088943e-07 0.5622690492396486 3.290682900136796e-07 0.5611395143522533 3.290683500757169e-07 0.559799205480933 \
3.290684093585124e-07 0.5584782058326896 3.290684844152261e-07 0.5568072508052372 3.290685540978827e-07 0.5552574373576753 3.290686396864492e-07 0.5533559356568912 \
3.290687267538207e-07 0.5514265885063823 3.290688104163414e-07 0.5495763264044081 3.290688965613662e-07 0.5476734676082877 3.290689922659868e-07 0.5455621222678217 \
3.290690965509387e-07 0.5432673229847179 3.290692112181133e-07 0.5407497407899529 3.290693199365745e-07 0.5383664115638558 3.290694295088142e-07 0.5359693749054023 \
3.290695418135745e-07 0.5335193270114367 3.290696685891956e-07 0.530759392645703 3.290697908664272e-07 0.5281021910076299 3.290699309524049e-07 0.5250685463469849 \
3.290700679697626e-07 0.5221084647952599 3.29070218271135e-07 0.5188705764247719 3.290703771663761e-07 0.5154582091324615 3.290705515002589e-07 0.5117250894133971 \
3.29070738517481e-07 0.5077378180012799 3.290709438354859e-07 0.5033745272871338 3.290711556776788e-07 0.498891131759938 3.29071408479721e-07 0.4935662239713107 \
3.2907161056737e-07 0.4893264048484654 3.290718451606753e-07 0.4844277613141263 3.290720812752722e-07 0.4795194943790256 3.290723344517689e-07 0.474283574581623 \
3.290726449817317e-07 0.4679020429045382 3.290728630397103e-07 0.4634451779596257 3.290730364853444e-07 0.4599153839204358 3.290732129777809e-07 0.4563351808422506 \
3.290734924595775e-07 0.4506930409909046 3.290737247034844e-07 0.4460279192631412 3.290740117970732e-07 0.44029020239849 3.290742296431809e-07 0.435960758243863 \
3.290744396957687e-07 0.4318042429497612 3.290746408936045e-07 0.4278406951573778 3.290748233137656e-07 0.4242617300271556 3.290749972087507e-07 0.4208637793449936 \
3.290751620728668e-07 0.4176529694331993 3.290753208268398e-07 0.4145718140694327 3.290754870737866e-07 0.4113577680628809 3.290756357189934e-07 0.4084923702366076 \
3.290757880872491e-07 0.4055658186126443 3.290759301504318e-07 0.4028468403491589 3.290760995263099e-07 0.3996150665462138 3.290762199082301e-07 0.3973276483660343 \
3.290763298814939e-07 0.3952449223617059 3.290764448068949e-07 0.3930732253581283 3.290765970484751e-07 0.3902080468194818 3.290767092695403e-07 0.3881039677199808 \
3.290768164620408e-07 0.386098874836553 3.290769689902897e-07 0.383254723448244 3.290770971374193e-07 0.380874963946598 3.290772199854117e-07 0.3786015923730871 \
3.290773990837881e-07 0.375299968600122 3.290775481684202e-07 0.3725653942578417 3.290777158758077e-07 0.3695018296724824 3.290778712734425e-07 0.3666748141177644 \
3.290779954402882e-07 0.3644243980538668 3.290781093321555e-07 0.3623666676050148 3.29078230775526e-07 0.3601804966264144 3.290784109272934e-07 0.3569532670533712 \
3.290785774151136e-07 0.3539878629329621 3.29078767834223e-07 0.3506138544217919 3.290789595908186e-07 0.3472380408565978 3.290791426402121e-07 0.344035729794033 \
3.290792916122767e-07 0.3414435189591631 3.290794115521823e-07 0.3393660536257183 3.290795342136651e-07 0.3372483242714233 3.290796572441514e-07 0.3351324902755385 \
3.29079802148562e-07 0.3326515017845288 3.290799054613373e-07 0.3308907757076019 3.290799991908464e-07 0.3292979229163631 3.290800898511484e-07 0.3277620998585528 \
3.29080200972602e-07 0.3258853746017661 3.290803081455789e-07 0.3240820510456246 3.290804064202303e-07 0.3224338250618513 3.290805188247763e-07 0.3205545940512134 \
3.290806827646764e-07 0.3178277446588927 3.290808444025551e-07 0.3151576097143818 3.290809921893013e-07 0.3127316247504084 3.290811544345159e-07 0.3100832165115083 \
3.290813144650734e-07 0.3074868334344322 3.290814667283718e-07 0.3050304870660137 3.290816201002421e-07 0.3025703731928215 3.29081778808771e-07 0.3000411640344692 \
3.290819432578998e-07 0.297437246442505 3.290821104849764e-07 0.2948063590562646 3.290822635965136e-07 0.292412731930112 3.290824466944405e-07 0.2895700146919417 \
3.290826370021783e-07 0.2866380344427262 3.290827859052365e-07 0.2843603072871506 3.290829598425416e-07 0.2817165165722222 3.290831367199302e-07 0.2790484233348025 \
3.290832843171486e-07 0.2768363681311815 3.290834739488487e-07 0.2740172295061162 3.290836239507675e-07 0.2718052906662373 3.290837610609577e-07 0.2697943906627059 \
3.290839025914008e-07 0.2677397479842996 3.290840160502698e-07 0.2661005451260196 3.290841523405965e-07 0.2641384584581135 3.290842824172175e-07 0.2622807416655737 \
3.290844006714701e-07 0.2606037730704709 3.290845185270663e-07 0.2589348966568543 3.290846494208769e-07 0.2570853888657079 3.290847896596348e-07 0.2551145527343576 \
3.290849051542211e-07 0.2534976852533538 3.290850340055979e-07 0.2516957519945816 3.290851491515796e-07 0.2500885525459272 3.290853024625469e-07 0.2479513765689386 \
3.290854403163083e-07 0.2460367343642474 3.290855797779604e-07 0.2441002375748529 3.29085735245815e-07 0.2419427021952501 3.290858600284303e-07 0.2402176526454788 \
3.290859998933384e-07 0.2382916534360561 3.290861285955144e-07 0.2365220787132559 3.290862495543663e-07 0.234860341242685 3.290863665996657e-07 0.2332541163798121 \
3.290864926007302e-07 0.2315368940272461 3.290865893203229e-07 0.2302195772445239 3.290866814091961e-07 0.2289683907689286 3.290867958266674e-07 0.2274152998827935 \
3.290868941973141e-07 0.2260807986508055 3.290870113441077e-07 0.2244933520241092 3.290871144352257e-07 0.2231010305483718 3.290872199499518e-07 0.2216798666278746 \
3.290873008680117e-07 0.2205933880575098 3.290873745391968e-07 0.2196046443759679 3.290874172684338e-07 0.2190314036349237 3.29087460398579e-07 0.2184540235451489 \
3.290875111960607e-07 0.217774515685755 3.290875483709394e-07 0.217277430841393 3.29087589041954e-07 0.2167338127731004 3.290876318337555e-07 0.2161620985357572 \
3.290876682448971e-07 0.2156758299561118 3.290877101698878e-07 0.2151161507306283 3.290877647120985e-07 0.2143884526296278 3.290878031708565e-07 0.2138756926875936 \
3.290878427976257e-07 0.2133496230586122 3.290879046301276e-07 0.212531488259555 3.290879663565787e-07 0.2117156525305126 3.290880224938542e-07 0.210974237875411 \
3.290880861490837e-07 0.210134110843225 3.290881802401172e-07 0.2088936328424611 3.290882670483761e-07 0.2077505933124353 3.290883610050201e-07 0.2065146061917991 \
3.290884590472537e-07 0.2052266823513323 3.290885606346195e-07 0.2038976009052371 3.290886615435679e-07 0.2025832113009377 3.290887582793767e-07 0.2013244528083448 \
3.290888604043477e-07 0.1999972806373927 3.290889637359055e-07 0.1986583046056677 3.29089073618507e-07 0.1972379690671278 3.290891825607647e-07 0.1958337611883887 \
3.290893023958847e-07 0.1942937175364915 3.290894126797513e-07 0.1928822800638286 3.290895205584963e-07 0.191507108810815 3.290896466212543e-07 0.1899051957406391 \
3.290897364889608e-07 0.1887671190866151 3.290898469673e-07 0.1873723090993208 3.290899245002487e-07 0.1863971337376019 3.290900088239919e-07 0.1853400660204312 \
3.2909009641205e-07 0.1842452710069853 3.290901842046442e-07 0.18315095174413 3.290902659245155e-07 0.1821357652581398 3.290903634861928e-07 0.1809282658474054 \
3.290904701973441e-07 0.1796118512064394 3.29090570679026e-07 0.178377576484793 3.290906948502376e-07 0.1768595317522179 3.290908287417608e-07 0.1752320886156309 \
3.290909476539533e-07 0.1737937102924047 3.290910980541469e-07 0.1719851742607024 3.290912088892401e-07 0.1706594030660365 3.290913486559821e-07 0.168997130456427 \
3.290914671812902e-07 0.1675953052211382 3.29091572608521e-07 0.1663548750207849 3.290916673183802e-07 0.1652455210322802 3.290917606281544e-07 0.1641568522804657 \
3.290918615342705e-07 0.1629842804551663 3.290919569521023e-07 0.1618800504313296 3.290920541430255e-07 0.1607598891027116 3.290921357045071e-07 0.1598237474547246 \
3.290922410209519e-07 0.1586229753023833 3.290923245006587e-07 0.1576763029943549 3.290924260299495e-07 0.1565306813704828 3.290925032604858e-07 0.1556635090415242 \
3.29092594132523e-07 0.154647919213242 3.290926634838334e-07 0.1538765336840219 3.290927480678846e-07 0.1529397840535594 3.290928224610911e-07 0.1521208717489242 \
3.290929018312932e-07 0.151251902275755 3.290929764189645e-07 0.1504388356812226 3.290930456405212e-07 0.1496871728711989 3.290931403213281e-07 0.1486640077242138 \
3.29093210087093e-07 0.1479134441579097 3.290932945316558e-07 0.147008717574758 3.290933560970016e-07 0.1463518850554192 3.290934301394933e-07 0.1455673550676988 \
3.290935035250169e-07 0.1447940960774066 3.290935849602586e-07 0.1439395015691976 3.290936544094048e-07 0.1432139999234875 3.290937295111024e-07 0.1424323701137583 \
3.290938194231735e-07 0.1415006120834361 3.290938965067932e-07 0.1407052977810757 3.290939956173774e-07 0.1396885207473417 3.290940651574398e-07 0.138983077430453 \
3.290941464759156e-07 0.1381612812129989 3.290942166443247e-07 0.1374549162714094 3.290942956124378e-07 0.1366629455350578 3.290943745907205e-07 0.1358740351737466 \
3.290944469125105e-07 0.1351544405911459 3.290945162779692e-07 0.1344667589602006 3.290945649819766e-07 0.1339854049281765 3.290946557443483e-07 0.1330945614011112 \
3.290946877658758e-07 0.1327823711724506 3.290947758698441e-07 0.131925672678654 3.290948083638864e-07 0.1316105445757083 3.290949070315436e-07 0.1306564447580443 \
3.290949506875193e-07 0.130235859061297 3.290950286693357e-07 0.1294866595045693 3.290950660002937e-07 0.1291289430202982 3.290951681516938e-07 0.128153223240932 \
3.290952355956539e-07 0.1275115375392494 3.290953007486116e-07 0.1268935577290946 3.290953666546259e-07 0.1262729746041904 3.290954378066093e-07 0.1256052797936485 \
3.290955207439704e-07 0.1248293808775363 3.290956061394508e-07 0.1240331657139879 3.290956822268445e-07 0.1233259817834828 3.290957626875214e-07 0.1225806238777534 \
3.290958207714622e-07 0.1220441728027253 3.29095892104936e-07 0.1213870835332726 3.290959768933693e-07 0.1206085709991845 3.290960380484021e-07 0.1200487744399507 \
3.290961081348534e-07 0.1194096117168642 3.290961706401422e-07 0.1188419501154776 3.290962366450903e-07 0.1182453094891599 3.290963054178569e-07 0.1176255789053269 \
3.290963748744814e-07 0.1170017375875525 3.29096458038731e-07 0.1162574953874909 3.290965311562548e-07 0.1156056107435251 3.29096601870241e-07 0.1149774116339468 \
3.290966612219237e-07 0.1144518657417393 3.290967665191357e-07 0.1135239342411639 3.290968123866298e-07 0.1131212254602471 3.290968993406834e-07 0.1123603821649216 \
3.290969423544638e-07 0.1119852310621949 3.290969872212112e-07 0.1115947726395539 3.29097076954706e-07 0.1108164664143028 3.290971478390574e-07 0.110204256460374 \
3.290972266925708e-07 0.109525796983828 3.290972894703463e-07 0.1089876103666232 3.290973494647019e-07 0.1084750215669379 3.290974604624741e-07 0.1075310013968523 \
3.2909754121676e-07 0.1068475792877216 3.290976536800859e-07 0.1059005796323111 3.290977048246292e-07 0.1054717782906781 3.290977878097979e-07 0.1047785948356612 \
3.290978459745031e-07 0.1042945647727652 3.29097960212503e-07 0.1033482075721767 3.290980101159701e-07 0.1029366076865433 3.290980958575694e-07 0.1022320954501846 \
3.290981448890196e-07 0.1018307629303728 3.290982274554409e-07 0.101157455862875 3.290982983877772e-07 0.1005815064560546 3.290983665381274e-07 0.1000302812267231 \
3.290984441484433e-07 0.0994053199805509 3.290985164918144e-07 0.09882546240595018 3.29098594067778e-07 0.09820656846618626 3.290986827384394e-07 0.09750287271560702 \
3.290987565532273e-07 0.09692010793638871 3.290988381442348e-07 0.09627924899616347 3.290989162827031e-07 0.09566870926115327 3.290990020324936e-07 0.09500229249765579 \
3.290990897294021e-07 0.09432453920671229 3.290991836389668e-07 0.09360304191323381 3.290992800982852e-07 0.09286661217778783 3.290993587289458e-07 0.09226977907248698 \
3.290994614525456e-07 0.09149473120661993 3.290995452801959e-07 0.09086620530027881 3.290996660323777e-07 0.08996702094116031 3.29099795302029e-07 0.08901247130467421 \
3.290999511904932e-07 0.08787237469953549 3.291001062900762e-07 0.08675000010972149 3.291002633058824e-07 0.08562614142917294 3.291004433267348e-07 0.08435280068725284 \
3.291005938476015e-07 0.08330035525696428 3.291007422216238e-07 0.08227363395463329 3.291008798388548e-07 0.08133079092382095 3.291010197585049e-07 0.08038162993974078 \
3.291011563654934e-07 0.07946425488810546 3.291012950927908e-07 0.07854214404995859 3.291014404036529e-07 0.07758663187171365 3.29101588151466e-07 0.07662571164688473 \
3.291017467483332e-07 0.07560598447141591 3.29101911000851e-07 0.07456266320243836 3.291020800179273e-07 0.07350246718885647 3.29102261906921e-07 0.07237646636762114 \
3.291024625290194e-07 0.07115268999588262 3.291026764065622e-07 0.0698691158856425 3.291029040406938e-07 0.0685263410462881 3.291031456262355e-07 0.06712722147996912 \
3.29103427215414e-07 0.06552977831071743 3.291037243695346e-07 0.06388229915275011 3.291040478026115e-07 0.06213267023812474 3.29104438962031e-07 0.0600758559534558 \
3.29104840456333e-07 0.05803293250078725 3.291052173970595e-07 0.05617754872181892 3.291055845107909e-07 0.05442503025024555 3.291059346274713e-07 0.05280240270907886 \
3.291062539331247e-07 0.05136309724710254 3.291065582574072e-07 0.05002640192327024 3.291068551633126e-07 0.04875503464657577 3.291071371636386e-07 0.04757867888787161 \
3.291074175969433e-07 0.04643900623749339 3.291076823205669e-07 0.04538777697325767 3.291079582182789e-07 0.04431704973151576 3.291082326831433e-07 0.04327654260273706 \
3.291085311024235e-07 0.04217254828989973 3.291087576184799e-07 0.04135316230013186 3.291090695313176e-07 0.04025053053625379 3.291092897861088e-07 0.03948972371590862 \
3.291095070508635e-07 0.03875470657060948 3.291097167735126e-07 0.03806113111453101 3.291100269559001e-07 0.03705828856757609 3.291102495537778e-07 0.03635538859683734 \
3.29110496919279e-07 0.03559019656168042 3.291107693256556e-07 0.03476651972027592 3.291109899582094e-07 0.03411384091885184 3.291112742384598e-07 0.03329124852897781 \
3.291115121517525e-07 0.0326183788879464 3.291117502411637e-07 0.03195887699386461 3.291119854964917e-07 0.03132132139405813 3.291122142751987e-07 0.03071728735992773 \
3.291124470059479e-07 0.03011490821398154 3.291126663089891e-07 0.02955843195412813 3.291128702520595e-07 0.02905055018162466 3.291132691617956e-07 0.02808303002558106 \
3.291134563160508e-07 0.02764052191221165 3.29113828521772e-07 0.0267814187683372 3.29114015473295e-07 0.02635997027055515 3.291143848272417e-07 0.02554620807076183 \
3.291145384804102e-07 0.02521471147941385 3.291149546945644e-07 0.02434161493068329 3.291151601823807e-07 0.02392065165079968 3.291154991903413e-07 0.02323955384462723 \
3.291156818850694e-07 0.02287916718068597 3.291161389789784e-07 0.02199597290476789 3.291162687197144e-07 0.02174967209293581 3.291167221401377e-07 0.02089828923199067 \
3.2911686451243e-07 0.0206336680476187 3.291173940791906e-07 0.01967289368906444 3.291175202861975e-07 0.01945139161001456 3.291180825206354e-07 0.01850749734048266 \
3.29118245259022e-07 0.01824627541187189 3.291188094390872e-07 0.01738327200207762 3.291189611831539e-07 0.01716165742474803 3.291196628626383e-07 0.01618760396393164 \
3.291198329517282e-07 0.01596324388168 3.291204880096043e-07 0.01513221026437959 3.291206545239164e-07 0.01492874613340729 3.291213876376758e-07 0.01406966818047924 \
3.291215209008543e-07 0.01391906482409888 3.291223725580289e-07 0.01299647369571925 3.291225105004775e-07 0.01285324185793544 3.291234505599668e-07 0.0119198170026788 \
3.29123614321604e-07 0.01176347583728811 3.291246015550385e-07 0.01085909507266535 3.291247361441145e-07 0.0107410715025141 3.291258775835447e-07 0.009819907073012045 \
3.291259858224434e-07 0.009738548299709823 3.29127309069827e-07 0.00880579379490502 3.291274418155253e-07 0.008718202093769473 3.291289643166501e-07 0.007760835273143199 \
3.29129076858719e-07 0.007690148685505111 3.291307691503061e-07 0.00669558715138598 3.291309094168915e-07 0.00662113250846694 3.291329824261937e-07 0.005629132576249021 \
3.291331749877106e-07 0.005545002188831318 3.291353851975589e-07 0.004656096148610405 3.291357919842319e-07 0.004507219767123045 3.291386137242086e-07 0.003590578528330178 \
3.291391350199587e-07 0.00344214578404881 3.291433471210094e-07 0.002447529662748036 3.291438996838773e-07 0.002340875287107731 3.291497829734169e-07 0.001359168649576994 \
3.291500322464151e-07 0.001311490127959886 3.291631823674654e-07 0.0003136950974005476 3.291632991504353e-07 0.0003112730584132499 3.589900000000113e-07 3.042397160644726e-06 \
4.027466670270133e-07 -0.0009024818035526668 4.027467394426295e-07 -0.001022682652537627 4.027471754673471e-07 -0.001858525046639076 4.027472623617301e-07 -0.002046124893065343 \
4.027476170650434e-07 -0.00288168582347465 4.027477166116442e-07 -0.003135075204051477 4.027479768813486e-07 -0.003828199033013717 4.027481172037501e-07 -0.004216406518003108 \
4.027483446898323e-07 -0.004856871791621592 4.027484818972713e-07 -0.005239031028659006 4.0274886679612e-07 -0.006187559915121 4.027489988933069e-07 -0.006423332025500122 \
4.027496873363354e-07 -0.005917035979538006 4.027498442650689e-07 -0.005202654566481615 4.027499719142314e-07 -0.004414133290428114 4.027500994560215e-07 -0.003433350487145549 \
4.027502171302335e-07 -0.002355902309038119 4.027503162699201e-07 -0.001320627313728655 4.027504216526298e-07 -9.507383675133965e-05 4.027505355599331e-07 0.001369964538583592 \
4.027506666153286e-07 0.003229572948258866 4.027507919785475e-07 0.005172303930030842 4.027509838204114e-07 0.008432154569684791 4.027511274902044e-07 0.01107975669588844 \
4.027512854720174e-07 0.01417105828876112 4.027514340716643e-07 0.01723098336859398 4.02751587122593e-07 0.02051714008521248 4.027517461875693e-07 0.02405720796424875 \
4.02751899257778e-07 0.02756764950178633 4.027520476048421e-07 0.03105219347129199 4.027521967112842e-07 0.03462388853332505 4.027523512757131e-07 0.03838854885099419 \
4.027525119616768e-07 0.04235886888523473 4.027526766408632e-07 0.04647718198980624 4.027528531638066e-07 0.05093664320808645 4.027530321756059e-07 0.05549818742091989 \
4.027532229484479e-07 0.0603932190016783 4.027534277958001e-07 0.06567927942044927 4.027536482930531e-07 0.07139554989571946 4.027538812110213e-07 0.07745499876455469 \
4.027541304587992e-07 0.08395499695136356 4.027544033803266e-07 0.09108394918256098 4.027547001733835e-07 0.09884095133633181 4.027550276098956e-07 0.1073964775374675 \
4.027553974236946e-07 0.1170487607486894 4.027557923699755e-07 0.1273407304921971 4.027562504585284e-07 0.1392499850125259 4.027567825583881e-07 0.1530377249371455 \
4.027574081103967e-07 0.169180864038255 4.027580941024627e-07 0.1867931863309214 4.027588969458782e-07 0.2072766958045763 4.027597962582096e-07 0.2300508264895909 \
4.027606966983226e-07 0.2526618731709107 4.027614985898552e-07 0.2726215666318766 4.027621940969962e-07 0.2897857674353052 4.027628269312821e-07 0.3052728323588638 \
4.027634223397735e-07 0.3197161646377594 4.027639693828152e-07 0.3328722959176427 4.027645031431617e-07 0.3455929446372428 4.027650223825863e-07 0.3578476146335662 \
4.027655297740487e-07 0.3697097539883151 4.027660333952181e-07 0.3813674725871593 4.027665451381145e-07 0.3930934709428262 4.027670522991229e-07 0.404595334768291 \
4.027675825951367e-07 0.4164962117964878 4.027680687086257e-07 0.4272847049163567 4.027685468169473e-07 0.437781779057129 4.027689862490711e-07 0.4473362978389137 \
4.027691094085349e-07 0.4500002106608159 4.027693557274626e-07 0.4553046876287923 4.027696989994585e-07 0.4626558934952216 4.02770010436459e-07 0.4692815017887791 \
4.027702611477243e-07 0.4745855323881177 4.027705319768677e-07 0.480281321066213 4.02770868458777e-07 0.4873122872019196 4.027712244673881e-07 0.4946959640027882 \
4.027715417375557e-07 0.5012322602315481 4.027717806181048e-07 0.506122906570856 4.027720216462867e-07 0.5110269393752048 4.027722735779908e-07 0.5161276795544476 \
4.027725137318346e-07 0.5209621749612534 4.027727364832964e-07 0.5254248476203834 4.027729250409435e-07 0.5291850880529715 4.027731397909867e-07 0.5334523706207774 \
4.027733543393784e-07 0.5376948565446859 4.027736131036701e-07 0.5427871977552768 4.027738639312417e-07 0.5477009885064807 4.027741193501039e-07 0.5526782776843104 \
4.027744703926295e-07 0.5594898819265107 4.027747350009544e-07 0.5645984056527484 4.027750014175097e-07 0.569709962982798 4.027752619318197e-07 0.5746801970751495 \
4.027755290218824e-07 0.5797469183389945 4.027757721599625e-07 0.5843213438768613 4.02776027852189e-07 0.5890994944692448 4.027762556711592e-07 0.5933243819692556 \
4.027764932159793e-07 0.5976999800355528 4.027767046064655e-07 0.6015679915939678 4.027769167472246e-07 0.6054277082074113 4.027771059366022e-07 0.6088479815213901 \
4.027772370949197e-07 0.6112112531841202 4.027773693914781e-07 0.6135871094428261 4.02777554614204e-07 0.6169015645304802 4.027777166365907e-07 0.6197943209800671 \
4.027778750557552e-07 0.6226100751126036 4.027780091676215e-07 0.6249846001944386 4.027781814887287e-07 0.6280247049765127 4.027783104275314e-07 0.6302937061188456 \
4.027784308050438e-07 0.6324061607157294 4.027785713339149e-07 0.634864734791624 4.027787644194074e-07 0.6382321981637986 4.027789142301853e-07 0.6408363654380513 \
4.027790815377796e-07 0.6437327988167145 4.027792625920029e-07 0.6468572757970242 4.027794659184327e-07 0.6503523798695617 4.027796487715879e-07 0.6534819287355287 \
4.027798193958343e-07 0.6563879501053153 4.027799968600742e-07 0.6594029650344411 4.027801628390247e-07 0.6622113135173925 4.027803200758144e-07 0.6648594636266301 \
4.02780460561866e-07 0.6672075432495704 4.027806042919945e-07 0.6695987751186935 4.027807373389854e-07 0.6718055529208897 4.02780879311128e-07 0.6741523780906628 \
4.027809993716612e-07 0.6761293215200647 4.027811443097483e-07 0.6785098354674278 4.027812603067977e-07 0.6804095298668216 4.027813798866854e-07 0.6823647593763783 \
4.027814788466604e-07 0.68397755359623 4.027815973550785e-07 0.6859039329668146 4.027816843993602e-07 0.6873150904607619 4.027818064101795e-07 0.6892866586554622 \
4.027819053327908e-07 0.6908817703737582 4.027819972281661e-07 0.6923536807698466 4.027820971967054e-07 0.6939486118486815 4.02782195442366e-07 0.6955126686751646 \
4.027822871561283e-07 0.6969676095571918 4.027823912890697e-07 0.698613189139943 4.02782527015812e-07 0.7007470979739818 4.027826816242742e-07 0.7031613517373301 \
4.027828167319862e-07 0.7052558942641604 4.027829630685319e-07 0.7075085519458914 4.027830915360735e-07 0.7094732734147607 4.02783215720207e-07 0.7113609898537658 \
4.027833256245073e-07 0.7130225953369277 4.027834422075759e-07 0.7147759898693785 4.027835423854067e-07 0.7162749667021007 4.027836794742156e-07 0.7183149847558421 \
4.027837994632423e-07 0.7200901405411056 4.027839185766902e-07 0.7218426783097279 4.02784045072077e-07 0.723693513465353 4.027841709394491e-07 0.7255245570057045 \
4.027842935604676e-07 0.7272980597885179 4.027844211779915e-07 0.7291334326655684 4.027845514267828e-07 0.7309957624152177 4.02784673019733e-07 0.73272442801297 \
4.027848117884253e-07 0.7346853525547948 4.02784912196869e-07 0.7360963845229137 4.027850155842573e-07 0.7375412410987998 4.027851092446997e-07 0.7388443755773992 \
4.027852208662967e-07 0.7403895158541485 4.027853073348996e-07 0.7415798421827293 4.027854081980104e-07 0.7429609798983192 4.027855402947324e-07 0.7447573558536402 \
4.027856494960337e-07 0.7462323422761349 4.027857540276639e-07 0.747635567415085 4.027858776741446e-07 0.7492836897664436 4.027860263705797e-07 0.7512497161812216 \
4.027861482512389e-07 0.7528480713857697 4.02786261855803e-07 0.7543274008692354 4.027864023754882e-07 0.7561429069656862 4.027865435649301e-07 0.7579511824827749 \
4.027866613111062e-07 0.7594470562859095 4.027867900007657e-07 0.7610693809796742 4.027869325554127e-07 0.7628512182523866 4.027870484119641e-07 0.7642872416835913 \
4.027871941752297e-07 0.7660789429779771 4.02787316007677e-07 0.7675637574673733 4.02787434476374e-07 0.7689965471136999 4.02787557264006e-07 0.7704700089613156 \
4.027876834168886e-07 0.7719718272910862 4.027877937859393e-07 0.7732757954107932 4.02787919217035e-07 0.7747465774777432 4.027880246987464e-07 0.775974259539018 \
4.027881578651758e-07 0.7775122819577122 4.02788280546631e-07 0.7789173428708996 4.027884153096743e-07 0.7804473432620218 4.027885259809625e-07 0.7816923373676121 \
4.027886353025911e-07 0.7829118427552927 4.027887704350256e-07 0.7844048889494442 4.027889212140504e-07 0.7860523747618094 4.027890615829581e-07 0.7875692293014268 \
4.027891812944828e-07 0.7888502570533434 4.027893195488235e-07 0.7903153082715967 4.027894429191593e-07 0.7916096503654788 4.027895880177844e-07 0.7931164937536124 \
4.027897277580435e-07 0.7945521172774316 4.027898549394667e-07 0.7958455533278409 4.027899739792201e-07 0.7970449251022731 4.027900863374111e-07 0.7981670522831598 \
4.027901905661906e-07 0.79919939674296 4.027902859050021e-07 0.8001364844871954 4.027904221931122e-07 0.8014634245741865 4.027905390856557e-07 0.8025894467082511 \
4.02790658725145e-07 0.8037305025474466 4.027907806067166e-07 0.8048811831579785 4.027909029850537e-07 0.8060245537852575 4.027910310137332e-07 0.8072081965553952 \
4.027911556585317e-07 0.8083483262222385 4.027912861572795e-07 0.8095291977395493 4.027914126177069e-07 0.8106611567088965 4.027915397436747e-07 0.8117869190804841 \
4.027916448611513e-07 0.8127087429624065 4.027917501113405e-07 0.8136235164943317 4.027918412515906e-07 0.8144090748259969 4.027919646696249e-07 0.8154632009865571 \
4.027920517482738e-07 0.8162003374872545 4.02792151070959e-07 0.8170344894488412 4.027922959927027e-07 0.8182390501293432 4.027924322612063e-07 0.8193582434421302 \
4.027925417234847e-07 0.8202477434185359 4.027926878435863e-07 0.8214214001843773 4.02792839202198e-07 0.8226208465286928 4.027929650061201e-07 0.8236052915965452 \
4.027931094167794e-07 0.824721541823094 4.027932340177296e-07 0.8256729463037898 4.027933847297913e-07 0.8268094083523665 4.0279352010105e-07 0.8278169867326588 \
4.027936453039791e-07 0.8287379047458127 4.027937629733617e-07 0.829593908450195 4.027939088013387e-07 0.8306418458276996 4.027940752973201e-07 0.8318207857986918 \
4.027942061544082e-07 0.8327345044534114 4.027943796038485e-07 0.833928356718921 4.027945477223224e-07 0.8350667646575466 4.027947175961246e-07 0.8361988603660855 \
4.027948984507537e-07 0.8373843006762304 4.027950416331349e-07 0.8383085120571983 4.027951557464787e-07 0.8390361588138326 4.027952858124697e-07 0.8398559950134801 \
4.027953876877057e-07 0.8404909448220066 4.027955045669982e-07 0.8412116130393378 4.027956416789287e-07 0.8420465258793415 4.027958395595721e-07 0.843231707656198 \
4.027960313457652e-07 0.8443585547012582 4.027962407088286e-07 0.8455646258450146 4.027964228224064e-07 0.846593677725298 4.027966199171782e-07 0.8476867969181797 \
4.02796793185875e-07 0.8486305714188691 4.02796976264561e-07 0.8496104335327738 4.027971474015872e-07 0.8505103231661706 4.027973220804384e-07 0.8514128411730317 \
4.02797497318728e-07 0.8523022053693007 4.027976734583675e-07 0.8531802340241421 4.027978638096238e-07 0.8541115036082744 4.027980543867704e-07 0.855025905954957 \
4.027982548181929e-07 0.8559685891497206 4.027984474106693e-07 0.8568563992305701 4.027986582738064e-07 0.8578086227668252 4.027988861871822e-07 0.8588150784816577 \
4.027991522177188e-07 0.8599606428795262 4.027994507388009e-07 0.8612090806949765 4.027997266924816e-07 0.8623286542354505 4.028000109545961e-07 0.8634483918036945 \
4.028002851030458e-07 0.8644969441068078 4.02800557392313e-07 0.8655088801415273 4.028008275580888e-07 0.8664846790737442 4.028010847361862e-07 0.8673881555543895 \
4.028013572993529e-07 0.868319368003445 4.02801633304697e-07 0.8692355072818493 4.028019034186287e-07 0.870106770567397 4.028022032450018e-07 0.8710447971670072 \
4.028025742222908e-07 0.8721640818024149 4.028028691540118e-07 0.8730224021943973 4.028031234323761e-07 0.873740732376842 4.028034216772072e-07 0.8745584461000401 \
4.028036952852192e-07 0.8752856917963749 4.028039314154438e-07 0.8758961959341748 4.028041717609793e-07 0.8765017794770257 4.028043940971677e-07 0.8770481951318053 \
4.028045881024505e-07 0.8775144010549708 4.028049178237936e-07 0.8782846129827527 4.028050729968195e-07 0.8786376896881318 4.028053907524076e-07 0.8793424631377607 \
4.028055696169827e-07 0.8797286397841958 4.028059120784622e-07 0.8804474051285093 4.028060962178168e-07 0.880822800830328 4.028065711184754e-07 0.881756283451624 \
4.028067385131538e-07 0.8820737784441692 4.028072043462e-07 0.8829272622221894 4.028073851704931e-07 0.8832470363605239 4.028078792047929e-07 0.8840891816604841 \
4.028080205486687e-07 0.8843218944112644 4.028086269405857e-07 0.8852805359894154 4.028087790117662e-07 0.8855111592597558 4.028094256914359e-07 0.8864506941541785 \
4.028095539876422e-07 0.8866295550025313 4.028102021648149e-07 0.8874976172723908 4.028103319236755e-07 0.8876644392549727 4.028111001444974e-07 0.8886037370453904 \
4.02811229881009e-07 0.8887539063021698 4.028120833066544e-07 0.8896836309705964 4.028122265650877e-07 0.8898301468060963 4.02813212785821e-07 0.890764641901611 \
4.02813434267227e-07 0.8909571971396437 4.028145773086277e-07 0.8918770673440963 4.028147072981167e-07 0.8919774876506176 4.028160589233886e-07 0.8929731820841386 \
4.028162092835701e-07 0.89307657739048 4.028176899161688e-07 0.8939986636922405 4.028179288179339e-07 0.8941315911431026 4.028196933116327e-07 0.894999985510941 \
4.028200009949781e-07 0.8951330875684044 4.028225222661808e-07 0.8960612226716312 4.02822959317422e-07 0.8961978289811912 4.028268627296431e-07 0.8971619289239613 \
4.028271095114498e-07 0.8972094058147089 4.028346860012845e-07 0.8981998139535015 4.028348019130314e-07 0.8982099955090975 4.028539004457353e-07 0.8992062631372056 \
4.028542978885091e-07 0.8992194728667773 4.030047133235903e-07 0.9002121614362558 4.03004979381947e-07 0.9002436812458944 4.030102475320153e-07 0.8993470931706574 \
4.030104539029324e-07 0.899191170936528 4.030119320157425e-07 0.8982046351054961 4.030121124663985e-07 0.8981003355419954 4.030143349480612e-07 0.8971299612768925 \
4.030145410405757e-07 0.897079983173831 4.030249493066813e-07 0.8980580240048047 4.03025087164257e-07 0.8980839755683444 4.030318845132984e-07 0.8990685088718567 \
4.030320700847659e-07 0.8990874390200084 4.035282992589679e-07 0.9000706848616691 4.03528359054814e-07 0.9000975977971888 4.035296126054321e-07 0.9010828413531861 \
4.035297182980354e-07 0.9012097231395001 4.035303764287524e-07 0.9021613947651476 4.035305136110213e-07 0.9023918767045529 4.035310366376409e-07 0.9033649777562528 \
4.035310995012334e-07 0.9034908765919824 4.035315720967825e-07 0.904476514442582 4.035316234105955e-07 0.9045863669199017 4.035320893739314e-07 0.9055619780118375 \
4.035321215783922e-07 0.9056252631670594 4.035328386771295e-07 0.9066212416280413 4.035329231134019e-07 0.9066528951765993 4.035335231797814e-07 0.9059679814895146 \
4.035336430373927e-07 0.9055903401525059 4.03533774200172e-07 0.9050640446667092 4.035339090199249e-07 0.9043926011431642 4.035340571549842e-07 0.9034897747335404 \
4.035341947143354e-07 0.902493211317788 4.035343349260954e-07 0.9013135799985507 4.035344335882047e-07 0.9003872218501816 4.035345192720141e-07 0.8995148096066522 \
4.035346018362134e-07 0.8986166894493001 4.035347166188419e-07 0.8972773101170661 4.03534797717086e-07 0.8962642459447687 4.03534877134364e-07 0.8952218112132616 \
4.035349825888917e-07 0.8937633947192651 4.035351052301954e-07 0.8919606744930825 4.035352049542744e-07 0.890414036797163 4.035353751486854e-07 0.8876203405523397 \
4.035355213337767e-07 0.8850727273800474 4.035356895519253e-07 0.8819879035815887 4.035358617130214e-07 0.8786780617039783 4.035360460991142e-07 0.8749807502679057 \
4.035362306654577e-07 0.8711418063496947 4.035364149129437e-07 0.8671917613865908 4.035366002486073e-07 0.8631174608718694 4.035367746363354e-07 0.8592060069639053 \
4.035369573402717e-07 0.8550405244181323 4.035371326873658e-07 0.8509893565349284 4.035373150168772e-07 0.8467313026054767 4.035375053303062e-07 0.8422468264612591 \
4.035376756604352e-07 0.838204894125699 4.035378421840737e-07 0.8342320488410089 4.035380047549371e-07 0.830337741667393 4.035381546161599e-07 0.8267359097041467 \
4.035383057921791e-07 0.8230937075736249 4.035384949376529e-07 0.8185270080344306 4.035386406557074e-07 0.8150026134285653 4.035388156466743e-07 0.8107652770601156 \
4.035389641182175e-07 0.807166938184282 4.035391360056828e-07 0.8029987283123258 4.035393050739223e-07 0.7988973224349885 4.035394692526316e-07 0.7949140139776875 \
4.035396285801687e-07 0.7910485911592836 4.035397890297763e-07 0.7871568543472617 4.035399908491574e-07 0.7822630953020117 4.035401392968917e-07 0.7786646206504594 \
4.03540293464276e-07 0.77492821376164 4.035404305476362e-07 0.7716074476660475 4.035405399330824e-07 0.7689587163513494 4.035406458665383e-07 0.7663946531324515 \
4.035407728808854e-07 0.7633217481666642 4.035408872438541e-07 0.7605561828888391 4.035409900916761e-07 0.7580702160470256 4.035411116819926e-07 0.7551325442760125 \
4.035412224592673e-07 0.7524575925939972 4.035413393080924e-07 0.7496376180588871 4.035414500928178e-07 0.7469652567786068 4.035415684589191e-07 0.7441116745915923 \
4.035416932860144e-07 0.7411038668912771 4.035418458478099e-07 0.7374292753756717 4.035419797447979e-07 0.7342062928952946 4.035421007762374e-07 0.7312947572377408 \
4.035422649737523e-07 0.7273475399259534 4.035424423346988e-07 0.7230877912371642 4.035426245451075e-07 0.7187161681757385 4.035428055423726e-07 0.7143786395952922 \
4.035429862063158e-07 0.7100537072471783 4.035431763578828e-07 0.7055071781827296 4.035433641177769e-07 0.7010230964996226 4.035435646508815e-07 0.696237807975249 \
4.035437733363431e-07 0.6912646166759551 4.035439809799078e-07 0.6863227581165517 4.03544208547776e-07 0.6809140411171237 4.035444008226102e-07 0.6763521085712711 \
4.035446380878582e-07 0.6707310800019505 4.035448313661221e-07 0.6661595641347996 4.035450640988686e-07 0.6606646229758047 4.035452696563363e-07 0.6558174602470968 \
4.035455020097575e-07 0.6503484594495911 4.035456970117276e-07 0.6457674053103037 4.035459002403362e-07 0.6410004262200759 4.035460800928814e-07 0.6367906205544323 \
4.035462591993119e-07 0.6326052789263827 4.035464225765258e-07 0.628795088826817 4.035465946259304e-07 0.6247880828503264 4.035467581187693e-07 0.6209892715878097 \
4.035469339085876e-07 0.6169100951581823 4.035471158475732e-07 0.6126978430086294 4.035473043313055e-07 0.6083422542008314 4.035475107637274e-07 0.6035858951323969 \
4.035476900783897e-07 0.5994633272559844 4.035478872572566e-07 0.5949432360761027 4.035480963453974e-07 0.5901646611556908 4.035483020946604e-07 0.5854760387944159 \
4.035485426053479e-07 0.5800160304866983 4.035487157334496e-07 0.5760958285528379 4.035488806274519e-07 0.5723746772837877 4.035490614880267e-07 0.5683014035092815 \
4.035492187741233e-07 0.5647722902613652 4.035493877569178e-07 0.5609879409349005 4.03549567863379e-07 0.5569709657351898 4.03549720846506e-07 0.5535669615732179 \
4.035498525609507e-07 0.5506462283231492 4.035499999486508e-07 0.5473865746199473 4.035500873742421e-07 0.5454560063082221 4.035501722454816e-07 0.5435860258811447 \
4.03550270874694e-07 0.5414171943998213 4.035503429668553e-07 0.5398340751058975 4.035504400578744e-07 0.5377039800781129 4.035505256482577e-07 0.5358302678688993 \
4.035505907291341e-07 0.5344081412607664 4.03550714329502e-07 0.5317121235594142 4.035508087537724e-07 0.52965475734789 4.035509062769941e-07 0.5275349985745696 \
4.035510791376451e-07 0.5237893654184622 4.035512141331662e-07 0.5208709659121862 4.035513683166277e-07 0.5175498113398643 4.03551542781984e-07 0.5138002600288881 \
4.035516945879704e-07 0.510550000123414 4.03551840818953e-07 0.5074290310664136 4.035519847178261e-07 0.5043644611166801 4.035521277396695e-07 0.5013276181140283 \
4.035522233495175e-07 0.499301733014788 4.035523177934733e-07 0.4973032961550828 4.035524388494141e-07 0.4947494705229025 4.035525337277099e-07 0.4927525559781179 \
4.035526495585533e-07 0.4903172469328811 4.035527368224019e-07 0.4884854516151125 4.035528192528481e-07 0.4867593351188191 4.035529146608016e-07 0.484765406725184 \
4.035530153710815e-07 0.4826639978995959 4.035531122314731e-07 0.4806459052877932 4.035532509612246e-07 0.4777646955734051 4.035533866660861e-07 0.4749532752442271 \
4.035535871508094e-07 0.4708139964547478 4.035538024649621e-07 0.4663911383470885 4.03553984040267e-07 0.462674698484628 4.035541830122363e-07 0.4586189944293299 \
4.035543535777573e-07 0.455154096457448 4.035545279314447e-07 0.4516251957269069 4.035546968646987e-07 0.4482170126441485 4.035548694618603e-07 0.4447467276163349 \
4.035550520681902e-07 0.4410867902598327 4.035552406170555e-07 0.4373240875354826 4.035554340845929e-07 0.4334777823509549 4.035556424052318e-07 0.4293535036700135 \
4.035558567504624e-07 0.4251286740881063 4.035560824557922e-07 0.4207018662297695 4.035563089991605e-07 0.4162771402745992 4.035565711759108e-07 0.4111844468197049 \
4.035568202097347e-07 0.4063709766754009 4.035571213084326e-07 0.4005865607947761 4.035574107292502e-07 0.3950673729298416 4.035577182435291e-07 0.3892455819062323 \
4.035580404399245e-07 0.3831936848847286 4.035583681704072e-07 0.3770882112794804 4.035587006001628e-07 0.3709500980558715 4.035590303291706e-07 0.3649083177186754 \
4.035593515587582e-07 0.3590729273462687 4.03559682375082e-07 0.3531219177045733 4.035600247306453e-07 0.3470224718704957 4.035603243716774e-07 0.3417374346434491 \
4.035606541592421e-07 0.3359723367088904 4.035609810531852e-07 0.3303128110141857 4.03561319032532e-07 0.3245206193888226 4.035616280036957e-07 0.3192755432624759 \
4.035619528016686e-07 0.31382336954194 4.035622684318663e-07 0.3085864885517507 4.035625734190322e-07 0.3035810258414895 4.035628287576776e-07 0.2994330834535801 \
4.03563093620834e-07 0.295170851203172 4.035633807035187e-07 0.2905978071194348 4.035636036732975e-07 0.2870801635277143 4.035638032125666e-07 0.2839591363066187 \
4.035640128685797e-07 0.2807045410859125 4.035641931251209e-07 0.2779290029372279 4.035643554698416e-07 0.2754463208250681 4.035645059048156e-07 0.2731629026725527 \
4.035646569101242e-07 0.2708866524077067 4.035648538007149e-07 0.2679392949564011 4.035649849454786e-07 0.2659970646012914 4.035651096820175e-07 0.2641561221543183 \
4.035652612740599e-07 0.2619266655689588 4.03565357242231e-07 0.2605306204207966 4.035654537935996e-07 0.2591282589302421 4.035655784133887e-07 0.2573209601776467 \
4.035657209899234e-07 0.255257422470362 4.035658799234579e-07 0.25296979123958 4.035660125895253e-07 0.251062957019046 4.03566196158294e-07 0.2484301322588876 \
4.035663773934597e-07 0.2458327969660818 4.035665889075646e-07 0.2428051031600066 4.035667914973991e-07 0.2399069804317323 4.035669580538467e-07 0.2375282895552967 \
4.03567168273059e-07 0.2345337828133105 4.035673416909451e-07 0.2320692345528927 4.035675705336728e-07 0.2288260787734411 4.035677911684244e-07 0.2257162440502939 \
4.035679668301377e-07 0.2232503232699662 4.035681472906433e-07 0.2207258962977968 4.035683180470208e-07 0.2183528725291195 4.035684982432872e-07 0.2158619697278009 \
4.035686649739047e-07 0.2135675266585953 4.035688140953261e-07 0.2115251542210239 4.035689699053442e-07 0.2094125291275523 4.035691050857695e-07 0.2075875692769576 \
4.035692551671966e-07 0.2055694209972212 4.035693876128229e-07 0.2037957203154137 4.035695281573595e-07 0.2019220745191926 4.035696452261239e-07 0.2003748851744883 \
4.035697749337302e-07 0.1986681706274326 4.035698969911991e-07 0.1970700654731777 4.035700195346348e-07 0.1954731161836187 4.035701375539584e-07 0.1939418157697267 \
4.035702725767313e-07 0.1921981789937757 4.03570417201182e-07 0.1903420634523806 4.035705455516813e-07 0.1887049708672087 4.03570669186156e-07 0.1871351133418249 \
4.035707667362788e-07 0.1859021016257166 4.035708818092082e-07 0.1844539912642748 4.035709755078879e-07 0.1832809848801438 4.035710742920116e-07 0.1820493959460708 \
4.035711972265529e-07 0.1805230483556907 4.035712929805559e-07 0.1793400249325384 4.035714220681073e-07 0.177753298391591 4.035715245334772e-07 0.1764993061988986 \
4.035716227869744e-07 0.1753029542432101 4.035717428741866e-07 0.1738483570896001 4.03571845423405e-07 0.1726127298531683 4.035719558810642e-07 0.1712877101305652 \
4.035720843709282e-07 0.1697552709290656 4.035721758557694e-07 0.1686698090598139 4.035722803403581e-07 0.1674358120019214 4.035723552770942e-07 0.1665544493622226 \
4.03572444845591e-07 0.1655049734124585 4.035724954106002e-07 0.164914347906921 4.035725453889764e-07 0.1643318187475747 4.03572610358061e-07 0.163576534137217 \
4.035726458720287e-07 0.1631646263336159 4.035727180712023e-07 0.162329174921529 4.035727852002975e-07 0.1615546732967998 4.035728444300318e-07 0.160873195114598 \
4.035728881756305e-07 0.1603710314414745 4.035729358224586e-07 0.1598254649913795 4.03573006202993e-07 0.1590230739426561 4.03573088541159e-07 0.1580883269013631 \
4.035731667127594e-07 0.1572048664554128 4.035732487657085e-07 0.1562816770844126 4.035733414693307e-07 0.1552436243401225 4.035734642494946e-07 0.153877370231325 \
4.035735633955882e-07 0.1527810927807017 4.035736648959355e-07 0.1516651170047695 4.035737661711265e-07 0.1505582666538253 4.035738626629107e-07 0.1495093242781697 \
4.035739620809455e-07 0.1484346886615803 4.03574046381569e-07 0.1475281828465028 4.035741393202594e-07 0.1465342051547719 4.035742219212e-07 0.1456551508734999 \
4.035743306872851e-07 0.1445034822456445 4.035744363302651e-07 0.1433917535370727 4.035745179898545e-07 0.1425365900703354 4.03574611735024e-07 0.1415598856352903 \
4.03574705302971e-07 0.1405903867550886 4.035747881874616e-07 0.139735765814107 4.035748763466362e-07 0.1388313836440244 4.035749561327222e-07 0.1380170907865772 \
4.035750497281217e-07 0.1370669869522621 4.035751396606459e-07 0.1361590166429519 4.035752102110423e-07 0.1354501541392388 4.035752799712188e-07 0.1347521119166949 \
4.035753941201259e-07 0.1336164586193709 4.035754760987401e-07 0.1328058651355588 4.035755637040425e-07 0.1319440719770354 4.035756632052385e-07 0.1309710196939938 \
4.035757723852409e-07 0.1299110174488692 4.03575874550573e-07 0.1289256009328031 4.035759820107789e-07 0.1278959836800649 4.035761020450569e-07 0.1267549558890445 \
4.035761962530915e-07 0.1258657925752028 4.03576327232195e-07 0.1246390638240933 4.035764266598965e-07 0.1237164070883829 4.035765357815822e-07 0.1227104370444639 \
4.035766446347502e-07 0.1217138859540913 4.035767369441536e-07 0.120874257454373 4.035768497844844e-07 0.1198547128626846 4.035769467965243e-07 0.118986084968971 \
4.035770510628723e-07 0.1180628196869088 4.035771600298026e-07 0.1171053395831002 4.035772595693683e-07 0.1162371554254778 4.035773765620782e-07 0.1152245300989246 \
4.035774636628686e-07 0.1144761644999183 4.035775729545201e-07 0.1135478691973115 4.035776544795827e-07 0.1128618460838699 4.035777542545759e-07 0.1120273350449922 \
4.03577871679726e-07 0.1110526766231405 4.035779734648438e-07 0.1102143708571793 4.035780612037922e-07 0.1094962336869811 4.035781420032999e-07 0.1088432886892514 \
4.035782289543192e-07 0.1081456845520918 4.035783097409448e-07 0.1075007757815706 4.035783999475114e-07 0.1067842832273628 4.03578490898266e-07 0.1060655611559195 \
4.035785795687901e-07 0.1053685613006139 4.035786785836107e-07 0.1045946508745568 4.035787722897869e-07 0.1038723470842792 4.035788661490627e-07 0.1031520741219857 \
4.035789669765109e-07 0.1023817709659086 4.035790716074088e-07 0.1015861061604995 4.035791955701651e-07 0.1006484085638475 4.035792929694782e-07 0.09991551135558702 \
4.035794132274253e-07 0.09901872452754552 4.035795240953005e-07 0.09819831936474602 4.035796285683363e-07 0.09742874659471555 4.035797458050452e-07 0.09656937225591002 \
4.035798475993662e-07 0.09582695326576983 4.035799455749168e-07 0.09511577589263259 4.035800860794065e-07 0.09410164141823299 4.035801911572026e-07 0.09334832721827611 \
4.035802897700187e-07 0.09264549593674179 4.035803824848273e-07 0.09198739948435641 4.035804686832124e-07 0.09137785861853052 4.035805625961876e-07 0.09071637432184691 \
4.035806596969337e-07 0.09003559055802626 4.035807691179881e-07 0.08927317549644689 4.035808701015371e-07 0.08857281843916648 4.035809637594832e-07 0.08792605868920525 \
4.035810379341552e-07 0.08741581771673042 4.03581175834007e-07 0.08647193599618339 4.035812481910108e-07 0.08597917321277694 4.035813835122141e-07 0.08506274029062395 \
4.035814694238195e-07 0.08448410751389913 4.03581614152054e-07 0.08351486081643937 4.035817103826189e-07 0.0828744112740944 4.035817982183981e-07 0.08229260392026354 \
4.035819140173063e-07 0.08152964121883956 4.035820291457576e-07 0.08077575264951149 4.0358214291219e-07 0.08003553900012179 4.035822831696828e-07 0.0791300282244784 \
4.035824245457162e-07 0.07822490276368012 4.035825741817577e-07 0.07727536491519127 4.035827186706132e-07 0.07636690312463701 4.035828698447241e-07 0.07542565384097814 \
4.035830192155436e-07 0.07450459906593411 4.03583168562251e-07 0.0735926433331697 4.035833285177668e-07 0.07262574717347114 4.035834846646777e-07 0.07169171823582712 \
4.035836591531124e-07 0.07065947636250877 4.035838288622191e-07 0.0696671357044583 4.035840140413029e-07 0.0685979885997255 4.035842107623799e-07 0.06747763456279594 \
4.035844212801998e-07 0.06629631776014881 4.03584643312255e-07 0.06507007089066431 4.035848735242764e-07 0.0638195278444372 4.035851160353819e-07 0.06252626147401 \
4.035853766894672e-07 0.06116236403900636 4.035856565885314e-07 0.05972739422233359 4.035859501722554e-07 0.05825544847408989 4.035862651082393e-07 0.05671370145268265 \
4.035866079141644e-07 0.05507846134953124 4.035869573807585e-07 0.0534565727116736 4.035873662849152e-07 0.05161746230842366 4.035877129499425e-07 0.05010669351290297 \
4.035881003649955e-07 0.04846839895323611 4.035884445827877e-07 0.04705645202362623 4.035887680090468e-07 0.04576625679949029 4.035890730548091e-07 0.04458093278443617 \
4.035893659168059e-07 0.04347099288378908 4.035896500577229e-07 0.04242242262004604 4.03589926078015e-07 0.04142902112907627 4.03590192930566e-07 0.04049015932812138 \
4.035904618227892e-07 0.03956531631184226 4.035907378832112e-07 0.03863769040165695 4.035910254787821e-07 0.03769451689421055 4.035912650444083e-07 0.03692662498323904 \
4.03591554211835e-07 0.03602084344675294 4.03591770003438e-07 0.03535960341037672 4.035919577204764e-07 0.03479599077274986 4.035921558495825e-07 0.03421285035004928 \
4.03592518724446e-07 0.03317032497347058 4.03592776866276e-07 0.03244834222605905 4.0359308657919e-07 0.0316030971185694 4.035933520493286e-07 0.03089664771451467 \
4.035936201684082e-07 0.03019941363307669 4.03593899042439e-07 0.02949128999862272 4.035941452288756e-07 0.02888043298519722 4.035943758602853e-07 0.02832033800396738 \
4.035946141502041e-07 0.02775711540944564 4.035948491575685e-07 0.02721270742060762 4.03595076940031e-07 0.02669509678424227 4.035954855523029e-07 0.02579039168486155 \
4.03595661854632e-07 0.02540904040268441 4.03596016332316e-07 0.02465798827491217 4.035962002032883e-07 0.02427641469830137 4.035965351520103e-07 0.02359448510613503 \
4.035966990607275e-07 0.02326678168937357 4.035970913313036e-07 0.02249905491676728 4.035972473220689e-07 0.02220010404946675 4.035976789254264e-07 0.02138321689778962 \
4.035978163148065e-07 0.0211255367654138 4.03598333123589e-07 0.02017559010600388 4.035984586594829e-07 0.01995091418019728 4.035989159010076e-07 0.01915998482559782 \
4.035990750469891e-07 0.01889493739859509 4.035996822854669e-07 0.01793263500095189 4.03599816822955e-07 0.01772934138481063 4.036004800869477e-07 0.01678091027541291 \
4.036006734103789e-07 0.01651856846389665 4.036013410670396e-07 0.01565087920017967 4.03601502655887e-07 0.01544858341705342 4.0360225789114e-07 0.01454101846553843 \
4.036024074521069e-07 0.01436800730673201 4.036032977899311e-07 0.01338293844200974 4.036033964478169e-07 0.01327873262558703 4.03604353121314e-07 0.01230993787860994 \
4.036044742310216e-07 0.01219243157195396 4.036054657237297e-07 0.01126376273051215 4.036056292524602e-07 0.01111855113153209 4.036067591745355e-07 0.01018247077230436 \
4.036068716217739e-07 0.01009565848301377 4.036082494452622e-07 0.009103273453806031 4.036083883905334e-07 0.009009747578659758 4.036099427888684e-07 0.008018073335410726 \
4.0361005485534e-07 0.00794673960805117 4.036116998381698e-07 0.006958154532207958 4.036118070906645e-07 0.006899512253112593 4.036137515841525e-07 0.005937533026687714 \
4.036139584821097e-07 0.005843834961138424 4.036162973698526e-07 0.00487227039639981 4.036167213562637e-07 0.004712306502041247 4.036194935894604e-07 0.003780857497341114 \
4.036199418985521e-07 0.003647790772321777 4.03623582397237e-07 0.00272553831825111 4.036240790530716e-07 0.002619503085887757 4.036298301734959e-07 0.001650572925599863 \
4.036301169553825e-07 0.001609446887446839 4.036354719440668e-07 0.0006353228983793809 4.036356773006917e-07 0.0005920420449145349 4.062827120745074e-07 -0.0002718533828215428 \
4.062828679501107e-07 -0.0004579010352009555 4.062834162652028e-07 -0.001326296959495401 4.062835290488787e-07 -0.001543805653187533 4.062839635410185e-07 -0.002491429791030493 \
4.062840393661749e-07 -0.002673591589873599 4.062843960167732e-07 -0.003590195133438418 4.062845230658532e-07 -0.003936807634339821 4.062848015662471e-07 -0.004716444651655622 \
4.062849096507305e-07 -0.005020876868076652 4.06285253249855e-07 -0.00592430224391268 4.062853602437202e-07 -0.006162325733041658 4.062862596141159e-07 -0.005653094509861465 \
4.062864380475456e-07 -0.004687598829536962 4.062865437709605e-07 -0.003940993102967527 4.062866688337378e-07 -0.002883597584075996 4.062867624178337e-07 -0.001971418478057775 \
4.062868402573964e-07 -0.001132968824455395 4.062869203293945e-07 -0.0001977429743171 4.062870427022047e-07 0.001370578777960296 4.062871609580771e-07 0.003041212838230153 \
4.062872796071873e-07 0.004860750887681821 4.06287393089626e-07 0.006730904986417607 4.062874965327645e-07 0.008536402178002854 4.062876111920181e-07 0.01064190690353853 \
