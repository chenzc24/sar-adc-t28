4.062878017758113e-07 0.0143607330143792 4.062879355659492e-07 0.01711819191720031 4.062880858195149e-07 0.02033933849841947 4.062882409887625e-07 0.02378599874269359 \
4.062883963808114e-07 0.0273434151175349 4.062885440880426e-07 0.03080849965087477 4.062886930776679e-07 0.03437359286003162 4.06288848068751e-07 0.03814545786868043 \
4.062890074393648e-07 0.04208062121327779 4.062891723727756e-07 0.04620305710844342 4.062893473191046e-07 0.0506208066052034 4.062895264491763e-07 0.05518387280380205 \
4.062897162384316e-07 0.06005265756871143 4.062899199354002e-07 0.06530840376289772 4.062901397459318e-07 0.07100650943730057 4.062903714973765e-07 0.07703584544314998 \
4.062906193226736e-07 0.08349927754587044 4.062908906436034e-07 0.09058756662233436 4.062911853563813e-07 0.09829181712822582 4.062915106140293e-07 0.106792896697727 \
4.062918768597349e-07 0.1163551101154179 4.062922701564477e-07 0.1266079356677421 4.062927228093435e-07 0.1383809089651769 4.062932485245108e-07 0.1520098384503803 \
4.062938677380491e-07 0.1679979965193872 4.062945484823656e-07 0.1854865650013753 4.062953421573204e-07 0.2057488551561759 4.062962309229534e-07 0.2282732214494322 \
4.062970443122153e-07 0.2487218262351868 4.062977660617924e-07 0.2667261628598245 4.062984017258005e-07 0.282460740414376 4.062989734425617e-07 0.2965101025186013 \
4.062995089968458e-07 0.3095696210007924 4.063000123552588e-07 0.3217495654069301 4.063004886827015e-07 0.3331878525640654 4.063009626063057e-07 0.3444754071334732 \
4.063014200780245e-07 0.3552759747331513 4.06301886058294e-07 0.3661792384270033 4.063023350461038e-07 0.376592601923634 4.063028311526457e-07 0.3879857357798637 \
4.063033509145082e-07 0.3998002499051578 4.063037303191525e-07 0.4083447473225827 4.063041703278757e-07 0.4181679450526055 4.063046400968136e-07 0.4285466970600206 \
4.063051256177522e-07 0.4391589006481625 4.063055650658585e-07 0.4486701556983262 4.063056268188069e-07 0.4500002248264944 4.063057503247038e-07 0.4526540461147197 \
4.063059973364976e-07 0.4579447795386873 4.063062499314088e-07 0.463325462421476 4.063064475025244e-07 0.467511453725808 4.063066730742715e-07 0.4722681264242033 \
4.06306994642268e-07 0.4790073975813253 4.063072634214966e-07 0.4846013351959894 4.063074820729701e-07 0.4891262574467725 4.063076921769364e-07 0.4934547887280634 \
4.063079185824616e-07 0.4980921872304203 4.063081276876522e-07 0.5023516957637455 4.063083170899107e-07 0.5061927337048852 4.06308441251129e-07 0.5086969563931187 \
4.063085680062259e-07 0.5112441466129884 4.06308728004704e-07 0.5144514110933732 4.063089756476561e-07 0.5193914248715521 4.063091542341148e-07 0.5229351592435862 \
4.063093251876918e-07 0.5263079149198099 4.063095865372878e-07 0.5314455197962068 4.063098126088702e-07 0.5358634945234868 4.063100157405374e-07 0.5398188128751134 \
4.063101809712675e-07 0.5430252218652345 4.063103377582878e-07 0.5460612552756139 4.063105269149053e-07 0.5497137532216215 4.063107287826585e-07 0.5535976061995346 \
4.063109529339811e-07 0.5578986282275192 4.063111913163462e-07 0.5624617013850463 4.06311426077985e-07 0.566941985223824 4.063116563486904e-07 0.5713275351537204 \
4.063118621413239e-07 0.5752375533958141 4.063120671255381e-07 0.5791255875933676 4.063123099407797e-07 0.5837094709690289 4.063125646983618e-07 0.588493349632063 \
4.063127929267933e-07 0.5927514274590796 4.063130307656652e-07 0.5971656109489694 4.063132430431008e-07 0.6010807441713891 4.063134548365055e-07 0.6049674646600495 \
4.06313708720774e-07 0.6095919957414236 4.063139133143013e-07 0.6132953190650409 4.063141650376543e-07 0.6178178328453598 4.063143528271744e-07 0.6211736970442716 \
4.063146057002513e-07 0.6256587164710262 4.063148041096133e-07 0.6291560967673944 4.06314983842284e-07 0.6323071487074056 4.063152541130913e-07 0.6370161336915187 \
4.063154713968567e-07 0.6407803561788556 4.063156519232363e-07 0.6438916924996977 4.063158530841308e-07 0.6473460740030906 4.063160216675126e-07 0.650231451944099 \
4.063162260257198e-07 0.6537144072723954 4.063163716887783e-07 0.6561873372238678 4.063165362473771e-07 0.6589728476742622 4.063167057165935e-07 0.6618316558839334 \
4.063168592566751e-07 0.664412775690417 4.06317000490202e-07 0.6667750288922751 4.063171440660136e-07 0.6691685747430841 4.06317277296139e-07 0.6713840140331436 \
4.063174191964594e-07 0.6737368819239464 4.063175394300862e-07 0.6757233098298149 4.063176840811384e-07 0.6781085120392751 4.063178002998436e-07 0.6800197521569988 \
4.063179193821632e-07 0.6819757159594566 4.063180179604767e-07 0.6835903813535821 4.063181355581833e-07 0.6855122399681081 4.063182229941461e-07 0.6869376986921233 \
4.063183477402322e-07 0.6889650632873403 4.063184475472963e-07 0.6905825000046129 4.063185400370926e-07 0.6920753042469043 4.063186413211772e-07 0.6937043390836264 \
4.063187391142832e-07 0.695273833970533 4.063188303850746e-07 0.6967333967490603 4.063189328429049e-07 0.6983656370917724 4.063190657521356e-07 0.7004728611232253 \
4.063192207675414e-07 0.7029137789397926 4.063193556492269e-07 0.7050222373350452 4.063195011450183e-07 0.7072806469370021 4.063196289996853e-07 0.709252249158637 \
4.063197534579806e-07 0.7111597484283609 4.063198647836849e-07 0.7128563623504806 4.063199788137127e-07 0.7145852226468989 4.063200793249296e-07 0.7161013069709498 \
4.063202165260769e-07 0.7181590832501857 4.063203364719788e-07 0.7199473375636642 4.06320455641778e-07 0.7217141075019444 4.063205825867917e-07 0.7235855504531626 \
4.063207073542094e-07 0.7254141264975077 4.063208308495973e-07 0.7272133847865295 4.063209576308702e-07 0.7290498056238117 4.063210882203554e-07 0.730930225429108 \
4.063212104322583e-07 0.7326797786847141 4.063213474902716e-07 0.7346298644824388 4.063214487056265e-07 0.7360619656663578 4.063215536745619e-07 0.7375401619041119 \
4.063216451659951e-07 0.7388229997694907 4.06321758241356e-07 0.7404001534680551 4.063218455422403e-07 0.7416107338190071 4.063219500055706e-07 0.7430512000342341 \
4.063220807687029e-07 0.7448411286358657 4.063221906822003e-07 0.7463352048609909 4.063222953419585e-07 0.7477488743938407 4.0632241917362e-07 0.7494094725133206 \
4.063225679269713e-07 0.751387874302702 4.06322689842132e-07 0.7529958494242643 4.063228036963925e-07 0.7544867042370438 4.0632294419585e-07 0.7563117925204224 \
4.063230855193645e-07 0.7581313010100689 4.063232032989716e-07 0.7596352654099263 4.063233316974594e-07 0.7612620174900669 4.06323474021161e-07 0.7630496612437514 \
4.063235904103157e-07 0.7644991888858087 4.063237361339775e-07 0.7662987831554334 4.063238579138671e-07 0.7677897310961733 4.06323976478797e-07 0.7692300520321635 \
4.063240990922458e-07 0.7707078417740018 4.063242255436292e-07 0.77221964326554 4.06324335666584e-07 0.7735261258099556 4.063244611887263e-07 0.7750039859681491 \
4.06324566849672e-07 0.7762386743660952 4.063247020268293e-07 0.7778058706872942 4.063248256373457e-07 0.7792267957652825 4.06324955634725e-07 0.7807078764205345 \
4.06325068606223e-07 0.7819831642610904 4.063251765001111e-07 0.7831908181350914 4.063253130307933e-07 0.7847046126527283 4.063254631517019e-07 0.7863508260127218 \
4.063256054160057e-07 0.7878933964149381 4.063257249975189e-07 0.7891771019825847 4.06325861808649e-07 0.7906313890246753 4.063259843124129e-07 0.7919206245676671 \
4.063261289843411e-07 0.7934276941869095 4.063262697694143e-07 0.794878360380241 4.063263965852094e-07 0.796171745508174 4.063265156326018e-07 0.7973744708066829 \
4.063266278955628e-07 0.7984986270115709 4.063267322833333e-07 0.7995352562746869 4.063268275603949e-07 0.8004739840425704 4.063269639028913e-07 0.8018044219089175 \
4.063270807679598e-07 0.8029326473252685 4.063272003644895e-07 0.8040757482679398 4.063273222502994e-07 0.8052288531124292 4.063274448385593e-07 0.8063765489401953 \
4.06327572579618e-07 0.8075599074701925 4.06327697362526e-07 0.8087035441861687 4.063278278629006e-07 0.8098867241643505 4.063279542295969e-07 0.8110199871086299 \
4.06328081578389e-07 0.8121498004723215 4.063281867911793e-07 0.8130740322933268 4.063282914951838e-07 0.8139855427426806 4.063283830253901e-07 0.8147757515715357 \
4.063285063983601e-07 0.8158311616195392 4.063285933524084e-07 0.8165684017534872 4.063286922082447e-07 0.8173999442793862 4.063288367108844e-07 0.8186029267949408 \
4.063289730365726e-07 0.8197243345631372 4.063290824450085e-07 0.8206145128367788 4.06329228461948e-07 0.821788834531623 4.063293802030074e-07 0.8229927727264784 \
4.063295061195854e-07 0.8239792970156907 4.063296505686489e-07 0.8250971468990039 4.063297752648172e-07 0.8260503472050121 4.063299258788342e-07 0.8271873005969326 \
4.063300612493023e-07 0.8281959289694237 4.063301864729373e-07 0.8291179217777711 4.063303041288969e-07 0.8299746468143927 4.063304499105104e-07 0.8310230722388168 \
4.063306163942599e-07 0.8322027532553667 4.063307472150236e-07 0.8331167337813133 4.063309206750455e-07 0.834311196379941 4.063310887878414e-07 0.8354501125721271 \
4.063312586689692e-07 0.8365827385393307 4.063314395126276e-07 0.8377685497174457 4.063315827046921e-07 0.8386931238161603 4.063316968221893e-07 0.8394210074154138 \
4.063318268737995e-07 0.8402408682651782 4.063319287535162e-07 0.8408758513273116 4.063320456411389e-07 0.841596551294542 4.063321827868591e-07 0.8424315815669623 \
4.063323806960722e-07 0.8436167827761205 4.063325725154114e-07 0.8447436440637145 4.063327818661576e-07 0.8459494874145237 4.06332964017768e-07 0.8469786287449077 \
4.063331611039906e-07 0.8480715276019779 4.063333343567189e-07 0.8490148531186206 4.063335174509634e-07 0.8499943787178993 4.063336885824299e-07 0.8508936588199895 \
4.063338632702719e-07 0.8517955326875627 4.063340385042873e-07 0.8526841769874772 4.063342146411542e-07 0.8535614892404448 4.063344050084938e-07 0.8544920815553035 \
4.063345955808447e-07 0.8554057038167108 4.063347959768378e-07 0.8563474066245403 4.063349885664635e-07 0.8572344253714166 4.06335199466375e-07 0.858185963363946 \
4.063354273418618e-07 0.8591913103610016 4.063356934247181e-07 0.8603357477151101 4.063359919268544e-07 0.8615822374427254 4.063362678163234e-07 0.8627000332972231 \
4.063365520834927e-07 0.8638181192989086 4.063368262214432e-07 0.8648650323418529 4.06337098522366e-07 0.8658754039994767 4.063373686785625e-07 0.8668495780678541 \
4.063376258626989e-07 0.8677515347235455 4.063378984216134e-07 0.8686810999091764 4.063381744693316e-07 0.8695957110915412 4.063384445895985e-07 0.8704649939918846 \
4.063387444494889e-07 0.8714007440816277 4.063391154301144e-07 0.8725171209518352 4.063394103525362e-07 0.8733732402027278 4.063396646282709e-07 0.8740897163373675 \
4.06339962841735e-07 0.8749052413925265 4.063402364113466e-07 0.8756305047096297 4.063404725347486e-07 0.8762394088953867 4.063407128598864e-07 0.8768433401198644 \
4.063409351938211e-07 0.8773882060838187 4.063411292002539e-07 0.8778530214284207 4.063414589096812e-07 0.8786208714695904 4.063416140810901e-07 0.87897283049042 \
4.063419317234907e-07 0.8796750328643211 4.063421106040349e-07 0.8800599154915705 4.063424530647979e-07 0.8807759898408113 4.063426372672098e-07 0.8811501695110489 \
4.063431122965131e-07 0.8820806183873429 4.06343279683462e-07 0.8823969901232691 4.063437454598435e-07 0.8832471741583867 4.063439262991872e-07 0.8835657112976044 \
4.063444203088053e-07 0.8844044135654346 4.063445616237109e-07 0.8846360992458032 4.063451678673266e-07 0.8855901496945974 4.063453199425258e-07 0.8858196526512701 \
4.06345966662599e-07 0.8867549368993356 4.063460949492666e-07 0.8869330782847171 4.063467431586864e-07 0.8877977435561634 4.06346872882985e-07 0.8879638504720397 \
4.063476413020527e-07 0.8888993076310558 4.063477710739033e-07 0.8890488273083775 4.063486247365088e-07 0.8899738047157748 4.063487677615613e-07 0.8901192131187072 \
4.06349754067048e-07 0.8910487927319016 4.063499755535999e-07 0.8912403904783051 4.063511183781385e-07 0.8921548233216382 4.063512482580762e-07 0.8922544308366913 \
4.063526007584981e-07 0.8932425879319322 4.063527510414313e-07 0.8933452769452155 4.063542315756977e-07 0.8942627870546499 4.063544704854918e-07 0.8943950258099049 \
4.063562525184327e-07 0.8952625983306248 4.063566382658602e-07 0.895426813549116 4.063590404240788e-07 0.8963023915260389 4.063595153600487e-07 0.8964490046842035 \
4.063634332871647e-07 0.8974035634625627 4.063639032474093e-07 0.8974927205890085 4.063722720353868e-07 0.8984807567386782 4.063724925457144e-07 0.8984960697096243 \
4.064170720742927e-07 0.8994905034760702 4.064182734601916e-07 0.8995076493514624 4.065540832686943e-07 0.9004821828323031 4.065542622454192e-07 0.9005421539807538 \
4.065577071203374e-07 0.8996085030263692 4.065578799041918e-07 0.8994755022453073 4.065592062238996e-07 0.8985168769831137 4.06559392989208e-07 0.8983970610744239 \
4.065611771942332e-07 0.8974304740967198 4.065613893245152e-07 0.8973403978332656 4.065747300202991e-07 0.8983331062395279 4.065748433081446e-07 0.8983517458922662 \
4.065835466612414e-07 0.8993273409280406 4.0658409447182e-07 0.8993637478389299 4.070766218437148e-07 0.9003542216796759 4.070767175825666e-07 0.9004233209197793 \
4.070776601319424e-07 0.9014023545001312 4.070778225852538e-07 0.9016297223302431 4.070783892915005e-07 0.9025464066367429 4.070784964622122e-07 0.9027401250447874 \
4.07078889770564e-07 0.9035002370985188 4.07079022567928e-07 0.9037710185404622 4.070794021690344e-07 0.9045728679206633 4.070795323837805e-07 0.9048512534150681 \
4.070799937900729e-07 0.9057878278182891 4.070801130371311e-07 0.9060008176934132 4.070815426461655e-07 0.9050557440230738 4.070816263162926e-07 0.9046580283931719 \
4.070817516221221e-07 0.9039622140338933 4.070818594362906e-07 0.9032622438705011 4.070819784306371e-07 0.9023800387125585 4.070820938028541e-07 0.9014106868475621 \
4.070821838997509e-07 0.900578017289966 4.070822953474549e-07 0.8994526603282017 4.070823814266029e-07 0.8985125975436928 4.070824873922515e-07 0.8972736935213672 \
4.070825871606176e-07 0.8960214106762436 4.070826681562277e-07 0.8949470092681954 4.070827778041954e-07 0.8934133399212493 4.070828633916057e-07 0.8921520042367302 \
4.070829555142149e-07 0.8907345325087322 4.07083043733598e-07 0.8893220116766375 4.070831525083507e-07 0.8875100775672261 4.070832354013856e-07 0.8860780350921965 \
4.070833439750574e-07 0.8841400608632336 4.070834362012525e-07 0.8824412727986957 4.070835208217502e-07 0.8808423775446282 4.0708360666218e-07 0.8791839877465467 \
4.0708368587706e-07 0.8776224824828824 4.070837619650304e-07 0.8760960492665846 4.070838543013988e-07 0.874210837196514 4.070839141777347e-07 0.8729702140710593 \
4.070839715660192e-07 0.8717685933706794 4.070840335611921e-07 0.8704574090763495 4.070840968400435e-07 0.8691057216070059 4.070841469113811e-07 0.8680269866686803 \
4.070841963535335e-07 0.8669542389500936 4.070842600232402e-07 0.8655623656543436 4.070843359706592e-07 0.8638877358586781 4.070843848016709e-07 0.8628032002737418 \
4.070844333256242e-07 0.8617197496806845 4.07084509037347e-07 0.8600184098866027 4.070845762461248e-07 0.8584975010852487 4.070846189526312e-07 0.8575263577286506 \
4.070846628552044e-07 0.8565244243916033 4.070847506603509e-07 0.8545103166059256 4.070848135135196e-07 0.8530605771626394 4.070848721831768e-07 0.8517018597088126 \
4.070849083617785e-07 0.8508614974547222 4.070849431802581e-07 0.8500510151036469 4.070849782062432e-07 0.8492340038666518 4.070850482582133e-07 0.8475953578585981 \
4.07085096728698e-07 0.8464581214772323 4.070851406734992e-07 0.8454248116355969 4.070851861912554e-07 0.8443523575543517 4.070852500921664e-07 0.8428433081697474 \
4.070853162185396e-07 0.8412777165526386 4.07085421348608e-07 0.8387809254526315 4.070855092832832e-07 0.8366857089760468 4.070855882285649e-07 0.834800137446173 \
4.070856763936023e-07 0.8326899670047023 4.070857632095989e-07 0.8306078985741704 4.070858511012833e-07 0.8284959280419055 4.070859423503732e-07 0.8262996967350639 \
4.070860451122409e-07 0.8238226494465998 4.070861436157165e-07 0.8214450402687625 4.070862559486315e-07 0.8187302447322098 4.070863689227678e-07 0.8159967029774419 \
4.070864902106627e-07 0.8130591602364435 4.070866207178167e-07 0.8098958628758253 4.070867497637196e-07 0.8067658935936169 4.070869032393199e-07 0.8030416153605923 \
4.070870685235405e-07 0.799029304640783 4.070872362647447e-07 0.7949567682299736 4.070874327883338e-07 0.7901857478752816 4.07087637550659e-07 0.7852160332972318 \
4.070878502277154e-07 0.7800563994093253 4.070880508476619e-07 0.7751902022758907 4.070882517063895e-07 0.7703212856706637 4.070884017284074e-07 0.766686939713112 \
4.070885322635739e-07 0.7635264252913375 4.070886666810141e-07 0.7602735436595947 4.070887728765446e-07 0.7577048602246427 4.070889061828774e-07 0.754482067181252 \
4.070890132158029e-07 0.7518959494812111 4.070891562917044e-07 0.7484409822837247 4.07089320797846e-07 0.7444713482725677 4.070894416150925e-07 0.74155777711076 \
4.070896127217565e-07 0.7374334100931738 4.070897736123089e-07 0.733558046396253 4.070899902049297e-07 0.7283457217000903 4.070901834606309e-07 0.7236999380850822 \
4.07090362395765e-07 0.7194029726762079 4.070905292123874e-07 0.7154015770462002 4.070907154183522e-07 0.7109395231330657 4.070909033515935e-07 0.7064416825495208 \
4.070910692736986e-07 0.7024749886985119 4.07091261631787e-07 0.6978803202016938 4.07091402988682e-07 0.6945068232011449 4.070915599964439e-07 0.6907636199298515 \
4.07091755976089e-07 0.6860965106368763 4.070919184101942e-07 0.6822325558671515 4.070920795863762e-07 0.6784034260021697 4.070922718945739e-07 0.6738409413562468 \
4.070924895564538e-07 0.6686845685784016 4.070927375777557e-07 0.6628199086538362 4.07092915635219e-07 0.6586162961343578 4.070931641790282e-07 0.6527567611811057 \
4.070933667862709e-07 0.6479896840619462 4.070935365969381e-07 0.6440011601507294 4.07093695213124e-07 0.6402799599229552 4.070938337435587e-07 0.637035894415233 \
4.070939699513215e-07 0.6338503464729111 4.070940962626978e-07 0.6309003762865483 4.070942257219331e-07 0.6278810604265532 4.070943540536725e-07 0.6248911458464299 \
4.070944853836027e-07 0.6218374290191309 4.070946174102147e-07 0.6187713222160208 4.070947615700952e-07 0.6154276788919771 4.070949057786871e-07 0.6120888358645944 \
4.070950534337911e-07 0.6086753592300279 4.070952004901491e-07 0.6052842859263143 4.070953583041757e-07 0.6016504852589418 4.070954909098278e-07 0.5986039825107707 \
4.070956223747947e-07 0.5955897059985247 4.070957418045935e-07 0.5928552647156846 4.070958778732863e-07 0.5897484304797134 4.070959928015483e-07 0.5871283594046445 \
4.070961439122689e-07 0.5836892419704927 4.070962585613368e-07 0.5810871834776226 4.070963764990064e-07 0.5784138884735546 4.070964662802944e-07 0.576381560286313 \
4.070965565996887e-07 0.5743415774978985 4.070966232905592e-07 0.5728373329037385 4.070966888523724e-07 0.5713590910263378 4.070967398944957e-07 0.5702089751121119 \
4.070968015962151e-07 0.5688198806440578 4.070968646860707e-07 0.5674025889664359 4.070969290444246e-07 0.5659586381304559 4.070969824382236e-07 0.5647616504486359 \
4.070970750808062e-07 0.5626864159088959 4.070971516880785e-07 0.5609719030357503 4.070972075131406e-07 0.5597256439368602 4.070972765672667e-07 0.5581857825097393 \
4.070973834553926e-07 0.5558054549196561 4.070974611990176e-07 0.5540764009223496 4.070975620491174e-07 0.5518382286767042 4.070976877299716e-07 0.5490568313009737 \
4.070977879716568e-07 0.5468419758621708 4.070978998893402e-07 0.5443739014182352 4.070980031552469e-07 0.5421024366463116 4.070981229045887e-07 0.5394737463112931 \
4.07098224637469e-07 0.5372436950013484 4.070983401572132e-07 0.5347185748314579 4.070984551922987e-07 0.5322102907975605 4.07098581673211e-07 0.529456475824718 \
4.070987070470086e-07 0.5267350629320526 4.070988538629319e-07 0.5235577714138258 4.070989894263807e-07 0.5206304261698983 4.070991471246342e-07 0.5172373565578411 \
4.070993094436886e-07 0.5137528589513558 4.070994902675847e-07 0.5098871206809381 4.070996827159054e-07 0.5057874350093188 4.070998956212086e-07 0.5012700264709963 \
4.071001278026081e-07 0.4963634062180514 4.071003850931867e-07 0.4909555076455908 4.071006247190101e-07 0.4859407514401474 4.071009264344461e-07 0.479662588092526 \
4.071012143537997e-07 0.4737079198104491 4.071015272426189e-07 0.4672821326282255 4.071018469808238e-07 0.4607585360408045 4.071021865759847e-07 0.4538766993710576 \
4.071025134784829e-07 0.4472977926730654 4.071028490368641e-07 0.4405887635920606 4.071031661327868e-07 0.4342949501181722 4.071035003705415e-07 0.4277061431972559 \
4.071038518016635e-07 0.4208322784122511 4.071041663278176e-07 0.4147233751108969 4.07104489505308e-07 0.4084912998479469 4.071049306200656e-07 0.400057814108821 \
4.071052727361035e-07 0.3935812134363078 4.071055726806328e-07 0.3879522399691127 4.071059478116385e-07 0.3809760137481454 4.071062775558777e-07 0.3749002425561211 \
4.071065607988036e-07 0.3697269896098562 4.071068609450588e-07 0.3642865787664632 4.071071405472531e-07 0.3592589179584539 4.071073643233647e-07 0.3552676761685443 \
4.071075761036954e-07 0.3515151294490645 4.071077785371594e-07 0.3479514629380864 4.071079796284271e-07 0.3444362246481504 4.071081853428453e-07 0.3408632458568372 \
4.071084529657171e-07 0.3362478643926977 4.071086918970113e-07 0.3321601360780691 4.07108925403074e-07 0.3281974319442653 4.071091388684736e-07 0.3246000376975314 \
4.071093602460465e-07 0.3208952602338652 4.071095602096931e-07 0.3175728982722026 4.071097644820061e-07 0.3142073831356898 4.071099618288778e-07 0.3109812293225088 \
4.071101472014048e-07 0.3079732989686547 4.071103433077958e-07 0.3048147723336881 4.071105455849362e-07 0.3015820927993307 4.071107212432327e-07 0.2988007390096292 \
4.0711090711339e-07 0.295878328903569 4.071111140927825e-07 0.2926488196724605 4.071112994143739e-07 0.2897857719971084 4.071114946411816e-07 0.2867989994419413 \
4.07111650415531e-07 0.28443329608414 4.071118291723129e-07 0.2817356906084737 4.071120102032329e-07 0.2790344478478936 4.071121601003467e-07 0.2768142575519123 \
4.071123611437744e-07 0.273859574769726 4.071125102589039e-07 0.2716833853889438 4.071126487983335e-07 0.2696726034832688 4.071128006734089e-07 0.2674956304896134 \
4.071129151475376e-07 0.2658586287383957 4.071130466774683e-07 0.2639823142040156 4.071131724359563e-07 0.2622048582339201 4.071132767763623e-07 0.2607341604582348 \
4.071133897557217e-07 0.2591418073851619 4.071135060842464e-07 0.2575033437579446 4.071136490116675e-07 0.2554974228347739 4.071137622731725e-07 0.2539102348881249 \
4.071138964299053e-07 0.2520298733123076 4.071140069027097e-07 0.2504818583075984 4.071141623352847e-07 0.2483006006477398 4.071143032203835e-07 0.2463217957442577 \
4.071144546129539e-07 0.2441928603691365 4.071146097750346e-07 0.2420086586735095 4.071147391842834e-07 0.2401849910837116 4.071148738963765e-07 0.2382868210192302 \
4.071150115942015e-07 0.2363478190565156 4.071151293462172e-07 0.2346905900295477 4.071152886704099e-07 0.2324499447852502 4.071154259326364e-07 0.2305210708572645 \
4.071155666789934e-07 0.2285488733964877 4.071156724701667e-07 0.2270688194984586 4.071158024115646e-07 0.2252532503786337 4.071159029480282e-07 0.2238506847401111 \
4.071160052817357e-07 0.2224250970611539 4.071160790103172e-07 0.2214012665004395 4.071161582442603e-07 0.2203047212273054 4.071162292155075e-07 0.2193236206014474 \
4.071162806785351e-07 0.218612902325451 4.071163336269882e-07 0.2178825126218075 4.071164127819908e-07 0.2167921001391954 4.071164550546259e-07 0.2162104926182252 \
4.071164948991708e-07 0.2156628374086678 4.071165381228204e-07 0.2150692779925967 4.071165790298225e-07 0.2145080585354088 4.071166491522843e-07 0.2135474129702876 \
4.071166828372557e-07 0.2130867492099046 4.071167276666377e-07 0.212477723463 4.071167865237998e-07 0.2116792343136102 4.071168513092605e-07 0.2108017053965978 \
4.071169087900245e-07 0.2100241135398916 4.071169692190328e-07 0.209207737948094 4.071170662554631e-07 0.2078991976528634 4.07117150945123e-07 0.2067595417901527 \
4.071172598558851e-07 0.2052972881712416 4.071173562566921e-07 0.2040065614180294 4.071174512733294e-07 0.2027428333585779 4.071175547051275e-07 0.2013717100485363 \
4.071176496344728e-07 0.2001158751783069 4.071177526548994e-07 0.198757993281026 4.071178577373321e-07 0.1973779917312911 4.071179670461462e-07 0.1959482000350934 \
4.071180774896281e-07 0.1945091075764383 4.071181937799036e-07 0.1929996650696684 4.071183037098964e-07 0.1915811184357085 4.071184133723204e-07 0.1901717999899754 \
4.071185150889654e-07 0.1888694322720079 4.071186080436791e-07 0.1876837490531375 4.07118700772569e-07 0.1865049219968967 4.07118774458125e-07 0.1855719169757668 \
4.071188572993399e-07 0.1845269810791141 4.071189318853365e-07 0.1835895008849975 4.071190016086783e-07 0.1827150226754214 4.071190683270854e-07 0.1818808699270075 \
4.071191641704113e-07 0.1806871657728035 4.071192468771839e-07 0.1796611249561687 4.071193404410076e-07 0.1785035608809835 4.07119435337095e-07 0.1773351434884491 \
4.071195467074053e-07 0.1759704596301353 4.071196883497589e-07 0.1742450478777388 4.071198035966122e-07 0.1728486436789435 4.071199481442513e-07 0.1711076225712051 \
4.071200597399285e-07 0.1697708811114609 4.071202009589021e-07 0.1680898955975501 4.071203166961755e-07 0.1667201145354908 4.071204226568608e-07 0.1654722325850081 \
4.071205214164775e-07 0.164314417410061 4.071206177596498e-07 0.1631901152369615 4.071207064174022e-07 0.1621596955203892 4.071208317516728e-07 0.1607099933926625 \
4.071209262770884e-07 0.1596224416957933 4.071210240160401e-07 0.1585042187118262 4.071211321109172e-07 0.1572745454417887 4.071212267786047e-07 0.1562036643369483 \
4.071213342264514e-07 0.1549951394274829 4.071214253154951e-07 0.1539767092330788 4.071215320872068e-07 0.1527896463435911 4.071216354804728e-07 0.1516469620792683 \
4.071217465609577e-07 0.1504267727114754 4.071218357869395e-07 0.1494522115900035 4.071219212668682e-07 0.1485231035185812 4.071220051920549e-07 0.1476157397758405 \
4.071220748986192e-07 0.1468658175993407 4.071221535366968e-07 0.1460232248551682 4.071222318479542e-07 0.1451880611912267 4.071223024838273e-07 0.1444378248611795 \
4.071223879746948e-07 0.1435337156153706 4.071224753636722e-07 0.1426139614481139 4.071225569511858e-07 0.1417594571206545 4.071226542701372e-07 0.1407454482154784 \
4.071227349596596e-07 0.139910090776864 4.071228257446906e-07 0.1389752404035735 4.07122947088963e-07 0.1377336220260025 4.071230361386038e-07 0.13682812281983 \
4.07123134655454e-07 0.1358318692385875 4.071232217417229e-07 0.1349560640726983 4.071233321526109e-07 0.1338550874529322 4.071234206114333e-07 0.1329791517134813 \
4.071235213400266e-07 0.1319874611681985 4.071236261295802e-07 0.1309622419763913 4.071237205198131e-07 0.1300442429014473 4.07123817024605e-07 0.1291112112475518 \
4.071239165112583e-07 0.1281591654439075 4.071240029124292e-07 0.1273384721630967 4.071240978925599e-07 0.1264411177628728 4.071242020813879e-07 0.1254629331099751 \
4.071243112001386e-07 0.124445178694 4.071244055505945e-07 0.1235704029653004 4.07124517846343e-07 0.1225411084520107 4.071246133096967e-07 0.1216733466577494 \
4.071247175205873e-07 0.1207311846737792 4.071248068659445e-07 0.1199276649878674 4.071248772532175e-07 0.1192980345746366 4.071249526392512e-07 0.1186268760051257 \
4.071250287714207e-07 0.1179522201461119 4.071250977489184e-07 0.1173458504859956 4.071251802680909e-07 0.1166263596898966 4.071252522115779e-07 0.1160015972854393 \
4.071253342903043e-07 0.1152916772467617 4.071254186247801e-07 0.1145654108773922 4.07125496418619e-07 0.113898375935255 4.071255891835211e-07 0.1131065723182637 \
4.071257047873425e-07 0.1121254933399327 4.071258106929114e-07 0.1112341778178403 4.071258883498312e-07 0.1105854195321705 4.071259766463023e-07 0.1098504899494786 \
4.071260567033545e-07 0.1091866403929743 4.071261536294793e-07 0.1083861389179563 4.07126248864964e-07 0.1076031391441806 4.071263374361587e-07 0.1068780200140514 \
4.071264387442599e-07 0.1060523297458165 4.071265442899473e-07 0.1051963702337609 4.071266534843119e-07 0.1043160928234657 4.071267616019328e-07 0.1034503663302994 \
4.071268815196938e-07 0.1024949450012773 4.071269828815214e-07 0.1016914181115986 4.071270888911509e-07 0.100855068690839 4.071272146827803e-07 0.09986840123414902 \
4.071273442400857e-07 0.09885896724496235 4.071274799154405e-07 0.09780904711780367 4.071276559873037e-07 0.09645781830037269 4.071278197878238e-07 0.09521257997344186 \
4.071279826125652e-07 0.09398642071914091 4.071280677512003e-07 0.09334985726464029 4.07128137589223e-07 0.09282999162688726 4.071282070848284e-07 0.09231474740697931 \
4.071282810434879e-07 0.09176875214326782 4.071283771983755e-07 0.09106241641841166 4.071284516137408e-07 0.09051841344162129 4.071285296033096e-07 0.08995079828656057 \
4.071286060521396e-07 0.08939693755534793 4.071286935462239e-07 0.08876614459792892 4.071287957229341e-07 0.08803382885421264 4.071288842873223e-07 0.08740269463919083 \
4.071289939528099e-07 0.08662585268124241 4.071291100092175e-07 0.08580942306245626 4.07129251558034e-07 0.0848216759818637 4.071293844270176e-07 0.08390253510334872 \
4.071295251873282e-07 0.08293727564630923 4.071296748969478e-07 0.08192024575105315 4.071298106088348e-07 0.08100683753927941 4.071299521257171e-07 0.08006309454860433 \
4.071300872475907e-07 0.07917070961097784 4.071302285200282e-07 0.07824718349428782 4.071303756129204e-07 0.07729532867436953 4.07130527122786e-07 0.07632524417621221 \
4.071306924984999e-07 0.07527819040792309 4.071308562596902e-07 0.07425356708383206 4.071310323896319e-07 0.07316505371836476 4.071312215286099e-07 0.07201151367936541 \
4.071314322022337e-07 0.07074528708793332 4.071316517688556e-07 0.06944624562626683 4.071318865352622e-07 0.06808094281860989 4.071321449277003e-07 0.06660616301228137 \
4.071324395923605e-07 0.06496103773121734 4.071327436716829e-07 0.06330286177969326 4.071331045821629e-07 0.06138472526627536 4.071334404990352e-07 0.05964719353945821 \
4.071338806764061e-07 0.05743991201668189 4.071342590438092e-07 0.05560437501227136 4.071347015027716e-07 0.05352996728430704 4.071350555229165e-07 0.05192508193542229 \
4.071354420396718e-07 0.05022502935509546 4.07135786643729e-07 0.04875485597254389 4.071361086186649e-07 0.04741934964807833 4.07136412152492e-07 0.04619304551845941 \
4.071367070734883e-07 0.04503122626702559 4.071369895557667e-07 0.04394770877170886 4.071372666361775e-07 0.04291147062934708 4.071375323636684e-07 0.04194013461971725 \
4.071378035943552e-07 0.0409708748276704 4.071380798533722e-07 0.04000619535229137 4.071383697525942e-07 0.03901828782233653 4.071385981289875e-07 0.03825741181922668 \
4.071389030130544e-07 0.03726495139513845 4.071391196849105e-07 0.03657573971894532 4.071393110416374e-07 0.03597943984071691 4.071395096361558e-07 0.03537298232318693 \
4.071398395514967e-07 0.03438820140908775 4.071400814971701e-07 0.03368375433354889 4.071403968092223e-07 0.03278771666975258 4.071406669292072e-07 0.03203957074185158 \
4.071409233008807e-07 0.03134567005659093 4.071412033128806e-07 0.03060515313352298 4.071414489686567e-07 0.02997014710356035 4.071416817043018e-07 0.02938120249260199 \
4.07141924434299e-07 0.02878348292867495 4.071421611615635e-07 0.02821317433052753 4.071423898079744e-07 0.0276732289298247 4.071428070936345e-07 0.02671456010533928 \
4.071430022743284e-07 0.02627749693639509 4.071433834414109e-07 0.02544369227895442 4.071435606942329e-07 0.02506446942885681 4.071439031456878e-07 0.02434654114125227 \
4.071440564141201e-07 0.02403127656358269 4.071444314325841e-07 0.02327616399748992 4.071445690667252e-07 0.02300530455388665 4.071450533333593e-07 0.02207084195640928 \
4.071451729527604e-07 0.02184403312078184 4.071455899915636e-07 0.02106026682208277 4.07145733393791e-07 0.02079332360769017 4.071462546051726e-07 0.01984598817089831 \
4.071463823790427e-07 0.0196205814374062 4.071469667914167e-07 0.01863359713481367 4.071471392268229e-07 0.01835589372257288 4.071477433235728e-07 0.01743644241612937 \
4.071479047552142e-07 0.01720262545858322 4.071485447014338e-07 0.01631831686205014 4.071487230176005e-07 0.016083210242981 4.071493710016487e-07 0.01526127675881721 \
4.071495362552397e-07 0.01505930898173208 4.071502725571753e-07 0.01419381259610907 4.071504068332255e-07 0.01404154276213586 4.071512039327433e-07 0.01317592498067951 \
4.071513445303545e-07 0.01302934089458718 4.071523098735771e-07 0.0120661300044765 4.071524742123827e-07 0.01190857475316222 4.071534749435119e-07 0.01099048917119646 \
4.07153612213369e-07 0.01087009009405628 4.071547509078863e-07 0.009949273443646761 4.071548650857872e-07 0.009863136028526375 4.071562457306217e-07 0.008889755784408603 \
4.071564000878327e-07 0.00878832203975914 4.071579465820612e-07 0.00781340401000951 4.071580309437644e-07 0.007760176032106158 4.071597163710821e-07 0.006770348169342283 \
4.071598398995725e-07 0.00670487246831437 4.071618897141387e-07 0.005720970231232756 4.071620861142965e-07 0.005634691917282852 4.071644047936537e-07 0.004698942116576918 \
4.071648654079885e-07 0.004530544077955615 4.071676055035305e-07 0.003639937533647344 4.071681236485673e-07 0.00349159181499799 4.071722742898753e-07 0.002502201117031859 \
4.071728121398825e-07 0.002396807933581942 4.0717889437533e-07 0.001421603691354927 4.071791533557405e-07 0.001378272220758726 4.071844761190904e-07 0.0003814093765652445 \
4.071845892761344e-07 0.0003711807182531981 4.098307063923701e-07 -0.0004615907568095335 4.098308688313385e-07 -0.0006852153244161934 4.098313698328069e-07 -0.001554404032531494 \
4.098314540153697e-07 -0.001725199767551738 4.098318555381938e-07 -0.002626792336557519 4.098319448731607e-07 -0.002845673237760077 4.098322314649697e-07 -0.0035898660494722 \
4.098323590334993e-07 -0.003937855927128601 4.098326777451613e-07 -0.004830400105952924 4.098327919463135e-07 -0.00515011308870196 4.098330743466382e-07 -0.005887653497963378 \
4.098332045728569e-07 -0.006177415671381139 4.098341829257541e-07 -0.005220113099403402 4.098343702332871e-07 -0.004004368716724641 4.098345016776888e-07 -0.002901539130564616 \
4.098346071052425e-07 -0.001869327786897239 4.098346928227261e-07 -0.0009323217369615201 4.098347747492128e-07 4.151965372454519e-05 4.098348957860361e-07 0.001618129410352471 \
4.098349947146829e-07 0.003024565667809575 4.098351531113568e-07 0.005482561958548801 4.098353705585867e-07 0.00923691162542661 4.098355517808096e-07 0.0126653356758144 \
4.098357638749061e-07 0.01697021734206094 4.098359268985627e-07 0.02046388365739064 4.098360875209785e-07 0.02403759527126768 4.09836241061221e-07 0.02755862871109176 \
4.098363891179022e-07 0.031036270750196 4.098365381988111e-07 0.03460722192241437 4.098366927287225e-07 0.03837091703902212 4.098368533795379e-07 0.04234026030123839 \
4.098370180342186e-07 0.04645786783841532 4.098371945751169e-07 0.05091770581196236 4.098373735379688e-07 0.05547793877747508 4.098375642811338e-07 0.0603721650098247 \
4.09837769062163e-07 0.06565647483694508 4.098379895344492e-07 0.07137203566208646 4.098382223941741e-07 0.0774299331224613 4.098384715816505e-07 0.08392829098722057 \
4.098387444237776e-07 0.09105513637423955 4.098390411275777e-07 0.09880974921055499 4.098393684539683e-07 0.1073623706929605 4.098397381053549e-07 0.11701033799881 \
4.09840132977169e-07 0.1273002725707723 4.098405908154097e-07 0.1392030195235975 4.098411226222497e-07 0.1529832553757746 4.09841747860046e-07 0.1691182447448397 \
4.098424336075175e-07 0.1867241161332086 4.098432360033912e-07 0.2071957342970069 4.09844134802183e-07 0.2299563735557614 4.098449404156324e-07 0.2501946571168963 \
4.098456541669658e-07 0.2679877251922811 4.098462837288478e-07 0.2835633151515627 4.098468540922982e-07 0.2975737963344939 4.098473850476804e-07 0.3105173405876944 \
4.098478868351306e-07 0.3226580892822354 4.098483661296844e-07 0.3341673054699896 4.098488316851033e-07 0.3452566901045974 4.098492954815109e-07 0.3562094254686541 \
4.098497512295407e-07 0.3668794056881832 4.098502114496752e-07 0.3775613305945491 4.098507497336462e-07 0.3899285626759094 4.098512505841796e-07 0.4013172511919189 \
4.098516508068632e-07 0.4103337945930838 4.098521576676441e-07 0.421642452039157 4.098526436338564e-07 0.4323669409017459 4.098530431485677e-07 0.4410997362599856 \
4.098534537606271e-07 0.4500002277813482 4.098538826870602e-07 0.4592207708982954 4.098542842014423e-07 0.4677760623951868 4.098545915918887e-07 0.4742753916877908 \
4.098549418336473e-07 0.4816249679276425 4.098552950738506e-07 0.4889795533930016 4.0985554824443e-07 0.4942125642332652 4.098557811883199e-07 0.4989990073547648 \
4.098560228316108e-07 0.5039392821429431 4.098562478222295e-07 0.5085102868389438 4.098564398583375e-07 0.5123881070394828 4.098566246700343e-07 0.5161059569497825 \
4.098568469603498e-07 0.5205538992744256 4.098570136717574e-07 0.5238726938135662 4.098572308883525e-07 0.5281726418673847 4.098574339672442e-07 0.5321820613122353 \
4.098576113786994e-07 0.5356681922482178 4.098577994510863e-07 0.5393528234657015 4.098580354832656e-07 0.5439555888699217 4.098583013652896e-07 0.5491186112539347 \
4.098585231271783e-07 0.5534070305875756 4.098588031850331e-07 0.5588091140818973 4.098590461848179e-07 0.5634839438879177 4.09859321538161e-07 0.5687575845994758 \
4.098595665335016e-07 0.5734440561015828 4.098598068277205e-07 0.5780305526007354 4.098600478670234e-07 0.5826153106864888 4.09860305457841e-07 0.5874946531182738 \
4.098605408246178e-07 0.5919209497705462 4.09860772126727e-07 0.5962518282209535 4.098609946534482e-07 0.6003950532231523 4.098612030130559e-07 0.6042587207462122 \
4.098614408548706e-07 0.6086392006348278 4.098616517150854e-07 0.612499186772883 4.09861907322267e-07 0.617151767543529 4.098621060500327e-07 0.620751700070918 \
4.098623816826772e-07 0.6257066023742009 4.098626044387981e-07 0.6296824120643636 4.098628978099216e-07 0.6348814180513288 4.098631305799232e-07 0.6389753720667986 \
4.098633507813092e-07 0.6428252659334456 4.098635520519211e-07 0.6463216644290061 4.098637693407936e-07 0.6500784077528632 4.098639440567036e-07 0.6530842133917786 \
4.098641303213334e-07 0.6562672470877895 4.098643090603859e-07 0.6593113758161715 4.098644717643993e-07 0.6620700940033843 4.098646370334099e-07 0.6648583661366954 \
4.098647803012238e-07 0.6672607123132118 4.09864919531648e-07 0.669583864918244 4.098650593322146e-07 0.6719085596965743 4.098651941074223e-07 0.6741424479378803 \
4.098653216016633e-07 0.6762463034350935 4.098654545557747e-07 0.6784344250006583 4.098655761601249e-07 0.680430207161383 4.098657045733663e-07 0.6825336955632141 \
4.098658203404209e-07 0.6844241240890321 4.098659183815937e-07 0.686020684362688 4.098660190776997e-07 0.687656981754083 4.098661288314626e-07 0.689434454762776 \
4.098662455994179e-07 0.6913211166705923 4.098663368261916e-07 0.6927889453402305 4.098664460316049e-07 0.6945396927028351 4.098665471403262e-07 0.6961566646470493 \
4.098666425406182e-07 0.6976767415743361 4.098667520226426e-07 0.6994136821864276 4.098668864742773e-07 0.7015344809028976 4.098670354932137e-07 0.7038694457768003 \
4.098671644232324e-07 0.7058755144243859 4.09867311083691e-07 0.7081418729260142 4.098674378680718e-07 0.7100885084081828 4.098675624659611e-07 0.7119899232102255 \
4.098676743197281e-07 0.7136874821928206 4.098677872756922e-07 0.7153928249203609 4.098678878290893e-07 0.716903336497302 4.098680251105924e-07 0.7189542886859326 \
4.098681449794518e-07 0.7207346491296758 4.09868264162204e-07 0.7224952472954583 4.098683911643136e-07 0.7243608783177121 4.098685157126648e-07 0.726179956024653 \
4.098686393836757e-07 0.7279757435764195 4.09868765971953e-07 0.7298035010246171 4.098688965411881e-07 0.7316777339938921 4.098690190562223e-07 0.7334262671520465 \
4.098691552997129e-07 0.7353588786631546 4.098692567424861e-07 0.7367901064855561 4.09869362765969e-07 0.7382789144707947 4.098694532971524e-07 0.7395446819117977 \
4.098695671233782e-07 0.7411267287627761 4.098696547849604e-07 0.742338113895605 4.098697606802377e-07 0.7437932991468792 4.098698910335325e-07 0.7455718205320391 \
4.098700016011403e-07 0.7470699275523445 4.098701062716115e-07 0.7484790865773925 4.09870230233143e-07 0.7501360792234356 4.09870378790597e-07 0.752105598322839 \
4.098705004731933e-07 0.7537054667443914 4.098706145848825e-07 0.7551949470168074 4.098707550054835e-07 0.7570132059451244 4.098708965335436e-07 0.7588296197226846 \
4.098710143228134e-07 0.7603289862386273 4.098711425226351e-07 0.7619481626911874 4.098712845904683e-07 0.7637269294216019 4.098714014655762e-07 0.7651780119234867 \
4.098715471393621e-07 0.7669714049983392 4.098716688778096e-07 0.7684572223066155 4.098717875183015e-07 0.7698939375992205 4.098719099845946e-07 0.7713653733660819 \
4.098720367016846e-07 0.7728756341192486 4.098721466036788e-07 0.7741754302862822 4.098722722190223e-07 0.7756497674172792 4.098723780294307e-07 0.7768823528242577 \
4.098725141995534e-07 0.7784559787239111 4.098726385466015e-07 0.7798807766277074 4.098727659718769e-07 0.7813271999647126 4.098728805279564e-07 0.7826155184370988 \
4.098729872082259e-07 0.7838050786084815 4.098731251508229e-07 0.785328674235108 4.098732746003193e-07 0.7869612315653352 4.098734194525364e-07 0.7885256944569791 \
4.098735388882871e-07 0.7898026796320731 4.0987367431316e-07 0.7912364721526877 4.09873795807481e-07 0.7925100718437531 4.098739391665555e-07 0.7939977458315933 \
4.09874082600237e-07 0.7954699260458764 4.098742084112467e-07 0.7967479640295563 4.098743274579285e-07 0.7979459892863545 4.098744394715731e-07 0.7990632136113104 \
4.098745442634543e-07 0.8000996927221937 4.098746394563032e-07 0.8010335634530776 4.098747758668286e-07 0.8023587211299719 4.098748926790049e-07 0.8034813603122919 \
4.098750121402484e-07 0.8046180202255495 4.098751341806002e-07 0.8057672874017472 4.098752570806969e-07 0.8069126780167393 4.098753842000533e-07 0.8080849010520604 \
4.098755093419151e-07 0.8092265787736463 4.098756398931422e-07 0.8104047139317369 4.09875765969389e-07 0.811530109085512 4.098758939660489e-07 0.8126603425876329 \
4.098759994272971e-07 0.8135823118114501 4.098761026965977e-07 0.814477091043954 4.098761953499458e-07 0.8152732203909091 4.098763190441811e-07 0.8163262937528154 \
4.098764066640956e-07 0.8170655553659417 4.098765053301514e-07 0.8178914289762149 4.098766488771539e-07 0.819080619224994 4.098767844633066e-07 0.8201904093102529 \
4.098768936532881e-07 0.8210742465492874 4.098770411027471e-07 0.8222539401850584 4.09877191506449e-07 0.8234410273756358 4.098773169754118e-07 0.8244188977545531 \
4.098774611413952e-07 0.8255287290252299 4.098775854299599e-07 0.8264738611628292 4.098777359002563e-07 0.8276038147969816 4.098778715066145e-07 0.8286089145501508 \
4.09877996601616e-07 0.8295251220930787 4.098781143174533e-07 0.8303776282987162 4.098782602030521e-07 0.8314210189912619 4.098784266961482e-07 0.8325942517713072 \
4.098785575628508e-07 0.833503494447128 4.098787310074617e-07 0.8346911703335461 4.098788991402022e-07 0.8358239212093587 4.098790689939496e-07 0.8369500705213252 \
4.098792498869552e-07 0.838129582835239 4.098793930212163e-07 0.8390486258646698 4.098795071191619e-07 0.8397723391454259 4.098796372463218e-07 0.8405879656882547 \
4.098797391021787e-07 0.8412191375388212 4.098798559475988e-07 0.8419354178465567 4.098799929193963e-07 0.84276453896487 4.098801907591422e-07 0.843942473808897 \
4.098803824446297e-07 0.8450620046306492 4.09880591850993e-07 0.8462610422160779 4.098807738618767e-07 0.8472832413425977 4.098809709773334e-07 0.8483697584184032 \
4.098811442904469e-07 0.8493077402131245 4.098813273256562e-07 0.8502809338042043 4.098814984787832e-07 0.8511747489972419 4.098816731317363e-07 0.8520708361396651 \
4.098818483828913e-07 0.8529540285731302 4.098820245303913e-07 0.8538259128238825 4.098822148367787e-07 0.8547503816925358 4.098824054277479e-07 0.8556583881771193 \
4.098826059797908e-07 0.8565949481971697 4.098827985825885e-07 0.8574764650234362 4.098830093312883e-07 0.8584213553684483 4.098832373621857e-07 0.8594210644592908 \
4.098835032419522e-07 0.8605573106989262 4.098838018200941e-07 0.8617960322792503 4.098840779837292e-07 0.8629075153790151 4.098843622302292e-07 0.8640180616030438 \
4.098846364142308e-07 0.8650581816846495 4.098849086694401e-07 0.8660616517296992 4.098851788589146e-07 0.8670295451208139 4.098854360232381e-07 0.8679256252637404 \
4.098857085969722e-07 0.8688492356117473 4.098859846024351e-07 0.8697577927663542 4.09886254710518e-07 0.8706213441784563 4.098865545689379e-07 0.8715508809746347 \
4.098869255828164e-07 0.8726599440782473 4.098872205155291e-07 0.873510245983525 4.098874748008955e-07 0.8742218447789023 4.098877730441708e-07 0.8750318897722944 \
4.098880466409288e-07 0.8757523113099853 4.098882827679075e-07 0.8763571312809064 4.098885231072055e-07 0.876957042728428 4.098887454408612e-07 0.8774982514557473 \
4.098889394467937e-07 0.8779599514934209 4.098892691652286e-07 0.8787226653583874 4.098894243380191e-07 0.8790722725343518 4.098897420714095e-07 0.8797700114458387 \
4.098899209390604e-07 0.880152324917399 4.09890263400534e-07 0.8808637455080008 4.098904475523683e-07 0.8812353200296749 4.098909224784184e-07 0.8821594045029107 \
4.098910898716537e-07 0.8824737723885729 4.098915556929605e-07 0.8833186808430151 4.098917365204472e-07 0.883635209600208 4.098922305497857e-07 0.8844687288968743 \
4.098923718877729e-07 0.8846990198924604 4.098929782491027e-07 0.8856473543416146 4.098931303209552e-07 0.8858754372639542 4.098937770089477e-07 0.8868048391838264 \
4.098939053031091e-07 0.8869818633102416 4.098945534965822e-07 0.8878410756373726 4.098946832451334e-07 0.8880061989117775 4.09895451498601e-07 0.8889361126992519 \
4.098955812406254e-07 0.8890847997417872 4.098964346975575e-07 0.8900046759307325 4.098965779246734e-07 0.8901495209380393 4.098975641580769e-07 0.8910738355210844 \
4.09897785636141e-07 0.8912643084423501 4.098989286536885e-07 0.8921737958641509 4.098990586319894e-07 0.8922730011388891 4.099004103389882e-07 0.8932565980587214 \
4.099005606923423e-07 0.8933589605607284 4.09902041315768e-07 0.8942730372387374 4.0990228021907e-07 0.8944047337041336 4.099040613442277e-07 0.8952702388217941 \
4.099044473255946e-07 0.8954343910560414 4.099068488716345e-07 0.896309305076933 4.099073238084202e-07 0.8964562995603377 4.099111419701395e-07 0.8973944547681553 \
4.099116244593365e-07 0.897487269196476 4.099195104748494e-07 0.898471373493449 4.099201266375397e-07 0.8985180228791175 4.100152826123789e-07 0.899508178894561 \
4.100167732145567e-07 0.8995204306067698 4.101280612887407e-07 0.9005118233983579 4.101282376257435e-07 0.9005706457326812 4.10131860757067e-07 0.8996048713171836 \
4.101320419550936e-07 0.8994654179496379 4.101333530765704e-07 0.8985275682722235 4.101335349539762e-07 0.8984123497545736 4.101353579441702e-07 0.8974436520388238 \
4.101355178574244e-07 0.8973766233009967 4.101486686887231e-07 0.8983720910457982 4.101487796702765e-07 0.8983905835035384 4.101576012543832e-07 0.8993863063850064 \
4.101581480238467e-07 0.8994226481040219 4.106507199766805e-07 0.9003987622903815 4.106507897691656e-07 0.9004496773542636 4.106516224219291e-07 0.9012853800543292 \
4.106517484680941e-07 0.9014513953152168 4.106523289889575e-07 0.9023435091985418 4.106524699532118e-07 0.9025895326188698 4.106528690912908e-07 0.9033428289365844 \
4.106530192408316e-07 0.9036449200440446 4.106534623221535e-07 0.9045762589490434 4.106536194942562e-07 0.9049121924877023 4.106540651209874e-07 0.9058152254958243 \
4.106541635773263e-07 0.9059929146639856 4.106555802587204e-07 0.9052304871087643 4.10655711415865e-07 0.904616184869324 4.106558804230411e-07 0.9036290332250884 \
4.106560457149166e-07 0.9024406226812831 4.106561519806978e-07 0.9015554774641358 4.106562554175281e-07 0.9006052096506509 4.106563411842469e-07 0.8997486040545581 \
4.106564306782332e-07 0.8987887485205278 4.106565549226324e-07 0.8973492764100613 4.106566730035805e-07 0.8958624931586439 4.106567602196721e-07 0.8946938835082598 \
4.106568845267161e-07 0.8929289312882503 4.106569915106439e-07 0.8913158670103165 4.106570913423478e-07 0.8897378501708729 4.106572176331742e-07 0.8876466417139378 \
4.106573858217853e-07 0.884705368138502 4.106575415215381e-07 0.8818365157686672 4.106577381263672e-07 0.8780362649814708 4.106579217476167e-07 0.8743271923380105 \
4.106581332550105e-07 0.8698916163736473 4.106583140648106e-07 0.8659808238081558 4.106584986458582e-07 0.8618945354625286 4.106586716498537e-07 0.8579913311618118 \
4.106588570505038e-07 0.8537436868396935 4.106590361336512e-07 0.8495884889292737 4.106592197227131e-07 0.8452850234109005 4.106593864844183e-07 0.8413449312544377 \
4.10659554574996e-07 0.8373487193315756 4.10659717684167e-07 0.8334514816705533 4.106598728704027e-07 0.829729402178684 4.10660045969282e-07 0.8255639501984255 \
4.106602319597377e-07 0.8210763864673301 4.106603965802216e-07 0.8170961425007568 4.106605614501323e-07 0.8131038678717658 4.106607367821645e-07 0.8088537582860886 \
4.106609012086681e-07 0.8048648186953292 4.106610698442787e-07 0.8007719922541914 4.106612606476452e-07 0.7961398815555145 4.106614461718184e-07 0.7916360074082958 \
4.106616551006281e-07 0.7865651471012967 4.10661879917618e-07 0.7811107659751856 4.106620697327054e-07 0.77650678233121 4.106622715901883e-07 0.7716133355283564 \
4.106624158608269e-07 0.76811790639139 4.106625575043926e-07 0.7646880872338248 4.106626852021022e-07 0.7615975116975136 4.106627962479435e-07 0.7589113686396982 \
4.106629248105796e-07 0.7558028559024855 4.10663057376087e-07 0.7525995467138866 4.106631706977832e-07 0.7498629233610832 4.106633070324095e-07 0.7465723252212872 \
4.106634134316607e-07 0.7440058350410135 4.106635726504468e-07 0.7401674766516904 4.106637450281421e-07 0.7360137588823189 4.10663907275386e-07 0.7321074183421575 \
4.106640796243437e-07 0.7279612819449855 4.106642390105271e-07 0.7241302920521341 4.106644468157139e-07 0.7191408067115369 4.106646073553789e-07 0.7152908836069264 \
4.106647998447152e-07 0.7106793324906435 4.10664985361064e-07 0.7062404417184839 4.106651552371093e-07 0.7021802791355866 4.106653471069473e-07 0.6975984806629684 \
4.106654933309623e-07 0.6941099299715526 4.106656536173094e-07 0.6902897983225644 4.10665856006145e-07 0.6854719661536142 4.10666037294609e-07 0.681161582477689 \
4.106662061160357e-07 0.6771536053116509 4.106663919619109e-07 0.6727470762459599 4.106665978927512e-07 0.6678715161770782 4.10666765819558e-07 0.6639016226084196 \
4.106669260812615e-07 0.6601182542089066 4.106671649337354e-07 0.65448589698252 4.106673326948486e-07 0.6505369020837752 4.106675137682881e-07 0.6462813620835641 \
4.106676749231988e-07 0.642499550819208 4.106678211904597e-07 0.6390715923276049 4.106679598785689e-07 0.6358268652274862 4.106680892356149e-07 0.6328040340451749 \
4.106682186201702e-07 0.6297855584526113 4.106683469414899e-07 0.6267952385336898 4.106684771436295e-07 0.6237652412672913 4.106686061600736e-07 0.6207683673242944 \
4.106687447356331e-07 0.6175525629501428 4.106688928112201e-07 0.6141227553162802 4.106690791385052e-07 0.60981438109949 4.106692268222044e-07 0.6064079319686639 \
4.106694619864099e-07 0.600995965122186 4.106696544341406e-07 0.5965821560879089 4.106698950039548e-07 0.5910808370261941 4.106700640513256e-07 0.587228367631822 \
4.106702017177501e-07 0.5840969866928536 4.106703298227265e-07 0.581191110277254 4.10670443409422e-07 0.5786182870235701 4.106705347742257e-07 0.5765512826027382 \
4.106706241961132e-07 0.5745328691003393 4.106706914578463e-07 0.573016830490748 4.106707574780489e-07 0.5715297341779608 4.106708095317241e-07 0.5703577032508095 \
4.106708737705932e-07 0.5689124506700958 4.106709353071159e-07 0.5675311492520995 4.106709995886598e-07 0.5660899724818867 4.106710527797555e-07 0.5648985048860162 \
4.106711451255398e-07 0.5628316153148989 4.106712217014409e-07 0.5611191615154557 4.106712775450911e-07 0.5598732849310241 4.106713468881998e-07 0.5583285932816697 \
4.106714527394756e-07 0.5559733466166974 4.1067153043128e-07 0.5542469170533902 4.106716310298676e-07 0.5520159549745236 4.106717590630782e-07 0.5491849411292137 \
4.106718585604598e-07 0.5469885705929382 4.106719711258113e-07 0.544508366501287 4.106720741701315e-07 0.5422442603473754 4.106721942190172e-07 0.5396115972585003 \
4.106722958334261e-07 0.5373863339265779 4.10672411457693e-07 0.5348611538529422 4.106725265738742e-07 0.5323536236546169 4.106726530109181e-07 0.529604142030661 \
4.106727785251858e-07 0.5268822104345234 4.106729252048618e-07 0.5237112381511962 4.106730608755698e-07 0.5207845659358002 4.106732186414087e-07 0.5173942078023266 \
4.106733810633495e-07 0.5139116507621072 4.106735619718178e-07 0.5100482739823553 4.106737545639722e-07 0.5059503908118104 4.106739675557428e-07 0.5014368974673542 \
4.106741999884595e-07 0.4965308659362653 4.106744575093732e-07 0.49112491222925 4.106746974735513e-07 0.4861095397820235 4.106749986779057e-07 0.4798501326413723 \
4.106752869755342e-07 0.4738957353990632 4.106756000618611e-07 0.4674739717793394 4.106759195881407e-07 0.4609631488871989 4.106762590854062e-07 0.4540919149088484 \
4.106765852755184e-07 0.4475353831519197 4.106769217567802e-07 0.4408159131180407 4.106772384675873e-07 0.4345373385230166 4.106775725526604e-07 0.4279587671099637 \
4.106779242615287e-07 0.4210864038135054 4.106782387463783e-07 0.4149846225409808 4.106785621928357e-07 0.4087533091618546 4.106790031209485e-07 0.400331870031168 \
4.106793449160247e-07 0.3938679283557566 4.106796443500686e-07 0.3882534014213259 4.10680018872672e-07 0.3812944595528024 4.106803482503896e-07 0.375233915169682 \
4.10680631354694e-07 0.3700684563936956 4.106809310997049e-07 0.3646408765157301 4.106812105955488e-07 0.3596219010422631 4.10681434267487e-07 0.3556377385586224 \
4.106816459791946e-07 0.3518907610576284 4.106818484819268e-07 0.3483292724130969 4.10682049543475e-07 0.3448190020587957 4.106822552213837e-07 0.3412518188287665 \
4.106824735968598e-07 0.3374887625241871 4.106827173592566e-07 0.3333167726275162 4.106829441158294e-07 0.3294678078423895 4.106831640268007e-07 0.3257615367192951 \
4.106833824514083e-07 0.3221060038181086 4.106835864764178e-07 0.318715141566024 4.106837883342076e-07 0.3153870758963987 4.106839886575955e-07 0.3121102802474151 \
4.106841752715021e-07 0.309079115007194 4.106843725731086e-07 0.3058982938882217 4.10684581156335e-07 0.3025606704206737 4.106847867910569e-07 0.2992974534031506 \
4.106850115231368e-07 0.2957609785165763 4.106852284189794e-07 0.2923771984023277 4.106854360983307e-07 0.2891642611511841 4.106856671491776e-07 0.2856239464683982 \
4.10685841949429e-07 0.2829684481899911 4.10686021147604e-07 0.2802647299798244 4.106861900221201e-07 0.2777348429135014 4.106864183453934e-07 0.274348458173166 \
4.106865950826614e-07 0.2717528218126659 4.106867633653918e-07 0.2693020894036587 4.106869358321621e-07 0.2668230333489093 4.106870699344411e-07 0.264903804409765 \
4.10687215894446e-07 0.2628277003548514 4.106873545899465e-07 0.2608803500812688 4.106874768715512e-07 0.2591684246570544 4.106876109903814e-07 0.2572942758553639 \
4.106877400914859e-07 0.2554978336754472 4.106878595252204e-07 0.2538430842138498 4.106879863604196e-07 0.2520939183506197 4.106881060014414e-07 0.2504447954274527 \
4.106882556176353e-07 0.2483797066042054 4.106883904811462e-07 0.2465170278296022 4.106885200385602e-07 0.2447289494531232 4.10688677103379e-07 0.2425624627506451 \
4.106888010990138e-07 0.2408491463446025 4.106889412471492e-07 0.2389135279283614 4.106890711400503e-07 0.2371200701944942 4.106891917576705e-07 0.2354534357320198 \
4.106893542306008e-07 0.2332087289724075 4.106895002846996e-07 0.2311905595759856 4.106896386054839e-07 0.2292825126447264 4.106897465327019e-07 0.2277949627009887 \
4.106898773176093e-07 0.225993474229161 4.106899758236256e-07 0.22463752857886 4.106900799069717e-07 0.2232056532573264 4.106901527838364e-07 0.2222046546567725 \
4.10690234937313e-07 0.2210804129356655 4.10690302346398e-07 0.2201585377209549 4.106903490506606e-07 0.2195201149856669 4.106903984680203e-07 0.2188449488487562 \
4.10690489422163e-07 0.2176035744446363 4.106905558165761e-07 0.2166983392055156 4.106906027798693e-07 0.2160586379972232 4.106906530910749e-07 0.2153737902794619 \
4.106907122404248e-07 0.2145693142997165 4.106907550863284e-07 0.2139870779821451 4.10690798893629e-07 0.2133941263688522 4.106908684238941e-07 0.2124566309962414 \
4.106909553407082e-07 0.2112864027023158 4.106910365295633e-07 0.2101949018929156 4.106911224290264e-07 0.2090416531541652 4.106912165752074e-07 0.2077796428137634 \
4.106913083290811e-07 0.2065517647617813 4.106914036255171e-07 0.2052788208685862 4.106915001042083e-07 0.2039945431316728 4.106916009294901e-07 0.2026602783061639 \
4.106916968855022e-07 0.2013924147365721 4.10691799571213e-07 0.2000377255165624 4.106919026075665e-07 0.1986831378210229 4.10692012697906e-07 0.1972405340748948 \
4.106921214497938e-07 0.1958206085628783 4.106922411717489e-07 0.1942631948714586 4.106923516146512e-07 0.1928328887741874 4.106924596174588e-07 0.1914411844406488 \
4.10692584973803e-07 0.1898318066870429 4.106926779079788e-07 0.1886434908940876 4.106927562787551e-07 0.1876443873000938 4.10692832918829e-07 0.1866698667869858 \
4.106929154301432e-07 0.1856249297118943 4.106929849397592e-07 0.1847473639743596 4.106930508953873e-07 0.1839166514106665 4.106931151627221e-07 0.1831089953192083 \
4.106932271462069e-07 0.1817072258029639 4.106933212001737e-07 0.1805353135896268 4.106934288419354e-07 0.1791985758407087 4.106935353149934e-07 0.1778827552324552 \
4.106936553069199e-07 0.1764073736674057 4.106937933595456e-07 0.174720142305475 4.106939095201005e-07 0.1733081217455876 4.106940716169029e-07 0.1713503924599185 \
4.106941867054196e-07 0.1699688234017716 4.106943266910192e-07 0.1682987764548305 4.106944438970947e-07 0.1669083002780509 4.106945548164474e-07 0.1655990025649634 \
4.106946524449328e-07 0.1644521190704843 4.106947472954813e-07 0.1633427224865242 4.106948633498935e-07 0.161991523106341 4.106949548984438e-07 0.1609305136382055 \
4.106950510074198e-07 0.1598214181625073 4.106951452255534e-07 0.1587403933520305 4.106952387261563e-07 0.1576732160104884 4.106953323234783e-07 0.1566104070550305 \
4.106954280050165e-07 0.1555300824433628 4.106955185929212e-07 0.1545132165873678 4.106956096060781e-07 0.1534969984004868 4.106957051545556e-07 0.1524358767948732 \
4.106957958202681e-07 0.1514342506187442 4.106958988926308e-07 0.1503020548964867 4.106959713440797e-07 0.1495100717445464 4.106960504448726e-07 0.148649146151682 \
4.106961249930915e-07 0.1478424742503694 4.106961960245005e-07 0.1470770917224498 4.106962687889816e-07 0.1462962409077327 4.106963434061567e-07 0.1454990959398698 \
4.106964133891184e-07 0.1447543557055888 4.106964875500381e-07 0.143968261688537 4.106965412953772e-07 0.1434005634796054 4.106965945789319e-07 0.1428396203849428 \
4.106966597746903e-07 0.1421555039833398 4.106967310807313e-07 0.141411576573238 4.106967954507931e-07 0.1407432786314442 4.106968688027537e-07 0.1399847409254479 \
4.106969294203207e-07 0.1393607073002494 4.106970154538046e-07 0.1384787080092832 4.106970914048206e-07 0.1377037134581418 4.106971813727262e-07 0.1367902106004182 \
4.106972630996836e-07 0.1359645165492482 4.106973457896615e-07 0.1351360437760365 4.106974283459693e-07 0.1343145513298757 4.106975339081247e-07 0.1332698421778018 \
4.106976157754082e-07 0.1324642397250402 4.106977131428679e-07 0.1315110876582503 4.106978031437286e-07 0.130634908321232 4.106978911139876e-07 0.1297829978838479 \
4.106979740438426e-07 0.1289892226181523 4.106980482809344e-07 0.1282822873521282 4.106981479319927e-07 0.1273377645104763 4.106982436870518e-07 0.1264350619688987 \
4.106983305344566e-07 0.1256206895242312 4.106984205359939e-07 0.1247808744623497 4.106985008686745e-07 0.1240346855852102 4.106985875627031e-07 0.1232365419604467 \
4.106986863930319e-07 0.1223331159004786 4.106987764751698e-07 0.1215131568528167 4.106988867184272e-07 0.1205141992263624 4.106989739498662e-07 0.1197275966302077 \
4.106990425230003e-07 0.1191120727131645 4.106991271853926e-07 0.1183553887582162 4.106991936928737e-07 0.1177634990399222 4.106992651487993e-07 0.1171309945267847 \
4.106993348226041e-07 0.1165184920865242 4.106994121596921e-07 0.1158409171037389 4.106995079029745e-07 0.1150054407698888 4.10699579157887e-07 0.1143861389207103 \
4.106996465274204e-07 0.1138025718558601 4.106997149641909e-07 0.113211685696446 4.106997905545423e-07 0.1125613765304429 4.106998812963886e-07 0.1117840233035959 \
4.106999640001163e-07 0.1110788257213999 4.107000775991873e-07 0.1101151050704521 4.107001874748992e-07 0.1091895325357105 4.107002796742132e-07 0.1084169374841771 \
4.107004036235445e-07 0.1073835127717347 4.107004919878672e-07 0.1066505015902263 4.107006314468373e-07 0.1055001025916527 4.107007307435382e-07 0.1046863788921388 \
4.107008233935897e-07 0.1039306459201802 4.10700933598102e-07 0.1030359883605075 4.107010188925422e-07 0.1023467905686673 4.107011037933452e-07 0.101663637589173 \
4.107011867443086e-07 0.1009989740617136 4.107013092542103e-07 0.1000225794851696 4.107014311960626e-07 0.09905761200121259 4.10701557818349e-07 0.09806258992746317 \
4.107016706304718e-07 0.09718220909187772 4.107018152059564e-07 0.09606278874246346 4.107019529198845e-07 0.09500564015228773 4.107020696106743e-07 0.09411672853020667 \
4.107021973542416e-07 0.0931507147971556 4.107022970187578e-07 0.09240236948627445 4.107023764526375e-07 0.09180921593916676 4.107024751879354e-07 0.09107599640376031 \
4.10702553063239e-07 0.09050081472416407 4.107026345291548e-07 0.08990210528957472 4.107027092464628e-07 0.0893557072655629 4.107027897762006e-07 0.08876971652456604 \
4.107029086085259e-07 0.08791061481419053 4.107029982690622e-07 0.08726673116015753 4.107031031831091e-07 0.08651800316437093 4.107032346576667e-07 0.08558693768262025 \
4.107033957658019e-07 0.08445695903909305 4.107035359474973e-07 0.08348350561263763 4.107036844501031e-07 0.08246223579158835 4.10703821170292e-07 0.08153124812726546 \
4.107039611820024e-07 0.08058696725890066 4.10704098179202e-07 0.07967195061625794 4.107042367898133e-07 0.07875532825288725 4.107043812626999e-07 0.07780967510081127 \
4.107045288089374e-07 0.07685421131041187 4.107046863126477e-07 0.07584560580436887 4.107048507078841e-07 0.07480523464991846 4.107050187999819e-07 0.07375451744755303 \
4.10705199799341e-07 0.07263751640721161 4.107053985126234e-07 0.07142823309373261 4.10705611921415e-07 0.07014922396308329 4.107058380853001e-07 0.06881630383186611 \
4.107060786456226e-07 0.06742468841361035 4.107063562065355e-07 0.06585179211508728 4.107066534109385e-07 0.06420523370201831 4.107069717116618e-07 0.06248365192299224 \
4.10707361695962e-07 0.06043183534616462 4.107077605227481e-07 0.05839861031494715 4.10708202994687e-07 0.05621846258761681 4.107085879755898e-07 0.05438828987170503 \
4.107090000221824e-07 0.05249218901100536 4.10709351759698e-07 0.05092353490091287 4.107096872643497e-07 0.04946969867921969 4.107099977632446e-07 0.04816021644386199 \
4.107102917000643e-07 0.04695194805701195 4.107105844309969e-07 0.04577883625507727 4.107108592742044e-07 0.04470700909733757 4.107111331179271e-07 0.04366353526031765 \
4.107113988076876e-07 0.04267398813878486 4.107116741167033e-07 0.04167180388267511 4.107119586736207e-07 0.04066026046469497 4.107122549717362e-07 0.03963283340811159 \
4.107125138471216e-07 0.03875659098599576 4.107127418035276e-07 0.03800131046948733 4.107129605287219e-07 0.03729095380188759 4.107131803834489e-07 0.03659437723507575 \
4.107135212495136e-07 0.03554043311314246 4.107137972903943e-07 0.03470953269536187 4.107140907211692e-07 0.03384790442147732 4.107143732890922e-07 0.03303898052111545 \
4.107146281985287e-07 0.03232625790162248 4.107149088829884e-07 0.03155947796597136 4.107151547163818e-07 0.03090318379665042 4.107153868776701e-07 0.03029616297556957 \
4.10715627215008e-07 0.02968398395812225 4.107158628518432e-07 0.02909722707395018 4.107160910630208e-07 0.0285403787496557 4.107165078357495e-07 0.02755138287878544 \
4.10716702361127e-07 0.02710176794309662 4.107170886015322e-07 0.02623051698020805 4.10717267770925e-07 0.0258356865503758 4.107176189981086e-07 0.02507792837274256 \
4.107177869041566e-07 0.0247229612172224 4.107181711668123e-07 0.02392944198669211 4.107182864485406e-07 0.02369675911063252 4.107187284963783e-07 0.02282172072611499 \
4.107189503116517e-07 0.02239223679446916 4.107194739313108e-07 0.02139838041889957 4.107196292938196e-07 0.02110714647916685 4.107201469998876e-07 0.02015295207761772 \
4.10720272033152e-07 0.01992792118872039 4.10720796234659e-07 0.01901759738223179 4.107209324540342e-07 0.01879045572456909 4.107215387304897e-07 0.01783210191617334 \
4.107217057396231e-07 0.01758082406519646 4.107223489472666e-07 0.01666064795441237 4.107225280915353e-07 0.0164167113061686 4.107232182502689e-07 0.01551958953683085 \
4.107233818701531e-07 0.01531511209162885 4.107241423508398e-07 0.01440332854054019 4.107242893929629e-07 0.01423371673427115 4.107251072646214e-07 0.01333087949608782 \
4.107252268131343e-07 0.01320411419549955 4.107261426746556e-07 0.01227329163592313 4.107262840275722e-07 0.01213544173166964 4.107272325031483e-07 0.01124488043697059 \
4.107273911425863e-07 0.01110230805801717 4.1072857354363e-07 0.01011356759191894 4.107286716440201e-07 0.01003725601038859 4.1072993325548e-07 0.009120360285939955 \
4.107300676693304e-07 0.009028655389366201 4.107316082406548e-07 0.008043892937307966 4.107316892739987e-07 0.007992925041580451 4.107332778679313e-07 0.007023242357651564 \
4.10733410759078e-07 0.006948518507451114 4.107353874624203e-07 0.005952856104192286 4.107355692005682e-07 0.005869662958407677 4.107376715542283e-07 0.004980929874643355 \
4.107381123459968e-07 0.004810448874467742 4.107407675608552e-07 0.003892108290451164 4.107412441403943e-07 0.003745909362026665 4.107448822226149e-07 0.00279447349697209 \
4.107454077460605e-07 0.002678838783887205 4.107510138108453e-07 0.001700248310874221 4.107513248985468e-07 0.001653333728976835 4.107564592262458e-07 0.0006858192122199529 \
4.107566532060193e-07 0.0006440832883579712 4.134045769148618e-07 -0.0002037173203380238 4.134047411152831e-07 -0.0003889174928863678 4.134053144580912e-07 -0.001270938904608877 \
4.134053893922784e-07 -0.001411855863724778 4.134058499760551e-07 -0.002393592696522268 4.134059619168068e-07 -0.002660411672198376 4.134062151887948e-07 -0.003300974950034667 \
4.134063815720996e-07 -0.003745951779090856 4.134066765678696e-07 -0.004566571567208835 4.134067880554425e-07 -0.00488071790655901 4.134070674282164e-07 -0.005641221413069743 \
4.134071883865554e-07 -0.005938820066262044 4.134082823393885e-07 -0.005180465225493313 4.13408406471631e-07 -0.004410796826645887 4.134085308790492e-07 -0.003456122327429311 \
4.134086504354286e-07 -0.002364170815481491 4.13408748579805e-07 -0.001341064316055312 4.13408855004127e-07 -0.0001052154991983786 4.134089672399721e-07 0.001336046702817826 \
4.134091021958209e-07 0.003249882807978809 4.134092247823306e-07 0.005149402351921401 4.134094136442457e-07 0.008353592055059769 4.134095548265785e-07 0.01094873860302964 \
4.134097081879224e-07 0.01393943619118621 4.134098515614267e-07 0.01687898420971235 4.13410005752867e-07 0.02017576688295359 4.134101618928252e-07 0.02363796584892512 \
4.134103176188778e-07 0.02719811802828209 4.134104651125568e-07 0.03065407560139007 4.134106137843234e-07 0.03420778369279751 4.134107691144076e-07 0.03798436241030867 \
4.134109277402875e-07 0.04189786275883118 4.134110926734479e-07 0.0460171220807938 4.134112670963364e-07 0.05041857973200652 4.134114460857363e-07 0.05497510627343041 \
4.134116353855968e-07 0.05982852266675163 4.134118383936028e-07 0.06506368941101938 4.134120578706689e-07 0.07075025585284363 4.134122889353305e-07 0.07675903373893865 \
4.134125359956494e-07 0.08319974270080552 4.134128064206373e-07 0.0902619122132732 4.134130999843244e-07 0.09793335781011638 4.13413424033306e-07 0.1064001814721126 \
4.134137882548562e-07 0.1159066558703892 4.134141808063258e-07 0.1261372395632307 4.134146303042508e-07 0.1378252442462487 4.134151530964837e-07 0.1513754922073403 \
4.134157666942192e-07 0.1672157090591849 4.134164444550933e-07 0.184625848284817 4.134172327202124e-07 0.2047487967247964 4.134181155530716e-07 0.22712469896725 \
4.134189338390288e-07 0.2476994923478653 4.13419661268608e-07 0.2658503723959502 4.134203013816358e-07 0.2817009601644404 4.134208756853502e-07 0.2958213763442377 \
4.134214132513172e-07 0.3089396094373287 4.134219172487762e-07 0.3211464104224903 4.1342239337143e-07 0.3325930942309646 4.134228712594449e-07 0.3439912352478621 \
4.134233245925507e-07 0.3547121966731367 4.134237958852587e-07 0.3657614311162562 4.134242385610847e-07 0.3760518588326446 4.13424757059872e-07 0.3879885572071845 \
4.134252842219919e-07 0.3999987293386327 4.134256631316234e-07 0.4085537955782026 4.134261930471663e-07 0.4204060347738258 4.13426622963746e-07 0.429919877745455 \
4.134270766645209e-07 0.4398653393542544 4.134275433780368e-07 0.4500002271552926 4.134279810592672e-07 0.4594210430579985 4.134283890215308e-07 0.468120704286539 \
4.134287084545646e-07 0.4748816926501604 4.134290805898366e-07 0.4826992142337162 4.134293155719776e-07 0.4876010339127531 4.13429549178225e-07 0.4924491904621348 \
4.134297971906479e-07 0.4975647713404599 4.134300955920778e-07 0.5036796627825791 4.134303519484798e-07 0.5088948470128004 4.134305642417897e-07 0.5131878547336713 \
4.134307582598616e-07 0.5170959594548015 4.134309052463942e-07 0.5200432695146362 4.134310592244046e-07 0.523118600542271 4.134312771061538e-07 0.5274469616807909 \
4.134315302104803e-07 0.5324525256580425 4.134317400493245e-07 0.5365797337241586 4.134319515026335e-07 0.5407247601751553 4.134322337095338e-07 0.5462280430697679 \
4.134324632548168e-07 0.5506821559930507 4.134326791510236e-07 0.5548604062613707 4.134329613725408e-07 0.560308769190463 4.134332126802682e-07 0.5651538146135803 \
4.134335103411598e-07 0.5708625224168123 4.134337605680607e-07 0.5756519166658941 4.134340169315557e-07 0.5805516059354519 4.134342573415699e-07 0.585116682128892 \
4.134345155213862e-07 0.5900038400537884 4.134347391135916e-07 0.5942175703762435 4.134349776231628e-07 0.5986919452581434 4.134351852078615e-07 0.6025689278491061 \
4.134354017304866e-07 0.6065904171332736 4.134356510330919e-07 0.6111939272561876 4.134358561065347e-07 0.6149609706257601 4.134361073788606e-07 0.6195555361399968 \
4.13436310600886e-07 0.6232455818254186 4.134365074727914e-07 0.6267987644955494 4.134367007643072e-07 0.630267737067843 4.134369555427623e-07 0.6348113783570861 \
4.13437185753374e-07 0.638887973644319 4.134374031071848e-07 0.6427143472883045 4.134377015129076e-07 0.6479268061885751 4.134379169157571e-07 0.6516657345437264 \
4.134381181394757e-07 0.6551344108237934 4.134382930609835e-07 0.6581323437428509 4.13438458126254e-07 0.6609495238976936 4.134386275947746e-07 0.6638251431769452 \
4.134387797316125e-07 0.666392827642013 4.134389176422984e-07 0.6687037209181631 4.134390664784122e-07 0.6711867545200138 4.134391945930143e-07 0.6733159837320549 \
4.134393378158276e-07 0.6756849429836936 4.134394590900776e-07 0.6776819274526149 4.134395966887617e-07 0.6799401191146522 4.134397160692161e-07 0.6818929034138137 \
4.134398631769624e-07 0.6842914131385206 4.134399803786278e-07 0.6861933934268433 4.13440073884205e-07 0.6877071857403232 4.13440164873897e-07 0.6891752279197846 \
4.134402676159613e-07 0.6908280855439021 4.134403691335249e-07 0.6924555900607121 4.134404875166309e-07 0.6943444167618776 4.134405996372169e-07 0.6961264383846065 \
4.134407171927181e-07 0.6979868779962457 4.134409023430049e-07 0.7008959348649784 4.134410335352131e-07 0.7029413755586562 4.134411697037528e-07 0.7050491462541959 \
4.134412912224561e-07 0.7069171228306749 4.134414311454679e-07 0.7090538254196674 4.134415350881169e-07 0.7106315721465845 4.134416462491007e-07 0.712309798010818 \
4.134417505089649e-07 0.7138759052437967 4.134418801470564e-07 0.7158124745844324 4.134419770777692e-07 0.7172526339884565 4.134421160000042e-07 0.7193052800722975 \
4.134422355492927e-07 0.7210612846995991 4.134423551218654e-07 0.7228080613301419 4.134424808972429e-07 0.7246353354365959 4.134426076155857e-07 0.7264656873164689 \
4.134427296554369e-07 0.728218443613998 4.134428578038805e-07 0.7300486655261287 4.13442987872205e-07 0.7318956587421809 4.134431088632273e-07 0.7336041830685722 \
4.134432496338107e-07 0.7355801168346318 4.1344335060338e-07 0.7369898206659778 4.134434522042367e-07 0.7384020079314992 4.13443548224548e-07 0.7397310783624924 \
4.134436591374029e-07 0.7412570822736337 4.134437467850298e-07 0.7424563811251772 4.134438466394007e-07 0.7438154404043728 4.134439814045385e-07 0.7456370856934184 \
4.13444097699018e-07 0.747198032089633 4.13444201190815e-07 0.7485782798032956 4.134443254462628e-07 0.7502239458264747 4.13444470359203e-07 0.7521280942578691 \
4.134445883397714e-07 0.753666143975803 4.134447072708787e-07 0.7552056331692281 4.134448468504184e-07 0.7569980918234445 4.134449912028081e-07 0.7588357421297242 \
4.134451092636163e-07 0.7603265096672839 4.134452340853355e-07 0.7618908200857619 4.134453739165311e-07 0.7636286950759973 4.134454986794279e-07 0.7651662633748356 \
4.134456421928987e-07 0.7669199865864609 4.134457628783765e-07 0.7683824344671055 4.13445883722124e-07 0.7698356273746885 4.134460033670484e-07 0.7712633747646481 \
4.134461330746874e-07 0.7727989859455529 4.134462418184901e-07 0.7740766298596218 4.134463644662266e-07 0.7755070372682662 4.134464742429112e-07 0.7767778749889983 \
4.13446603267025e-07 0.7782599816788072 4.134467350433437e-07 0.7797610257751375 4.134468483559198e-07 0.7810403609326458 4.134469694418617e-07 0.7823954393038701 \
4.134470733144949e-07 0.7835479431998941 4.134472155975174e-07 0.785111775748914 4.134473638006659e-07 0.7867227488076519 4.134475226942012e-07 0.7884297907063792 \
4.134476428872234e-07 0.7897074707829422 4.134477924539297e-07 0.7912811323018302 4.134479165691468e-07 0.7925734175081853 4.134480422734439e-07 0.7938699048627912 \
4.134481452190109e-07 0.7949224966762399 4.134482595901654e-07 0.7960823495211882 4.134483720644089e-07 0.7972131756542409 4.134484623369833e-07 0.7981137961420948 \
4.134485516778793e-07 0.7989989930139054 4.134486769038167e-07 0.800229513878344 4.134487846751798e-07 0.8012785338618679 4.134489143429785e-07 0.8025281307685926 \
4.134490357222573e-07 0.8036855380110038 4.134491522780568e-07 0.8047859282369955 4.134492730834528e-07 0.80591497746663 4.134494057087579e-07 0.8071413435168892 \
4.134495275023783e-07 0.8082555056211007 4.13449654106103e-07 0.8094015704683005 4.134497797196214e-07 0.8105266036187198 4.13449899211046e-07 0.8115857443778658 \
4.134500374092988e-07 0.8127973981963581 4.134501469085475e-07 0.8137473213416323 4.134502310566626e-07 0.8144713378799666 4.134503518607202e-07 0.8155017394983226 \
4.134504473695572e-07 0.8163089346032877 4.134505836603603e-07 0.8174496006492775 4.13450726424414e-07 0.8186303638797883 4.13450860857535e-07 0.8197292014569521 \
4.134509707295191e-07 0.8206175763825388 4.134511146291367e-07 0.8217677661037901 4.134512679567201e-07 0.8229768690765377 4.134513958055741e-07 0.8239722812379519 \
4.134515362029048e-07 0.8250521595273246 4.13451662107844e-07 0.8260088941474263 4.134518167240102e-07 0.8271688948348412 4.134519490793395e-07 0.8281489842609937 \
4.134520753461681e-07 0.8290730392392056 4.134521930066954e-07 0.8299245984162376 4.134523414090921e-07 0.8309852945996649 4.134525086032604e-07 0.8321626230293395 \
4.134526413805716e-07 0.8330844501529713 4.134528142817687e-07 0.8342675727345584 4.134529826990627e-07 0.8354015168591284 4.134531521935363e-07 0.8365246342267009 \
4.134533336304179e-07 0.8377070668209077 4.134534761865593e-07 0.8386219603417975 4.134535900974499e-07 0.8393441765511721 4.134537209736586e-07 0.8401643924869071 \
4.134538225966329e-07 0.8407940582489307 4.134539390368715e-07 0.8415078269750864 4.134540743300576e-07 0.8423269142909066 4.134542715951592e-07 0.8435017451489455 \
4.134544621144827e-07 0.844614933042255 4.13454672039296e-07 0.8458175693076773 4.134548528178267e-07 0.8468334846981137 4.134550501858462e-07 0.8479221976595614 \
4.134552240443405e-07 0.8488638701886076 4.134554065585834e-07 0.8498353939890455 4.134555779026936e-07 0.8507314120859523 4.13455752248258e-07 0.8516272398309612 \
4.134559276512583e-07 0.8525125793730954 4.134561038964483e-07 0.8533864315694911 4.134562936653265e-07 0.8543099749208749 4.134564844233442e-07 0.8552205033559714 \
4.134566862125501e-07 0.8561646193034282 4.134568789161161e-07 0.8570482883232282 4.134570883567927e-07 0.8579892478796384 4.134573180985592e-07 0.8589986827500428 \
4.134575835675109e-07 0.8601360945383778 4.134578822138556e-07 0.8613786760148464 4.134581606012222e-07 0.8625023989005415 4.134584447911769e-07 0.8636161469557806 \
4.13458719285784e-07 0.8646608622318305 4.134589913772806e-07 0.8656672252055042 4.134592615937268e-07 0.8666387059277968 4.134595187619146e-07 0.8675381145236246 \
4.134597913209795e-07 0.8684653318325959 4.1346006734232e-07 0.8693777905953765 4.13460337484171e-07 0.8702455402709716 4.134606372319547e-07 0.8711796653984102 \
4.134610081058124e-07 0.872294745819888 4.134613030287967e-07 0.8731503023941 4.134615572848448e-07 0.8738665406311316 4.134618555155772e-07 0.8746822274488602 \
4.134621291339016e-07 0.8754080260278182 4.134623652695491e-07 0.8760175227551726 4.134626056214059e-07 0.876622281264788 4.134628279637853e-07 0.8771680781109068 \
4.134630219681285e-07 0.8776338860468618 4.134633516912075e-07 0.8784037109613512 4.1346350686397e-07 0.8787567114621292 4.134638246164967e-07 0.879461652496718 \
4.134640034818579e-07 0.8798480920375044 4.134643459433238e-07 0.8805675499479563 4.134645300848474e-07 0.8809434933546246 4.134650049902839e-07 0.8818790560183651 \
4.134651723847029e-07 0.8821975058309585 4.134656382161285e-07 0.8830540251881659 4.134658190409674e-07 0.8833751042472839 4.134663130743469e-07 0.8842212008576973 \
4.134664544170557e-07 0.884455124402366 4.13467060806836e-07 0.8854193259359495 4.134672128789829e-07 0.8856514227360587 4.134678595574705e-07 0.8865980751852495 \
4.134679878538246e-07 0.8867785329419297 4.134686359799261e-07 0.8876550049536978 4.134687657724472e-07 0.8878236738033012 4.134695440340947e-07 0.8887860366092379 \
4.134696590259732e-07 0.8889208282599539 4.134705147583919e-07 0.8898661633196656 4.134706600215368e-07 0.8900169066926564 4.134716457777221e-07 0.8909664261264102 \
4.134718668828627e-07 0.8911622482549515 4.134730119973067e-07 0.8921020388386462 4.134731432072641e-07 0.8922053928944147 4.134743308657994e-07 0.8931033243919096 \
4.134744844860915e-07 0.8932130731307282 4.13475894522803e-07 0.8941348173026452 4.13476117329622e-07 0.8942660193790342 4.134777980203304e-07 0.8951452796684343 \
4.134781256415096e-07 0.8952966652167414 4.134803555826309e-07 0.8961896554712738 4.134809084965924e-07 0.8963788593752812 4.134844767111233e-07 0.8973573335043913 \
4.134848002235382e-07 0.8974284307984646 4.134911566318259e-07 0.8984120886469452 4.134917055346727e-07 0.8984686671268907 4.13544207609024e-07 0.8994658645395698 \
4.135448506378865e-07 0.8994692460188505 4.137369893085195e-07 0.9004073346715066 4.137371907224907e-07 0.9004708280105613 4.137411505004318e-07 0.8995366825576255 \
4.137413345272296e-07 0.8993953949813248 4.137426511245044e-07 0.8984641879157507 4.137428231683587e-07 0.8983566564859006 4.137447195446537e-07 0.8973720929359315 \
4.137448932508418e-07 0.897304621671452 4.137574671778748e-07 0.8982933655523699 4.137575523681118e-07 0.8983081509245614 4.137658192411513e-07 0.8993078551592517 \
4.137662939605718e-07 0.8993433667976791 4.142597948700116e-07 0.9002974142054325 4.142599143497356e-07 0.9003767372269074 4.142608071727864e-07 0.9012336455299185 \
4.142609534294226e-07 0.901423267690772 4.142615483221009e-07 0.9023325668564308 4.142616832929176e-07 0.9025673929107925 4.14262187968707e-07 0.9035294259428087 \
4.142623205796079e-07 0.9038000271808221 4.142627212069726e-07 0.9046475051114249 4.142628655723708e-07 0.9049556543240072 4.142632886935802e-07 0.9058123566484279 \
4.142633841506385e-07 0.9059850892484415 4.142648087094547e-07 0.9052205906349737 4.142649337473088e-07 0.9046352442223391 4.142650601578981e-07 0.9039223775493039 \
4.142651628066418e-07 0.9032486771507763 4.142652900219319e-07 0.9022944222362175 4.142654088677579e-07 0.9012801950564071 4.142655065202371e-07 0.9003603330664713 \
4.142655885222584e-07 0.8995243596151602 4.142656681858213e-07 0.8986589236008835 4.142657789639895e-07 0.8973708307079206 4.142658801400036e-07 0.8961049472956977 \
4.142659630844751e-07 0.8950067229086057 4.142660715298925e-07 0.8934921260891034 4.142661799938501e-07 0.8918872687155874 4.14266275049989e-07 0.8904106867557802 \
4.142663959226416e-07 0.8884444419111864 4.14266516699262e-07 0.8863849482818795 4.142666297444327e-07 0.8843763393508186 4.142667329151817e-07 0.8824794505619851 \
4.142668185153382e-07 0.8808620855018965 4.142668929893991e-07 0.8794251273161163 4.142669873129417e-07 0.8775673968166831 4.142670757738577e-07 0.8757888800524039 \
4.142671548468696e-07 0.8741711975775893 4.142672488342247e-07 0.872216793437976 4.142673301795293e-07 0.8704993514258973 4.14267425093555e-07 0.8684673705816817 \
4.14267518136275e-07 0.8664480751909672 4.142676149220692e-07 0.8643215060814092 4.142677382174414e-07 0.8615778533848952 4.142678516644525e-07 0.859022019682563 \
4.142679775164913e-07 0.8561558571929792 4.142681008446355e-07 0.8533196845306243 4.142682300229265e-07 0.850323637950593 4.142683706197831e-07 0.8470370034914 \
4.142684793995045e-07 0.8444782910716596 4.142686144592575e-07 0.8412850455921466 4.14268724119566e-07 0.8386804253780991 4.142688532993454e-07 0.8356002443501571 \
4.14268979483175e-07 0.8325812421138936 4.142691065735304e-07 0.8295317031556502 4.142692355958039e-07 0.826427745883674 4.142693446760448e-07 0.8237985689995477 \
4.142694845267009e-07 0.8204223029647078 4.142696239548932e-07 0.8170507778356514 4.142697567085239e-07 0.8138366863616762 4.142698867771992e-07 0.8106848159989707 \
4.142700104726457e-07 0.8076853837479523 4.142701474270357e-07 0.8043627031572629 4.142702611388824e-07 0.8016030849198694 4.142703886159226e-07 0.7985086235398901 \
4.142704994169941e-07 0.7958187897651571 4.142706186034522e-07 0.7929254985494992 4.142707319825085e-07 0.7901733724735396 4.142708662929012e-07 0.7869138859547327 \
4.142709733871687e-07 0.7843152933129034 4.142710894043117e-07 0.7815009627552112 4.142712185952754e-07 0.778367508739124 4.142713162077106e-07 0.7760002683782802 \
4.142714217871509e-07 0.773440790716327 4.142715304693199e-07 0.7708069008430674 4.142716328855832e-07 0.7683258101021144 4.142717262792412e-07 0.7660641808432364 \
4.142718458350171e-07 0.7631702213567544 4.142719383073787e-07 0.7609327305817616 4.14272030945494e-07 0.7586922094322426 4.142721293703097e-07 0.7563124992069843 \
4.142722373479617e-07 0.7537030947613649 4.142723336164742e-07 0.7513778334636231 4.142724198728768e-07 0.7492952979736797 4.142725227366661e-07 0.7468128004450286 \
4.14272601580994e-07 0.744910856519283 4.142727023870358e-07 0.7424801602439853 4.142728369152764e-07 0.7392377693660663 4.142729741401358e-07 0.7359316755186537 \
4.142731176199873e-07 0.7324773442723981 4.142732660441767e-07 0.7289066083419234 4.142734093054719e-07 0.7254625447335662 4.142735493824514e-07 0.7220977259655398 \
4.142737058083174e-07 0.7183435968963056 4.142738302100673e-07 0.715360858370426 4.14273951271848e-07 0.7124600029613375 4.1427410478411e-07 0.7087850045121084 \
4.142742395660554e-07 0.7055614325718365 4.142743656650877e-07 0.7025479112911024 4.142745088393713e-07 0.6991289103945657 4.142746289211628e-07 0.6962626602560111 \
4.142747581554914e-07 0.6931807499479741 4.142748646405391e-07 0.6906432840523983 4.142749769163615e-07 0.6879696524977363 4.142750732516477e-07 0.6856773754336868 \
4.142751760613402e-07 0.683232326200841 4.14275270865193e-07 0.6809792012818872 4.142753761871231e-07 0.6784784437814733 4.14275484625777e-07 0.6759058899658261 \
4.142755836350576e-07 0.673558569590366 4.142757003916503e-07 0.6707929011939652 4.142758084769278e-07 0.6682347329991606 4.142759184831366e-07 0.6656332609774134 \
4.142760045709787e-07 0.6635992664604092 4.142761341661182e-07 0.6605400273835189 4.142762267673659e-07 0.6583552307294462 4.142763225550924e-07 0.6560965362104854 \
4.142764075070784e-07 0.6540950852804182 4.142765268016021e-07 0.6512869789851043 4.142766140715399e-07 0.6492343850333612 4.142767047785614e-07 0.6471030993779646 \
4.14276805943536e-07 0.6447280068361273 4.142768857743593e-07 0.6428551652550211 4.142769745601937e-07 0.6407732405330839 4.142770522504205e-07 0.6389536101386547 \
4.142771140193684e-07 0.6375081226244841 4.142771777840134e-07 0.6360167668935747 4.142772410182332e-07 0.634538653569437 4.142772802588059e-07 0.6336218002627473 \
4.142773208978281e-07 0.6326726453797233 4.142774009823624e-07 0.6308039353694699 4.142774708865426e-07 0.6291742390428672 4.142775215232567e-07 0.6279942052995945 \
4.142775602728994e-07 0.6270914175114127 4.142775992678787e-07 0.6261832343283663 4.142776438826267e-07 0.6251445623164014 4.142776867390832e-07 0.6241478292286105 \
4.142777370536867e-07 0.6229782634938205 4.142777889908641e-07 0.6217719122409077 4.142778740584487e-07 0.6197972300178722 4.142779340388659e-07 0.6184052992407258 \
4.142780238260749e-07 0.61632338076978 4.142781002901565e-07 0.6145529519516876 4.142781798544472e-07 0.6127119801362371 4.142782608910593e-07 0.6108383709630588 \
4.142783501053817e-07 0.6087775861620425 4.142784409653938e-07 0.6066826282541496 4.142785281841023e-07 0.6046739453334793 4.142786219572931e-07 0.6025158549334848 \
4.142787236427565e-07 0.6001788642681311 4.142788232408485e-07 0.5978941858483342 4.142789350958888e-07 0.5953317151711254 4.14279051129026e-07 0.5926772450523136 \
4.142791727501318e-07 0.5899020947998995 4.142792771339459e-07 0.5875236635596754 4.142794219241658e-07 0.5842296531729801 4.142795345841267e-07 0.5816734289694181 \
4.14279643596094e-07 0.5792035939892568 4.142797360755373e-07 0.5771100174076607 4.142798295261766e-07 0.5749994714793375 4.142799218520404e-07 0.5729181236728181 \
4.142799944387413e-07 0.571283073141143 4.142800503929671e-07 0.5700232888304386 4.142801114612485e-07 0.5686498830286455 4.142802099507645e-07 0.5664400707212188 \
4.142802731622084e-07 0.5650238531380825 4.14280333588177e-07 0.5636708824310654 4.142804105365601e-07 0.5619492451093103 4.142804736951014e-07 0.5605380106414651 \
4.142805620087099e-07 0.558569506627369 4.14280633210033e-07 0.5569845302974165 4.14280719745787e-07 0.555060151797141 4.142808410985601e-07 0.5523665438352664 \
4.142809690278082e-07 0.5495364947125975 4.142810671584392e-07 0.5473694328713704 4.142811802824346e-07 0.5448752016832871 4.14281282350254e-07 0.5426314425864434 \
4.142814012991245e-07 0.5400217272291628 4.142815043868322e-07 0.5377630705755105 4.142816185939865e-07 0.5352670017334624 4.142817320096582e-07 0.532794946211756 \
4.14281859080713e-07 0.5300302694710822 4.14281982900802e-07 0.5273426867079006 4.142821276896071e-07 0.5242103332418484 4.142822635131097e-07 0.5212782585303676 \
4.142824185679684e-07 0.5179428401013338 4.142825794198528e-07 0.5144913885072363 4.142827581493005e-07 0.5106699876709851 4.1428294832834e-07 0.5066200804011861 \
4.142831582303623e-07 0.5021665212646098 4.142833869363468e-07 0.4973332357952056 4.142836408642853e-07 0.4919960258408594 4.142838817977506e-07 0.4869529241725989 \
4.142841779602358e-07 0.4807889695952298 4.142844679576231e-07 0.4747910561470179 4.142847742009558e-07 0.4684976697011882 4.142850948768875e-07 0.4619520863481486 \
4.142854227440541e-07 0.4553041925245184 4.142857629891091e-07 0.4484521981997251 4.142860884146545e-07 0.4419418052309769 4.142864103218022e-07 0.4355465312739703 \
4.142867405359073e-07 0.4290298934287748 4.142870965284996e-07 0.4220583188787752 4.142874154069286e-07 0.4158579595363656 4.14287752858691e-07 0.4093433989943853 \
4.142881807254075e-07 0.4011531841887147 4.142885294373556e-07 0.3945419525178304 4.142888370733194e-07 0.388759214407489 4.142892168998106e-07 0.3816861832573664 \
4.142895480893721e-07 0.3755780492082042 4.142898316974524e-07 0.370391509977049 4.142901425163967e-07 0.3647512908748707 4.142904218330045e-07 0.3597258263082204 \
4.142906483291526e-07 0.3556836811642302 4.142908640115379e-07 0.3518598964090484 4.142910612955428e-07 0.3483842179544538 4.142912662800023e-07 0.3447988491770444 \
4.142914785019664e-07 0.3411119200457455 4.142917338071541e-07 0.33670771290924 4.142919753294027e-07 0.3325734463267218 4.14292206706731e-07 0.3286464933807047 \
4.142924215592308e-07 0.3250253651850565 4.142926421183882e-07 0.3213332986541765 4.142928435443551e-07 0.3179852906236645 4.142930466126061e-07 0.3146379646143546 \
4.142932445082156e-07 0.3114011111455273 4.142934314693022e-07 0.3083651674074345 4.142936252695217e-07 0.3052406640298299 4.142938291861339e-07 0.3019773030815858 \
4.142940082554678e-07 0.2991336297844484 4.142942438463241e-07 0.2954229173226265 4.142944446504233e-07 0.2922868215109002 4.142946458293147e-07 0.2891696385850206 \
4.142948696390574e-07 0.2857334090862961 4.142950342018033e-07 0.2832271910241367 4.142952111291889e-07 0.2805503385691353 4.14295396922194e-07 0.2777610713150803 \
4.142955787376702e-07 0.2750538970423583 4.142957577624632e-07 0.2724132377985424 4.142959251076164e-07 0.2699606650006489 4.142960855365337e-07 0.2676371805838822 \
4.142962081102854e-07 0.2658719571410424 4.14296357874814e-07 0.2637236906090554 4.142964855719403e-07 0.2619099339733745 4.142965928803121e-07 0.2603957336038235 \
4.142967088809744e-07 0.2587625259947361 4.142968191895705e-07 0.2572125806747212 4.142969450687671e-07 0.2554509781935611 4.142970605506183e-07 0.2538402638894013 \
4.142971951315211e-07 0.2519757335310172 4.142973071947753e-07 0.2504255755821768 4.142974575341346e-07 0.2483447107137444 4.142975971599893e-07 0.2464124269747185 \
4.142977430518096e-07 0.2444035064209518 4.142978760124476e-07 0.2425734862730615 4.14297999574161e-07 0.2408709992523319 4.142981467838532e-07 0.2388417729476062 \
4.142982633706824e-07 0.2372355665500016 4.142984028258316e-07 0.23532008003217 4.142985370003013e-07 0.2334768281602104 4.142986629767575e-07 0.2317465561243653 \
4.142987823761605e-07 0.2301094434087779 4.142988772305854e-07 0.2288105340759602 4.142989903681845e-07 0.2272617792622066 4.142990706846421e-07 0.2261626001158484 \
4.142991582496986e-07 0.2249657246820506 4.142992837868356e-07 0.2232507767215072 4.142993894805428e-07 0.2218101326756785 4.142994791350539e-07 0.2205921574607158 \
4.14299549986253e-07 0.2196300825522397 4.142995930147827e-07 0.2190460135436258 4.142996353053263e-07 0.2184724035808872 4.142996776470424e-07 0.2178984240735344 \
4.142997498424616e-07 0.2169203674089526 4.142997922358174e-07 0.2163464205126744 4.14299827490656e-07 0.2158693585303403 4.142998716822395e-07 0.2152716287340076 \
4.142999412904665e-07 0.2143309212991285 4.142999756337965e-07 0.2138672544767182 4.143000200933248e-07 0.2132698436071631 4.143000877718062e-07 0.2123628126304402 \
4.143001741990649e-07 0.2112058698236149 4.143002488356675e-07 0.2102078598594563 4.143003301376756e-07 0.2091219706754807 4.143004270150594e-07 0.2078300362310651 \
4.143005529985482e-07 0.2061528795789772 4.143006555333841e-07 0.2047906894256944 4.143007570169014e-07 0.2034500128132261 4.143008580825969e-07 0.202119416354989 \
4.143009546968166e-07 0.2008491615811921 4.143010566612396e-07 0.1995112314821507 4.143011633834836e-07 0.1981153840927639 4.143012717886237e-07 0.1967018790395962 \
4.143013837827796e-07 0.1952465002768531 4.14301496249907e-07 0.1937897263683151 4.143016083232463e-07 0.1923454332378671 4.143017162157206e-07 0.1909603537828802 \
4.143018175986494e-07 0.1896629368444172 4.143019092360985e-07 0.1884941330679491 4.143020032117073e-07 0.1872990757663449 4.143020744780721e-07 0.1863957871745983 \
4.1430215115336e-07 0.1854271890400033 4.143022548124749e-07 0.184122202819407 4.143023284795955e-07 0.1831974022686171 4.143024018254956e-07 0.1822796569444652 \
4.143025152158449e-07 0.1808667181969195 4.143026030744852e-07 0.1797760932362061 4.143026869231622e-07 0.1787387947787487 4.143028158855897e-07 0.1771515524267008 \
4.143029177720844e-07 0.1759040172436072 4.143030234727908e-07 0.1746156056808686 4.143031251208657e-07 0.1733818993219825 4.143032559825841e-07 0.1718019019596718 \
4.143033631792215e-07 0.1705140034701537 4.14303492508118e-07 0.168969083715685 4.143036042046102e-07 0.167642098072289 4.143037045351887e-07 0.1664555496840579 \
4.143038003357432e-07 0.1653276075899142 4.143039111480153e-07 0.1640289617085985 4.143039985482962e-07 0.1630090521997956 4.143041098694134e-07 0.1617156184952586 \
4.143042028212722e-07 0.1606409001560029 4.143042903941502e-07 0.1596330843918451 4.143043920250233e-07 0.1584700928658864 4.143044764790781e-07 0.1575086241734052 \
4.143045515834575e-07 0.1566573095634876 4.143046294056999e-07 0.1557789554714152 4.143047097635688e-07 0.1548759612316424 4.143048108183989e-07 0.1537464547857493 \
4.143048932519626e-07 0.1528311848879565 4.143049855565143e-07 0.1518114053368895 4.143050624909871e-07 0.150965812476358 4.143051454135576e-07 0.1500585909391909 \
4.143052169442981e-07 0.1492793026301012 4.143053133277974e-07 0.1482344968214558 4.143053835562832e-07 0.1474766665551334 4.143054665365612e-07 0.1465853655470201 \
4.143055279788246e-07 0.1459298106834085 4.143055996612094e-07 0.1451677491870439 4.14305668289752e-07 0.1444408762699853 4.143057185582615e-07 0.1439102090153988 \
4.143057661380673e-07 0.143409423336876 4.14305820187418e-07 0.1428423132663369 4.143058795295158e-07 0.1422216078256897 4.143059475649228e-07 0.1415124633834424 \
4.14306023828345e-07 0.1407207186008814 4.143060921081446e-07 0.1400161356079559 4.143061868943229e-07 0.1390460813732662 4.143062764481352e-07 0.1381341561933974 \
4.143063481336088e-07 0.1374075731330657 4.143064320850176e-07 0.1365606113096345 4.143064973974727e-07 0.1359045398875483 4.143065588405982e-07 0.1352895588344758 \
4.143066331170967e-07 0.1345490408254265 4.143066953273574e-07 0.1339328028964004 4.143067632983657e-07 0.133265236037424 4.143068225054055e-07 0.1326856657519672 \
4.143068951778785e-07 0.1319767402814105 4.143069701979877e-07 0.1312477270463112 4.143070556514107e-07 0.1304208267333309 4.143071417517503e-07 0.1295914604616623 \
4.143072418772051e-07 0.1286317929389105 4.143073231668748e-07 0.127857435971709 4.143074249342228e-07 0.1268981149578782 4.143075091821821e-07 0.1261072369695883 \
4.143076079989111e-07 0.1251836587365037 4.143076808394557e-07 0.1245055382686853 4.143077608655429e-07 0.1237631876254407 4.14307831351338e-07 0.1231117958237987 \
4.143079038817606e-07 0.1224439308288319 4.143079813507563e-07 0.1217331219782777 4.143080887021039e-07 0.1207554316575004 4.143081893401196e-07 0.1198442997624752 \
4.143082619276736e-07 0.1191899427853172 4.143083307595138e-07 0.1185715582611356 4.143083965463339e-07 0.1179824683205609 4.143084661751317e-07 0.1173610347366148 \
4.143085365588769e-07 0.1167350538439435 4.143086117372496e-07 0.1160688810594495 4.143087159914846e-07 0.1151493019715505 4.143087911261386e-07 0.114489769343061 \
4.143088600412231e-07 0.1138870655592168 4.143089232460945e-07 0.1133369146236164 4.143089927874599e-07 0.1127339156958381 4.14309050088964e-07 0.1122385190692166 \
4.14309121730019e-07 0.1116210355509516 4.143091795650925e-07 0.1111240709857579 4.143092516865272e-07 0.1105063809580559 4.1430931410261e-07 0.1099736279351742 \
4.143093984241316e-07 0.1092565349771765 4.143094660201e-07 0.1086842173446869 4.143095748160323e-07 0.1077671916889585 4.143096791265639e-07 0.1068924975608609 \
4.14309758614772e-07 0.1062289053282379 4.143098461831825e-07 0.1055008617114655 4.143099096395349e-07 0.1049752776433979 4.143099713506517e-07 0.10446579874651 \
4.14310075190416e-07 0.103612238268202 4.143101578711175e-07 0.1029362225408096 4.143102563391439e-07 0.1021348761715451 4.14310340785582e-07 0.101450818648051 \
4.143104572630618e-07 0.1005121841703865 4.143105919965077e-07 0.09943411943161744 4.143107280660444e-07 0.0983541971400249 4.143108423854515e-07 0.09745369041838402 \
4.143109278525961e-07 0.09678457778867394 4.143110381342688e-07 0.09592640631053104 4.143111189226223e-07 0.09530159220710262 4.143112184734934e-07 0.09453592511176086 \
4.143113084215428e-07 0.09384821103094763 4.14311380924943e-07 0.09329669945188329 4.143114626670093e-07 0.09267796846073476 4.143115907872446e-07 0.09171467366828615 \
4.143116721993079e-07 0.09110674702409056 4.143117466312153e-07 0.09055373306570065 4.143118216050993e-07 0.08999936228352182 4.143119010240745e-07 0.08941505746347288 \
4.143120096849318e-07 0.08862052380504259 4.143121040449035e-07 0.08793517800096999 4.143121934400264e-07 0.08728987318634121 4.143123002057426e-07 0.086524181682867 \
4.143124187081826e-07 0.08568073755029131 4.143125602332527e-07 0.08468224831562859 4.143126933716762e-07 0.08375174214918565 4.143128342170073e-07 0.08277682112810406 \
4.143129832689884e-07 0.08175525972387458 4.143131190667176e-07 0.08083369778093191 4.143132605232322e-07 0.0798830809748103 4.143133957831475e-07 0.07898330517332906 \
4.143135371649882e-07 0.07805242629322809 4.143136842327613e-07 0.07709434677344783 4.143138359609018e-07 0.07611680364043326 4.143140013092032e-07 0.07506403321855706 \
4.143141651767209e-07 0.07403332863189842 4.143143414906487e-07 0.07293832728335037 4.143145309257506e-07 0.07177777688466977 4.143147416924551e-07 0.07050569389938771 \
4.143149614649522e-07 0.06920150027616521 4.143151964331044e-07 0.06783224552442871 4.14315455333654e-07 0.06635227408830123 4.14315750264117e-07 0.06470266364809808 \
4.143160546101784e-07 0.06304001691994518 4.143164165564573e-07 0.06111393619706453 4.143167326842125e-07 0.05947639552636011 4.143171740066774e-07 0.0572596911373907 \
4.143174875727196e-07 0.05573556853365672 4.14317911072189e-07 0.0537382660685313 4.143182550240426e-07 0.05216649213267931 4.143185952653102e-07 0.05065508790922631 \
4.143189061028998e-07 0.04931137323461653 4.143192005748017e-07 0.04807062469528345 4.143194942742994e-07 0.04686392507224969 4.143197691455356e-07 0.04576537019482012 \
4.143200446857014e-07 0.04468949010490332 4.143203097762298e-07 0.04367785045825667 4.143205865333108e-07 0.04264571401740119 4.143208698014357e-07 0.04161414314527601 \
4.143211677947347e-07 0.04055545327485047 4.143214272801311e-07 0.03965542606183669 4.143216573035691e-07 0.03887446236327848 4.143218769951559e-07 0.03814321686473518 \
4.14322101935296e-07 0.0374128399305801 4.1432242218897e-07 0.0363978329183388 4.143227099868201e-07 0.03550963653148703 4.143229863821537e-07 0.03467738358988744 \
4.143232702012828e-07 0.03384352473043348 4.143235083105866e-07 0.03315996078327022 4.143237926213707e-07 0.03236211345273886 4.143240345332207e-07 0.03169864947531036 \
4.143242696733945e-07 0.03106710921041438 4.143245113809233e-07 0.03043352335444016 4.143247483338566e-07 0.02982731501219571 4.14324978676274e-07 0.02925002048968134 \
4.143251924268523e-07 0.02872465224286764 4.143253982738151e-07 0.02822791768061097 4.143257906108381e-07 0.02730524204782691 4.143259790028487e-07 0.02687312495148303 \
4.143263546143073e-07 0.02603163971789 4.143265290810819e-07 0.02564950258131362 4.143269530155409e-07 0.02474274850847508 4.14327073769958e-07 0.02449086781212801 \
4.143275440207215e-07 0.02353384026002922 4.143276932357865e-07 0.02323677291035493 4.143280868679981e-07 0.02246740853134286 4.143282578943424e-07 0.02213909006726131 \
4.143287451732745e-07 0.02121869533024997 4.143288872209832e-07 0.02095326544309953 4.143294202372519e-07 0.01997576278857772 4.14329542401289e-07 0.01975737097014436 \
4.143300645590335e-07 0.01885981776906158 4.143302351373363e-07 0.01857989792133653 4.143307224503994e-07 0.01781360777737795 4.143308939733227e-07 0.01755501440977742 \
4.143315137600803e-07 0.01666567753024489 4.143316846844061e-07 0.0164316648397145 4.143323902353964e-07 0.01551160061118263 4.14332552852409e-07 0.01530799450170666 \
4.143333097458994e-07 0.01439879525764199 4.143334506625442e-07 0.01423641007536438 4.143343506613842e-07 0.01324361033368418 4.143344380106346e-07 0.01315122959105692 \
4.14335342363989e-07 0.01223321097894121 4.14335479555938e-07 0.01209984223734439 4.14336450212214e-07 0.01118944790767422 4.14336578130092e-07 0.01107451071402888 \
4.143377285400387e-07 0.01011008206277823 4.143378223420747e-07 0.01003687265682024 4.143390783878875e-07 0.009120584045805383 4.143392159292007e-07 0.009026502753623255 \
4.14340774683602e-07 0.008029670037698805 4.143408584862873e-07 0.007977066150721189 4.143424638651059e-07 0.00699828665725172 4.143425747634502e-07 0.006935886594503895 \
4.143445070098238e-07 0.005959177461785255 4.143446867147596e-07 0.005876661013304485 4.143467985058761e-07 0.004981749118765498 4.143471412910116e-07 0.004848482978762325 \
4.143496544570453e-07 0.003966891390423618 4.143501241787149e-07 0.003819799497680527 4.143537644949897e-07 0.002847564273158896 4.143542802321751e-07 0.002731633924241866 \
4.143596220620139e-07 0.001773027297371861 4.14359907382299e-07 0.001729522787584184 4.143651360301289e-07 0.0007540451492352357 4.143653101766958e-07 0.0007162692714263865 \
4.170136987690021e-07 -0.0001123232525192561 4.170138717942903e-07 -0.0002901710972538241 4.170144915460445e-07 -0.001202022686018724 4.170145801152216e-07 -0.001365806793032466 \
4.170149410863549e-07 -0.002110727959526865 4.1701506578065e-07 -0.002395793696299351 4.170154296225314e-07 -0.003299857180474864 4.170156008981996e-07 -0.003758114451912169 \
4.170158948960377e-07 -0.004576312838821549 4.170160051044431e-07 -0.004886880824040592 4.170162833584409e-07 -0.005643955697619643 4.1701640463225e-07 -0.00594200199557267 \
4.17017498254348e-07 -0.00517389603226481 4.170176213582281e-07 -0.004409713243767066 4.170177448263029e-07 -0.003462788751204457 4.170178649920999e-07 -0.002366010162083454 \
4.170179628537677e-07 -0.001346276287748183 4.170180695561039e-07 -0.0001076498664581183 4.170181813974884e-07 0.001328007358939307 4.170183173718548e-07 0.003256083960376262 \
4.170184394010113e-07 0.00514709866632534 4.170186278172891e-07 0.008343062029134115 4.170187688058191e-07 0.01093380316938193 4.170189215775226e-07 0.01391176330477175 \
4.170190642801506e-07 0.01683596409946878 4.170192186323876e-07 0.02013443377634912 4.170193744260432e-07 0.02358734537610087 4.170195304833402e-07 0.02715365164079262 \
4.170196778877403e-07 0.03060642997674319 4.170198265044852e-07 0.03415780069914553 4.170199819257017e-07 0.03793559522944389 4.170201403115322e-07 0.04184227512730877 \
4.170203052511541e-07 0.04596085539464361 4.170204795004229e-07 0.05035714787605008 4.170206584435392e-07 0.05491177248689325 4.170208475830321e-07 0.0597604232635115 \
4.170210503636104e-07 0.06498910043066243 4.170212697356369e-07 0.07067233091134768 4.170215005721334e-07 0.07667464705993039 4.170217473839693e-07 0.0831083675499642 \
4.1702201751608e-07 0.09016243555275107 4.170223107041881e-07 0.0978236474935409 4.170226343596258e-07 0.1062798466079799 4.170229979269121e-07 0.1157689210849182 \
4.170233902204302e-07 0.1259925151671456 4.170238386999148e-07 0.1376538644086695 4.170243603994004e-07 0.1511757390224034 4.170249727720439e-07 0.1669844191341421 \
4.170256494173592e-07 0.1843663871188266 4.170264363276496e-07 0.2044554566749352 4.170273175487439e-07 0.2267919980918504 4.170281372923844e-07 0.2474048556006221 \
4.170288657453285e-07 0.2655829647002126 4.17029507221317e-07 0.2814688958417333 4.170300831444854e-07 0.2956305456066151 4.170306204013019e-07 0.3087428400511723 \
4.17031124292597e-07 0.3209487846516751 4.17031601896145e-07 0.3324328152479784 4.170320800193789e-07 0.343838772307344 4.170325321182285e-07 0.3545331600964184 \
4.170330038845194e-07 0.365596737404158 4.170334475813599e-07 0.3759140547845509 4.170339695498976e-07 0.3879344734281669 4.170344970878305e-07 0.399956933836353 \
4.170348766025744e-07 0.4085271910771138 4.170354055641746e-07 0.4203606102508351 4.170358748832554e-07 0.4307444005277802 4.170363100387911e-07 0.4402814026247405 \
4.170367575161174e-07 0.4500002273945978 4.170371975395924e-07 0.4594737646471725 4.170376008413354e-07 0.4680814138276727 4.170379192411013e-07 0.4748254127722248 \
4.170382892190148e-07 0.4826007100982719 4.17038525472097e-07 0.4875314737878706 4.170387605434932e-07 0.4924129045770672 4.170390118828312e-07 0.4975994385012801 \
4.170393182698655e-07 0.5038799449729535 4.170395752283189e-07 0.5091120301871851 4.170397837026154e-07 0.5133309170973237 4.170399840849048e-07 0.5173683849445317 \
4.170401264786059e-07 0.5202244049244739 4.170402754030717e-07 0.5231993726577677 4.170404869493287e-07 0.5274019882470222 4.170407130069516e-07 0.5318780389403845 \
4.170409075493335e-07 0.5357103559602913 4.170410966812289e-07 0.539423417888626 4.170413261282768e-07 0.5439012399750046 4.170415086340828e-07 0.5474563135343053 \
4.170417459969519e-07 0.5520623276458133 4.170420149912601e-07 0.5572695987004129 4.170422639017101e-07 0.5620706638085723 4.170425079185314e-07 0.5667633705755619 \
4.170427802737438e-07 0.5719926523718327 4.170430416698736e-07 0.5769928369418796 4.170432993012793e-07 0.5819084237686675 4.17043546144628e-07 0.586601202059797 \
4.170437918903539e-07 0.5912552023551558 4.170440184678743e-07 0.5955288021520931 4.170442496200641e-07 0.5998646534936181 4.170444559004441e-07 0.6037202012184053 \
4.170446840212041e-07 0.6079592993751251 4.170449064011853e-07 0.6120725203834017 4.17045133377667e-07 0.6162454422471376 4.170453484306168e-07 0.6201823359462864 \
4.170455778001903e-07 0.6243500782103125 4.170458468230649e-07 0.6292041961704016 4.170460698367118e-07 0.6331993632081415 4.170462820912892e-07 0.6369772451758789 \
4.170464934888789e-07 0.6407176358819484 4.17046693558109e-07 0.644236566349866 4.170469231519586e-07 0.6482486956559365 4.170471639888863e-07 0.6524328529570182 \
4.170473457382733e-07 0.6555667906748446 4.170475342865e-07 0.6588018260593631 4.170476873661394e-07 0.6614154033769962 4.170478593744213e-07 0.6643352515471471 \
4.170480095472396e-07 0.6668697017322168 4.170481460645294e-07 0.6691578850264722 4.170482956937163e-07 0.6716547631652277 4.170484234340851e-07 0.673777752640997 \
4.170485630202226e-07 0.6760856948620949 4.170486872589102e-07 0.6781310478824312 4.170488184087496e-07 0.6802827752320969 4.170489428500932e-07 0.6823179209931315 \
4.170490800809157e-07 0.6845542421253382 4.170492003290863e-07 0.6865048414796368 4.170493416605295e-07 0.6887891282595083 4.170494419916407e-07 0.6904033553735033 \
4.170495631093427e-07 0.6923460943304175 4.170496538868777e-07 0.6937948943079848 4.170497511453436e-07 0.6953408241330762 4.170498473532237e-07 0.6968660703265798 \
4.170499359670681e-07 0.6982647859968389 4.170500332550912e-07 0.6997938110311075 4.170501657237294e-07 0.7018622871835729 4.170503209139279e-07 0.7042674555997347 \
4.170504587918793e-07 0.7063866855441746 4.170506036461533e-07 0.7085960165693863 4.170507307079098e-07 0.7105202221428537 4.170508553934701e-07 0.7123960184768648 \
4.170509680988463e-07 0.7140814553427599 4.170510798891907e-07 0.7157437310299281 4.170511806678399e-07 0.7172341607972841 4.170513179462954e-07 0.7192525454101454 \
4.170514376303672e-07 0.7210013704967912 4.170515570598379e-07 0.7227365757678518 4.170516839430602e-07 0.7245692610776365 4.170518083607121e-07 0.7263556789600311 \
4.170519320935366e-07 0.728121726658988 4.170520586890634e-07 0.7299181396522603 4.170521890744641e-07 0.7317573312219798 4.170523118842844e-07 0.7334798522758219 \
4.170524473200596e-07 0.7353678990088863 4.170525486098379e-07 0.7367723836293941 4.170526562323338e-07 0.7382576460517265 4.170527457604157e-07 0.7394878879617913 \
4.170528603087849e-07 0.7410528648863303 4.170529483370413e-07 0.7422487366778059 4.170530554151068e-07 0.7436953530868765 4.170531854801004e-07 0.7454403311053276 \
4.170532967597954e-07 0.7469230742113165 4.170534013783548e-07 0.7483084058091373 4.170535254613402e-07 0.7499400420429273 4.170536737621685e-07 0.7518749696944975 \
4.170537951620328e-07 0.7534462209622173 4.170539096027802e-07 0.7549170836379747 4.170540499400977e-07 0.7567069362027918 4.170541917029811e-07 0.7584995177563068 \
4.170543095039188e-07 0.759977341175643 4.170544374807853e-07 0.761570846386187 4.170545791832092e-07 0.7633205808366864 4.170546966945227e-07 0.7647599110190483 \
4.170548422997917e-07 0.7665289162262866 4.170549639940994e-07 0.7679951561698679 4.170550827247088e-07 0.7694149786178283 4.170552050113037e-07 0.7708662727382939 \
4.170553320558197e-07 0.77236234268503 4.170554416997921e-07 0.7736439866494906 4.170555673867047e-07 0.7751025186690397 4.170556734018052e-07 0.776323977486031 \
4.170558089877718e-07 0.7778743028704433 4.170559339507686e-07 0.7792913979962601 4.17056059856921e-07 0.7807070123991936 4.17056175124167e-07 0.7819915514687489 \
4.170562814286401e-07 0.7831664991275713 4.17056419833432e-07 0.7846822315516878 4.170565691298821e-07 0.7862997378875561 4.170567146373276e-07 0.7878588534534761 \
4.170568340418389e-07 0.7891257303126159 4.170569691346634e-07 0.7905455128963393 4.170570903878263e-07 0.7918076974797237 4.170572333811048e-07 0.7932816011184505 \
4.170573775854105e-07 0.7947523458802197 4.170575031222391e-07 0.7960199014141693 4.170576221686118e-07 0.7972110037065316 4.170577341044954e-07 0.7983213107123885 \
4.170578389760474e-07 0.7993531099923881 4.170579342264591e-07 0.8002831901653534 4.170580705697047e-07 0.8016020813281191 4.170581873938354e-07 0.8027203407102198 \
4.170583067984452e-07 0.803852171037294 4.170584289052493e-07 0.8049980820693966 4.170585518602505e-07 0.8061401395390313 4.17058678828951e-07 0.8073073595000361 \
4.170588040685604e-07 0.8084467645495962 4.17058934640955e-07 0.8096220968518901 4.170590606314733e-07 0.8107441738369082 4.170591888173857e-07 0.8118738099374113 \
4.170592943471138e-07 0.8127947795787664 4.170593972188869e-07 0.8136847278655364 4.17059490214057e-07 0.8144826950388273 4.170596140106596e-07 0.8155354283166244 \
4.170597019789174e-07 0.8162769513478326 4.170598007099885e-07 0.8171027376706747 4.170599439751418e-07 0.8182889948057973 4.170600792538271e-07 0.8193962136425846 \
4.170601883684495e-07 0.8202800249700468 4.17060336451758e-07 0.8214657808291811 4.170604862226849e-07 0.8226492530953341 4.170606114572855e-07 0.8236267526687548 \
4.170607554487032e-07 0.8247372275730155 4.170608795047738e-07 0.8256825756473101 4.170610299680322e-07 0.8268152483647575 4.17061165678884e-07 0.8278240064655301 \
4.170612906973921e-07 0.828742521381556 4.170614084523219e-07 0.8295983347934622 4.170615544291349e-07 0.8306466023667578 4.170617209384522e-07 0.8318251482734692 \
4.170618518610282e-07 0.8327390940956469 4.170620252884658e-07 0.8339327615268647 4.170621934353481e-07 0.8350717495747054 4.170623632702773e-07 0.8362042975620877 \
4.170625441950479e-07 0.8373912937861997 4.170626872933069e-07 0.8383160748488641 4.170628013791983e-07 0.8390446117604563 4.170629315531841e-07 0.8398665237782376 \
4.170630333942664e-07 0.8405024977857931 4.170631502136154e-07 0.8412243379523001 4.170632870780449e-07 0.8420597162999857 4.170634848766686e-07 0.8432475311273343 \
4.170636764807398e-07 0.8443767279905872 4.170638859212216e-07 0.8455874169714939 4.170640678468519e-07 0.8466193100105236 4.170642649799575e-07 0.8477171434207121 \
4.170644383298479e-07 0.8486653666163242 4.170646213292318e-07 0.8496493024239481 4.17064792495495e-07 0.8505537352954988 4.170649671272818e-07 0.8514606693963016 \
4.170651423896692e-07 0.8523550102558151 4.170653185417845e-07 0.8532381479010797 4.170655088128238e-07 0.8541746551565574 4.170656994147745e-07 0.85509499218684 \
4.170659000624008e-07 0.8560449689899254 4.170660926729659e-07 0.8569390259424264 4.170663033306522e-07 0.8578972157030333 4.170665314560509e-07 0.8589122247267402 \
4.170667972133685e-07 0.8600655879592763 4.17067095837813e-07 0.8613244245924475 4.170673721693318e-07 0.862454900702886 4.170676564023905e-07 0.8635842083919951 \
4.17067930614306e-07 0.8646423892283146 4.170682028423722e-07 0.8656634505877856 4.170684730511913e-07 0.8666487272755322 4.170687302040671e-07 0.8675609437488442 \
4.170690027863351e-07 0.868501515423508 4.170692787713349e-07 0.8694269133137555 4.170695488729115e-07 0.8703069289141475 4.170698487348628e-07 0.8712546000783432 \
4.170702197689933e-07 0.8723856543073821 4.170705147067536e-07 0.8732530157608677 4.170707689975357e-07 0.8739790309043101 4.170710672549513e-07 0.8748056771600844 \
4.170713408634847e-07 0.8755409825400007 4.170715769915496e-07 0.8761583495732972 4.170718173369303e-07 0.876770807053994 4.170720396702121e-07 0.8773233906735478 \
4.170722336759598e-07 0.8777948466981503 4.17072563398506e-07 0.8785737911727464 4.170727185719444e-07 0.8789308835864816 4.17073036347473e-07 0.8796437246174529 \
4.170732152091701e-07 0.8800342982281311 4.170735576710472e-07 0.8807611334253193 4.170737417995192e-07 0.8811407335605206 4.170742166778565e-07 0.8820849466541889 \
4.170743840740528e-07 0.8824061830950772 4.170748499154564e-07 0.8832696475595492 4.170750307376651e-07 0.8835931319180218 4.170755247759143e-07 0.8844450822729043 \
4.170756661243274e-07 0.8846804878101884 4.170762724573853e-07 0.8856498028150036 4.170764245267248e-07 0.8858829444029697 4.170770712152002e-07 0.8868329272509302 \
4.170771995097231e-07 0.8870138524519416 4.170778476269279e-07 0.8878919388991984 4.170779774257916e-07 0.8880607713689423 4.17078755627481e-07 0.8890227771434612 \
4.170788706844142e-07 0.8891574578072456 4.170797263428482e-07 0.8901003239091128 4.170798717076157e-07 0.8902505899439886 4.1708085746403e-07 0.8911948786459364 \
4.170810785690402e-07 0.8913892999646706 4.170822236960192e-07 0.8923206810037944 4.170823549126186e-07 0.892422953350996 4.170836961242674e-07 0.8934189515818408 \
4.170838475232108e-07 0.8935240845833778 4.170853289614591e-07 0.8944568913393511 4.170855678408922e-07 0.8945912088657246 4.170873371610739e-07 0.8954685138428928 \
4.170877263108405e-07 0.895637400736999 4.170901199766276e-07 0.896526474291006 4.170905956894499e-07 0.8966764365754722 4.17094011699057e-07 0.8975478548673914 \
4.170946588490717e-07 0.8976786076740833 4.171021370136781e-07 0.8986646932675814 4.171028095907965e-07 0.8987192862546014 4.171952539953667e-07 0.8997188196574962 \
4.171959172280509e-07 0.8997241906476866 4.17385126389945e-07 0.900686595210158 4.173852884627892e-07 0.9007292695325627 4.173879339836764e-07 0.8998161167154269 \
4.173881025331539e-07 0.8996881690130656 4.173893792855451e-07 0.8987393243250013 4.173895814518808e-07 0.8986030018074492 4.173911895612674e-07 0.8976721249252815 \
4.173913816671926e-07 0.8975774045828077 4.174064950498388e-07 0.8985726115129884 4.174066831087563e-07 0.8986004060702872 4.174179880377677e-07 0.8995874924221801 \
4.174183614235164e-07 0.8996034751727418 4.17907373786698e-07 0.9005892719715856 4.179074845548976e-07 0.9006868984798269 4.179082372272589e-07 0.9015617873136611 \
4.179083390219455e-07 0.9017086238768567 4.179088744204902e-07 0.9025814930725723 4.179089769296628e-07 0.9027670217776843 4.179093691484817e-07 0.9035254014384071 \
4.17909509991429e-07 0.9038129158713877 4.179099510288813e-07 0.9047472953155866 4.179101365144842e-07 0.9051402477015744 4.179106528276013e-07 0.9061269394579334 \
4.17910737502694e-07 0.9062564181617988 4.179119721747438e-07 0.9053011091537977 4.179121293881559e-07 0.9045688862145235 4.179123212048176e-07 0.9034162411061901 \
4.179124880453484e-07 0.9021712267446264 4.179126350037463e-07 0.9008824031243315 4.179127491199425e-07 0.8997575350477262 4.179128789920323e-07 0.8983446880789033 \
4.179129901095502e-07 0.8970273815442567 4.179130829140294e-07 0.8958483937359277 4.17913171236719e-07 0.8946639786015808 4.179132744174779e-07 0.8932058048613533 \
4.179133666254135e-07 0.8918333298588224 4.179134541956103e-07 0.8904732289418564 4.179135681890766e-07 0.8886245408236838 4.179137299935004e-07 0.8858564722885236 \
4.179139149921176e-07 0.8825005184224666 4.179141071517853e-07 0.8788219124347386 4.179143085991386e-07 0.874780227084481 4.179145150097281e-07 0.8704697801294994 \
4.179147001816807e-07 0.8664790122147591 4.179148846894051e-07 0.862405115500708 4.179150578412964e-07 0.8585071391690239 4.179152428873213e-07 0.8542751393552932 \
4.179154202615245e-07 0.8501657390392787 4.179155970079552e-07 0.8460284987362284 4.179157631666058e-07 0.8421077870518131 4.179159252110445e-07 0.8382599993991456 \
4.179160917839251e-07 0.8342839555277276 4.179162504376618e-07 0.8304816347052207 4.179164413136869e-07 0.8258903812682129 4.179166162972586e-07 0.8216694867670907 \
4.179167862433926e-07 0.8175615830390965 4.179169514195676e-07 0.8135626411663678 4.179171246116744e-07 0.8093650119631921 4.179172956738769e-07 0.8052155696745213 \
4.179174637749139e-07 0.801136095357175 4.179176541098628e-07 0.7965156511928794 4.179178376918066e-07 0.7920591698039 4.179180456827317e-07 0.7870113041480956 \
4.179182682592422e-07 0.7816114142545842 4.17918457674258e-07 0.7770174196885687 4.17918650984654e-07 0.7723312127316435 4.179187944302406e-07 0.7688556734481145 \
4.179189438535907e-07 0.7652374066097742 4.179190630060629e-07 0.7623536300085233 4.179191757225445e-07 0.7596269484184472 4.179192849974512e-07 0.7569846861296079 \
4.179194210272094e-07 0.753697254849378 4.179195338230239e-07 0.750972995067179 4.179196560209801e-07 0.7480232093637929 4.179197676057526e-07 0.7453311011793381 \
4.179198923122156e-07 0.7423241425761796 4.179200466941669e-07 0.7386034578119585 4.179202134782327e-07 0.7345862494782525 4.179204306429213e-07 0.7293605768817599 \
4.179206252035101e-07 0.7246835946359503 4.179207855343955e-07 0.7208333202545074 4.179209609599985e-07 0.7166251500492028 4.179211507235729e-07 0.7120779400724765 \
4.179213394518974e-07 0.7075610435995559 4.179215212732644e-07 0.7032145396962334 4.179217058706759e-07 0.6988062725207448 4.179218429538112e-07 0.6955348514212173 \
4.179219962420495e-07 0.6918805091472418 4.179221916137951e-07 0.6872279990818534 4.179223477705467e-07 0.6835136309588888 4.179225057227664e-07 0.6797605476340507 \
4.179227039740297e-07 0.6750570282453686 4.179228973199279e-07 0.6704763548785364 4.17923133825274e-07 0.6648822204491218 4.179233200303777e-07 0.6604858901039825 \
4.179235576526979e-07 0.6548824851665868 4.179237444514522e-07 0.6504854738275335 4.179239250092116e-07 0.6462424706993735 4.179240880851561e-07 0.6424159959781919 \
4.179242326967206e-07 0.6390271817202816 4.179243732990706e-07 0.6357379642635244 4.179245001086569e-07 0.632774906490579 4.179246322451931e-07 0.6296924762754078 \
4.179247584891446e-07 0.6267508340255646 4.179248897527744e-07 0.6236963630311418 4.179250188505141e-07 0.6206978048938425 4.179251582761788e-07 0.6174624210713571 \
4.179253066461711e-07 0.6140261568477932 4.179255012030603e-07 0.6095278574984737 4.179256446489368e-07 0.6062198040692683 4.179258791091827e-07 0.6008245134060309 \
4.179260510074948e-07 0.5968818013610552 4.179262639280334e-07 0.5920102583789468 4.179264363946513e-07 0.5880775912131976 4.179265667191976e-07 0.5851108450968721 \
4.179266982755174e-07 0.5821241897920357 4.179268085055992e-07 0.5796262478458715 4.179269041598466e-07 0.5774603558442819 4.179270033938061e-07 0.5752182923213994 \
4.179270863119075e-07 0.5733484809858778 4.179271652275343e-07 0.5715706040143225 4.179272281563093e-07 0.5701535626562365 4.179272936647862e-07 0.5686800671140783 \
4.179273741508387e-07 0.5668736364148982 4.179274240168465e-07 0.5657560592102344 4.179274732056154e-07 0.5646541775062763 4.179275346754008e-07 0.5632780399140616 \
4.179275825969294e-07 0.5622058085646952 4.179276334416479e-07 0.5610687758404553 4.179276925419032e-07 0.5597501790023616 4.1792775115623e-07 0.5584442118409422 \
4.179278267823233e-07 0.5567607189607793 4.17927897341035e-07 0.5551915720267918 4.17927986471042e-07 0.5532116467156011 4.1792807569462e-07 0.5512351177508077 \
4.179281609982305e-07 0.5493490637975145 4.17928248625197e-07 0.5474138635528197 4.179283456271202e-07 0.545274424894262 4.179284499728913e-07 0.5429792414815097 \
4.179285662643155e-07 0.5404269323775457 4.17928672601932e-07 0.5380963700835184 4.179287843108152e-07 0.5356536306660374 4.179288966052949e-07 0.5332047801427824 \
4.179290238028543e-07 0.5304364255197962 4.17929146572528e-07 0.5277698476303582 4.179292887969246e-07 0.5246912237717902 4.179294251600566e-07 0.5217463069543907 \
4.179295773811234e-07 0.5184691491721333 4.179297370173294e-07 0.5150420887864461 4.179299129925215e-07 0.5112761258030903 4.179301015011087e-07 0.5072591542828934 \
4.179303085676898e-07 0.5028616940969075 4.179305335096624e-07 0.4981043078903621 4.179307849056189e-07 0.4928144328841237 4.179310213311851e-07 0.4878598554762091 \
4.179313184949192e-07 0.4816683149127979 4.179316091722113e-07 0.4756487143466775 4.17931917027196e-07 0.469313240945046 4.179322308529534e-07 0.4628991126846517 \
4.179325599943131e-07 0.4562163541974347 4.179328933724197e-07 0.4494927613461197 4.179332249990283e-07 0.4428490490857003 4.179335465484253e-07 0.4364504708187015 \
4.179338742242378e-07 0.4299742838549845 4.179342218438604e-07 0.4231546934710667 4.179345550651743e-07 0.4166645133789623 4.179349009744022e-07 0.4099771621835854 \
4.179353463882216e-07 0.4014400148089548 4.179357041780923e-07 0.3946500490499754 4.179360183349117e-07 0.3887397205534429 4.179364027453916e-07 0.3815756289527631 \
4.179367327200365e-07 0.3754830843203271 4.179370179301253e-07 0.3702633801070484 4.179373262203822e-07 0.3646649204592909 4.179376060174434e-07 0.3596257204303125 \
4.179378320117929e-07 0.3555880084110294 4.179380468497475e-07 0.3517755993421203 4.179382452848198e-07 0.3482769933469286 4.179384492243371e-07 0.3447071465415313 \
4.179386597603963e-07 0.3410461989361561 4.179389167345215e-07 0.3366091000429626 4.179391579951288e-07 0.3324763702393667 4.179393895688451e-07 0.3285420159269506 \
4.179396042222912e-07 0.3249208057821749 4.17939825046275e-07 0.3212218866489027 4.179400262928671e-07 0.3178749657716667 4.179402293821204e-07 0.3145250552959265 \
4.179404272269915e-07 0.3112865758726304 4.179406140799367e-07 0.3082497660855442 4.179408080166626e-07 0.3051208532403978 4.179410117613171e-07 0.30185834615803 \
4.179411904885829e-07 0.2990186060348319 4.179414281343783e-07 0.2952727068736475 4.179416278966111e-07 0.2921508861588616 4.179418295254275e-07 0.2890253490052915 \
4.179420549918856e-07 0.285561995332 4.17942221086285e-07 0.2830312764183137 4.179423997053871e-07 0.2803277612349699 4.179425814095885e-07 0.2775983111934518 \
4.179427700433049e-07 0.2747882307029562 4.17942947466508e-07 0.2721695222189568 4.179431246596456e-07 0.2695724116247911 4.179432847315606e-07 0.2672552081803913 \
4.179434051322386e-07 0.2655193337608355 4.179435529583031e-07 0.2633957862580221 4.179436815880755e-07 0.2615692882062232 4.179437837936585e-07 0.2601227034409412 \
4.179439020289393e-07 0.2584516051170885 4.179440224822997e-07 0.2567534139348401 4.179441461906177e-07 0.2550183706610066 4.179442644426428e-07 0.2533694204037282 \
4.179443922957733e-07 0.2515887492000971 4.179445125816039e-07 0.249915736161692 4.179446652612099e-07 0.2477917697339537 4.179448001739884e-07 0.2459264316518071 \
4.1794492881341e-07 0.2441493177932957 4.17945086528788e-07 0.2419705448111171 4.179452132100908e-07 0.2402201997919771 4.179453485361585e-07 0.2383592392624043 \
4.179454874487268e-07 0.2364550510890953 4.179456052210313e-07 0.2348405558720491 4.179457644918496e-07 0.2326580599570062 4.179459010137043e-07 0.2307878375452989 \
4.179460422456504e-07 0.2288626996658652 4.179461480586929e-07 0.2274220928889542 4.179462784016402e-07 0.2256484734765637 4.17946378112453e-07 0.2242944442559471 \
4.179464809338881e-07 0.2228991027388591 4.179465543495424e-07 0.2219046249368765 4.179466341811041e-07 0.2208265149641777 4.179467042283352e-07 0.2198809561195558 \
4.179467546314264e-07 0.2192009305305119 4.179468068832254e-07 0.2184966408607167 4.179468861207429e-07 0.2174292050927151 4.179469279646958e-07 0.2168658036437602 \
4.179469673046481e-07 0.216336351877609 4.179470103400575e-07 0.2157575332679269 4.179470545074838e-07 0.2151638767852215 4.179471282732236e-07 0.2141731338947761 \
4.179471637852207e-07 0.2136967174286463 4.179472115000211e-07 0.2130606706933813 4.17947272229561e-07 0.2122518321687151 4.179473404867867e-07 0.2113438957752176 \
4.179474130085659e-07 0.2103801801047663 4.179474856831929e-07 0.2094152724966429 4.179475939991808e-07 0.2079788886429202 4.179476916703231e-07 0.20668564243436 \
4.179478032218192e-07 0.2052110974836689 4.179479017572532e-07 0.2039136008387587 4.179480052503929e-07 0.2025572972554956 4.179481011521277e-07 0.2013021587886929 \
4.17948203780057e-07 0.1999606878451601 4.179483066031699e-07 0.1986207062101238 4.179484167227972e-07 0.1971897063011611 4.179485254183531e-07 0.1957815523781236 \
4.179486450955818e-07 0.1942360962608612 4.179487553732606e-07 0.192818053470401 4.179488634364806e-07 0.1914343471929882 4.179489885351485e-07 0.1898375077741012 \
4.179490785049817e-07 0.1886931806549971 4.179491571919347e-07 0.1876950225942949 4.17949234476806e-07 0.1867173468865102 4.179493209853825e-07 0.1856271834369256 \
4.179494199345929e-07 0.1843848109964498 4.179494904434582e-07 0.1835017733581451 4.179495618945114e-07 0.1826096997732476 4.179496670398458e-07 0.1813018727451555 \
4.179497462794755e-07 0.1803200401832796 4.179498273633695e-07 0.1793174195483187 4.179499208553101e-07 0.1781663090788374 4.179500216312847e-07 0.1769308188703378 \
4.179501713433884e-07 0.175105380089017 4.179502871327037e-07 0.1737009932372819 4.179504381380806e-07 0.1718807311127691 4.179505492465001e-07 0.1705485445502526 \
4.179506913729584e-07 0.168854666407182 4.179508090313791e-07 0.167460358327668 4.179509139359749e-07 0.1662230887079887 4.179510089985733e-07 0.1651069099307241 \
4.179511024298279e-07 0.1640147999883682 4.179512034764903e-07 0.1628388413495604 4.179512998233979e-07 0.1617223204899406 4.179513969756437e-07 0.1606011553546776 \
4.179514800242163e-07 0.1596469772300165 4.179515900618698e-07 0.1583897228513109 4.179516723644316e-07 0.1574542248873526 4.179517773641412e-07 0.156267858580057 \
4.179518550602102e-07 0.1553950893374849 4.179519378796887e-07 0.1544690878994293 4.179520195415937e-07 0.1535604570452941 4.179521088908844e-07 0.152571060794856 \
4.1795218460332e-07 0.1517364980793458 4.179522671659343e-07 0.1508307726525361 4.179523437473671e-07 0.1499942554682341 4.179524120352535e-07 0.1492531084507001 \
4.179525054022655e-07 0.1482449401818621 4.179525745556768e-07 0.1475015570698688 4.179526501800083e-07 0.1466917482325688 4.179527117291286e-07 0.1460354497178591 \
4.179527789778923e-07 0.1453208357145237 4.179528500398917e-07 0.1445684785944268 4.179529255373203e-07 0.143772322008306 4.179529844488598e-07 0.1431546944759192 \
4.179530611224699e-07 0.1423563022825049 4.179531414432115e-07 0.1415233898163201 4.179532145945195e-07 0.1407682091691316 4.179533087509408e-07 0.139800669784813 \
4.179533803551248e-07 0.1390684367429364 4.179534538159005e-07 0.1383201464810226 4.179535373276515e-07 0.1374732033664194 4.179536268067954e-07 0.1365744208092838 \
4.179536918717003e-07 0.1359252211013016 4.179538039977229e-07 0.1348115665849295 4.179538691838635e-07 0.1341670699454539 4.179539392221084e-07 0.1334770515823289 \
4.179539995271633e-07 0.1328849371768329 4.179540545379868e-07 0.1323464455745446 4.17954142654965e-07 0.1314871014507438 4.179541834412595e-07 0.131090685705856 \
4.179542871440105e-07 0.1300923774523848 4.179543304565801e-07 0.1296773144713907 4.17954391675178e-07 0.1290920262082728 4.179544365118974e-07 0.1286643765206081 \
4.179545241079233e-07 0.127831527987147 4.179545656618794e-07 0.1274377589706847 4.179546255233895e-07 0.1268718307679372 4.179546973671149e-07 0.1261946708524367 \
4.179547535798413e-07 0.1256664967939027 4.179548160673402e-07 0.125081039250218 4.179548902953232e-07 0.1243877959456236 4.179549649763284e-07 0.1236954937854857 \
4.179550521595408e-07 0.1228905551604285 4.179551205580918e-07 0.1222610287411191 4.17955201128775e-07 0.1215216597888775 4.179552824242559e-07 0.120778012781285 \
4.179553493407808e-07 0.1201677797529914 4.179554321577256e-07 0.1194156054679852 4.179554913464481e-07 0.1188799972037829 4.179555572674477e-07 0.1182853617472536 \
4.179556371414917e-07 0.1175675408705869 4.179557136372899e-07 0.1168828806096336 4.179557950994005e-07 0.1161574242846086 4.179558935702815e-07 0.1152852106851665 \
4.179559686806303e-07 0.114622623867465 4.179560716684202e-07 0.1137180076826871 4.179561458523715e-07 0.1130691786503039 4.179562434718251e-07 0.1122190343868764 \
4.179563392827804e-07 0.1113890351962442 4.179564351312053e-07 0.110562946039519 4.179565160694118e-07 0.1098685209805978 4.179566044526832e-07 0.1091134439098378 \
4.179567030526616e-07 0.108274944429282 4.179567758368656e-07 0.1076586405352824 4.17956865109775e-07 0.1069058608836731 4.179569270917884e-07 0.1063852406583179 \
4.179569896849557e-07 0.1058613310701875 4.179570749071042e-07 0.105150777260444 4.179571803694782e-07 0.1042758147594986 4.179572601999606e-07 0.1036167065755082 \
4.179573409142144e-07 0.1029530974056021 4.179574235279495e-07 0.1022768941101355 4.179574939725617e-07 0.1017026162492672 4.179575972319282e-07 0.1008648142128753 \
4.179576700720535e-07 0.1002767039768694 4.179577557123351e-07 0.09958839426015198 4.179578745140727e-07 0.09863954321822334 4.179579421518979e-07 0.09810250133474645 \
4.179580119020204e-07 0.09755100310752296 4.17958089237e-07 0.09694230106952094 4.179581816572539e-07 0.09621870517595056 4.17958253354782e-07 0.09566033062548993 \
4.179583391719417e-07 0.09499542738017568 4.17958441597192e-07 0.09420660575030523 4.17958534892083e-07 0.09349264652734962 4.179586312085565e-07 0.09276005482712441 \
4.179587081108176e-07 0.09217843893134048 4.179588015908053e-07 0.09147541043939374 4.179588808332317e-07 0.09088281005358793 4.17958995455426e-07 0.0900310686188453 \
4.179591250636858e-07 0.08907580221142102 4.179592583208766e-07 0.08810234090122065 4.179594023507657e-07 0.08705990691030199 4.179595595189096e-07 0.08593388720602639 \
4.179597092953871e-07 0.08487214151476249 4.179598717629786e-07 0.08373303262435308 4.179600149429843e-07 0.08273971668837025 4.17960167622107e-07 0.0816913199659166 \
4.179603018918778e-07 0.08077856892457436 4.179604436441555e-07 0.07982444400446118 4.179605786438163e-07 0.07892500874648442 4.179607206012136e-07 0.07798882638923543 \
4.179608674486441e-07 0.07703088995320664 4.17961019894053e-07 0.07604750978240994 4.179611851127758e-07 0.07499422991502351 4.179613492506213e-07 0.07396067809208305 \
4.17961526112024e-07 0.07286119333145537 4.179617164535802e-07 0.07169407515132428 4.179619274100931e-07 0.07042030845332216 4.179621478192316e-07 0.0691121699798517 \
4.17962383344393e-07 0.06773900533435212 4.179626437937674e-07 0.0662496528900723 4.179629394591772e-07 0.06459579389282195 4.179632445814628e-07 0.06292902455725519 \
4.179636095760241e-07 0.06098725515092194 4.179640044568393e-07 0.05894944116461652 4.179644108474933e-07 0.05692211719668253 4.179648265730353e-07 0.05491854459141238 \
4.179651893793582e-07 0.0532251207245777 4.179655339806477e-07 0.05166301626031383 4.179658491605098e-07 0.05027284652491828 4.179661446898748e-07 0.04900240867073854 \
4.179664426703825e-07 0.04775344010203557 4.179667184691725e-07 0.04662857640242725 4.179669972437684e-07 0.04551884372531381 4.179672611786382e-07 0.04449205559535935 \
4.179675372013766e-07 0.04344260531795661 4.179678161576298e-07 0.04240676967887352 4.179681298509633e-07 0.04127097799875453 4.179683658512502e-07 0.04043636567030678 \
4.179686216459875e-07 0.03955075129286261 4.17968881769487e-07 0.03867033103466553 4.179691519047594e-07 0.03778142289416799 4.179694311247467e-07 0.03688501536902895 \
4.179697129633963e-07 0.03600226561751176 4.17969989839066e-07 0.03515600409566183 4.179702689326649e-07 0.03432349610146775 4.179705018102725e-07 0.03364444121149882 \
4.179707856469894e-07 0.03283527291840588 4.179710257519236e-07 0.03216626441466421 4.179712655507464e-07 0.0315119836023277 4.179715048279204e-07 0.03087436846876356 \
4.179717400849421e-07 0.03026290129608995 4.17971971011964e-07 0.02967475842909434 4.17972186001007e-07 0.02913788335257221 4.179725881554596e-07 0.02816043724496065 \
4.179727868782784e-07 0.02768988489927659 4.179731605612946e-07 0.0268265706552881 4.179733473596173e-07 0.02640514011949098 4.179736949193039e-07 0.02563810810034544 \
4.179738168487671e-07 0.0253740445387235 4.179741993202075e-07 0.02456430406701914 4.179743700282368e-07 0.02421180751242828 4.179748271256211e-07 0.02328894863848502 \
4.179750127580069e-07 0.0229225623309489 4.179753762152598e-07 0.02221803970155307 4.179755965826125e-07 0.02179832126591805 4.179760543089696e-07 0.02093867417890744 \
4.179761897285988e-07 0.02068687731869814 4.179767196240474e-07 0.01972418011126781 4.17976838945017e-07 0.01951377505543128 4.179774047306961e-07 0.01856069823426573 \
4.17977569110437e-07 0.0182962226476828 4.179781876557339e-07 0.01735107502432094 4.179783577099333e-07 0.01710418363667701 4.179788898421661e-07 0.01636278834442301 \
4.179790869261418e-07 0.01610013864443424 4.179798100452149e-07 0.01517806887136661 4.179799746753809e-07 0.01497647803580381 4.179807238007678e-07 0.01409711804523418 \
4.179808571001203e-07 0.01394643716836554 4.179817173537587e-07 0.01301449210748497 4.179818524573794e-07 0.01287422877142914 4.179827950348197e-07 0.01193816285908547 \
4.179829586305738e-07 0.01178202925388569 4.179839599872008e-07 0.0108653384673985 4.179840975299883e-07 0.01074500730514941 4.179853196363713e-07 0.009765086624518643 \
4.179854265890839e-07 0.00968516078425012 4.179868307805774e-07 0.008707372520026449 4.179869356112841e-07 0.008639312158696611 4.179884704482461e-07 0.00767719340797631 \
4.179885657315476e-07 0.007617466071856052 4.179901745288685e-07 0.006680264535635283 4.179903086056077e-07 0.006609506832171614 4.179924056185594e-07 0.005610918814474722 \
4.179926361631908e-07 0.005510783990371394 4.179949591584347e-07 0.004586584533412417 4.179954404886379e-07 0.004413562233393853 4.179982780502688e-07 0.003511943147855551 \
4.179988229699549e-07 0.003360532104877318 4.180029471783516e-07 0.002408309874554541 4.180034909020111e-07 0.002305347543005144 4.180093621912368e-07 0.001333291345955189 \
4.180096050564212e-07 0.001286469439319215 4.180239329487719e-07 0.0002880570268237783 4.180240775074142e-07 0.0002853642807229123 4.206613564285128e-07 -0.0006859155495331031 \
4.206614959836499e-07 -0.000901903561740745 4.206620050775826e-07 -0.001859438188174024 4.206620945650851e-07 -0.002052812934985279 4.206624579599451e-07 -0.00291126965001638 \
4.206625489820155e-07 -0.003143482006111167 4.206629144200523e-07 -0.004127275145644371 4.206630246806195e-07 -0.004436819103926468 4.206633367277739e-07 -0.005309594399865315 \
4.206634394426211e-07 -0.005584800160857357 4.206638032904768e-07 -0.006384516484886619 4.206639680812086e-07 -0.006586298968823262 4.206645476774082e-07 -0.005791490933239759 \
4.206647227875511e-07 -0.004914057272375438 4.206648394794853e-07 -0.004132845175365214 4.206649660640906e-07 -0.003100877896798674 4.206650678730126e-07 -0.002132773363901063 \
4.206651883617228e-07 -0.0008283127610571584 4.206652788087988e-07 0.0002599396317828252 4.206653766989305e-07 0.001541559978017447 4.206654757632395e-07 0.002943971508909197 \
4.206656465705158e-07 0.005594911825788154 4.206658683385388e-07 0.00944046646559993 4.206660642423845e-07 0.01317281463966807 4.206662231237664e-07 0.01639870563256729 \
4.206663875522632e-07 0.01989779506365397 4.206665419182936e-07 0.02331070396473752 4.20666700690818e-07 0.02693200463312963 4.20666847428777e-07 0.03036422445567413 \
4.206669960527481e-07 0.0339113704936035 4.20667151667245e-07 0.03768995713197771 4.206673089092589e-07 0.04156499463828727 4.206674738020577e-07 0.04567927910670353 \
4.206676472215784e-07 0.05005184210758699 4.20667825915293e-07 0.05459761989277153 4.206680145311307e-07 0.05943075613080645 4.206682154312736e-07 0.06460909294799391 \
4.206684348880646e-07 0.0702927970720964 4.206686644343515e-07 0.07626037976612585 4.20668910133291e-07 0.08266408948881369 4.206691786982297e-07 0.08967663153997742 \
4.206694700401445e-07 0.09728936802005522 4.206697917081718e-07 0.1056939239977524 4.20670152022263e-07 0.1150987971742611 4.206705430017012e-07 0.1252892839303718 \
4.206709864165172e-07 0.1368209045172546 4.206715027296046e-07 0.1502062239570841 4.206721089348208e-07 0.16586000516691 4.206727801918478e-07 0.1831102247110778 \
4.206735596915048e-07 0.20301830483439 4.206744320013886e-07 0.2251413938832897 4.206752623367137e-07 0.2460320778586349 4.206759936670634e-07 0.264292249712138 \
4.206766416128433e-07 0.280346965484095 4.206772249233171e-07 0.29469740877147 4.20677760655584e-07 0.3077798509628869 4.20678263914169e-07 0.3199778888071559 \
4.2067874911767e-07 0.3316516836183861 4.206792280403756e-07 0.3430829066939081 4.20679674471008e-07 0.3536501814456421 4.206801488007181e-07 0.3647819492304352 \
4.206805979917124e-07 0.3752331958288908 4.206810884639696e-07 0.3865396207984229 4.206816170367226e-07 0.3985997842463301 4.206819881810625e-07 0.4069920784971888 \
4.206825159354181e-07 0.4188173133762567 4.206829782921778e-07 0.4290642331729484 4.206834506243179e-07 0.4394285229343968 4.206839324090407e-07 0.4498981261869666 \
4.206839654481592e-07 0.4506126593745911 4.206840032071518e-07 0.45142837879914 4.20684078725137e-07 0.4530572051633331 4.206842297611073e-07 0.4563088938659436 \
4.206844372803726e-07 0.460764549126051 4.206846253191843e-07 0.4647825567212808 4.206848443283984e-07 0.469441659996985 4.206850871594094e-07 0.4745824626509371 \
4.206853869350375e-07 0.4808894567257585 4.206856247281872e-07 0.4858624696070272 4.206858879495879e-07 0.4913374535260851 4.206861488471327e-07 0.4967277906005185 \
4.206863784012197e-07 0.5014431429135263 4.206866014614136e-07 0.506003872007333 4.206868030374043e-07 0.5100983586086808 4.206869518674631e-07 0.51310967141356 \
4.206871961785157e-07 0.5180317772556589 4.206873287837491e-07 0.5206893064287169 4.206874681403308e-07 0.5234717264876519 4.206876791057242e-07 0.5276623644271943 \
4.206878539796058e-07 0.5311266030493931 4.206881220278524e-07 0.5364094032095129 4.206883170535098e-07 0.5402319029111832 4.206884966150174e-07 0.5437361368949839 \
4.206887475711459e-07 0.5486228351952749 4.20689024979257e-07 0.5540035987981641 4.20689308928559e-07 0.5594901708581531 4.206895645658505e-07 0.5644152233389156 \
4.206898555480696e-07 0.570006772487656 4.20690115853754e-07 0.5749917787111524 4.206903842978736e-07 0.5801232573974072 4.206906270630043e-07 0.5847450403362237 \
4.206908835942051e-07 0.5896146675871002 4.206911097576483e-07 0.59388771440121 4.206913470991427e-07 0.5983512154742827 4.206915564878602e-07 0.6022720321566808 \
4.206917702606284e-07 0.6062574570422776 4.206920237134688e-07 0.6109557890491497 4.206922265678164e-07 0.6146943332140289 4.206924193723378e-07 0.6182333111593361 \
4.206926096773651e-07 0.6217090173923294 4.206928003358541e-07 0.6251694921350958 4.206930029137796e-07 0.6288260100903066 4.206932656625422e-07 0.6335359534764116 \
4.206934946302321e-07 0.6376100987349322 4.206937145778672e-07 0.6414991146358265 4.206939402625401e-07 0.6454625140719233 4.206941491499662e-07 0.6491091855837361 \
4.206943708035853e-07 0.652957810138281 4.206945556930106e-07 0.6561429680377227 4.206947457075645e-07 0.6594017273991298 4.206948958626861e-07 0.6619630641908443 \
4.206950707405929e-07 0.6649292185271485 4.206952164613095e-07 0.6673855496832628 4.206953524938417e-07 0.6696641287411549 4.206955008561211e-07 0.672138295335571 \
4.206956303038336e-07 0.6742883907026684 4.206957641695307e-07 0.6764996355878535 4.206958925139303e-07 0.6786115243545502 4.206960179020585e-07 0.6806677490053815 \
4.20696147367755e-07 0.6827843190971332 4.206962783489702e-07 0.6849171426143115 4.206964267220724e-07 0.6873221141612875 4.206965347848267e-07 0.6890667486235877 \
4.206966633164996e-07 0.6911333958680312 4.206967987562836e-07 0.6933004139195943 4.206969236906071e-07 0.6952876996714908 4.206970494478751e-07 0.6972799977491608 \
4.206971559637663e-07 0.6989584331773744 4.20697273081655e-07 0.7007929859467624 4.206973916214007e-07 0.7026383448210159 4.206975149247975e-07 0.704545102273978 \
4.206976180976957e-07 0.7061304255463237 4.206977690688591e-07 0.7084341141567283 4.206978853230653e-07 0.7101955266062138 4.206980158834539e-07 0.7121605601685687 \
4.206981344459821e-07 0.7139335830373704 4.206982405198518e-07 0.7155108922888329 4.206983405447916e-07 0.716990346352101 4.206984778700066e-07 0.719009255813789 \
4.206985965313623e-07 0.7207429633399333 4.20698718230586e-07 0.7225107522614664 4.206988434131515e-07 0.7243181860083944 4.206989654329653e-07 0.7260693242762759 \
4.206990934647187e-07 0.7278954552757622 4.20699217946458e-07 0.7296603419865877 4.206993462457807e-07 0.7314685590147565 4.206994733395841e-07 0.7332489547570846 \
4.206995993644231e-07 0.7350034830462163 4.2069970210311e-07 0.7364262918236342 4.206998167758557e-07 0.7380063527755659 4.206998981819179e-07 0.7391232259175492 \
4.207000173814378e-07 0.7407496908814458 4.207001100237781e-07 0.7420059782745783 4.207002481828348e-07 0.7438668850244906 4.207003792383344e-07 0.7456179978167152 \
4.207005093705019e-07 0.7473439783685625 4.207006143445769e-07 0.7487266533969134 4.207007534844189e-07 0.7505456565005918 4.207009074287187e-07 0.7525407731682957 \
4.207010293729987e-07 0.7541080835708853 4.207011769193594e-07 0.7559892974429111 4.20701298924537e-07 0.7575320275232224 4.207014476244666e-07 0.7593968175435225 \
4.207015816710922e-07 0.7610632318338031 4.207017039243472e-07 0.7625711443351471 4.207018167902567e-07 0.763953046884334 4.207019596412247e-07 0.7656882893306027 \
4.207020863641194e-07 0.7672149413549471 4.207022021689945e-07 0.7685995877768005 4.207023319108228e-07 0.7701390587657672 4.207024476492106e-07 0.7715019052061673 \
4.207025706016372e-07 0.7729391548276606 4.20702688317297e-07 0.7743051053122872 4.207027942872733e-07 0.7755262985206828 4.207029106984675e-07 0.7768586864857919 \
4.207030173164004e-07 0.7780703956921795 4.207031295151206e-07 0.7793369495935717 4.207032161836897e-07 0.7803089322889447 4.207033195691813e-07 0.7814603789665585 \
4.207034327334326e-07 0.7827108149434853 4.207035383807156e-07 0.783868819044773 4.207036477202729e-07 0.7850578567336689 4.207037548972878e-07 0.786214126597127 \
4.20703884303365e-07 0.7875981444497275 4.207039967207506e-07 0.7887899291890393 4.207041201084898e-07 0.7900869036018625 4.207042375588255e-07 0.7913106402786101 \
4.207043810857437e-07 0.7927918312347375 4.20704496005322e-07 0.7939667362870242 4.207046347277352e-07 0.7953719780830618 4.207047727598755e-07 0.7967562205547866 \
4.207048822530295e-07 0.7978444364842524 4.207049832714595e-07 0.7988406866985471 4.207050843594198e-07 0.7998302780396641 4.207052167466158e-07 0.8011146558616069 \
4.207053354720369e-07 0.8022550163876687 4.207054572565424e-07 0.8034134048507504 4.207055763463359e-07 0.8045351524060473 4.207056975508533e-07 0.8056657048884367 \
4.207058291946645e-07 0.8068811249615274 4.207059522127029e-07 0.8080052413861453 4.207060798230234e-07 0.8091594649786741 4.20706210891683e-07 0.8103325925767672 \
4.207063342120463e-07 0.8114249716726942 4.207064421363105e-07 0.8123719892944993 4.207065499317031e-07 0.8133095350680949 4.20706631652631e-07 0.8140147772069938 \
4.207067485202474e-07 0.815015186305849 4.207068395812563e-07 0.8157880755829442 4.207069737498876e-07 0.8169164295805346 4.2070711832076e-07 0.8181184617099191 \
4.207072518231266e-07 0.8192158725965917 4.207073617890376e-07 0.8201107352847025 4.207075056546975e-07 0.8212684563313245 4.207076589602621e-07 0.8224861772268215 \
4.207077866985553e-07 0.8234883060891934 4.207079273408909e-07 0.8245786478120171 4.207080531244555e-07 0.8255423809867173 4.207082077424273e-07 0.8267124309768116 \
4.207083401541937e-07 0.8277017767197102 4.207084664337982e-07 0.8286345641820314 4.20708584064113e-07 0.8294941055817234 4.207087322309758e-07 0.8305638349826423 \
4.207088993752207e-07 0.8317531470681401 4.207090319938809e-07 0.832683775428688 4.20709204938569e-07 0.8338803479528284 4.207093733252244e-07 0.8350269493631071 \
4.207095428597542e-07 0.8361634673386688 4.207097242289089e-07 0.8373596561587384 4.207098668614913e-07 0.8382862741713709 4.207099807973396e-07 0.8390176620397163 \
4.207101115711344e-07 0.8398476357987267 4.207102132250742e-07 0.8404856735008092 4.207103297188026e-07 0.8412091703399448 4.207104652363492e-07 0.8420405885319162 \
4.20710662580143e-07 0.8432318270427018 4.20710853245141e-07 0.8443612543037786 4.207110631019802e-07 0.8455804035625291 4.207112440391043e-07 0.8466117334714958 \
4.207114413745909e-07 0.8477160230260256 4.207116151614274e-07 0.8486711109012058 4.207117977428814e-07 0.8496572451898022 4.207119690624607e-07 0.850566499179887 \
4.207121434475075e-07 0.8514760798656241 4.207123188310518e-07 0.8523748177975867 4.207124950632094e-07 0.8532619682996843 4.207126849014518e-07 0.8542000584728613 \
4.207128756376655e-07 0.8551245802328369 4.20713077434399e-07 0.856083442102113 4.207132701277753e-07 0.8569809170305027 4.207134797560765e-07 0.857937542729613 \
4.207137091938401e-07 0.8589615588718806 4.207139749904802e-07 0.8601183337444025 4.207142735657076e-07 0.8613802063570262 4.207145514672209e-07 0.8625196921548358 \
4.207148356776949e-07 0.8636511027355716 4.207151100894824e-07 0.8647118800460076 4.207153822523641e-07 0.8657341977214618 4.207156524214556e-07 0.8667205537246333 \
4.207159096161394e-07 0.8676338760342862 4.207161821558105e-07 0.868575115807136 4.207164581902909e-07 0.8695013130444248 4.207167283429862e-07 0.8703818891200001 \
4.207170280497877e-07 0.8713292845176382 4.207173988672582e-07 0.8724597217497643 4.207176937859212e-07 0.8733269024855727 4.207179480301993e-07 0.8740525764960509 \
4.207182462541985e-07 0.8748787854419284 4.207185198789691e-07 0.8756137195941651 4.207187560179586e-07 0.8762307200963571 4.207189963736862e-07 0.8768427579093606 \
4.207192187193381e-07 0.8773949085683344 4.207194127230722e-07 0.877865919014753 4.207197424471962e-07 0.878644045115768 4.207198976198553e-07 0.8790007149587372 \
4.207202153732479e-07 0.879712598742095 4.207203942386052e-07 0.8801026384247937 4.207207367000935e-07 0.8808283583858193 4.207209208412927e-07 0.8812073588304842 \
4.207213957461144e-07 0.8821499412898334 4.207215631406012e-07 0.8824705695712217 4.207220289718891e-07 0.8833323038036038 4.207222097967714e-07 0.8836551183393088 \
4.207227038300282e-07 0.8845051821644966 4.207228451726029e-07 0.8847400410050358 4.207234515631179e-07 0.8857071861637142 4.207236036356849e-07 0.8859397703602404 \
4.207242503137577e-07 0.8868873789663725 4.207243786102467e-07 0.8870678433440622 4.207250267232453e-07 0.8879435266410994 4.207251565285235e-07 0.8881118897635528 \
4.20725934785608e-07 0.8890711781604964 4.207260497804227e-07 0.8892053868933587 4.207269055110619e-07 0.8901454611437621 4.207270507776287e-07 0.8902951528450479 \
4.207280365337324e-07 0.8912364417375994 4.207282576409459e-07 0.8914302300078862 4.207294027520271e-07 0.892358484239638 4.207295339601744e-07 0.8924604119362172 \
4.207308752633695e-07 0.8934531785430913 4.207310266510305e-07 0.8935579568409697 4.207325081098674e-07 0.8944876667405802 4.207327469902294e-07 0.894621531696939 \
4.207345164619859e-07 0.8954958910368339 4.207349055688235e-07 0.8956641700186337 4.207372993342323e-07 0.8965498195158238 4.207377748942228e-07 0.8966991754584082 \
4.20741837950387e-07 0.8976977719002629 4.207423294244079e-07 0.8977905759376156 4.207506459514872e-07 0.8987839664765119 4.207515658053769e-07 0.8988472044554419 \
4.208777709459031e-07 0.8998441026240215 4.20878784754255e-07 0.8998514601858095 4.210704973474114e-07 0.8990059056521554 4.210707273489741e-07 0.8988405173838494 \
4.210723422215349e-07 0.8978439928078279 4.210725199353886e-07 0.8977495532019018 4.210892857104286e-07 0.8987316330193963 4.210894216988253e-07 0.8987497732072308 \
4.211048844279385e-07 0.8997471920221268 4.211051522925305e-07 0.8997526389354535 4.215889776197985e-07 0.9006560548284696 4.215890984089986e-07 0.9007687033315858 \
4.215898861800374e-07 0.9017381658104292 4.215900203187565e-07 0.901943163319478 4.215905139335305e-07 0.9027850367016239 4.21590658833145e-07 0.9030569221572713 \
4.215910546405301e-07 0.9038490360455199 4.215911744361842e-07 0.9041001886668685 4.215915586097176e-07 0.9049189780371781 4.215916707313647e-07 0.9051556495331843 \
4.215921780523356e-07 0.9061253139956988 4.215922720511916e-07 0.90626859229291 4.215934307008982e-07 0.9055667778886739 4.215935336638317e-07 0.9051589876696525 \
4.215936175067007e-07 0.9047707260375384 4.215937512467522e-07 0.9040404158978201 4.215938519641334e-07 0.9033957423200318 4.215939595799193e-07 0.9026166239542108 \
4.215940771531732e-07 0.9016533104038295 4.21594165418223e-07 0.90085556431878 4.215942850516912e-07 0.8996698288011099 4.215943823733893e-07 0.8986166602050341 \
4.215944933908277e-07 0.8973222354192386 4.215945955004155e-07 0.8960407982554908 4.21594678931815e-07 0.8949326975987755 4.215947831128827e-07 0.8934749428758865 \
4.215948741996463e-07 0.8921321265381427 4.215949667404319e-07 0.8907058396397178 4.2159506189443e-07 0.8891776325191247 4.215951764494069e-07 0.88725933118288 \
4.215952652925089e-07 0.8857137884271823 4.215953635316907e-07 0.8839502506198179 4.215954489018647e-07 0.8823735982707064 4.215955298021067e-07 0.8808434949738935 \
4.215956027633997e-07 0.8794355441897157 4.215956697820454e-07 0.8781198554636557 4.215957383931237e-07 0.8767515715160701 4.215958218880357e-07 0.8750591081124355 \
4.215958840153664e-07 0.8737811510706814 4.215959469979638e-07 0.8724704924326797 4.215960421537153e-07 0.8704632161180945 4.215961427643535e-07 0.8683077530860182 \
4.215962226435446e-07 0.8665738309361769 4.215963069058141e-07 0.8647250601592834 4.215963860160737e-07 0.8629723295901451 4.215964488315189e-07 0.8615696597604833 \
4.215965362885537e-07 0.8596016864744445 4.215966021820844e-07 0.8581079708060287 4.215966702436265e-07 0.856556281928966 4.215967195561343e-07 0.8554267461646872 \
4.215967747929236e-07 0.85415654045335 4.215968155325295e-07 0.8532164928603474 4.215968618342832e-07 0.8521450198670055 4.21596892048343e-07 0.8514441160591502 \
4.215969210896253e-07 0.8507691938976955 4.215969517282201e-07 0.8500558939662993 4.215970130054097e-07 0.8486254874746039 4.215970660779718e-07 0.8473828229799116 \
4.215971197331653e-07 0.8461232012188223 4.215971823904472e-07 0.8446482873934593 4.215972456733951e-07 0.8431545995644786 4.21597336171269e-07 0.8410121009440262 \
4.215974331690495e-07 0.8387078554355326 4.215975161465499e-07 0.8367307351423475 4.215975981509054e-07 0.8347721678896715 4.215976872193066e-07 0.8326403548070889 \
4.215977717326432e-07 0.8306135893189693 4.215978625915234e-07 0.8284303722590877 4.215979545263781e-07 0.8262176456275642 4.215980569573085e-07 0.8237486178045141 \
4.215981570753404e-07 0.8213320995840899 4.215982718962233e-07 0.8185572053828121 4.215983841027604e-07 0.8158423448209959 4.215985090963053e-07 0.8128151787794674 \
4.215986403567133e-07 0.8096337870015397 4.215987856277547e-07 0.8061104108175116 4.215989401353681e-07 0.8023613213197434 4.215991115759889e-07 0.7981999722344618 \
4.215992756257814e-07 0.794217661721315 4.215994600412032e-07 0.7897413884478564 4.215996665335768e-07 0.7847307375046715 4.215998560274198e-07 0.7801344622909899 \
4.216000494211826e-07 0.775444374634302 4.216002499880375e-07 0.7705834242206392 4.21600397552439e-07 0.7670092004965298 4.216005275638895e-07 0.7638619034739171 \
4.216006624283032e-07 0.7605987503374771 4.216007689187539e-07 0.7580234999254772 4.216009006085467e-07 0.7548403390839162 4.216010070329759e-07 0.7522693550468039 \
4.21601150211605e-07 0.7488125398635642 4.216013113387162e-07 0.7449250928176189 4.216014295655331e-07 0.7420746008290786 4.216015997983541e-07 0.7379721584775248 \
4.216017657246235e-07 0.7339761998059781 4.216019852669538e-07 0.7286940862104242 4.216021784540779e-07 0.724050920820232 4.216023533680413e-07 0.719851304223293 \
4.216025203151389e-07 0.7158476177432674 4.216027078061003e-07 0.711355754450834 4.216028952345367e-07 0.7068709122373377 4.216030635710959e-07 0.7028473835914892 \
4.216032564016302e-07 0.6982428782038785 4.216033964513775e-07 0.694901318858167 4.216035527086664e-07 0.6911769338170629 4.216037468781132e-07 0.6865540563080536 \
4.216039059846016e-07 0.6827702245679255 4.216040643446318e-07 0.679008548037742 4.216042596617402e-07 0.6743756772263459 4.216044700905194e-07 0.6693917663527935 \
4.216047227926646e-07 0.6634173774538097 4.216049024606155e-07 0.6591769455535931 4.216051540374889e-07 0.6532475027332399 4.21605354410306e-07 0.6485340174553987 \
4.216055260641582e-07 0.6445032789616798 4.216056847562747e-07 0.6407814961122935 4.216058239642021e-07 0.637522316374186 4.216059602882518e-07 0.6343349641335875 \
4.216060875012759e-07 0.6313646237382058 4.216062169938336e-07 0.6283457899522861 4.216063449851212e-07 0.6253646753452949 4.216064760596301e-07 0.6223174651643489 \
4.216066067717051e-07 0.6192830747181834 4.216067493797576e-07 0.6159760732208495 4.216068921032356e-07 0.612672916206165 4.216070446510367e-07 0.6091471600588 \
4.216071891550245e-07 0.6058158037532523 4.216073531732721e-07 0.6020406322262999 4.216074906379333e-07 0.5988837056407329 4.21607625454949e-07 0.5957940466067043 \
4.216077469535923e-07 0.5930134750293682 4.216078858038966e-07 0.5898448108574432 4.216079994507128e-07 0.5872554148224447 4.216081508608854e-07 0.5838116422847746 \
4.216082645795603e-07 0.5812320812748947 4.216083839926513e-07 0.5785269636915771 4.216084726731778e-07 0.5765205397309219 4.216085638182694e-07 0.5744630259469776 \
4.216086291571447e-07 0.5729901393713442 4.216086936268468e-07 0.5715377831648228 4.21608744447459e-07 0.5703933076453638 4.216088034223984e-07 0.569066051987989 \
4.216088708671064e-07 0.5675516747474645 4.216089379592979e-07 0.5660472084764079 4.216089908797418e-07 0.5648615894615425 4.216090865272254e-07 0.5627204246953637 \
4.216091437083616e-07 0.5614413394337 4.216091975109775e-07 0.5602399192081799 4.216092592530825e-07 0.5588634520375642 4.216093450862141e-07 0.5569525037715509 \
4.216094277818617e-07 0.5551133137453282 4.216095539105889e-07 0.552313430559463 4.216096890096646e-07 0.5493247407981657 4.21609787329828e-07 0.5471534914294828 \
4.216098999078898e-07 0.5446716589975775 4.216100024523052e-07 0.5424173856211837 4.216101225611309e-07 0.5397821662853191 4.216102242487819e-07 0.5375541863492928 \
4.216103397527456e-07 0.5350300289250629 4.216104546438614e-07 0.5325260225312031 4.216105811211341e-07 0.5297740207092871 4.216107063383297e-07 0.5270565158317848 \
4.216108531843123e-07 0.5238798967507053 4.216109886424458e-07 0.5209557060405445 4.216111462030546e-07 0.5175672114705414 4.216113083572294e-07 0.5140875588169389 \
4.216114890683071e-07 0.5102248342695275 4.216116813160604e-07 0.5061308236654174 4.216118940383231e-07 0.5016182665703952 4.216121259434839e-07 0.4967183500883584 \
4.216123831371877e-07 0.4913135654247419 4.216126226904984e-07 0.4863004534671564 4.216129246203734e-07 0.4800178499336004 4.216132123868145e-07 0.4740665530855001 \
4.216135251890574e-07 0.4676409412178996 4.216138450208061e-07 0.4611139840073785 4.21614184657409e-07 0.4542292677834274 4.216145118732278e-07 0.4476411633207955 \
4.216148470347968e-07 0.4409363684817221 4.216151642914576e-07 0.4346351592989786 4.216154981114363e-07 0.4280489847791872 4.2161584979678e-07 0.4211625252737479 \
4.21616163864498e-07 0.4150547397555842 4.216164868937019e-07 0.4088175946446666 4.216169278730989e-07 0.4003732788922496 4.216172702759421e-07 0.3938810608698495 \
4.216175707238305e-07 0.3882325136127223 4.216179460534016e-07 0.3812375944419973 4.216182761286299e-07 0.3751439175705365 4.216185594064112e-07 0.3699597784791666 \
4.216188599137726e-07 0.3645020109013299 4.216191395612329e-07 0.3594637112692664 4.216193634235237e-07 0.3554634414471464 4.216195752745134e-07 0.35170280677964 \
4.216197776231135e-07 0.3481338771034005 4.216199787581392e-07 0.3446120049995081 4.216201845356566e-07 0.3410324794262659 4.216204455143708e-07 0.3365252478245505 \
4.216206850045531e-07 0.3324209773202946 4.21620917679624e-07 0.3284665339262754 4.216211317612159e-07 0.3248537323113044 4.21621352906983e-07 0.3211475567840967 \
4.21621553789873e-07 0.3178053707831449 4.216217571810749e-07 0.3144500223650613 4.216219548494876e-07 0.3112139453100684 4.216221410931751e-07 0.3081862077816076 \
4.216223360742573e-07 0.3050391973134606 4.216225395365023e-07 0.3017803754370622 4.216227174774077e-07 0.2989521325826759 4.216229532011123e-07 0.2952356640875101 \
4.216231513339656e-07 0.2921385263640672 4.216233526780327e-07 0.2890160050544278 4.216235769672297e-07 0.2855690750291008 4.216237418971288e-07 0.2830551950838826 \
4.216239195258139e-07 0.2803657404651576 4.216241039249613e-07 0.2775946687427531 4.216242877463064e-07 0.2748547260732712 4.216244662029787e-07 0.2722194282383935 \
4.216246381032459e-07 0.2696976713509589 4.216247986436534e-07 0.2673699088296289 4.216249201257116e-07 0.265617282026588 4.216250730472387e-07 0.2634201198254058 \
4.21625200480934e-07 0.2616085083773952 4.216253046546046e-07 0.2601317890528609 4.216254215590816e-07 0.2584775571399547 4.21625536570573e-07 0.2568557450124987 \
4.216256609328034e-07 0.2551103168403305 4.216257765070866e-07 0.2534925198640895 4.216259106146075e-07 0.2516172680784447 4.216260256018485e-07 0.2500177396912131 \
4.216261793514453e-07 0.2478798443778067 4.216263161546458e-07 0.2459790966208961 4.21626450740453e-07 0.2441094379339017 4.216266066045887e-07 0.2419575875351012 \
4.216267312534115e-07 0.2402378086535915 4.216268704689347e-07 0.2383186229544463 4.2162700069296e-07 0.236525770455347 4.216271210458007e-07 0.2348769158236033 \
4.216272564390845e-07 0.233027137746051 4.216274076440629e-07 0.2309620730808924 4.216275424005331e-07 0.2291249940296414 4.216276470867202e-07 0.2277003186426776 \
4.216277696228612e-07 0.2260366668203369 4.2162790456742e-07 0.2242086518061946 4.216279996831675e-07 0.2229209267876512 4.216281149432224e-07 0.2213657311907907 \
4.216281974762018e-07 0.2202562617028589 4.216282686815329e-07 0.2192992955643472 4.216283173890172e-07 0.2186449771734718 4.216283645839733e-07 0.2180112263680214 \
4.216284111327915e-07 0.2173864029843717 4.216284645213553e-07 0.2166701476649976 4.216285018980252e-07 0.2161690444847812 4.216285392831377e-07 0.2156680710113931 \
4.21628579604508e-07 0.2151283464800275 4.216286508546475e-07 0.2141753141901174 4.216286850689041e-07 0.2137180869447317 4.216287314635346e-07 0.2131018213873352 \
4.216287919072008e-07 0.2122998083652294 4.216288609101202e-07 0.2113853596849882 4.216289262050716e-07 0.210520730631805 4.216289941831954e-07 0.2096212333552783 \
4.21629110629525e-07 0.2080823984153433 4.216292005517136e-07 0.2068957989735914 4.216293082176197e-07 0.2054771097790837 4.216294042789353e-07 0.2042146625011118 \
4.216295076575089e-07 0.2028641889872041 4.216296043425437e-07 0.2016026287683381 4.216297071523967e-07 0.2002625524503448 4.216298079123679e-07 0.1989526210414513 \
4.216299190580346e-07 0.1975116692735505 4.216300260975286e-07 0.1961279675313261 4.216301440040638e-07 0.1946083430154048 4.216302521143875e-07 0.1932197128021231 \
4.216303614129877e-07 0.1918224631760269 4.216304820447392e-07 0.1902849927564414 4.216305769453309e-07 0.1890796997295432 4.216307055062502e-07 0.18745262875399 \
4.216307985410385e-07 0.1862801166370808 4.216309009375946e-07 0.1849947785893032 4.216309889048857e-07 0.1838942174288659 4.216310871755573e-07 0.182668828510528 \
4.216311837761789e-07 0.1814691026470878 4.216312704146923e-07 0.1803971466393716 4.216313568237045e-07 0.1793305247657973 4.216314526608142e-07 0.1781527189679156 \
4.216315573876885e-07 0.1768710765218302 4.216317031999754e-07 0.1750963017969037 4.216318191679069e-07 0.1736923427161618 4.216319756317111e-07 0.1718092975148396 \
4.2163208681163e-07 0.1704786474822015 4.216322270616306e-07 0.1688098560703619 4.216323500730353e-07 0.1673544160765056 4.216324565640335e-07 0.1661007559767333 \
4.216325528894916e-07 0.1649724583647661 4.216326503229586e-07 0.1638357962207703 4.216327541762373e-07 0.1626293386330815 4.216328459768101e-07 0.1615673458739011 \
4.216329443645254e-07 0.1604337426303964 4.216330272831699e-07 0.1594828374885931 4.216331226515033e-07 0.1583950132920943 4.216332052138515e-07 0.1574587876231885 \
4.216333077985372e-07 0.1563016192679324 4.21633384076854e-07 0.1554454316211293 4.216334726624788e-07 0.1544557264474612 4.216335448319839e-07 0.1536532700165102 \
4.216336265414731e-07 0.1527486200895024 4.216337002202809e-07 0.1519363404455653 4.216337804404095e-07 0.1510573496788611 4.216338521684844e-07 0.1502755532525617 \
4.216339204254628e-07 0.149534520573691 4.216340181414224e-07 0.1484788062294206 4.216340875916063e-07 0.147731872792437 4.216341703430852e-07 0.1468455801890639 \
4.216342303799948e-07 0.1462052652532956 4.216343006186586e-07 0.1454587420502366 4.216343720461929e-07 0.1447037411390827 4.216344525596948e-07 0.1438588888651768 \
4.216345158225991e-07 0.1431977449412327 4.216345934965784e-07 0.1423892845091393 4.216346828063428e-07 0.141463758692191 4.216347521699289e-07 0.1407479403162204 \
4.216348501181493e-07 0.1397418416088305 4.216349404626691e-07 0.1388188591118084 4.216350262429942e-07 0.1379520826379384 4.21635093896779e-07 0.1372719511642241 \
4.216351602046294e-07 0.1366075914250998 4.21635238824321e-07 0.1358227655030745 4.216353195192302e-07 0.135020537018139 4.21635377921894e-07 0.1344419857224206 \
4.216354386744168e-07 0.1338420332148588 4.21635532580729e-07 0.1329184183639811 4.216355749782324e-07 0.1325029080242558 4.216356542224261e-07 0.1317336600863391 \
4.216356945925846e-07 0.1313430593815061 4.216357842934634e-07 0.130477658168832 4.216358232415503e-07 0.1301029732927899 4.216359188572359e-07 0.1291862249441596 \
4.216359577410651e-07 0.1288146335111444 4.21636050975841e-07 0.1279263274670414 4.2163611931843e-07 0.1272775968534341 4.216361716392852e-07 0.1267823325594629 \
4.216362537399991e-07 0.1260075984242486 4.216363249033783e-07 0.1253406747583812 4.216364028563663e-07 0.1246136378429537 4.216364819761022e-07 0.1238779526756392 \
4.21636560619333e-07 0.1231489004754178 4.216366406542416e-07 0.122409328367501 4.216367023886578e-07 0.1218405706457005 4.216367759836405e-07 0.1211645344030958 \
4.216368593634578e-07 0.120401093559758 4.216369234601888e-07 0.1198161795466899 4.216369928987769e-07 0.119184869057559 4.216370659217156e-07 0.1185234239195788 \
4.216371507966272e-07 0.1177582144838446 4.216372301594785e-07 0.117046673033812 4.216373148931361e-07 0.1162898833629492 4.216374056044255e-07 0.1154830714735263 \
4.216374811875037e-07 0.1148135241260771 4.216375469154284e-07 0.1142333070693714 4.216376069752011e-07 0.1137047561823949 4.216376765809174e-07 0.1130943456353956 \
4.216377429999685e-07 0.1125141752866663 4.216378224112316e-07 0.1118230150855203 4.216379126741612e-07 0.1110406875128299 4.216379817184613e-07 0.1104447270551955 \
4.216380562735805e-07 0.1098035355921305 4.216381447575013e-07 0.1090456469739195 4.216382238656483e-07 0.1083709350695736 4.216382937340289e-07 0.1077773127978274 \
4.216383747433988e-07 0.1070920034756896 4.216384309482126e-07 0.106618206733547 4.216384936074922e-07 0.1060916009495399 4.216385587540976e-07 0.105545887371837 \
4.216386300897258e-07 0.1049504956797945 4.216387503861013e-07 0.1039516085561449 4.216388019396737e-07 0.103525508500865 4.216388570887417e-07 0.1030709598036589 \
4.216389477859257e-07 0.1023262935955709 4.216390301757782e-07 0.1016530765296615 4.216391257555856e-07 0.1008759670630478 4.216392329651519e-07 0.1000092507657299 \
4.216393366245585e-07 0.09917656019160864 4.216394228321611e-07 0.09848810438956324 4.216395090743862e-07 0.09780303991321163 4.216395886154605e-07 0.09717448010577609 \
4.216396686283335e-07 0.09654538840876434 4.216397599166613e-07 0.09583163072761708 4.216398416620796e-07 0.09519620281310773 4.216399305889172e-07 0.09450872319168514 \
4.216400203662242e-07 0.09381864801001834 4.216400973288722e-07 0.09323024625953365 4.216401876536891e-07 0.0925435244861572 4.216402514624153e-07 0.09206084550525626 \
4.216403239259827e-07 0.09151514907748673 4.216403880546354e-07 0.09103438864950099 4.216404663020107e-07 0.09045054736970405 4.216405660032922e-07 0.08971110930136832 \
4.216406400564437e-07 0.08916512281998501 4.216407266649787e-07 0.08852997392441805 4.216408729646849e-07 0.08746544055362569 4.216409836769483e-07 0.08666684197409438 \
4.216410939866262e-07 0.08587717033461532 4.216412361822689e-07 0.08486839672072237 4.216413762347203e-07 0.08388450488753585 4.216415188805343e-07 0.08289222299161547 \
4.21641667651249e-07 0.08186778387581196 4.216418043639349e-07 0.08093569403044946 4.21641946484565e-07 0.07997640434545976 4.21642081061545e-07 0.07907728405019222 \
4.21642221281423e-07 0.07814997945867638 4.216423690282294e-07 0.07718353387841098 4.216425189824149e-07 0.07621348085094087 4.216426836982467e-07 0.07516037195605636 \
4.216428472843634e-07 0.07412732798506308 4.216430219327157e-07 0.07303837372665309 4.216432089864081e-07 0.07188781219077654 4.216434189729257e-07 0.0706159374129187 \
4.216436370461739e-07 0.06931715807027321 4.216438703663275e-07 0.06795188046253516 4.216441248458817e-07 0.0664909822812602 4.2164441780254e-07 0.06484528303377844 \
4.21644719953089e-07 0.06318745987130532 4.216450576747916e-07 0.06138078634948794 4.216454527833931e-07 0.05932807220464856 4.216458202346361e-07 0.05747953410674719 \
4.216462378424018e-07 0.05544691527644593 4.216465828383762e-07 0.0538196438399016 4.216469333806655e-07 0.05221302159193914 4.21647248341029e-07 0.0508087490907442 \
4.216475475823956e-07 0.049508488261462 4.216478469482477e-07 0.04824029756235761 4.216481221909583e-07 0.04710512226277328 4.216484056545246e-07 0.04596497870754415 \
4.216486672549465e-07 0.04493681260994405 4.216489447070712e-07 0.04387103439794762 4.216492207665063e-07 0.04283531238677037 4.21649529036243e-07 0.04170718945545093 \
4.216497514688635e-07 0.0409114719535993 4.21650039009947e-07 0.03990505631995635 4.216502752428796e-07 0.0390969788355163 4.216505937045548e-07 0.03803800466874574 \
4.21650844115589e-07 0.03722710566490722 4.216511671003914e-07 0.03620720400565681 4.216514254364062e-07 0.03541203096995557 4.216517154102846e-07 0.03454066075983582 \
4.216519452051025e-07 0.0338658635512188 4.216522301004437e-07 0.03304787219836024 4.21652469846563e-07 0.03237513696606491 4.216527104811323e-07 0.03171392889024889 \
4.216529495996188e-07 0.03107212555077287 4.216531855385298e-07 0.03045460689686571 4.21653416367391e-07 0.02986254663395104 4.216536313939186e-07 0.02932175456294728 \
4.216540335597598e-07 0.0283374222946415 4.2165423211788e-07 0.02786401170979088 4.216546058190659e-07 0.02699470773596776 4.216547926322608e-07 0.02657042318767052 \
4.216551386335082e-07 0.02580176906824739 4.216552605769465e-07 0.02553595448027303 4.216556434299635e-07 0.02472011952872977 4.216558038641492e-07 0.02438657631284594 \
4.216562468653031e-07 0.02348572425118655 4.216564174793446e-07 0.02314627247835563 4.216567380559406e-07 0.02251902970747987 4.216569383408681e-07 0.0221336684630111 \
4.216573852788009e-07 0.02128811173678137 4.216575132229166e-07 0.02104854104185888 4.21658001100276e-07 0.02014826272243131 4.21658136077553e-07 0.01990454278080647 \
4.216586183290713e-07 0.0190640092473091 4.216587806551862e-07 0.01879235028057063 4.216592670495271e-07 0.01801148170254873 4.216594300771863e-07 0.01776103207540622 \
4.216601102988766e-07 0.01676849304257711 4.216602493826145e-07 0.01657541006259178 4.216609818771477e-07 0.01560782569993242 4.216611407707804e-07 0.01540693214221847 \
4.216619238518671e-07 0.01445869962397344 4.216620696444218e-07 0.01428952172302696 4.216629204257814e-07 0.01334248985256295 4.21663031529053e-07 0.01322388191882306 \
4.216639648234166e-07 0.0122699293983148 4.216640986614658e-07 0.01213902814618388 4.21665057199482e-07 0.01123495036716388 4.216651783165509e-07 0.01112486091825863 \
4.216663004003486e-07 0.01017270671243764 4.216664059016017e-07 0.01008921053061839 4.216677349760139e-07 0.009112307258623473 4.216678551802884e-07 0.009029744095492466 \
4.21669403542048e-07 0.008036808760534916 4.216694843298185e-07 0.007986285493236449 4.216710552093519e-07 0.007024564730313319 4.216711226255509e-07 0.006986095570813155 \
4.216730433922295e-07 0.006001386377072119 4.216732301941131e-07 0.005914747648762168 4.216755456080606e-07 0.0049318160947762 4.216759451349076e-07 0.004777795182599986 \
4.216785089444083e-07 0.003889929704329555 4.216790078153284e-07 0.003736330440833864 4.21682637539317e-07 0.002784984367379526 4.216831882332918e-07 0.002663729254427667 \
4.216885866736714e-07 0.001711392372544448 4.216888999412434e-07 0.001662511220227468 4.216938922337914e-07 0.0006970413096974805 4.216940762528259e-07 0.0006571176749162138 \
4.243425553956096e-07 -0.0002691198397987355 4.243427114545721e-07 -0.0004551674219448388 4.243432594384272e-07 -0.001322174727784445 4.243433723764199e-07 -0.001539785040943742 \
4.243438016313498e-07 -0.002474302920374066 4.24343907888515e-07 -0.002730173903076456 4.243441906906666e-07 -0.003454402452283872 4.243443042852103e-07 -0.003760966378165151 \
4.243446428397891e-07 -0.004705104513819927 4.243447552637498e-07 -0.005021586953003071 4.243450835416507e-07 -0.005887841248467669 4.243451910801718e-07 -0.006130875888161453 \
4.243460710062032e-07 -0.005789627805322099 4.243462462122502e-07 -0.004910736584223327 4.243463630430134e-07 -0.004127745010746014 4.243464899101376e-07 -0.00309221842859156 \
4.243465914428629e-07 -0.002125750314016509 4.243467128641333e-07 -0.0008095618968406578 4.243468030290462e-07 0.0002767910803854594 4.243469002126957e-07 0.001550247908954045 \
4.243469982869598e-07 0.002938803805678211 4.243471655080454e-07 0.005530627736217106 4.243473878133234e-07 0.009378371294171852 4.243475735517141e-07 0.01290572951649239 \
4.243477976330495e-07 0.01747895571448658 4.243479572777817e-07 0.02091945933227325 4.243481217671113e-07 0.02459614091902196 4.243482715915693e-07 0.0280452875125503 \
4.243484209914613e-07 0.03156498790849799 4.243485705227667e-07 0.03515592969144176 4.243487246026614e-07 0.03891669635189081 4.243488867868089e-07 0.0429309674228065 \
4.24349053210035e-07 0.0470989728378523 4.243492291435082e-07 0.05154884981278444 4.24349410271779e-07 0.05616867911875007 4.243496024027047e-07 0.06110225049351239 \
4.24349810098117e-07 0.0664648391313285 4.243500320181979e-07 0.07222051812179281 4.243502672196804e-07 0.07834079218654426 4.243505194059893e-07 0.08491829088081257 \
4.243507955452241e-07 0.09213111703448683 4.243510966667008e-07 0.1000001933597138 4.243514285865622e-07 0.1086702418150647 4.243518059053303e-07 0.1185147411083515 \
4.243522041953866e-07 0.1288888856248832 4.243526735037065e-07 0.1410822143415975 4.243532195292308e-07 0.1552200475789812 4.243538544895379e-07 0.1715918832733369 \
4.243545538901293e-07 0.1895291194622146 4.243553721290552e-07 0.2103807608661494 4.243562778230217e-07 0.2332840710921665 4.243570673340878e-07 0.253091928008631 \
4.243577710929056e-07 0.2706124241987875 4.243583889437195e-07 0.2858796548825839 4.243589545671311e-07 0.2997575097153312 4.243594763024047e-07 0.3124620269501652 \
4.243599740861211e-07 0.3244932238414255 4.243604577240811e-07 0.3360954048923613 4.243609145982154e-07 0.3469667650518959 4.243613874391095e-07 0.3581213589834248 \
4.243618270524661e-07 0.3684065070151987 4.24362314929562e-07 0.379719432411247 4.243628457299846e-07 0.3919028193132517 4.243633436253595e-07 0.4032143644097119 \
4.24363775002613e-07 0.41292177789323 4.243642618898012e-07 0.4237731225600331 4.243647619892433e-07 0.4348012155672935 4.243651066099338e-07 0.4423321287141763 \
4.243654600037777e-07 0.4500000647748709 4.243658877736169e-07 0.4592134948422093 4.243662796346881e-07 0.4675816212925634 4.243665799290445e-07 0.4739471552041949 \
4.243669218601248e-07 0.4811428413521782 4.243672651945704e-07 0.4883132334011818 4.24367525955058e-07 0.4937215836208605 4.243677680115876e-07 0.4987106167174703 \
4.243680340100557e-07 0.5041617362307154 4.243682934982395e-07 0.5094435946950286 4.243684834145397e-07 0.5132872703533161 4.243686986491409e-07 0.5176241792560061 \
4.243688371999001e-07 0.5204025546691405 4.243689820806791e-07 0.5232962183003332 4.243691954947458e-07 0.5275364624051522 4.243693975193605e-07 0.5315382148201082 \
4.243695902480239e-07 0.5353370730264509 4.243697755034039e-07 0.5389735557287745 4.243699525009277e-07 0.5424323215059959 4.243702617642633e-07 0.5484573594957171 \
4.243705229123106e-07 0.5535233414883098 4.243708247314806e-07 0.5593562770234363 4.243710801601219e-07 0.5642781701956761 4.243713725156194e-07 0.5698968483756405 \
4.243716319698133e-07 0.5748654731717864 4.243719020897901e-07 0.5800301911327002 4.243721441003479e-07 0.5846380733684551 4.24372401610146e-07 0.5895273573494454 \
4.243726280544834e-07 0.5938057549890672 4.243728649429657e-07 0.5982619499065401 4.24373074987873e-07 0.6021962733001386 4.243732879185847e-07 0.6061670177072124 \
4.243735413972821e-07 0.6108668889270118 4.24373744692931e-07 0.6146150465592417 4.243739363811142e-07 0.6181346807088086 4.243741250074786e-07 0.6215812235468744 \
4.243743123254166e-07 0.6249823889551316 4.243745179374062e-07 0.6286953279350977 4.243747677606249e-07 0.6331759959753138 4.243749715724035e-07 0.6368063379741715 \
4.243751792111212e-07 0.6404826298163093 4.24375371862737e-07 0.6438748386876914 4.243756164748105e-07 0.6481531432733096 4.243758643733136e-07 0.6524620620600715 \
4.243760442082188e-07 0.6555644139995785 4.243762349822552e-07 0.6588391718544121 4.24376388158437e-07 0.6614554104590837 4.243765598271469e-07 0.6643705886591137 \
4.243767102939677e-07 0.6669108747194671 4.243768468979714e-07 0.6692010654183506 4.243769963383726e-07 0.6716954191563786 4.243771240725235e-07 0.6738189269502312 \
4.2437726394477e-07 0.6761323074508511 4.24377388021905e-07 0.6781756764962316 4.243775193832699e-07 0.6803315871556701 4.243776435547311e-07 0.6823627547057004 \
4.243777813315919e-07 0.6846081866267727 4.243779015758123e-07 0.6865586181592046 4.243780436284175e-07 0.6888545186016138 4.243781438561225e-07 0.6904668682779994 \
4.243782651601134e-07 0.6924123325129877 4.243783561353879e-07 0.6938641504265992 4.243784535186708e-07 0.695411869780077 4.24378550601538e-07 0.6969507228893711 \
4.243786398841584e-07 0.6983595753378042 4.243787378559428e-07 0.699898781449533 4.243788681310304e-07 0.7019319515314388 4.243790215432551e-07 0.7043083163565919 \
4.243791571090672e-07 0.7063909659299702 4.24379301449562e-07 0.708591461371511 4.243794273204452e-07 0.710496752775434 4.243795523478311e-07 0.712376488910674 \
4.243796666301914e-07 0.7140841686551523 4.243797776133356e-07 0.7157331888171029 4.243798773084046e-07 0.7172065512867005 4.243800143526226e-07 0.7192196995505324 \
4.243801333798347e-07 0.7209572005600779 4.24380253677943e-07 0.7227029412191364 4.243803801768634e-07 0.7245276185835638 4.243805041084668e-07 0.7263044524160376 \
4.243806283948001e-07 0.7280754330070212 4.24380754759953e-07 0.7298652243312684 4.243808845716946e-07 0.7316925631262517 4.243810084102138e-07 0.7334254795816325 \
4.243811411911006e-07 0.735272086289578 4.243812420423058e-07 0.7366670415914529 4.243813552339755e-07 0.738224777043618 4.243814420199563e-07 0.7394137384482823 \
4.243815586452529e-07 0.7410021813026957 4.243816479345105e-07 0.7422110784210975 4.243817591113937e-07 0.7437075443329063 4.243818883701577e-07 0.7454347509364776 \
4.243820022291937e-07 0.7469455276109591 4.243821066334058e-07 0.74832188588007 4.243822310004373e-07 0.7499498655229884 4.243823782406159e-07 0.7518616907275563 \
4.243824985209068e-07 0.753411006437983 4.243826144254459e-07 0.7548933175676444 4.243827545012897e-07 0.7566706674475765 4.243828971129601e-07 0.7584645678799224 \
4.243830150672032e-07 0.7599365027959469 4.243831418837122e-07 0.7615071445339606 4.243832827668562e-07 0.7632375905494565 4.243834025603537e-07 0.7646969139886852 \
4.243835475192107e-07 0.7664484133613445 4.243836690779963e-07 0.7679052725436226 4.243837881174897e-07 0.7693214142140735 4.243839097488533e-07 0.7707575700077021 \
4.243840377178316e-07 0.772256936813787 4.243841469330139e-07 0.7735272422640712 4.243842718238923e-07 0.774969549136603 4.24384378939953e-07 0.7761978171588899 \
4.243845121931473e-07 0.7777146071439789 4.243846392965933e-07 0.7791497354387434 4.243847610475684e-07 0.7805132846941326 4.243848776321507e-07 0.7818078758210534 \
4.24384983459753e-07 0.7829735233300771 4.243851228258954e-07 0.7844949153190801 4.243852718976944e-07 0.786105286864636 4.24385419626362e-07 0.7876841235632186 \
4.243855389322397e-07 0.7889471147195867 4.243856729390521e-07 0.7903527806482344 4.243857933652268e-07 0.791604423795974 4.243859349104043e-07 0.7930616786923709 \
4.243860823364167e-07 0.7945638089648995 4.243862068109252e-07 0.7958198087139573 4.243863258549181e-07 0.7970105506108808 4.243864374452017e-07 0.7981174590942314 \
4.243865426744905e-07 0.7991530841216606 4.243866381855941e-07 0.8000862307887144 4.243867742475476e-07 0.8014036057482816 4.243868911236816e-07 0.8025237700417888 \
4.243870102773537e-07 0.8036549841722296 4.24387132589548e-07 0.8048050501807249 4.243872558616218e-07 0.8059526272620129 4.243873823583984e-07 0.8071184350969989 \
4.243875078610623e-07 0.8082633544790385 4.243876385869669e-07 0.8094437311890262 4.243877641549387e-07 0.8105658358439867 4.243878932098036e-07 0.8117072367686948 \
4.243879990659606e-07 0.8126345588578442 4.243881002348366e-07 0.8135133322873783 4.243881948546566e-07 0.8143286754242188 4.243883191357402e-07 0.8153900871385379 \
4.243884088474262e-07 0.816149614585347 4.243885078849502e-07 0.8169816577628611 4.243886456628271e-07 0.8181280288377792 4.243887801986773e-07 0.81923501721715 \
4.243888886049436e-07 0.8201180631035904 4.243890385184474e-07 0.8213254631869725 4.243891890970255e-07 0.8225223201378843 4.243893145921802e-07 0.8235077122548546 \
4.243894584387069e-07 0.8246238332260477 4.243895830219706e-07 0.8255790649890803 4.243897318751914e-07 0.8267066458678887 4.243898680237751e-07 0.827725029289517 \
4.243899930476024e-07 0.8286494160599757 4.243901107545823e-07 0.8295103773055483 4.243902563935805e-07 0.8305630309532103 4.243904227748753e-07 0.8317484146982921 \
4.243905533585646e-07 0.8326660250626342 4.243907268806749e-07 0.8338683097812621 4.243908950025776e-07 0.8350147136930499 4.243910648651803e-07 0.8361549927788252 \
4.243912457668832e-07 0.8373497079260466 4.243913888761651e-07 0.8382806519784776 4.24391502965127e-07 0.839013953006387 4.243916331276036e-07 0.8398410866028793 \
4.243917349727342e-07 0.8404811280669765 4.243918517989402e-07 0.8412075886390841 4.243919886903802e-07 0.8420483852080155 4.243921864976039e-07 0.843243620449199 \
4.243923781227506e-07 0.8443797466267589 4.24392587554618e-07 0.8455974227529048 4.243927695012999e-07 0.8466352798309468 4.243929666301539e-07 0.8477391449715804 \
4.243931399710144e-07 0.8486924050423899 4.243933229793209e-07 0.8496814535024207 4.243934941423557e-07 0.8505903669473519 4.243936687794506e-07 0.851501688465695 \
4.243938440392814e-07 0.8524001683007644 4.243940201897297e-07 0.8532872510191711 4.243942104700295e-07 0.8542278331088334 4.2439440106916e-07 0.8551519386507073 \
4.243946016923949e-07 0.8561055033533737 4.2439479430095e-07 0.8570028516027762 4.243950049816413e-07 0.8579644845832216 4.243952330831089e-07 0.8589827023971403 \
4.243954988710916e-07 0.860139640227508 4.243957974838522e-07 0.8614018215255795 4.243960737724907e-07 0.8625348754565382 4.243963580090103e-07 0.8636666213345715 \
4.243966322137804e-07 0.8647267940813509 4.243969044486385e-07 0.8657495569722869 4.243971746527799e-07 0.8667361702337206 4.243974318083905e-07 0.867649441901348 \
4.24397704388604e-07 0.8685908808535525 4.2439798037489e-07 0.8695169452638583 4.24398250477721e-07 0.870397355937691 4.243985503347982e-07 0.8713451925332844 \
4.243989213624563e-07 0.8724761722512941 4.243992162997666e-07 0.8733433185969293 4.243994705892065e-07 0.8740690226522811 4.243997688459906e-07 0.874895168896023 \
4.244000424554269e-07 0.8756299040683481 4.244002785839137e-07 0.8762466977562872 4.244005189298274e-07 0.8768585021646264 4.244007412634921e-07 0.8774104263690854 \
4.244009352691695e-07 0.8778812671168952 4.244012649918855e-07 0.8786590883967833 4.244014201653189e-07 0.8790156160651978 4.244017379413894e-07 0.8797272612331356 \
4.244019168030317e-07 0.8801171459162566 4.244022592648612e-07 0.8808425821290963 4.244024433930207e-07 0.881221400612852 4.244029182707539e-07 0.8821634994206867 \
4.244030856669651e-07 0.8824839765989225 4.244035515089056e-07 0.8833452998114757 4.244037323309576e-07 0.8836679564577563 4.244042263693833e-07 0.8845176198113115 \
4.24404367718007e-07 0.8847523712107549 4.244049740520726e-07 0.8857188576377059 4.244051261213959e-07 0.8859512996759633 4.244057728095585e-07 0.8868983431897121 \
4.2440590110417e-07 0.8870786909355212 4.244065492212318e-07 0.8879538337624689 4.244066790202949e-07 0.8881220828502663 4.244074572237723e-07 0.8890807033877333 \
4.24407572278734e-07 0.8892148977954012 4.244084279402065e-07 0.8901543051721961 4.244085733010758e-07 0.8903040038307473 4.244095590571273e-07 0.8912446482480114 \
4.244097801624957e-07 0.8914382978987679 4.244109252894234e-07 0.8923659558950503 4.244110565064392e-07 0.8924678262926897 4.244123977150129e-07 0.8934599079028542 \
4.24412549114272e-07 0.8935646301988298 4.244140305519949e-07 0.8944937559627255 4.244142694313731e-07 0.8946275407274444 4.244160387469791e-07 0.8955013787854181 \
4.244164278981914e-07 0.8956696032899972 4.244188215611417e-07 0.8965547188539188 4.244192972701398e-07 0.8967039926079825 4.244233604302104e-07 0.8977020505850396 \
4.24423851854269e-07 0.8977948037134476 4.24432168453822e-07 0.898787348739254 4.244330883529499e-07 0.8988506593152591 4.245765735834803e-07 0.8998476076348748 \
4.245776920164557e-07 0.8998537475785264 4.247827836359558e-07 0.898985773748599 4.247830107254573e-07 0.8988224379910277 4.247846203322555e-07 0.8978282360369357 \
4.247847977407988e-07 0.8977338482811539 4.248017048890995e-07 0.8987315468430059 4.248018143281978e-07 0.8987460089186867 4.248175950494439e-07 0.8997418097871094 \
4.248178913753395e-07 0.8997476966799167 4.25301325027745e-07 0.9007060148833608 4.253014540780854e-07 0.9008313386292994 4.253021042279306e-07 0.9016292186224167 \
4.253022937236614e-07 0.9019133038041363 4.253027969456399e-07 0.9027675859898705 4.253029324182996e-07 0.9030208676018907 4.253033328770163e-07 0.9038195223753869 \
4.253034648149532e-07 0.9040958310886574 4.253038660300166e-07 0.9049509627747726 4.253039642901937e-07 0.9051582028152527 4.253044301640043e-07 0.9060587574877488 \
4.253045916627274e-07 0.9063060456044927 4.253057356752505e-07 0.9055153668657776 4.253058806545959e-07 0.9049059606760256 4.253060592073535e-07 0.9039396653125833 \
4.253062394026313e-07 0.9027054491383806 4.253063820935606e-07 0.9015369228101149 4.253064992531646e-07 0.9004524619440171 4.253065882345255e-07 0.8995505656965809 \
4.253066798781777e-07 0.8985529714258781 4.253068129901104e-07 0.8969831049011855 4.253069067111929e-07 0.8957895978311226 4.253069978500018e-07 0.8945634483845346 \
4.253071111423133e-07 0.8929516940777753 4.253072142512258e-07 0.8913998138690341 4.253073105184064e-07 0.8898830246517148 4.253074296555229e-07 0.8879200664089764 \
4.253075982407716e-07 0.8849885378698126 4.253077600122728e-07 0.8820195265790133 4.253079532313317e-07 0.8782956415026882 4.253081387944432e-07 0.8745571577041361 \
4.253083490607478e-07 0.8701566079887386 4.253085313097886e-07 0.8662213066841463 4.253087161731834e-07 0.8621339172744639 4.253088888583302e-07 0.8582419637438897 \
4.253090749664034e-07 0.8539816046497358 4.253092527824914e-07 0.849858603441091 4.253094334990722e-07 0.8456251963850057 4.253095986373313e-07 0.8417258760277182 \
4.253097639114333e-07 0.837798995916667 4.253099271590959e-07 0.8339004324287677 4.253100857493696e-07 0.8300982805770993 4.253102626737714e-07 0.8258418712800655 \
4.253104591875839e-07 0.8211009660847696 4.253106267441254e-07 0.8170498602679914 4.253107934845439e-07 0.8130123908857781 4.253109679080616e-07 0.8087844286215062 \
4.253111372776842e-07 0.8046757316210446 4.253113054767786e-07 0.8005936994537799 4.25311494325046e-07 0.7960093488074458 4.253116851408819e-07 0.7913773844868103 \
4.253118935230917e-07 0.7863203192056716 4.25312119942597e-07 0.7808277108969495 4.253123091427939e-07 0.7762391340290878 4.253125192894832e-07 0.7711455503222944 \
4.253126680579875e-07 0.7675418410361046 4.253127990509761e-07 0.7643705172588006 4.25312936616212e-07 0.7610417440783073 4.253130423674414e-07 0.7584842184275663 \
4.253131771410752e-07 0.7552262509102785 4.253132889738005e-07 0.7525244432456109 4.253134184089644e-07 0.7493992292091655 4.253135735976883e-07 0.7456545577979357 \
4.253136852334407e-07 0.7429626190147979 4.253138448080549e-07 0.7391166470929011 4.253140201296882e-07 0.7348935218456193 4.253142325051509e-07 0.7297828120356423 \
4.253144253876789e-07 0.7251458607116523 4.253145820889711e-07 0.7213823872711312 4.253147687636618e-07 0.716903961299824 4.253149576500111e-07 0.7123775767926828 \
4.253151485342027e-07 0.70780884692282 4.253153352821382e-07 0.7033444557767304 4.253155183669542e-07 0.698972331957095 4.253156556859354e-07 0.6956951921588121 \
4.253158089288925e-07 0.6920418367118417 4.253160040575431e-07 0.6873949992893974 4.253161613518718e-07 0.6836535194673684 4.25316320746467e-07 0.6798660670227984 \
4.253165164902601e-07 0.6752219404489795 4.253167086893939e-07 0.6706682621108646 4.253169436410222e-07 0.6651105611269369 4.2531713111727e-07 0.6606839627962382 \
4.253173683544039e-07 0.6550894036851447 4.253175575343661e-07 0.6506361170423679 4.253177381501785e-07 0.6463915264929231 4.253179018447415e-07 0.6425504277539856 \
4.253180463961504e-07 0.6391628119244788 4.2531818686792e-07 0.6358764726647652 4.253183139687075e-07 0.6329064225879303 4.253184462761836e-07 0.6298198307262635 \
4.253185728632297e-07 0.626870110582017 4.253187034434976e-07 0.62383130535404 4.253188327128966e-07 0.6208285625908692 4.253189718197929e-07 0.6176004736356133 \
4.253191203301029e-07 0.6141606483517721 4.253193098786583e-07 0.6097777958748198 4.253194555819145e-07 0.6064170107178907 4.253196906324778e-07 0.601007464699683 \
4.253198736317494e-07 0.5968099615921 4.253200979734226e-07 0.5916778694808832 4.253202691466717e-07 0.5877753019413697 4.253204014804909e-07 0.5847634284691802 \
4.253205332770303e-07 0.5817721407249107 4.253206398209335e-07 0.5793579518205488 4.25320735711292e-07 0.5771868999037388 4.25320828211542e-07 0.5750974572268882 \
4.25320920638905e-07 0.5730134868920421 4.253209930672116e-07 0.5713818265150021 4.25321048796317e-07 0.5701269325864891 4.253211099054046e-07 0.5687522410723198 \
4.2532120667008e-07 0.5665806864277688 4.253212681615946e-07 0.5652027770813386 4.253213272142164e-07 0.5638802801505602 4.253214028408818e-07 0.5621878686488651 \
4.253214698636602e-07 0.5606896577364279 4.253215434607697e-07 0.5590483558003441 4.253216110667724e-07 0.5575429304381756 4.253217271358289e-07 0.5549610936632026 \
4.253218273422345e-07 0.5527359403974305 4.253219393494244e-07 0.5502565947066531 4.253220338414751e-07 0.5481686943853854 4.253221549961726e-07 0.5454955387196141 \
4.253222551839389e-07 0.5432910220514219 4.253223711744508e-07 0.5407443765731218 4.253224788782885e-07 0.5383833065966291 4.253225884569768e-07 0.5359861028148916 \
4.253227005784207e-07 0.5335400310751951 4.253228275156047e-07 0.5307765704644959 4.253229496651232e-07 0.5281221248815906 4.253230894260376e-07 0.525095489155881 \
4.253232265641539e-07 0.522132778766487 4.253233765292441e-07 0.5189020692106626 4.253235353022474e-07 0.5154923220538846 4.253237093279044e-07 0.511765695450105 \
4.25323896158028e-07 0.5077823379664483 4.253241011259936e-07 0.5034264211640872 4.253243238349422e-07 0.4987133299464507 4.253245767391391e-07 0.4933874474923696 \
4.253248116930461e-07 0.4884604410272814 4.253251079613079e-07 0.4822828691822955 4.253253977512662e-07 0.4762763831984252 4.253257040870848e-07 0.4699660956099861 \
4.253260164056119e-07 0.4635767846525711 4.253263549710683e-07 0.4566963260653934 4.25326678082485e-07 0.4501741115777416 4.253270164777878e-07 0.4433881855507311 \
4.253273403090534e-07 0.4369378830387565 4.253276647034741e-07 0.4305204627449936 4.253280076377603e-07 0.4237851826852676 4.253283469185779e-07 0.4171698123421442 \
4.253286863932124e-07 0.4105997181257849 4.253291295050583e-07 0.4020958655332711 4.253294915732268e-07 0.3952155038183801 4.253298121249644e-07 0.3891775711374149 \
4.253301990595345e-07 0.3819561902961204 4.253305269297949e-07 0.3758957719299574 4.253308120888516e-07 0.3706704968427373 4.253311304576464e-07 0.3648820026298218 \
4.253314132885732e-07 0.3597820188690578 4.253316419773369e-07 0.3556924369094372 4.253318598701416e-07 0.3518226517641353 4.253320551194862e-07 0.3483769517668343 \
4.253322620275857e-07 0.344751588202948 4.253324768243417e-07 0.3410137651016431 4.253327290508921e-07 0.3366564674340092 4.253329710462048e-07 0.3325077909124976 \
4.253332018984844e-07 0.3285822460490526 4.253334167466748e-07 0.3249550452085373 4.253336371033643e-07 0.3212604562488142 4.253338386742641e-07 0.3179050685021769 \
4.253340417582106e-07 0.3145531374773136 4.253342396555968e-07 0.3113121771742085 4.253344267548364e-07 0.3082694484595072 4.253346206551795e-07 0.3051385396431291 \
4.253348257035143e-07 0.3018527636900292 4.253350059382659e-07 0.2989872106339772 4.253352418362775e-07 0.2952669081535775 4.253354431238275e-07 0.2921198200609627 \
4.253356445146313e-07 0.2889965001417216 4.253358691637942e-07 0.2855437159941698 4.253360345437678e-07 0.2830223598911593 4.253362123481056e-07 0.280330186126118 \
4.253363960043191e-07 0.277570343839212 4.253365812460764e-07 0.2748090658167894 4.253367593914542e-07 0.2721781298892599 4.253369329835173e-07 0.2696316866093095 \
4.253370933483699e-07 0.267306655456324 4.253372144595526e-07 0.2655585721882695 4.253373676543406e-07 0.2633570345323199 4.253374949857892e-07 0.2615475749425888 \
4.253375983136284e-07 0.2600830587034867 4.25337715638424e-07 0.2584225376281647 4.253378334453812e-07 0.2567591557214636 4.253379574091473e-07 0.2550199666844239 \
4.253380743933138e-07 0.2533821414201824 4.253382051894417e-07 0.2515535495016885 4.253383223995523e-07 0.2499173892700276 4.253384756526766e-07 0.2477853623028658 \
4.253386111831973e-07 0.2459029165157107 4.253387428644058e-07 0.244074199323236 4.25338899457317e-07 0.2419017673596028 4.253390246538746e-07 0.2401755227310949 \
4.253391603715014e-07 0.2383060149301216 4.253392927986628e-07 0.2364844144139329 4.253394127723238e-07 0.2348355337769661 4.253395758201609e-07 0.232606585912384 \
4.253397146272525e-07 0.230713852557009 4.253398531009719e-07 0.2288300961780371 4.253399586457212e-07 0.2273962817971701 4.253400870074011e-07 0.2256537837490921 \
4.253401911350241e-07 0.2242444877898851 4.25340291651026e-07 0.222886569499566 4.253403666954022e-07 0.2218745444235658 4.253404440284576e-07 0.2208349692306942 \
4.253405187916369e-07 0.2198305887827458 4.253405967553143e-07 0.218785487158918 4.253406516218243e-07 0.2180503923904892 4.253407081185998e-07 0.2172938400168352 \
4.253407515721192e-07 0.2167123195211523 4.253407916131654e-07 0.2161767335077376 4.253408308521132e-07 0.2156521099473339 4.253408717263501e-07 0.2151058606261434 \
4.253409258788401e-07 0.2143825797409383 4.253409642959715e-07 0.2138698309421548 4.253410035846784e-07 0.2133480458229882 4.253410651213865e-07 0.2125332203444249 \
4.253411270989155e-07 0.2117131287842428 4.253411835756643e-07 0.2109664019951111 4.253412482072545e-07 0.2101124842966758 4.253413437158761e-07 0.2088522205996687 \
4.253414310316075e-07 0.207701294711168 4.253415276412079e-07 0.2064291756790013 4.253416248707623e-07 0.2051510266126755 4.253417257178229e-07 0.2038307158897115 \
4.253418263175944e-07 0.2025192706911573 4.253419228088913e-07 0.2012627769767186 4.253420249910648e-07 0.1999338657614989 4.253421286307215e-07 0.1985898465970496 \
4.253422384047342e-07 0.1971698847140261 4.253423475797596e-07 0.1957617939809042 4.253424676778517e-07 0.1942174441246506 4.253425776973761e-07 0.1928086337505992 \
4.253426858092848e-07 0.1914295694688549 4.253428088379843e-07 0.1898652723262108 4.253428989485537e-07 0.1887234630454603 4.253430063140445e-07 0.1873671680421656 \
4.253430831253526e-07 0.1864004060894758 4.253431665706207e-07 0.1853535952511875 4.253432561024323e-07 0.1842338297700716 4.253433406678985e-07 0.1831790839553313 \
4.253434203840387e-07 0.1821880912968773 4.253435217092422e-07 0.1809331989518758 4.253436300564713e-07 0.1795959386230563 4.253437265321694e-07 0.1784102562612937 \
4.25343851909986e-07 0.1768766438339704 4.253439846934562e-07 0.1752616821119887 4.253441024642794e-07 0.1738362801839788 4.253442481158562e-07 0.1720835746408261 \
4.253443587130081e-07 0.1707596463148658 4.25344500843447e-07 0.1690680578777541 4.253446165530702e-07 0.1676985735146403 4.253447220270832e-07 0.166456424915798 \
4.253448165437425e-07 0.1653485352650968 4.253449121811146e-07 0.1642320043563913 4.253450092529585e-07 0.1631032360400927 4.253451083042124e-07 0.161956192050434 \
4.253452022277692e-07 0.1608730077890209 4.253452875034443e-07 0.1598934595213354 4.253453878832364e-07 0.1587475631033795 4.253454721860728e-07 0.1577906478848196 \
4.25345574585582e-07 0.1566342854655733 4.253456519798444e-07 0.1557646215197878 4.253457443247583e-07 0.154731814591042 4.253458145762303e-07 0.1539498814072817 \
4.253459107506593e-07 0.1528844393027091 4.253459875753224e-07 0.152038051282755 4.253460663454742e-07 0.1511758489440315 4.253461402383946e-07 0.150370438825067 \
4.253462079361382e-07 0.1496353997608715 4.253463040000261e-07 0.1485973848112393 4.25346373572453e-07 0.1478489919002561 4.253464574616254e-07 0.1469503328160803 \
4.253465185934615e-07 0.146298213254472 4.253465908615431e-07 0.1455309799806117 4.253466633001063e-07 0.1447677488542132 4.253467442811468e-07 0.1439178685120187 \
4.253468103556157e-07 0.1432275520600639 4.253468877561137e-07 0.1424219220725307 4.253469771315706e-07 0.1414956876531561 4.253470479922163e-07 0.1407644282175171 \
4.253471468792833e-07 0.1397487730030469 4.253472241981923e-07 0.1389620820751095 4.253473062434185e-07 0.1381330876879582 4.2534739435453e-07 0.1372467208126059 \
4.25347461981677e-07 0.1365690714953818 4.253475422788589e-07 0.1357674830239305 4.253476170628882e-07 0.1350239185327315 4.253476850640654e-07 0.1343502586094245 \
4.253477317469739e-07 0.1338891847862563 4.253478209985674e-07 0.1330118383700247 4.253478592216168e-07 0.1326395291833771 4.253479282135268e-07 0.1319690872918072 \
4.253479809615963e-07 0.1314578750898332 4.253480639543784e-07 0.1306559489775353 4.253481041328288e-07 0.1302688434457458 4.253481966502028e-07 0.1293805059784019 \
4.253482353685699e-07 0.1290098403727171 4.253483091292851e-07 0.1283055160094505 4.253483707572868e-07 0.1277188748199021 4.253484427849764e-07 0.1270353589407805 \
4.253485109520081e-07 0.1263909833196726 4.253485855741693e-07 0.1256908956540175 4.253486674266349e-07 0.1249253613889138 4.253487508807973e-07 0.124147338931438 \
4.25348823832511e-07 0.1234692772477456 4.253488965594407e-07 0.122795332839617 4.253489565494355e-07 0.1222410931008323 4.253490429174471e-07 0.121445549533078 \
4.253491038861646e-07 0.1208856452315438 4.253491622719555e-07 0.1203507897957366 4.253492279066197e-07 0.119751336354628 4.253492872608612e-07 0.1192111367930785 \
4.253493552926419e-07 0.1185941868697126 4.25349452587012e-07 0.11771710490035 4.253495310789918e-07 0.1170124163111649 4.25349621315123e-07 0.1162055395685231 \
4.253497171618085e-07 0.1153523005684616 4.253497921195047e-07 0.1146878351828532 4.253498964789213e-07 0.1137670532163148 4.25349983267518e-07 0.1130053589403202 \
4.25350092924934e-07 0.1120476726212376 4.253501744789968e-07 0.1113387926087848 4.253502700926292e-07 0.1105114393564785 4.253503468048225e-07 0.10985058581598 \
4.253504417232868e-07 0.1090364400125625 4.253505175463918e-07 0.1083889268999046 4.253505952460493e-07 0.1077282965354292 4.253506775775e-07 0.1070311517075373 \
4.253507371427637e-07 0.1065286079538068 4.253508009005013e-07 0.1059924133642201 4.253508619951089e-07 0.1054803128126646 4.253509578588471e-07 0.1046801683739134 \
4.253510027219415e-07 0.1043071445723913 4.253510859626872e-07 0.1036173314376927 4.25351135082509e-07 0.1032117000904133 4.253512441312713e-07 0.1023149933518279 \
4.253512889673535e-07 0.1019479364619093 4.253513792285848e-07 0.1012117400678687 4.25351420105203e-07 0.1008795969612472 4.25351490563617e-07 0.1003088525914566 \
4.253515768510382e-07 0.09961307626065434 4.253516686285974e-07 0.09887705578174606 4.253517381566897e-07 0.09832225024344161 4.25351816683849e-07 0.09769854072774181 \
4.253519074125254e-07 0.09698178745350861 4.25351983228664e-07 0.09638605854785212 4.253520652414071e-07 0.09574500473888557 4.253521469944435e-07 0.09510943278387665 \
4.253522375022672e-07 0.09440967388330095 4.253523270615646e-07 0.09372126988887708 4.253524126713984e-07 0.09306698857649189 4.253525054508965e-07 0.09236212353634379 \
4.253525863388571e-07 0.0917510971760913 4.253526874678274e-07 0.09099177263830999 4.253527679613525e-07 0.09039108594384238 4.253528522042178e-07 0.08976589684797046 \
4.253529260492652e-07 0.08922077348043934 4.253530028987434e-07 0.08865632925481931 4.253530910391125e-07 0.08801255002475737 4.253531711034816e-07 0.08743108261130086 \
4.253532641396717e-07 0.08675939571108145 4.253533821403849e-07 0.08591369538214398 4.253535245136124e-07 0.08490278100234279 4.253536687619621e-07 0.08388867104764453 \
4.253538110896711e-07 0.08289807427203813 4.253539606674147e-07 0.08186746790234835 4.253540969811606e-07 0.08093761126893445 4.253542391015919e-07 0.0799778356000513 \
4.253543736550197e-07 0.07907840240745091 4.253545140077296e-07 0.07814980287393705 4.253546616898023e-07 0.0771833418413561 4.253548118052992e-07 0.07621180464723754 \
4.253549765257765e-07 0.07515824360926991 4.253551401551281e-07 0.07412455432658185 4.25355314933688e-07 0.07303438636984133 4.253555021863042e-07 0.07188220095900363 \
4.253557122313082e-07 0.07060976590783831 4.253559304415312e-07 0.06930979572898451 4.253561638986196e-07 0.06794333957253913 4.25356418744638e-07 0.06648001693367038 \
4.253567118391949e-07 0.06483321328442151 4.253570141789572e-07 0.06317411115207273 4.253573287658326e-07 0.06148945259513613 4.253577250265267e-07 0.05942677493938087 \
4.253580587436719e-07 0.05774249301432461 4.253584660545012e-07 0.05574994498853819 4.253587939392599e-07 0.05419380357502902 4.25359150629899e-07 0.05254809000207299 \
4.253594638680598e-07 0.05114243792209583 4.253597668351931e-07 0.04981740498512215 4.253600643757185e-07 0.04854875663330436 4.253603431552738e-07 0.04739109061078805 \
4.253606261551693e-07 0.04624570307560639 4.253608878954772e-07 0.04521055793698023 4.253611671343699e-07 0.04413130357485813 4.253614392402902e-07 0.0431040186124033 \
4.253617466070472e-07 0.04197194005652995 4.25361968409948e-07 0.04117329707315532 4.253622748704283e-07 0.04009446155587663 4.253625010598812e-07 0.03931650950691581 \
4.253627399772065e-07 0.03851359500741255 4.253629644010393e-07 0.03777663690506906 4.253631666633204e-07 0.03712468825868943 4.253633677059489e-07 0.03648814235703791 \
4.253637194799833e-07 0.03540095449820539 4.253639697258209e-07 0.03464776841732944 4.253642160441008e-07 0.03392252499723709 4.253644973769647e-07 0.03311308780599518 \
4.253647404679504e-07 0.03242954897046491 4.253649759417007e-07 0.03178112583711486 4.25365217601206e-07 0.03113119522156456 4.253654544834836e-07 0.03050988948014832 \
4.25365685016041e-07 0.02991733361391674 4.253658989845686e-07 0.02937801894285819 4.253661049271158e-07 0.02886851641492237 4.253664976516028e-07 0.02792196059063811 \
4.25366685729283e-07 0.02747992420741849 4.253670611682489e-07 0.02661861215736662 4.253672360424775e-07 0.02622659266649364 4.253676593654916e-07 0.02530049759795254 \
4.253677806148756e-07 0.02504150687334681 4.253682211765283e-07 0.02412433837770948 4.253683636746477e-07 0.02383402682615681 4.253686957281575e-07 0.02316883068419595 \
4.253688786936821e-07 0.02280879143785283 4.25369267997886e-07 0.02205689891561978 4.253694363435941e-07 0.02173705378531499 4.253699084579933e-07 0.02085107653961301 \
4.253700482027269e-07 0.0205916297664938 4.253705437828048e-07 0.01969297428531048 4.253706710082374e-07 0.01946923320191776 4.253712389173419e-07 0.01851512288677271 \
4.253714031712902e-07 0.0182513999453204 4.253720130430286e-07 0.0173209960017622 4.253721727282572e-07 0.01708922829277545 4.253726996397978e-07 0.01635462467776483 \
4.253729041570907e-07 0.01608193551804103 4.253736276344778e-07 0.01515939662837778 4.253737930766099e-07 0.01495683325581705 4.253745396363563e-07 0.01408081084911163 \
4.253746729395689e-07 0.01393008075245666 4.253755331241552e-07 0.01299799962960837 4.253756692055701e-07 0.01285670227674402 4.253766097994594e-07 0.01192267652923807 \
4.253767735725333e-07 0.01176632439256516 4.253777747514646e-07 0.01084959205883911 4.253779122291873e-07 0.01072929995296418 4.253790829267985e-07 0.009787962024485789 \
4.253791753231659e-07 0.009718668544398181 4.253805933990138e-07 0.008725931027897449 4.253806803751621e-07 0.00866912727384293 4.253822213707926e-07 0.00770199130002063 \
4.253823306868068e-07 0.007633428668288294 4.253839739346293e-07 0.006673746291950173 4.253841067919082e-07 0.006603544020797993 4.253862011722063e-07 0.005605323336654431 \
4.253864095769411e-07 0.00551468736035817 4.25388763913366e-07 0.004577307911602986 4.253892374721228e-07 0.004407121484391641 4.253921229089796e-07 0.003492041675788492 \
4.253926525733265e-07 0.00334538389506189 4.253968608005519e-07 0.00237996320858989 4.253973742348033e-07 0.002283557532494709 4.254031334854955e-07 0.001325291758975802 \
4.254033680667129e-07 0.001279502680325907 4.254180358940879e-07 0.0002809017338477542 4.2541814896418e-07 0.0002788534805396912 4.280551690439302e-07 -0.0006849217749926401 \
4.280553352056058e-07 -0.0009443270389602415 4.28055814074993e-07 -0.001850320037528519 4.280559067946197e-07 -0.002050462221988249 4.280562720196971e-07 -0.002913187630468476 \
4.280563636768137e-07 -0.00314709230904735 4.280567297831652e-07 -0.004133001189868674 4.280568399302907e-07 -0.004442309109773816 4.280571506685429e-07 -0.005311341427314526 \
4.280572524071878e-07 -0.005583925258601597 4.280576161113131e-07 -0.00638370916272213 4.280577809576365e-07 -0.006585924750287024 4.280583607549566e-07 -0.005792290386912202 \
4.280585355894154e-07 -0.004916934050781314 4.280586522790152e-07 -0.00413641027497409 4.280587787087077e-07 -0.00310656561120747 4.280588807309106e-07 -0.002137079422087956 \
4.28059000577393e-07 -0.0008406209844352954 4.280590912146293e-07 0.0002489246187367611 4.280591896346795e-07 0.001536790859923857 4.280592893583236e-07 0.002948496343048522 \
4.280594568423325e-07 0.005545701385567424 4.280596754209339e-07 0.009327395936412004 4.280598614912559e-07 0.0128572688386996 4.280600828738638e-07 0.01737012273305725 \
4.280602435339974e-07 0.02082840415615294 4.28060406999647e-07 0.02447866954313523 4.280605576351642e-07 0.02794359528291388 4.280607066909169e-07 0.03145289236167962 \
4.280608561536706e-07 0.03504014479003619 4.280610101846837e-07 0.03879791952579481 4.280611723009431e-07 0.04280891157365373 4.280613383304077e-07 0.04696567134311741 \
4.280615142832281e-07 0.05141478668696391 4.280616949538655e-07 0.05602187592747932 4.280618867748118e-07 0.06094655248807559 4.280620938803164e-07 0.06629309753158302 \
4.280623154520462e-07 0.07203901748582854 4.280625501862155e-07 0.07814662931008168 4.280628017257829e-07 0.08470684589377442 4.280630771678493e-07 0.09190125212984442 \
4.280633773636676e-07 0.09974607960254324 4.280637082958779e-07 0.108390578238945 4.280640839626117e-07 0.1181923833971668 4.280644815454798e-07 0.1285487285136021 \
4.280649483700824e-07 0.1406786766767902 4.280654913626172e-07 0.1547396794802719 4.2806612478764e-07 0.1710742296429572 4.280668207276907e-07 0.1889259607126788 \
4.280676362848005e-07 0.2097135943149445 4.280685463129037e-07 0.2327316641523666 4.280693395691243e-07 0.2526372689279454 4.280700450441999e-07 0.2702038474981599 \
4.280706639884678e-07 0.2855008995781749 4.280712310944079e-07 0.2994177966724069 4.280717541744141e-07 0.3121574438576628 4.280722531532068e-07 0.3242197130846058 \
4.280727371932144e-07 0.3358335658028451 4.280731924200473e-07 0.3466679577370423 4.280736669320092e-07 0.3578644504627745 4.280741068407172e-07 0.368158604789619 \
4.28074592685345e-07 0.3794271463718566 4.280751242881185e-07 0.3916316501999784 4.280756269514167e-07 0.4030538969706937 4.280760560236697e-07 0.4127111343288326 \
4.280765470403382e-07 0.4236561147984291 4.280770484704186e-07 0.434714731975362 4.280773950150088e-07 0.442288187401736 4.280777504243856e-07 0.4500000616404133 \
4.280781776521144e-07 0.4592019891792938 4.28078569851637e-07 0.4675774400278049 4.280788702333951e-07 0.4739448723400065 4.280792120451549e-07 0.4811381049525967 \
4.280795554849688e-07 0.4883107756756314 4.280798162200955e-07 0.4937186470393492 4.280800582500486e-07 0.4987071765458648 4.280803241952915e-07 0.5041573145298286 \
4.280805814645869e-07 0.509394255416739 4.280807715836905e-07 0.5132422368582924 4.280809851098511e-07 0.5175451019736222 4.280811248001571e-07 0.5203466115392713 \
4.280812710004491e-07 0.5232668091041763 4.280814849883502e-07 0.5275186200231483 4.280816930046097e-07 0.5316389396023125 4.280818854658791e-07 0.5354321131715788 \
4.280820705821105e-07 0.5390651926504321 4.280822449555568e-07 0.5424725330931349 4.280825494976334e-07 0.5484058192982523 4.280828100565151e-07 0.5534602958276967 \
4.280831114875446e-07 0.5592859190791987 4.280833658051381e-07 0.5641865993769294 4.280836586613278e-07 0.5698153316805189 4.280839178744799e-07 0.5747800306938655 \
4.280841889508119e-07 0.579963273174682 4.280844307945714e-07 0.5845680738798381 4.280846882997289e-07 0.5894577538325241 4.280849150436047e-07 0.5937419314630586 \
4.280851520444244e-07 0.5982006324572362 4.280853622309863e-07 0.6021379329905048 4.280855749915204e-07 0.6061060319396779 4.280858278702861e-07 0.6107954169450593 \
4.280860315335545e-07 0.6145509252949414 4.280862222509359e-07 0.6180531102377972 4.280864095873744e-07 0.6214768531423983 4.28086598465652e-07 0.6249070011644339 \
4.280868066654474e-07 0.6286671070650327 4.280870509975622e-07 0.6330499453121026 4.280872505640949e-07 0.6366057789565548 4.280874547098357e-07 0.6402215701419991 \
4.2808763934909e-07 0.643474671963314 4.28087908884781e-07 0.6481901084955864 4.280881365916373e-07 0.652149230294136 4.280883242633752e-07 0.6553888277830079 \
4.280885051635202e-07 0.6584949378977958 4.280886647046019e-07 0.661221510907812 4.280888351670024e-07 0.6641177016088209 4.280889869184432e-07 0.6666817235716488 \
4.280891245614551e-07 0.6689905419339194 4.280892735563186e-07 0.6714784915997724 4.280894012981823e-07 0.6736028790357499 4.280895442846951e-07 0.675968899142866 \
4.280896660677513e-07 0.6779749688503388 4.280898023511611e-07 0.6802121872853304 4.280899221800626e-07 0.682172759947357 4.280900687756234e-07 0.6845626218370968 \
4.280901872485649e-07 0.6864845934661837 4.280902831819268e-07 0.6880368302455475 4.280903757015115e-07 0.6895284278106264 4.280904807620225e-07 0.6912169000724893 \
4.280905788439078e-07 0.6927871490736753 4.280907159592253e-07 0.6949707622226827 4.28090835157868e-07 0.6968607547931925 4.280909450978383e-07 0.6985951241089645 \
4.280910825970815e-07 0.7007503743809057 4.280912140269832e-07 0.7027960765825516 4.280913462564987e-07 0.7048392108129343 4.280914594338973e-07 0.7065756917706891 \
4.280916138667517e-07 0.708927873976708 4.280917446467452e-07 0.7109048231498766 4.280918673154548e-07 0.7127465601965561 4.280919735837112e-07 0.7143329262278221 \
4.280920959637349e-07 0.7161490373358268 4.280921978172318e-07 0.7176517022913665 4.280923319551315e-07 0.7196190116794019 4.280924526481717e-07 0.7213783352064487 \
4.280925717899705e-07 0.7231049829175343 4.280926968079846e-07 0.7249059312823601 4.280928266477907e-07 0.7267645120560844 4.280929464599617e-07 0.7284691779696002 \
4.280930754532131e-07 0.730293808329565 4.280932075602774e-07 0.7321507998840678 4.280933258660953e-07 0.7338038328985433 4.280934691267862e-07 0.7357927618453034 \
4.280935715814729e-07 0.7372070005703254 4.280936677883586e-07 0.7385290937783453 4.280937728059804e-07 0.7399656334130889 4.280938835775113e-07 0.7414708009413548 \
4.280939852560522e-07 0.7428439364018735 4.280940882175066e-07 0.7442258341871242 4.280942051436606e-07 0.7457850038572696 4.280943339039365e-07 0.747489965072781 \
4.28094435062908e-07 0.7488201182152049 4.280945839319523e-07 0.7507626302114226 4.280947316114891e-07 0.75267249971878 4.280948509768551e-07 0.7542038164026367 \
4.280949974606996e-07 0.7560679527984652 4.280951206361903e-07 0.7576223900169708 4.280952614398646e-07 0.7593848990234215 4.280953980325311e-07 0.7610800595258669 \
4.280955201903812e-07 0.7625841275516777 4.280956328467787e-07 0.7639610711610054 4.280957745729197e-07 0.7656796138775311 4.280959007394198e-07 0.767196844592689 \
4.280960161567243e-07 0.768574452686535 4.28096146464904e-07 0.7701179991486644 4.280962621775718e-07 0.7714782821591826 4.280963850018603e-07 0.7729116492687436 \
4.280965028461285e-07 0.7742769236963016 4.280966084761185e-07 0.7754922619072108 4.280967238495534e-07 0.7768108638983861 4.280968291127158e-07 0.7780056027231214 \
4.28096940062529e-07 0.7792565499870431 4.280970264670306e-07 0.7802246528436213 4.280971305008506e-07 0.7813823422463088 4.28097244396594e-07 0.7826398494046257 \
4.280973474300136e-07 0.7837684443710583 4.280974555127141e-07 0.7849432998269023 4.280975637643697e-07 0.7861107422109641 4.280976991816164e-07 0.7875582910536544 \
4.280978118557238e-07 0.7887521292973186 4.280979362797841e-07 0.7900592323105087 4.28098054252648e-07 0.7912877959129118 4.280981987206026e-07 0.7927781272271259 \
4.280983163897418e-07 0.7939806363584788 4.280984522695815e-07 0.7953567374150946 4.280985870139538e-07 0.7967081403609936 4.280986980849332e-07 0.7978123285366109 \
4.280987979742732e-07 0.7987978371087655 4.280988996542306e-07 0.7997937268659365 4.280990328678971e-07 0.8010867894381996 4.280991512407162e-07 0.8022243628210853 \
4.280992727817905e-07 0.8033812848148773 4.280993921454424e-07 0.8045065422543012 4.280995132768188e-07 0.80563739819571 4.280996449762361e-07 0.8068544426691319 \
4.280997679845129e-07 0.8079795872959963 4.280998958281203e-07 0.8091371804586788 4.281000267346398e-07 0.8103101881504271 4.28100150327798e-07 0.8114062915203997 \
4.28100257500303e-07 0.8123479140825919 4.281003649295024e-07 0.8132835730547656 4.281004475986206e-07 0.8139979974227743 4.281005653103806e-07 0.8150069815425507 \
4.281006559159858e-07 0.8157770472204025 4.281007865694307e-07 0.8168774959419571 4.28100930959301e-07 0.8180800468042847 4.281010641337151e-07 0.8191766687328477 \
4.281011740251065e-07 0.8200725423139092 4.281013176239916e-07 0.8212302325252553 4.281014710146833e-07 0.8224508494407716 4.281015990929081e-07 0.8234574467428303 \
4.281017388802764e-07 0.8245431382086058 4.281018651298391e-07 0.8255122018650548 4.281020197283917e-07 0.8266841987320058 4.281021519393684e-07 0.8276738265999063 \
4.281022781661507e-07 0.8286078934539939 4.281023959138743e-07 0.8294698388787296 4.281025449866676e-07 0.8305480062617677 4.281027123182206e-07 0.8317406852496945 \
4.281028455394968e-07 0.8326770812274722 4.281030183208196e-07 0.8338744310092966 4.281031868261935e-07 0.8350236380668206 4.281033562054924e-07 0.8361608866600232 \
4.281035378407611e-07 0.8373606451951652 4.281036801740827e-07 0.8382866867625347 4.281037940110689e-07 0.8390185116470331 4.28103925192579e-07 0.8398522525089582 \
4.28104026724794e-07 0.8404903982372576 4.281041430090543e-07 0.8412135669902132 4.281042776438078e-07 0.8420406924792603 4.281044746666439e-07 0.8432316292878405 \
4.281046647721864e-07 0.8443592803112207 4.281048748954986e-07 0.8455816023960827 4.281050552136043e-07 0.8466107566581813 4.281052526767048e-07 0.8477171937062282 \
4.281054267458196e-07 0.8486750118570332 4.281056090652401e-07 0.8496608982186138 4.281057804803758e-07 0.8505716849290491 4.281059545936529e-07 0.8514808063694008 \
4.281061303246211e-07 0.8523822271368225 4.281063064363214e-07 0.8532696099472232 4.281064960541732e-07 0.8542074684498208 4.281066868356705e-07 0.8551330189126392 \
4.28106888431747e-07 0.8560917259710515 4.281070811660049e-07 0.856990088884472 4.281072900378257e-07 0.8579439907476532 4.281075207402632e-07 0.8589743400177088 \
4.281077851832273e-07 0.8601259267840322 4.281080840059149e-07 0.8613896125360476 4.281083639602158e-07 0.8625380186322354 4.281086480860817e-07 0.8636694076724545 \
4.28108922855057e-07 0.8647317823994775 4.281091947122167e-07 0.8657531067718063 4.281094650893343e-07 0.8667403371654003 4.281097221678556e-07 0.8676533221001362 \
4.281099947926866e-07 0.868594905839151 4.281102707598356e-07 0.8695208838709013 4.281105408640933e-07 0.8704012674911344 4.281108407401039e-07 0.8713491368600049 \
4.281112118011625e-07 0.8724801680184872 4.2811150674079e-07 0.8733472453740196 4.28111761036548e-07 0.8740729094291386 4.281120592974738e-07 0.8748989982677786 \
4.281123329040153e-07 0.8756336613858092 4.281125690299577e-07 0.876250392688866 4.281128093740557e-07 0.8768621356511911 4.281130317061818e-07 0.8774140071409635 \
4.28113225712247e-07 0.8778848105679672 4.281135554349973e-07 0.8786625669521169 4.281137106085256e-07 0.8790190643519731 4.281140283876062e-07 0.879730644938159 \
4.281142072488645e-07 0.8801204696806418 4.281145497107611e-07 0.8808457867651537 4.281147338373631e-07 0.8812245477320809 4.28115208711942e-07 0.8821665346129511 \
4.281153761083518e-07 0.8824869809105039 4.281158419518539e-07 0.883348261932613 4.281160227735483e-07 0.8836708855253055 4.281165168126507e-07 0.8845204537290557 \
4.281166581620591e-07 0.8847551796839913 4.281172645001219e-07 0.8857215808967022 4.281174165693362e-07 0.8859539944113424 4.28118063256356e-07 0.8869009218298172 \
4.281181915512387e-07 0.8870812460539503 4.28118839667745e-07 0.8879562712787433 4.281189694676407e-07 0.8881245027440973 4.281197476783404e-07 0.8890830197250962 \
4.281198627254718e-07 0.8892171882189283 4.281207183963142e-07 0.8901564861234483 4.281208637440773e-07 0.8903061494816453 4.281218494996487e-07 0.8912466483555094 \
4.281220706077111e-07 0.8914402669210102 4.281232157277145e-07 0.892367747196105 4.281233469391586e-07 0.8924695935232408 4.281246882116238e-07 0.8934615053489913 \
4.281248396029001e-07 0.8935661991834861 4.281263210551204e-07 0.8944951400107031 4.281265599348161e-07 0.8946288932334222 4.281283293566539e-07 0.895502508848118 \
4.281287184779452e-07 0.895670668133377 4.281311122106538e-07 0.8965556062201232 4.281315877505926e-07 0.8967047758494365 4.281356508198176e-07 0.8977025964496719 \
4.281361422956535e-07 0.8977953148389237 4.281444588927963e-07 0.8987880790885289 4.281453787942481e-07 0.8988514070442593 4.282992423701678e-07 0.8998485708192639 \
4.283028854964575e-07 0.8998628537402877 4.285296142766717e-07 0.8989664306490068 4.285298446165833e-07 0.8988008565867064 4.285314595368805e-07 0.897804750401333 \
4.285316372691665e-07 0.8977103535805105 4.285484036692715e-07 0.8986978311584225 4.285485397684025e-07 0.8987160394686986 4.285637106086718e-07 0.8997133888183054 \
4.285639877135078e-07 0.899719468756186 4.290480289064218e-07 0.9005852143835333 4.290482022410388e-07 0.9007408621809421 4.290488627306383e-07 0.9015135064485434 \
4.290490287958205e-07 0.9017527716291757 4.29049555130528e-07 0.9026184054967997 4.290497462444476e-07 0.9029704910143604 4.290501104654996e-07 0.9036902342402512 \
4.290502896649215e-07 0.9040628043424317 4.290506515515938e-07 0.9048333795345931 4.290508466611638e-07 0.9052442844328937 4.290513790595253e-07 0.9062266394381637 \
4.290515614131638e-07 0.9064623886473868 4.290525533935561e-07 0.905594670761786 4.290527149341233e-07 0.9049318860608667 4.290528829265756e-07 0.9040378649110347 \
4.290530427580612e-07 0.9029782421366458 4.29053180254799e-07 0.9018984154159868 4.290533131621115e-07 0.9007052793196499 4.290534395875788e-07 0.8994328447569792 \
4.290535469868187e-07 0.8982475863895881 4.290536514834769e-07 0.8970047013543965 4.290537655331467e-07 0.8955451342423859 4.290538555027343e-07 0.8943225684615312 \
4.290539603213726e-07 0.8928208677113324 4.290540497696119e-07 0.891473284704788 4.290541321453926e-07 0.8901820884368528 4.290542232383926e-07 0.8887006634027688 \
4.290543605744706e-07 0.8863657732814155 4.290544590674027e-07 0.8846195012157601 4.290545711411528e-07 0.8825649218508906 4.290547020241858e-07 0.880080778639088 \
4.290548384952159e-07 0.8774018563482072 4.290549919493788e-07 0.8742910281085086 4.290551510437468e-07 0.8709679977889497 4.290553153276494e-07 0.867445283300377 \
4.290554719957507e-07 0.8640104344288071 4.290556240865311e-07 0.860615744772629 4.290557778002064e-07 0.857132398554192 4.290559373623814e-07 0.853469801378647 \
4.290560924510829e-07 0.8498714074018293 4.290562661304016e-07 0.8458039138600054 4.290564291612694e-07 0.8419559450883216 4.29056590803684e-07 0.8381170660338335 \
4.290567534504205e-07 0.8342344554797501 4.290569148689274e-07 0.8303657475978833 4.29057083463406e-07 0.8263109424305363 4.290572663565043e-07 0.8219002364007665 \
4.290574341852182e-07 0.8178440888239877 4.290576024710332e-07 0.8137703061148112 4.290577732990847e-07 0.8096302849976138 4.290579454736422e-07 0.8054541271740473 \
4.290581132355611e-07 0.8013830614994394 4.290582968650184e-07 0.7969255463994016 4.290584682714962e-07 0.7927646873948894 4.290586537148024e-07 0.7882638003278283 \
4.290588203854536e-07 0.7842196820467244 4.290589892715847e-07 0.7801233737411432 4.290591734278819e-07 0.7756572567105651 4.290593680379105e-07 0.7709405333854473 \
4.290595152932414e-07 0.7673736106648734 4.29059641923832e-07 0.7643079795643375 4.290597837806443e-07 0.7608754495129878 4.290598881844221e-07 0.7583505812556488 \
4.290600205770739e-07 0.7551502542766809 4.290601301612705e-07 0.7525028097975122 4.290602633259231e-07 0.7492875979647342 4.290604195076852e-07 0.7455190770546114 \
4.290605327371121e-07 0.7427887939149777 4.290606952584764e-07 0.7388718945951063 4.290608674392915e-07 0.7347246296492568 4.29061063444044e-07 0.7300078517193382 \
4.290612278340228e-07 0.7260553905833119 4.290613802307036e-07 0.7223944885043934 4.290615439058578e-07 0.718466402706526 4.29061711831558e-07 0.7144406657912139 \
4.290618916719358e-07 0.7101336212543717 4.290620679658861e-07 0.7059164985576465 4.290622390405214e-07 0.7018286413152719 4.29062407358697e-07 0.6978099102718778 \
4.290625606248287e-07 0.6941537154717222 4.290627225083983e-07 0.6902960245155986 4.290629014599385e-07 0.6860364417190952 4.290630356714899e-07 0.6828448068431195 \
4.290631391777878e-07 0.6803854168085423 4.290632384622005e-07 0.6780286039046017 4.290633399166766e-07 0.6756220912380299 4.290634323732757e-07 0.6734303711245889 \
4.29063516962075e-07 0.6714267031582685 4.290636105394115e-07 0.6692114082407524 4.290637270816307e-07 0.6664546942583044 4.290638365591918e-07 0.6638675763958631 \
4.290639496722031e-07 0.6611971533414394 4.290640727909702e-07 0.6582923426231613 4.290641970172829e-07 0.6553636581362478 4.290643677774271e-07 0.6513432847262797 \
4.290645262260144e-07 0.6476181700514572 4.290646985138371e-07 0.6435738126612673 4.290648444919037e-07 0.6401512360303271 4.290649862851197e-07 0.6368325564797357 \
4.290651178835739e-07 0.6337564355289309 4.290652480468588e-07 0.630718219665797 4.290653735717996e-07 0.6277924818644975 4.290655053547071e-07 0.6247239543970449 \
4.290656352782026e-07 0.6217046839485236 4.290657715867779e-07 0.6185408917806742 4.290659162003453e-07 0.615188962872713 4.29066075692536e-07 0.611499189008522 \
4.290662491526524e-07 0.6074939486938447 4.290664201599544e-07 0.6035554342946753 4.290666515285226e-07 0.5982402936372396 4.290668949905284e-07 0.5926661367297537 \
4.29067069111016e-07 0.5886942528256315 4.290672153830935e-07 0.5853638081576373 4.290673497553116e-07 0.58231230528805 4.290674668502067e-07 0.5796585826255305 \
4.290675626145532e-07 0.5774900935424465 4.290676614610955e-07 0.5752566196463251 4.290677454384143e-07 0.5733628024369305 4.290678230524635e-07 0.571614165956722 \
4.290678843779373e-07 0.5702331258704825 4.290679490585756e-07 0.5687779664863769 4.290680303667114e-07 0.5669528575016536 4.290680804367073e-07 0.5658306078972934 \
4.290681297572688e-07 0.5647256890740617 4.29068191677069e-07 0.5633393552914843 4.290682395088943e-07 0.5622690492396486 4.290682900136796e-07 0.5611395143522533 \
4.290683500757169e-07 0.559799205480933 4.290684093585124e-07 0.5584782058326896 4.290684844152261e-07 0.5568072508052372 4.290685540978827e-07 0.5552574373576753 \
4.290686396864492e-07 0.5533559356568912 4.290687267538207e-07 0.5514265885063823 4.290688104163414e-07 0.5495763264044081 4.290688965613662e-07 0.5476734676082877 \
4.290689922659868e-07 0.5455621222678217 4.290690965509387e-07 0.5432673229847179 4.290692112181133e-07 0.5407497407899529 4.290693199365745e-07 0.5383664115638558 \
4.290694295088142e-07 0.5359693749054023 4.290695418135745e-07 0.5335193270114367 4.290696685891956e-07 0.530759392645703 4.290697908664272e-07 0.5281021910076299 \
4.290699309524049e-07 0.5250685463469849 4.290700679697626e-07 0.5221084647952599 4.29070218271135e-07 0.5188705764247719 4.290703771663761e-07 0.5154582091324615 \
4.290705515002589e-07 0.5117250894133971 4.29070738517481e-07 0.5077378180012799 4.290709438354859e-07 0.5033745272871338 4.290711556776788e-07 0.498891131759938 \
4.29071408479721e-07 0.4935662239713107 4.2907161056737e-07 0.4893264048484654 4.290718451606753e-07 0.4844277613141263 4.290720812752722e-07 0.4795194943790256 \
4.290723344517689e-07 0.474283574581623 4.290726449817317e-07 0.4679020429045382 4.290728630397103e-07 0.4634451779596257 4.290730364853444e-07 0.4599153839204358 \
4.290732129777809e-07 0.4563351808422506 4.290734924595775e-07 0.4506930409909046 4.290737247034844e-07 0.4460279192631412 4.290740117970732e-07 0.44029020239849 \
4.290742296431809e-07 0.435960758243863 4.290744396957687e-07 0.4318042429497612 4.290746408936045e-07 0.4278406951573778 4.290748233137656e-07 0.4242617300271556 \
4.290749972087507e-07 0.4208637793449936 4.290751620728668e-07 0.4176529694331993 4.290753208268398e-07 0.4145718140694327 4.290754870737866e-07 0.4113577680628809 \
4.290756357189934e-07 0.4084923702366076 4.29075788087249e-07 0.4055658186126443 4.290759301504318e-07 0.4028468403491589 4.290760995263099e-07 0.3996150665462138 \
4.290762199082301e-07 0.3973276483660343 4.290763298814939e-07 0.3952449223617059 4.290764448068949e-07 0.3930732253581283 4.290765970484751e-07 0.3902080468194818 \
4.290767092695403e-07 0.3881039677199808 4.290768164620408e-07 0.386098874836553 4.290769689902897e-07 0.383254723448244 4.290770971374193e-07 0.380874963946598 \
4.290772199854117e-07 0.3786015923730871 4.290773990837881e-07 0.375299968600122 4.290775481684202e-07 0.3725653942578417 4.290777158758077e-07 0.3695018296724824 \
4.290778712734425e-07 0.3666748141177644 4.290779954402882e-07 0.3644243980538668 4.290781093321555e-07 0.3623666676050148 4.29078230775526e-07 0.3601804966264144 \
4.290784109272934e-07 0.3569532670533712 4.290785774151136e-07 0.3539878629329621 4.29078767834223e-07 0.3506138544217919 4.290789595908186e-07 0.3472380408565978 \
4.290791426402121e-07 0.344035729794033 4.290792916122767e-07 0.3414435189591631 4.290794115521823e-07 0.3393660536257183 4.290795342136651e-07 0.3372483242714233 \
4.290796572441514e-07 0.3351324902755385 4.29079802148562e-07 0.3326515017845288 4.290799054613373e-07 0.3308907757076019 4.290799991908464e-07 0.3292979229163631 \
4.290800898511484e-07 0.3277620998585528 4.29080200972602e-07 0.3258853746017661 4.290803081455789e-07 0.3240820510456246 4.290804064202303e-07 0.3224338250618513 \
4.290805188247763e-07 0.3205545940512134 4.290806827646764e-07 0.3178277446588927 4.290808444025551e-07 0.3151576097143818 4.290809921893013e-07 0.3127316247504084 \
4.290811544345159e-07 0.3100832165115083 4.290813144650734e-07 0.3074868334344322 4.290814667283718e-07 0.3050304870660137 4.290816201002421e-07 0.3025703731928215 \
4.29081778808771e-07 0.3000411640344692 4.290819432578998e-07 0.297437246442505 4.290821104849764e-07 0.2948063590562646 4.290822635965136e-07 0.292412731930112 \
4.290824466944405e-07 0.2895700146919417 4.290826370021783e-07 0.2866380344427262 4.290827859052365e-07 0.2843603072871506 4.290829598425416e-07 0.2817165165722222 \
4.290831367199302e-07 0.2790484233348025 4.290832843171486e-07 0.2768363681311815 4.290834739488487e-07 0.2740172295061162 4.290836239507675e-07 0.2718052906662373 \
4.290837610609577e-07 0.2697943906627059 4.290839025914008e-07 0.2677397479842996 4.290840160502698e-07 0.2661005451260196 4.290841523405964e-07 0.2641384584581135 \
4.290842824172175e-07 0.2622807416655737 4.290844006714701e-07 0.2606037730704709 4.290845185270663e-07 0.2589348966568543 4.290846494208769e-07 0.2570853888657079 \
4.290847896596348e-07 0.2551145527343576 4.290849051542211e-07 0.2534976852533538 4.290850340055979e-07 0.2516957519945816 4.290851491515796e-07 0.2500885525459272 \
4.290853024625469e-07 0.2479513765689386 4.290854403163083e-07 0.2460367343642474 4.290855797779604e-07 0.2441002375748529 4.29085735245815e-07 0.2419427021952501 \
4.290858600284303e-07 0.2402176526454788 4.290859998933384e-07 0.2382916534360561 4.290861285955144e-07 0.2365220787132559 4.290862495543663e-07 0.234860341242685 \
4.290863665996657e-07 0.2332541163798121 4.290864926007302e-07 0.2315368940272461 4.290865893203229e-07 0.2302195772445239 4.290866814091961e-07 0.2289683907689286 \
4.290867958266674e-07 0.2274152998827935 4.290868941973141e-07 0.2260807986508055 4.290870113441077e-07 0.2244933520241092 4.290871144352257e-07 0.2231010305483718 \
4.290872199499517e-07 0.2216798666278746 4.290873008680117e-07 0.2205933880575098 4.290873745391968e-07 0.2196046443759679 4.290874172684338e-07 0.2190314036349237 \
4.29087460398579e-07 0.2184540235451489 4.290875111960607e-07 0.217774515685755 4.290875483709394e-07 0.217277430841393 4.29087589041954e-07 0.2167338127731004 \
4.290876318337555e-07 0.2161620985357572 4.290876682448971e-07 0.2156758299561118 4.290877101698877e-07 0.2151161507306283 4.290877647120985e-07 0.2143884526296278 \
4.290878031708565e-07 0.2138756926875936 4.290878427976257e-07 0.2133496230586122 4.290879046301276e-07 0.212531488259555 4.290879663565787e-07 0.2117156525305126 \
4.290880224938542e-07 0.210974237875411 4.290880861490837e-07 0.210134110843225 4.290881802401172e-07 0.2088936328424611 4.290882670483761e-07 0.2077505933124353 \
4.290883610050201e-07 0.2065146061917991 4.290884590472537e-07 0.2052266823513323 4.290885606346195e-07 0.2038976009052371 4.290886615435679e-07 0.2025832113009377 \
4.290887582793767e-07 0.2013244528083448 4.290888604043477e-07 0.1999972806373927 4.290889637359055e-07 0.1986583046056677 4.29089073618507e-07 0.1972379690671278 \
4.290891825607647e-07 0.1958337611883887 4.290893023958847e-07 0.1942937175364915 4.290894126797513e-07 0.1928822800638286 4.290895205584963e-07 0.191507108810815 \
4.290896466212543e-07 0.1899051957406391 4.290897364889608e-07 0.1887671190866151 4.290898469673e-07 0.1873723090993208 4.290899245002487e-07 0.1863971337376019 \
4.290900088239919e-07 0.1853400660204312 4.2909009641205e-07 0.1842452710069853 4.290901842046442e-07 0.18315095174413 4.290902659245155e-07 0.1821357652581398 \
4.290903634861928e-07 0.1809282658474054 4.290904701973441e-07 0.1796118512064394 4.29090570679026e-07 0.178377576484793 4.290906948502376e-07 0.1768595317522179 \
4.290908287417608e-07 0.1752320886156309 4.290909476539533e-07 0.1737937102924047 4.290910980541469e-07 0.1719851742607024 4.290912088892401e-07 0.1706594030660365 \
4.290913486559821e-07 0.168997130456427 4.290914671812902e-07 0.1675953052211382 4.29091572608521e-07 0.1663548750207849 4.290916673183802e-07 0.1652455210322802 \
4.290917606281544e-07 0.1641568522804657 4.290918615342705e-07 0.1629842804551663 4.290919569521023e-07 0.1618800504313296 4.290920541430255e-07 0.1607598891027116 \
4.290921357045071e-07 0.1598237474547246 4.290922410209519e-07 0.1586229753023833 4.290923245006587e-07 0.1576763029943549 4.290924260299495e-07 0.1565306813704828 \
4.290925032604858e-07 0.1556635090415242 4.29092594132523e-07 0.154647919213242 4.290926634838334e-07 0.1538765336840219 4.290927480678846e-07 0.1529397840535594 \
4.290928224610911e-07 0.1521208717489242 4.290929018312932e-07 0.151251902275755 4.290929764189645e-07 0.1504388356812226 4.290930456405211e-07 0.1496871728711989 \
4.290931403213281e-07 0.1486640077242138 4.29093210087093e-07 0.1479134441579097 4.290932945316558e-07 0.147008717574758 4.290933560970016e-07 0.1463518850554192 \
4.290934301394933e-07 0.1455673550676988 4.290935035250169e-07 0.1447940960774066 4.290935849602586e-07 0.1439395015691976 4.290936544094048e-07 0.1432139999234875 \
4.290937295111024e-07 0.1424323701137583 4.290938194231735e-07 0.1415006120834361 4.290938965067932e-07 0.1407052977810757 4.290939956173774e-07 0.1396885207473417 \
4.290940651574398e-07 0.138983077430453 4.290941464759156e-07 0.1381612812129989 4.290942166443247e-07 0.1374549162714094 4.290942956124378e-07 0.1366629455350578 \
4.290943745907205e-07 0.1358740351737466 4.290944469125105e-07 0.1351544405911459 4.290945162779692e-07 0.1344667589602006 4.290945649819766e-07 0.1339854049281765 \
4.290946557443483e-07 0.1330945614011112 4.290946877658758e-07 0.1327823711724506 4.290947758698441e-07 0.131925672678654 4.290948083638864e-07 0.1316105445757083 \
4.290949070315436e-07 0.1306564447580443 4.290949506875193e-07 0.130235859061297 4.290950286693357e-07 0.1294866595045693 4.290950660002936e-07 0.1291289430202982 \
4.290951681516938e-07 0.128153223240932 4.290952355956539e-07 0.1275115375392494 4.290953007486116e-07 0.1268935577290946 4.290953666546259e-07 0.1262729746041904 \
4.290954378066093e-07 0.1256052797936485 4.290955207439704e-07 0.1248293808775363 4.290956061394508e-07 0.1240331657139879 4.290956822268445e-07 0.1233259817834828 \
4.290957626875214e-07 0.1225806238777534 4.290958207714622e-07 0.1220441728027253 4.29095892104936e-07 0.1213870835332726 4.290959768933693e-07 0.1206085709991845 \
4.290960380484021e-07 0.1200487744399507 4.290961081348534e-07 0.1194096117168642 4.290961706401422e-07 0.1188419501154776 4.290962366450903e-07 0.1182453094891599 \
4.290963054178569e-07 0.1176255789053269 4.290963748744814e-07 0.1170017375875525 4.29096458038731e-07 0.1162574953874909 4.290965311562548e-07 0.1156056107435251 \
4.29096601870241e-07 0.1149774116339468 4.290966612219237e-07 0.1144518657417393 4.290967665191357e-07 0.1135239342411639 4.290968123866298e-07 0.1131212254602471 \
4.290968993406834e-07 0.1123603821649216 4.290969423544638e-07 0.1119852310621949 4.290969872212112e-07 0.1115947726395539 4.29097076954706e-07 0.1108164664143028 \
4.290971478390574e-07 0.110204256460374 4.290972266925708e-07 0.109525796983828 4.290972894703463e-07 0.1089876103666232 4.290973494647019e-07 0.1084750215669379 \
4.290974604624741e-07 0.1075310013968523 4.2909754121676e-07 0.1068475792877216 4.290976536800859e-07 0.1059005796323111 4.290977048246292e-07 0.1054717782906781 \
4.290977878097979e-07 0.1047785948356612 4.290978459745031e-07 0.1042945647727652 4.29097960212503e-07 0.1033482075721767 4.290980101159701e-07 0.1029366076865433 \
4.290980958575694e-07 0.1022320954501846 4.290981448890196e-07 0.1018307629303728 4.290982274554409e-07 0.101157455862875 4.290982983877772e-07 0.1005815064560546 \
4.290983665381274e-07 0.1000302812267231 4.290984441484433e-07 0.0994053199805509 4.290985164918144e-07 0.09882546240595018 4.29098594067778e-07 0.09820656846618626 \
4.290986827384394e-07 0.09750287271560702 4.290987565532273e-07 0.09692010793638871 4.290988381442348e-07 0.09627924899616347 4.290989162827031e-07 0.09566870926115327 \
4.290990020324936e-07 0.09500229249765579 4.290990897294021e-07 0.09432453920671229 4.290991836389668e-07 0.09360304191323381 4.290992800982852e-07 0.09286661217778783 \
4.290993587289458e-07 0.09226977907248698 4.290994614525456e-07 0.09149473120661993 4.290995452801959e-07 0.09086620530027881 4.290996660323777e-07 0.08996702094116031 \
4.29099795302029e-07 0.08901247130467421 4.290999511904932e-07 0.08787237469953549 4.291001062900762e-07 0.08675000010972149 4.291002633058824e-07 0.08562614142917294 \
4.291004433267348e-07 0.08435280068725284 4.291005938476015e-07 0.08330035525696428 4.291007422216238e-07 0.08227363395463329 4.291008798388548e-07 0.08133079092382095 \
4.291010197585049e-07 0.08038162993974078 4.291011563654933e-07 0.07946425488810546 4.291012950927907e-07 0.07854214404995859 4.291014404036529e-07 0.07758663187171365 \
4.29101588151466e-07 0.07662571164688473 4.291017467483332e-07 0.07560598447141591 4.29101911000851e-07 0.07456266320243836 4.291020800179273e-07 0.07350246718885647 \
4.29102261906921e-07 0.07237646636762114 4.291024625290194e-07 0.07115268999588262 4.291026764065622e-07 0.0698691158856425 4.291029040406938e-07 0.0685263410462881 \
4.291031456262355e-07 0.06712722147996912 4.29103427215414e-07 0.06552977831071743 4.291037243695346e-07 0.06388229915275011 4.291040478026115e-07 0.06213267023812474 \
4.29104438962031e-07 0.0600758559534558 4.29104840456333e-07 0.05803293250078725 4.291052173970595e-07 0.05617754872181892 4.291055845107909e-07 0.05442503025024555 \
4.291059346274713e-07 0.05280240270907886 4.291062539331247e-07 0.05136309724710254 4.291065582574072e-07 0.05002640192327024 4.291068551633126e-07 0.04875503464657577 \
4.291071371636386e-07 0.04757867888787161 4.291074175969432e-07 0.04643900623749339 4.291076823205669e-07 0.04538777697325767 4.291079582182789e-07 0.04431704973151576 \
4.291082326831433e-07 0.04327654260273706 4.291085311024235e-07 0.04217254828989973 4.291087576184799e-07 0.04135316230013186 4.291090695313176e-07 0.04025053053625379 \
4.291092897861088e-07 0.03948972371590862 4.291095070508635e-07 0.03875470657060948 4.291097167735126e-07 0.03806113111453101 4.291100269559001e-07 0.03705828856757609 \
4.291102495537778e-07 0.03635538859683734 4.29110496919279e-07 0.03559019656168042 4.291107693256556e-07 0.03476651972027592 4.291109899582094e-07 0.03411384091885184 \
4.291112742384598e-07 0.03329124852897781 4.291115121517525e-07 0.0326183788879464 4.291117502411637e-07 0.03195887699386461 4.291119854964917e-07 0.03132132139405813 \
4.291122142751987e-07 0.03071728735992773 4.291124470059479e-07 0.03011490821398154 4.291126663089891e-07 0.02955843195412813 4.291128702520595e-07 0.02905055018162466 \
4.291132691617956e-07 0.02808303002558106 4.291134563160508e-07 0.02764052191221165 4.29113828521772e-07 0.0267814187683372 4.29114015473295e-07 0.02635997027055515 \
4.291143848272417e-07 0.02554620807076183 4.291145384804101e-07 0.02521471147941385 4.291149546945643e-07 0.02434161493068329 4.291151601823807e-07 0.02392065165079968 \
4.291154991903413e-07 0.02323955384462723 4.291156818850694e-07 0.02287916718068597 4.291161389789784e-07 0.02199597290476789 4.291162687197143e-07 0.02174967209293581 \
4.291167221401377e-07 0.02089828923199067 4.2911686451243e-07 0.0206336680476187 4.291173940791906e-07 0.01967289368906444 4.291175202861975e-07 0.01945139161001456 \
4.291180825206354e-07 0.01850749734048266 4.29118245259022e-07 0.01824627541187189 4.291188094390872e-07 0.01738327200207762 4.291189611831539e-07 0.01716165742474803 \
4.291196628626383e-07 0.01618760396393164 4.291198329517282e-07 0.01596324388168 4.291204880096043e-07 0.01513221026437959 4.291206545239164e-07 0.01492874613340729 \
4.291213876376758e-07 0.01406966818047924 4.291215209008543e-07 0.01391906482409888 4.291223725580289e-07 0.01299647369571925 4.291225105004775e-07 0.01285324185793544 \
4.291234505599668e-07 0.0119198170026788 4.29123614321604e-07 0.01176347583728811 4.291246015550385e-07 0.01085909507266535 4.291247361441145e-07 0.0107410715025141 \
4.291258775835447e-07 0.009819907073012045 4.291259858224434e-07 0.009738548299709823 4.29127309069827e-07 0.00880579379490502 4.291274418155253e-07 0.008718202093769473 \
4.291289643166501e-07 0.007760835273143199 4.29129076858719e-07 0.007690148685505111 4.291307691503061e-07 0.00669558715138598 4.291309094168915e-07 0.00662113250846694 \
4.291329824261937e-07 0.005629132576249021 4.291331749877106e-07 0.005545002188831318 4.291353851975589e-07 0.004656096148610405 4.291357919842319e-07 0.004507219767123045 \
4.291386137242086e-07 0.003590578528330178 4.291391350199587e-07 0.00344214578404881 4.291433471210094e-07 0.002447529662748036 4.291438996838773e-07 0.002340875287107731 \
4.291497829734169e-07 0.001359168649576994 4.291500322464151e-07 0.001311490127959886 4.291631823674654e-07 0.0003136950974005476 4.291632991504353e-07 0.0003112730584132499 \
4.589900000000113e-07 3.042397160644726e-06 5.027466670270133e-07 -0.0009024818035526668 5.027467394426295e-07 -0.001022682652537627 5.02747175467347e-07 -0.001858525046639076 \
5.027472623617301e-07 -0.002046124893065343 5.027476170650434e-07 -0.00288168582347465 5.027477166116441e-07 -0.003135075204051477 5.027479768813486e-07 -0.003828199033013717 \
5.027481172037501e-07 -0.004216406518003108 5.027483446898323e-07 -0.004856871791621592 5.027484818972713e-07 -0.005239031028659006 5.0274886679612e-07 -0.006187559915121 \
5.027489988933069e-07 -0.006423332025500122 5.027496873363354e-07 -0.005917035979538006 5.027498442650688e-07 -0.005202654566481615 5.027499719142314e-07 -0.004414133290428114 \
5.027500994560215e-07 -0.003433350487145549 5.027502171302335e-07 -0.002355902309038119 5.0275031626992e-07 -0.001320627313728655 5.027504216526298e-07 -9.507383675133965e-05 \
5.02750535559933e-07 0.001369964538583592 5.027506666153286e-07 0.003229572948258866 5.027507919785475e-07 0.005172303930030842 5.027509838204114e-07 0.008432154569684791 \
5.027511274902044e-07 0.01107975669588844 5.027512854720173e-07 0.01417105828876112 5.027514340716643e-07 0.01723098336859398 5.02751587122593e-07 0.02051714008521248 \
5.027517461875693e-07 0.02405720796424875 5.027518992577779e-07 0.02756764950178633 5.027520476048421e-07 0.03105219347129199 5.027521967112842e-07 0.03462388853332505 \
5.027523512757131e-07 0.03838854885099419 5.027525119616768e-07 0.04235886888523473 5.027526766408632e-07 0.04647718198980624 5.027528531638066e-07 0.05093664320808645 \
5.027530321756059e-07 0.05549818742091989 5.027532229484479e-07 0.0603932190016783 5.027534277958001e-07 0.06567927942044927 5.02753648293053e-07 0.07139554989571946 \
5.027538812110213e-07 0.07745499876455469 5.027541304587991e-07 0.08395499695136356 5.027544033803265e-07 0.09108394918256098 5.027547001733835e-07 0.09884095133633181 \
5.027550276098956e-07 0.1073964775374675 5.027553974236945e-07 0.1170487607486894 5.027557923699755e-07 0.1273407304921971 5.027562504585284e-07 0.1392499850125259 \
5.027567825583881e-07 0.1530377249371455 5.027574081103967e-07 0.169180864038255 5.027580941024627e-07 0.1867931863309214 5.027588969458781e-07 0.2072766958045763 \
5.027597962582096e-07 0.2300508264895909 5.027606966983226e-07 0.2526618731709107 5.027614985898552e-07 0.2726215666318766 5.027621940969962e-07 0.2897857674353052 \
5.02762826931282e-07 0.3052728323588638 5.027634223397735e-07 0.3197161646377594 5.027639693828152e-07 0.3328722959176427 5.027645031431617e-07 0.3455929446372428 \
5.027650223825863e-07 0.3578476146335662 5.027655297740486e-07 0.3697097539883151 5.027660333952181e-07 0.3813674725871593 5.027665451381145e-07 0.3930934709428262 \
5.027670522991229e-07 0.404595334768291 5.027675825951367e-07 0.4164962117964878 5.027680687086257e-07 0.4272847049163567 5.027685468169473e-07 0.437781779057129 \
5.027689862490711e-07 0.4473362978389137 5.027691094085349e-07 0.4500002106608159 5.027693557274626e-07 0.4553046876287923 5.027696989994585e-07 0.4626558934952216 \
5.02770010436459e-07 0.4692815017887791 5.027702611477243e-07 0.4745855323881177 5.027705319768677e-07 0.480281321066213 5.027708684587769e-07 0.4873122872019196 \
5.027712244673881e-07 0.4946959640027882 5.027715417375557e-07 0.5012322602315481 5.027717806181048e-07 0.506122906570856 5.027720216462867e-07 0.5110269393752048 \
5.027722735779908e-07 0.5161276795544476 5.027725137318346e-07 0.5209621749612534 5.027727364832964e-07 0.5254248476203834 5.027729250409435e-07 0.5291850880529715 \
5.027731397909866e-07 0.5334523706207774 5.027733543393783e-07 0.5376948565446859 5.0277361310367e-07 0.5427871977552768 5.027738639312417e-07 0.5477009885064807 \
5.027741193501039e-07 0.5526782776843104 5.027744703926294e-07 0.5594898819265107 5.027747350009544e-07 0.5645984056527484 5.027750014175097e-07 0.569709962982798 \
5.027752619318197e-07 0.5746801970751495 5.027755290218824e-07 0.5797469183389945 5.027757721599625e-07 0.5843213438768613 5.02776027852189e-07 0.5890994944692448 \
5.027762556711592e-07 0.5933243819692556 5.027764932159793e-07 0.5976999800355528 5.027767046064655e-07 0.6015679915939678 5.027769167472246e-07 0.6054277082074113 \
5.027771059366022e-07 0.6088479815213901 5.027772370949197e-07 0.6112112531841202 5.027773693914781e-07 0.6135871094428261 5.02777554614204e-07 0.6169015645304802 \
5.027777166365907e-07 0.6197943209800671 5.027778750557552e-07 0.6226100751126036 5.027780091676215e-07 0.6249846001944386 5.027781814887287e-07 0.6280247049765127 \
5.027783104275314e-07 0.6302937061188456 5.027784308050438e-07 0.6324061607157294 5.027785713339149e-07 0.634864734791624 5.027787644194074e-07 0.6382321981637986 \
5.027789142301853e-07 0.6408363654380513 5.027790815377796e-07 0.6437327988167145 5.027792625920029e-07 0.6468572757970242 5.027794659184327e-07 0.6503523798695617 \
5.027796487715879e-07 0.6534819287355287 5.027798193958343e-07 0.6563879501053153 5.027799968600742e-07 0.6594029650344411 5.027801628390247e-07 0.6622113135173925 \
5.027803200758144e-07 0.6648594636266301 5.02780460561866e-07 0.6672075432495704 5.027806042919945e-07 0.6695987751186935 5.027807373389854e-07 0.6718055529208897 \
5.02780879311128e-07 0.6741523780906628 5.027809993716612e-07 0.6761293215200647 5.027811443097483e-07 0.6785098354674278 5.027812603067977e-07 0.6804095298668216 \
5.027813798866854e-07 0.6823647593763783 5.027814788466604e-07 0.68397755359623 5.027815973550785e-07 0.6859039329668146 5.027816843993602e-07 0.6873150904607619 \
5.027818064101795e-07 0.6892866586554622 5.027819053327908e-07 0.6908817703737582 5.027819972281661e-07 0.6923536807698466 5.027820971967053e-07 0.6939486118486815 \
5.02782195442366e-07 0.6955126686751646 5.027822871561283e-07 0.6969676095571918 5.027823912890697e-07 0.698613189139943 5.02782527015812e-07 0.7007470979739818 \
5.027826816242741e-07 0.7031613517373301 5.027828167319862e-07 0.7052558942641604 5.027829630685319e-07 0.7075085519458914 5.027830915360734e-07 0.7094732734147607 \
5.02783215720207e-07 0.7113609898537658 5.027833256245073e-07 0.7130225953369277 5.027834422075759e-07 0.7147759898693785 5.027835423854067e-07 0.7162749667021007 \
5.027836794742156e-07 0.7183149847558421 5.027837994632423e-07 0.7200901405411056 5.027839185766902e-07 0.7218426783097279 5.02784045072077e-07 0.723693513465353 \
5.027841709394491e-07 0.7255245570057045 5.027842935604676e-07 0.7272980597885179 5.027844211779915e-07 0.7291334326655684 5.027845514267828e-07 0.7309957624152177 \
5.02784673019733e-07 0.73272442801297 5.027848117884253e-07 0.7346853525547948 5.02784912196869e-07 0.7360963845229137 5.027850155842573e-07 0.7375412410987998 \
5.027851092446997e-07 0.7388443755773992 5.027852208662966e-07 0.7403895158541485 5.027853073348996e-07 0.7415798421827293 5.027854081980103e-07 0.7429609798983192 \
5.027855402947324e-07 0.7447573558536402 5.027856494960337e-07 0.7462323422761349 5.027857540276639e-07 0.747635567415085 5.027858776741446e-07 0.7492836897664436 \
5.027860263705797e-07 0.7512497161812216 5.027861482512389e-07 0.7528480713857697 5.02786261855803e-07 0.7543274008692354 5.027864023754882e-07 0.7561429069656862 \
5.027865435649301e-07 0.7579511824827749 5.027866613111062e-07 0.7594470562859095 5.027867900007657e-07 0.7610693809796742 5.027869325554126e-07 0.7628512182523866 \
5.027870484119641e-07 0.7642872416835913 5.027871941752297e-07 0.7660789429779771 5.02787316007677e-07 0.7675637574673733 5.02787434476374e-07 0.7689965471136999 \
5.027875572640059e-07 0.7704700089613156 5.027876834168886e-07 0.7719718272910862 5.027877937859393e-07 0.7732757954107932 5.02787919217035e-07 0.7747465774777432 \
5.027880246987463e-07 0.775974259539018 5.027881578651758e-07 0.7775122819577122 5.027882805466309e-07 0.7789173428708996 5.027884153096743e-07 0.7804473432620218 \
5.027885259809625e-07 0.7816923373676121 5.027886353025911e-07 0.7829118427552927 5.027887704350255e-07 0.7844048889494442 5.027889212140503e-07 0.7860523747618094 \
5.02789061582958e-07 0.7875692293014268 5.027891812944828e-07 0.7888502570533434 5.027893195488234e-07 0.7903153082715967 5.027894429191593e-07 0.7916096503654788 \
5.027895880177844e-07 0.7931164937536124 5.027897277580434e-07 0.7945521172774316 5.027898549394667e-07 0.7958455533278409 5.027899739792201e-07 0.7970449251022731 \
5.02790086337411e-07 0.7981670522831598 5.027901905661906e-07 0.79919939674296 5.027902859050021e-07 0.8001364844871954 5.027904221931121e-07 0.8014634245741865 \
5.027905390856556e-07 0.8025894467082511 5.02790658725145e-07 0.8037305025474466 5.027907806067166e-07 0.8048811831579785 5.027909029850537e-07 0.8060245537852575 \
5.027910310137332e-07 0.8072081965553952 5.027911556585317e-07 0.8083483262222385 5.027912861572794e-07 0.8095291977395493 5.027914126177069e-07 0.8106611567088965 \
5.027915397436747e-07 0.8117869190804841 5.027916448611512e-07 0.8127087429624065 5.027917501113405e-07 0.8136235164943317 5.027918412515906e-07 0.8144090748259969 \
5.027919646696249e-07 0.8154632009865571 5.027920517482738e-07 0.8162003374872545 5.02792151070959e-07 0.8170344894488412 5.027922959927027e-07 0.8182390501293432 \
5.027924322612063e-07 0.8193582434421302 5.027925417234846e-07 0.8202477434185359 5.027926878435863e-07 0.8214214001843773 5.02792839202198e-07 0.8226208465286928 \
5.027929650061201e-07 0.8236052915965452 5.027931094167794e-07 0.824721541823094 5.027932340177296e-07 0.8256729463037898 5.027933847297913e-07 0.8268094083523665 \
5.027935201010499e-07 0.8278169867326588 5.027936453039791e-07 0.8287379047458127 5.027937629733617e-07 0.829593908450195 5.027939088013387e-07 0.8306418458276996 \
5.027940752973201e-07 0.8318207857986918 5.027942061544082e-07 0.8327345044534114 5.027943796038484e-07 0.833928356718921 5.027945477223224e-07 0.8350667646575466 \
5.027947175961246e-07 0.8361988603660855 5.027948984507537e-07 0.8373843006762304 5.027950416331349e-07 0.8383085120571983 5.027951557464787e-07 0.8390361588138326 \
5.027952858124697e-07 0.8398559950134801 5.027953876877057e-07 0.8404909448220066 5.027955045669982e-07 0.8412116130393378 5.027956416789287e-07 0.8420465258793415 \
5.027958395595721e-07 0.843231707656198 5.027960313457652e-07 0.8443585547012582 5.027962407088286e-07 0.8455646258450146 5.027964228224063e-07 0.846593677725298 \
5.027966199171782e-07 0.8476867969181797 5.02796793185875e-07 0.8486305714188691 5.02796976264561e-07 0.8496104335327738 5.027971474015872e-07 0.8505103231661706 \
5.027973220804384e-07 0.8514128411730317 5.02797497318728e-07 0.8523022053693007 5.027976734583674e-07 0.8531802340241421 5.027978638096238e-07 0.8541115036082744 \
5.027980543867704e-07 0.855025905954957 5.027982548181928e-07 0.8559685891497206 5.027984474106693e-07 0.8568563992305701 5.027986582738063e-07 0.8578086227668252 \
5.027988861871822e-07 0.8588150784816577 5.027991522177188e-07 0.8599606428795262 5.027994507388009e-07 0.8612090806949765 5.027997266924816e-07 0.8623286542354505 \
5.028000109545961e-07 0.8634483918036945 5.028002851030457e-07 0.8644969441068078 5.028005573923129e-07 0.8655088801415273 5.028008275580887e-07 0.8664846790737442 \
5.028010847361862e-07 0.8673881555543895 5.028013572993529e-07 0.868319368003445 5.02801633304697e-07 0.8692355072818493 5.028019034186287e-07 0.870106770567397 \
5.028022032450018e-07 0.8710447971670072 5.028025742222908e-07 0.8721640818024149 5.028028691540118e-07 0.8730224021943973 5.028031234323761e-07 0.873740732376842 \
5.028034216772072e-07 0.8745584461000401 5.028036952852192e-07 0.8752856917963749 5.028039314154438e-07 0.8758961959341748 5.028041717609792e-07 0.8765017794770257 \
5.028043940971677e-07 0.8770481951318053 5.028045881024505e-07 0.8775144010549708 5.028049178237936e-07 0.8782846129827527 5.028050729968195e-07 0.8786376896881318 \
5.028053907524076e-07 0.8793424631377607 5.028055696169827e-07 0.8797286397841958 5.028059120784622e-07 0.8804474051285093 5.028060962178168e-07 0.880822800830328 \
5.028065711184754e-07 0.881756283451624 5.028067385131538e-07 0.8820737784441692 5.028072043462e-07 0.8829272622221894 5.028073851704931e-07 0.8832470363605239 \
5.028078792047928e-07 0.8840891816604841 5.028080205486687e-07 0.8843218944112644 5.028086269405857e-07 0.8852805359894154 5.028087790117662e-07 0.8855111592597558 \
5.028094256914359e-07 0.8864506941541785 5.028095539876422e-07 0.8866295550025313 5.028102021648149e-07 0.8874976172723908 5.028103319236754e-07 0.8876644392549727 \
5.028111001444974e-07 0.8886037370453904 5.02811229881009e-07 0.8887539063021698 5.028120833066544e-07 0.8896836309705964 5.028122265650877e-07 0.8898301468060963 \
5.02813212785821e-07 0.890764641901611 5.028134342672269e-07 0.8909571971396437 5.028145773086277e-07 0.8918770673440963 5.028147072981167e-07 0.8919774876506176 \
5.028160589233886e-07 0.8929731820841386 5.028162092835701e-07 0.89307657739048 5.028176899161688e-07 0.8939986636922405 5.028179288179339e-07 0.8941315911431026 \
5.028196933116327e-07 0.894999985510941 5.02820000994978e-07 0.8951330875684044 5.028225222661808e-07 0.8960612226716312 5.02822959317422e-07 0.8961978289811912 \
5.028268627296431e-07 0.8971619289239613 5.028271095114498e-07 0.8972094058147089 5.028346860012844e-07 0.8981998139535015 5.028348019130314e-07 0.8982099955090975 \
5.028539004457353e-07 0.8992062631372056 5.028542978885091e-07 0.8992194728667773 5.030047133235902e-07 0.9002121614362558 5.03004979381947e-07 0.9002436812458944 \
5.030102475320153e-07 0.8993470931706574 5.030104539029324e-07 0.899191170936528 5.030119320157425e-07 0.8982046351054961 5.030121124663985e-07 0.8981003355419954 \
5.030143349480612e-07 0.8971299612768925 5.030145410405756e-07 0.897079983173831 5.030249493066813e-07 0.8980580240048047 5.03025087164257e-07 0.8980839755683444 \
5.030318845132984e-07 0.8990685088718567 5.030320700847659e-07 0.8990874390200084 5.035282992589679e-07 0.9000706848616691 5.03528359054814e-07 0.9000975977971888 \
5.03529612605432e-07 0.9010828413531861 5.035297182980354e-07 0.9012097231395001 5.035303764287524e-07 0.9021613947651476 5.035305136110213e-07 0.9023918767045529 \
5.035310366376409e-07 0.9033649777562528 5.035310995012334e-07 0.9034908765919824 5.035315720967825e-07 0.904476514442582 5.035316234105955e-07 0.9045863669199017 \
5.035320893739313e-07 0.9055619780118375 5.035321215783922e-07 0.9056252631670594 5.035328386771295e-07 0.9066212416280413 5.035329231134019e-07 0.9066528951765993 \
5.035335231797813e-07 0.9059679814895146 5.035336430373927e-07 0.9055903401525059 5.035337742001719e-07 0.9050640446667092 5.035339090199249e-07 0.9043926011431642 \
5.035340571549842e-07 0.9034897747335404 5.035341947143354e-07 0.902493211317788 5.035343349260954e-07 0.9013135799985507 5.035344335882047e-07 0.9003872218501816 \
5.035345192720141e-07 0.8995148096066522 5.035346018362133e-07 0.8986166894493001 5.035347166188419e-07 0.8972773101170661 5.03534797717086e-07 0.8962642459447687 \
5.03534877134364e-07 0.8952218112132616 5.035349825888917e-07 0.8937633947192651 5.035351052301954e-07 0.8919606744930825 5.035352049542743e-07 0.890414036797163 \
5.035353751486854e-07 0.8876203405523397 5.035355213337766e-07 0.8850727273800474 5.035356895519253e-07 0.8819879035815887 5.035358617130214e-07 0.8786780617039783 \
5.035360460991142e-07 0.8749807502679057 5.035362306654577e-07 0.8711418063496947 5.035364149129436e-07 0.8671917613865908 5.035366002486073e-07 0.8631174608718694 \
5.035367746363354e-07 0.8592060069639053 5.035369573402717e-07 0.8550405244181323 5.035371326873658e-07 0.8509893565349284 5.035373150168772e-07 0.8467313026054767 \
5.035375053303061e-07 0.8422468264612591 5.035376756604352e-07 0.838204894125699 5.035378421840737e-07 0.8342320488410089 5.035380047549371e-07 0.830337741667393 \
5.035381546161599e-07 0.8267359097041467 5.035383057921791e-07 0.8230937075736249 5.035384949376529e-07 0.8185270080344306 5.035386406557074e-07 0.8150026134285653 \
5.035388156466743e-07 0.8107652770601156 5.035389641182174e-07 0.807166938184282 5.035391360056828e-07 0.8029987283123258 5.035393050739222e-07 0.7988973224349885 \
5.035394692526315e-07 0.7949140139776875 5.035396285801686e-07 0.7910485911592836 5.035397890297763e-07 0.7871568543472617 5.035399908491573e-07 0.7822630953020117 \
5.035401392968917e-07 0.7786646206504594 5.03540293464276e-07 0.77492821376164 5.035404305476362e-07 0.7716074476660475 5.035405399330824e-07 0.7689587163513494 \
5.035406458665383e-07 0.7663946531324515 5.035407728808854e-07 0.7633217481666642 5.035408872438541e-07 0.7605561828888391 5.03540990091676e-07 0.7580702160470256 \
5.035411116819926e-07 0.7551325442760125 5.035412224592673e-07 0.7524575925939972 5.035413393080924e-07 0.7496376180588871 5.035414500928178e-07 0.7469652567786068 \
5.035415684589191e-07 0.7441116745915923 5.035416932860144e-07 0.7411038668912771 5.035418458478099e-07 0.7374292753756717 5.035419797447979e-07 0.7342062928952946 \
5.035421007762374e-07 0.7312947572377408 5.035422649737523e-07 0.7273475399259534 5.035424423346988e-07 0.7230877912371642 5.035426245451075e-07 0.7187161681757385 \
5.035428055423725e-07 0.7143786395952922 5.035429862063158e-07 0.7100537072471783 5.035431763578828e-07 0.7055071781827296 5.035433641177769e-07 0.7010230964996226 \
5.035435646508815e-07 0.696237807975249 5.035437733363431e-07 0.6912646166759551 5.035439809799078e-07 0.6863227581165517 5.03544208547776e-07 0.6809140411171237 \
5.035444008226102e-07 0.6763521085712711 5.035446380878581e-07 0.6707310800019505 5.035448313661221e-07 0.6661595641347996 5.035450640988686e-07 0.6606646229758047 \
5.035452696563363e-07 0.6558174602470968 5.035455020097575e-07 0.6503484594495911 5.035456970117276e-07 0.6457674053103037 5.035459002403362e-07 0.6410004262200759 \
5.035460800928814e-07 0.6367906205544323 5.035462591993118e-07 0.6326052789263827 5.035464225765257e-07 0.628795088826817 5.035465946259304e-07 0.6247880828503264 \
5.035467581187693e-07 0.6209892715878097 5.035469339085876e-07 0.6169100951581823 5.035471158475732e-07 0.6126978430086294 5.035473043313055e-07 0.6083422542008314 \
5.035475107637274e-07 0.6035858951323969 5.035476900783896e-07 0.5994633272559844 5.035478872572566e-07 0.5949432360761027 5.035480963453974e-07 0.5901646611556908 \
5.035483020946604e-07 0.5854760387944159 5.035485426053479e-07 0.5800160304866983 5.035487157334496e-07 0.5760958285528379 5.035488806274519e-07 0.5723746772837877 \
5.035490614880266e-07 0.5683014035092815 5.035492187741233e-07 0.5647722902613652 5.035493877569178e-07 0.5609879409349005 5.03549567863379e-07 0.5569709657351898 \
5.03549720846506e-07 0.5535669615732179 5.035498525609507e-07 0.5506462283231492 5.035499999486508e-07 0.5473865746199473 5.035500873742421e-07 0.5454560063082221 \
5.035501722454816e-07 0.5435860258811447 5.03550270874694e-07 0.5414171943998213 5.035503429668553e-07 0.5398340751058975 5.035504400578744e-07 0.5377039800781129 \
5.035505256482576e-07 0.5358302678688993 5.035505907291341e-07 0.5344081412607664 5.03550714329502e-07 0.5317121235594142 5.035508087537724e-07 0.52965475734789 \
5.035509062769941e-07 0.5275349985745696 5.035510791376451e-07 0.5237893654184622 5.035512141331662e-07 0.5208709659121862 5.035513683166277e-07 0.5175498113398643 \
5.03551542781984e-07 0.5138002600288881 5.035516945879704e-07 0.510550000123414 5.03551840818953e-07 0.5074290310664136 5.03551984717826e-07 0.5043644611166801 \
5.035521277396694e-07 0.5013276181140283 5.035522233495175e-07 0.499301733014788 5.035523177934733e-07 0.4973032961550828 5.03552438849414e-07 0.4947494705229025 \
5.035525337277098e-07 0.4927525559781179 5.035526495585532e-07 0.4903172469328811 5.035527368224019e-07 0.4884854516151125 5.035528192528481e-07 0.4867593351188191 \
5.035529146608015e-07 0.484765406725184 5.035530153710815e-07 0.4826639978995959 5.03553112231473e-07 0.4806459052877932 5.035532509612246e-07 0.4777646955734051 \
5.035533866660861e-07 0.4749532752442271 5.035535871508094e-07 0.4708139964547478 5.035538024649621e-07 0.4663911383470885 5.03553984040267e-07 0.462674698484628 \
5.035541830122363e-07 0.4586189944293299 5.035543535777573e-07 0.455154096457448 5.035545279314447e-07 0.4516251957269069 5.035546968646987e-07 0.4482170126441485 \
5.035548694618603e-07 0.4447467276163349 5.035550520681902e-07 0.4410867902598327 5.035552406170554e-07 0.4373240875354826 5.035554340845929e-07 0.4334777823509549 \
5.035556424052317e-07 0.4293535036700135 5.035558567504624e-07 0.4251286740881063 5.035560824557922e-07 0.4207018662297695 5.035563089991605e-07 0.4162771402745992 \
5.035565711759108e-07 0.4111844468197049 5.035568202097347e-07 0.4063709766754009 5.035571213084326e-07 0.4005865607947761 5.035574107292502e-07 0.3950673729298416 \
5.03557718243529e-07 0.3892455819062323 5.035580404399245e-07 0.3831936848847286 5.035583681704071e-07 0.3770882112794804 5.035587006001628e-07 0.3709500980558715 \
5.035590303291706e-07 0.3649083177186754 5.035593515587582e-07 0.3590729273462687 5.03559682375082e-07 0.3531219177045733 5.035600247306453e-07 0.3470224718704957 \
5.035603243716774e-07 0.3417374346434491 5.035606541592421e-07 0.3359723367088904 5.035609810531851e-07 0.3303128110141857 5.03561319032532e-07 0.3245206193888226 \
5.035616280036957e-07 0.3192755432624759 5.035619528016686e-07 0.31382336954194 5.035622684318663e-07 0.3085864885517507 5.035625734190322e-07 0.3035810258414895 \
5.035628287576776e-07 0.2994330834535801 5.03563093620834e-07 0.295170851203172 5.035633807035186e-07 0.2905978071194348 5.035636036732975e-07 0.2870801635277143 \
5.035638032125665e-07 0.2839591363066187 5.035640128685797e-07 0.2807045410859125 5.035641931251209e-07 0.2779290029372279 5.035643554698416e-07 0.2754463208250681 \
5.035645059048156e-07 0.2731629026725527 5.035646569101241e-07 0.2708866524077067 5.035648538007149e-07 0.2679392949564011 5.035649849454786e-07 0.2659970646012914 \
5.035651096820175e-07 0.2641561221543183 5.035652612740599e-07 0.2619266655689588 5.03565357242231e-07 0.2605306204207966 5.035654537935995e-07 0.2591282589302421 \
5.035655784133887e-07 0.2573209601776467 5.035657209899234e-07 0.255257422470362 5.035658799234579e-07 0.25296979123958 5.035660125895253e-07 0.251062957019046 \
5.03566196158294e-07 0.2484301322588876 5.035663773934597e-07 0.2458327969660818 5.035665889075645e-07 0.2428051031600066 5.035667914973991e-07 0.2399069804317323 \
5.035669580538467e-07 0.2375282895552967 5.03567168273059e-07 0.2345337828133105 5.03567341690945e-07 0.2320692345528927 5.035675705336728e-07 0.2288260787734411 \
5.035677911684243e-07 0.2257162440502939 5.035679668301377e-07 0.2232503232699662 5.035681472906433e-07 0.2207258962977968 5.035683180470208e-07 0.2183528725291195 \
5.035684982432871e-07 0.2158619697278009 5.035686649739047e-07 0.2135675266585953 5.03568814095326e-07 0.2115251542210239 5.035689699053442e-07 0.2094125291275523 \
5.035691050857695e-07 0.2075875692769576 5.035692551671966e-07 0.2055694209972212 5.035693876128229e-07 0.2037957203154137 5.035695281573595e-07 0.2019220745191926 \
5.035696452261238e-07 0.2003748851744883 5.035697749337301e-07 0.1986681706274326 5.035698969911991e-07 0.1970700654731777 5.035700195346348e-07 0.1954731161836187 \
5.035701375539584e-07 0.1939418157697267 5.035702725767313e-07 0.1921981789937757 5.03570417201182e-07 0.1903420634523806 5.035705455516813e-07 0.1887049708672087 \
5.03570669186156e-07 0.1871351133418249 5.035707667362788e-07 0.1859021016257166 5.035708818092081e-07 0.1844539912642748 5.035709755078879e-07 0.1832809848801438 \
5.035710742920116e-07 0.1820493959460708 5.035711972265529e-07 0.1805230483556907 5.035712929805559e-07 0.1793400249325384 5.035714220681073e-07 0.177753298391591 \
5.035715245334772e-07 0.1764993061988986 5.035716227869744e-07 0.1753029542432101 5.035717428741866e-07 0.1738483570896001 5.03571845423405e-07 0.1726127298531683 \
5.035719558810641e-07 0.1712877101305652 5.035720843709282e-07 0.1697552709290656 5.035721758557694e-07 0.1686698090598139 5.035722803403581e-07 0.1674358120019214 \
5.035723552770941e-07 0.1665544493622226 5.03572444845591e-07 0.1655049734124585 5.035724954106002e-07 0.164914347906921 5.035725453889763e-07 0.1643318187475747 \
5.035726103580609e-07 0.163576534137217 5.035726458720287e-07 0.1631646263336159 5.035727180712023e-07 0.162329174921529 5.035727852002975e-07 0.1615546732967998 \
5.035728444300317e-07 0.160873195114598 5.035728881756304e-07 0.1603710314414745 5.035729358224586e-07 0.1598254649913795 5.03573006202993e-07 0.1590230739426561 \
5.03573088541159e-07 0.1580883269013631 5.035731667127594e-07 0.1572048664554128 5.035732487657084e-07 0.1562816770844126 5.035733414693307e-07 0.1552436243401225 \
5.035734642494946e-07 0.153877370231325 5.035735633955882e-07 0.1527810927807017 5.035736648959354e-07 0.1516651170047695 5.035737661711264e-07 0.1505582666538253 \
5.035738626629106e-07 0.1495093242781697 5.035739620809455e-07 0.1484346886615803 5.03574046381569e-07 0.1475281828465028 5.035741393202594e-07 0.1465342051547719 \
5.035742219212e-07 0.1456551508734999 5.035743306872851e-07 0.1445034822456445 5.035744363302651e-07 0.1433917535370727 5.035745179898545e-07 0.1425365900703354 \
5.03574611735024e-07 0.1415598856352903 5.035747053029709e-07 0.1405903867550886 5.035747881874616e-07 0.139735765814107 5.035748763466362e-07 0.1388313836440244 \
5.035749561327222e-07 0.1380170907865772 5.035750497281216e-07 0.1370669869522621 5.035751396606458e-07 0.1361590166429519 5.035752102110423e-07 0.1354501541392388 \
5.035752799712188e-07 0.1347521119166949 5.035753941201258e-07 0.1336164586193709 5.035754760987401e-07 0.1328058651355588 5.035755637040425e-07 0.1319440719770354 \
5.035756632052385e-07 0.1309710196939938 5.035757723852409e-07 0.1299110174488692 5.03575874550573e-07 0.1289256009328031 5.035759820107789e-07 0.1278959836800649 \
5.035761020450569e-07 0.1267549558890445 5.035761962530915e-07 0.1258657925752028 5.035763272321949e-07 0.1246390638240933 5.035764266598964e-07 0.1237164070883829 \
5.035765357815822e-07 0.1227104370444639 5.035766446347502e-07 0.1217138859540913 5.035767369441536e-07 0.120874257454373 5.035768497844843e-07 0.1198547128626846 \
5.035769467965243e-07 0.118986084968971 5.035770510628723e-07 0.1180628196869088 5.035771600298026e-07 0.1171053395831002 5.035772595693683e-07 0.1162371554254778 \
5.035773765620782e-07 0.1152245300989246 5.035774636628685e-07 0.1144761644999183 5.0357757295452e-07 0.1135478691973115 5.035776544795827e-07 0.1128618460838699 \
5.035777542545759e-07 0.1120273350449922 5.03577871679726e-07 0.1110526766231405 5.035779734648438e-07 0.1102143708571793 5.035780612037922e-07 0.1094962336869811 \
5.035781420032999e-07 0.1088432886892514 5.035782289543191e-07 0.1081456845520918 5.035783097409447e-07 0.1075007757815706 5.035783999475114e-07 0.1067842832273628 \
5.03578490898266e-07 0.1060655611559195 5.035785795687901e-07 0.1053685613006139 5.035786785836107e-07 0.1045946508745568 5.035787722897869e-07 0.1038723470842792 \
5.035788661490627e-07 0.1031520741219857 5.035789669765109e-07 0.1023817709659086 5.035790716074087e-07 0.1015861061604995 5.03579195570165e-07 0.1006484085638475 \
5.035792929694782e-07 0.09991551135558702 5.035794132274253e-07 0.09901872452754552 5.035795240953005e-07 0.09819831936474602 5.035796285683363e-07 0.09742874659471555 \
5.035797458050451e-07 0.09656937225591002 5.035798475993662e-07 0.09582695326576983 5.035799455749168e-07 0.09511577589263259 5.035800860794065e-07 0.09410164141823299 \
5.035801911572026e-07 0.09334832721827611 5.035802897700187e-07 0.09264549593674179 5.035803824848273e-07 0.09198739948435641 5.035804686832123e-07 0.09137785861853052 \
5.035805625961876e-07 0.09071637432184691 5.035806596969337e-07 0.09003559055802626 5.03580769117988e-07 0.08927317549644689 5.035808701015371e-07 0.08857281843916648 \
5.035809637594832e-07 0.08792605868920525 5.035810379341552e-07 0.08741581771673042 5.03581175834007e-07 0.08647193599618339 5.035812481910108e-07 0.08597917321277694 \
5.035813835122141e-07 0.08506274029062395 5.035814694238194e-07 0.08448410751389913 5.03581614152054e-07 0.08351486081643937 5.035817103826188e-07 0.0828744112740944 \
5.035817982183981e-07 0.08229260392026354 5.035819140173063e-07 0.08152964121883956 5.035820291457576e-07 0.08077575264951149 5.0358214291219e-07 0.08003553900012179 \
5.035822831696828e-07 0.0791300282244784 5.035824245457161e-07 0.07822490276368012 5.035825741817576e-07 0.07727536491519127 5.035827186706132e-07 0.07636690312463701 \
5.035828698447241e-07 0.07542565384097814 5.035830192155436e-07 0.07450459906593411 5.03583168562251e-07 0.0735926433331697 5.035833285177668e-07 0.07262574717347114 \
5.035834846646777e-07 0.07169171823582712 5.035836591531124e-07 0.07065947636250877 5.035838288622191e-07 0.0696671357044583 5.035840140413029e-07 0.0685979885997255 \
5.035842107623799e-07 0.06747763456279594 5.035844212801998e-07 0.06629631776014881 5.03584643312255e-07 0.06507007089066431 5.035848735242763e-07 0.0638195278444372 \
5.035851160353819e-07 0.06252626147401 5.035853766894672e-07 0.06116236403900636 5.035856565885314e-07 0.05972739422233359 5.035859501722554e-07 0.05825544847408989 \
5.035862651082392e-07 0.05671370145268265 5.035866079141644e-07 0.05507846134953124 5.035869573807585e-07 0.0534565727116736 5.035873662849151e-07 0.05161746230842366 \
5.035877129499425e-07 0.05010669351290297 5.035881003649955e-07 0.04846839895323611 5.035884445827877e-07 0.04705645202362623 5.035887680090468e-07 0.04576625679949029 \
5.035890730548091e-07 0.04458093278443617 5.035893659168059e-07 0.04347099288378908 5.035896500577228e-07 0.04242242262004604 5.035899260780149e-07 0.04142902112907627 \
5.03590192930566e-07 0.04049015932812138 5.035904618227892e-07 0.03956531631184226 5.035907378832112e-07 0.03863769040165695 5.035910254787821e-07 0.03769451689421055 \
5.035912650444083e-07 0.03692662498323904 5.03591554211835e-07 0.03602084344675294 5.03591770003438e-07 0.03535960341037672 5.035919577204764e-07 0.03479599077274986 \
5.035921558495825e-07 0.03421285035004928 5.03592518724446e-07 0.03317032497347058 5.03592776866276e-07 0.03244834222605905 5.0359308657919e-07 0.0316030971185694 \
5.035933520493286e-07 0.03089664771451467 5.035936201684082e-07 0.03019941363307669 5.03593899042439e-07 0.02949128999862272 5.035941452288756e-07 0.02888043298519722 \
5.035943758602853e-07 0.02832033800396738 5.035946141502041e-07 0.02775711540944564 5.035948491575684e-07 0.02721270742060762 5.03595076940031e-07 0.02669509678424227 \
5.035954855523029e-07 0.02579039168486155 5.03595661854632e-07 0.02540904040268441 5.03596016332316e-07 0.02465798827491217 5.035962002032882e-07 0.02427641469830137 \
5.035965351520103e-07 0.02359448510613503 5.035966990607275e-07 0.02326678168937357 5.035970913313036e-07 0.02249905491676728 5.035972473220689e-07 0.02220010404946675 \
5.035976789254264e-07 0.02138321689778962 5.035978163148065e-07 0.0211255367654138 5.03598333123589e-07 0.02017559010600388 5.035984586594829e-07 0.01995091418019728 \
5.035989159010076e-07 0.01915998482559782 5.035990750469891e-07 0.01889493739859509 5.035996822854669e-07 0.01793263500095189 5.03599816822955e-07 0.01772934138481063 \
5.036004800869477e-07 0.01678091027541291 5.036006734103789e-07 0.01651856846389665 5.036013410670396e-07 0.01565087920017967 5.03601502655887e-07 0.01544858341705342 \
5.0360225789114e-07 0.01454101846553843 5.036024074521069e-07 0.01436800730673201 5.036032977899311e-07 0.01338293844200974 5.036033964478169e-07 0.01327873262558703 \
5.03604353121314e-07 0.01230993787860994 5.036044742310215e-07 0.01219243157195396 5.036054657237297e-07 0.01126376273051215 5.036056292524602e-07 0.01111855113153209 \
5.036067591745355e-07 0.01018247077230436 5.036068716217738e-07 0.01009565848301377 5.036082494452622e-07 0.009103273453806031 5.036083883905334e-07 0.009009747578659758 \
5.036099427888684e-07 0.008018073335410726 5.0361005485534e-07 0.00794673960805117 5.036116998381698e-07 0.006958154532207958 5.036118070906645e-07 0.006899512253112593 \
5.036137515841525e-07 0.005937533026687714 5.036139584821097e-07 0.005843834961138424 5.036162973698526e-07 0.00487227039639981 5.036167213562637e-07 0.004712306502041247 \
5.036194935894604e-07 0.003780857497341114 5.036199418985521e-07 0.003647790772321777 5.03623582397237e-07 0.00272553831825111 5.036240790530716e-07 0.002619503085887757 \
5.036298301734959e-07 0.001650572925599863 5.036301169553825e-07 0.001609446887446839 5.036354719440668e-07 0.0006353228983793809 5.036356773006917e-07 0.0005920420449145349 \
5.062827120745073e-07 -0.0002718533828215428 5.062828679501106e-07 -0.0004579010352009555 5.062834162652027e-07 -0.001326296959495401 5.062835290488787e-07 -0.001543805653187533 \
5.062839635410185e-07 -0.002491429791030493 5.062840393661748e-07 -0.002673591589873599 5.062843960167732e-07 -0.003590195133438418 5.062845230658532e-07 -0.003936807634339821 \
5.062848015662471e-07 -0.004716444651655622 5.062849096507304e-07 -0.005020876868076652 5.06285253249855e-07 -0.00592430224391268 5.062853602437201e-07 -0.006162325733041658 \
5.062862596141159e-07 -0.005653094509861465 5.062864380475456e-07 -0.004687598829536962 5.062865437709605e-07 -0.003940993102967527 5.062866688337378e-07 -0.002883597584075996 \
5.062867624178337e-07 -0.001971418478057775 5.062868402573964e-07 -0.001132968824455395 5.062869203293945e-07 -0.0001977429743171 5.062870427022046e-07 0.001370578777960296 \
5.062871609580771e-07 0.003041212838230153 5.062872796071872e-07 0.004860750887681821 5.06287393089626e-07 0.006730904986417607 5.062874965327644e-07 0.008536402178002854 \
5.062876111920181e-07 0.01064190690353853 5.062878017758113e-07 0.0143607330143792 5.062879355659492e-07 0.01711819191720031 5.062880858195149e-07 0.02033933849841947 \
5.062882409887625e-07 0.02378599874269359 5.062883963808114e-07 0.0273434151175349 5.062885440880426e-07 0.03080849965087477 5.062886930776679e-07 0.03437359286003162 \
5.06288848068751e-07 0.03814545786868043 5.062890074393647e-07 0.04208062121327779 5.062891723727756e-07 0.04620305710844342 5.062893473191046e-07 0.0506208066052034 \
5.062895264491763e-07 0.05518387280380205 5.062897162384316e-07 0.06005265756871143 5.062899199354002e-07 0.06530840376289772 5.062901397459318e-07 0.07100650943730057 \
5.062903714973765e-07 0.07703584544314998 5.062906193226736e-07 0.08349927754587044 5.062908906436034e-07 0.09058756662233436 5.062911853563813e-07 0.09829181712822582 \
5.062915106140293e-07 0.106792896697727 5.062918768597349e-07 0.1163551101154179 5.062922701564477e-07 0.1266079356677421 5.062927228093435e-07 0.1383809089651769 \
5.062932485245107e-07 0.1520098384503803 5.06293867738049e-07 0.1679979965193872 5.062945484823656e-07 0.1854865650013753 5.062953421573203e-07 0.2057488551561759 \
5.062962309229534e-07 0.2282732214494322 5.062970443122153e-07 0.2487218262351868 5.062977660617924e-07 0.2667261628598245 5.062984017258005e-07 0.282460740414376 \
5.062989734425617e-07 0.2965101025186013 5.062995089968458e-07 0.3095696210007924 5.063000123552588e-07 0.3217495654069301 5.063004886827015e-07 0.3331878525640654 \
5.063009626063057e-07 0.3444754071334732 5.063014200780244e-07 0.3552759747331513 5.06301886058294e-07 0.3661792384270033 5.063023350461038e-07 0.376592601923634 \
5.063028311526456e-07 0.3879857357798637 5.063033509145082e-07 0.3998002499051578 5.063037303191525e-07 0.4083447473225827 5.063041703278757e-07 0.4181679450526055 \
5.063046400968136e-07 0.4285466970600206 5.063051256177521e-07 0.4391589006481625 5.063055650658585e-07 0.4486701556983262 5.063056268188068e-07 0.4500002248264944 \
5.063057503247038e-07 0.4526540461147197 5.063059973364976e-07 0.4579447795386873 5.063062499314088e-07 0.463325462421476 5.063064475025244e-07 0.467511453725808 \
5.063066730742714e-07 0.4722681264242033 5.06306994642268e-07 0.4790073975813253 5.063072634214966e-07 0.4846013351959894 5.0630748207297e-07 0.4891262574467725 \
5.063076921769364e-07 0.4934547887280634 5.063079185824616e-07 0.4980921872304203 5.063081276876521e-07 0.5023516957637455 5.063083170899107e-07 0.5061927337048852 \
5.06308441251129e-07 0.5086969563931187 5.063085680062259e-07 0.5112441466129884 5.06308728004704e-07 0.5144514110933732 5.063089756476561e-07 0.5193914248715521 \
5.063091542341148e-07 0.5229351592435862 5.063093251876918e-07 0.5263079149198099 5.063095865372878e-07 0.5314455197962068 5.063098126088702e-07 0.5358634945234868 \
5.063100157405373e-07 0.5398188128751134 5.063101809712675e-07 0.5430252218652345 5.063103377582878e-07 0.5460612552756139 5.063105269149053e-07 0.5497137532216215 \
5.063107287826585e-07 0.5535976061995346 5.06310952933981e-07 0.5578986282275192 5.063111913163462e-07 0.5624617013850463 5.06311426077985e-07 0.566941985223824 \
5.063116563486904e-07 0.5713275351537204 5.063118621413239e-07 0.5752375533958141 5.063120671255381e-07 0.5791255875933676 5.063123099407797e-07 0.5837094709690289 \
5.063125646983618e-07 0.588493349632063 5.063127929267933e-07 0.5927514274590796 5.063130307656652e-07 0.5971656109489694 5.063132430431007e-07 0.6010807441713891 \
5.063134548365055e-07 0.6049674646600495 5.06313708720774e-07 0.6095919957414236 5.063139133143013e-07 0.6132953190650409 5.063141650376543e-07 0.6178178328453598 \
5.063143528271744e-07 0.6211736970442716 5.063146057002513e-07 0.6256587164710262 5.063148041096133e-07 0.6291560967673944 5.06314983842284e-07 0.6323071487074056 \
5.063152541130913e-07 0.6370161336915187 5.063154713968567e-07 0.6407803561788556 5.063156519232363e-07 0.6438916924996977 5.063158530841307e-07 0.6473460740030906 \
5.063160216675126e-07 0.650231451944099 5.063162260257198e-07 0.6537144072723954 5.063163716887783e-07 0.6561873372238678 5.063165362473771e-07 0.6589728476742622 \
5.063167057165935e-07 0.6618316558839334 5.063168592566751e-07 0.664412775690417 5.06317000490202e-07 0.6667750288922751 5.063171440660136e-07 0.6691685747430841 \
5.063172772961389e-07 0.6713840140331436 5.063174191964593e-07 0.6737368819239464 5.063175394300862e-07 0.6757233098298149 5.063176840811384e-07 0.6781085120392751 \
5.063178002998436e-07 0.6800197521569988 5.063179193821632e-07 0.6819757159594566 5.063180179604767e-07 0.6835903813535821 5.063181355581832e-07 0.6855122399681081 \
5.063182229941461e-07 0.6869376986921233 5.063183477402321e-07 0.6889650632873403 5.063184475472963e-07 0.6905825000046129 5.063185400370926e-07 0.6920753042469043 \
5.063186413211772e-07 0.6937043390836264 5.063187391142832e-07 0.695273833970533 5.063188303850746e-07 0.6967333967490603 5.063189328429049e-07 0.6983656370917724 \
5.063190657521356e-07 0.7004728611232253 5.063192207675414e-07 0.7029137789397926 5.063193556492269e-07 0.7050222373350452 5.063195011450183e-07 0.7072806469370021 \
5.063196289996853e-07 0.709252249158637 5.063197534579806e-07 0.7111597484283609 5.063198647836849e-07 0.7128563623504806 5.063199788137127e-07 0.7145852226468989 \
5.063200793249296e-07 0.7161013069709498 5.063202165260769e-07 0.7181590832501857 5.063203364719788e-07 0.7199473375636642 5.06320455641778e-07 0.7217141075019444 \
5.063205825867916e-07 0.7235855504531626 5.063207073542093e-07 0.7254141264975077 5.063208308495972e-07 0.7272133847865295 5.063209576308702e-07 0.7290498056238117 \
5.063210882203554e-07 0.730930225429108 5.063212104322583e-07 0.7326797786847141 5.063213474902715e-07 0.7346298644824388 5.063214487056265e-07 0.7360619656663578 \
5.063215536745619e-07 0.7375401619041119 5.06321645165995e-07 0.7388229997694907 5.06321758241356e-07 0.7404001534680551 5.063218455422403e-07 0.7416107338190071 \
5.063219500055705e-07 0.7430512000342341 5.063220807687029e-07 0.7448411286358657 5.063221906822003e-07 0.7463352048609909 5.063222953419584e-07 0.7477488743938407 \
5.0632241917362e-07 0.7494094725133206 5.063225679269713e-07 0.751387874302702 5.06322689842132e-07 0.7529958494242643 5.063228036963925e-07 0.7544867042370438 \
5.0632294419585e-07 0.7563117925204224 5.063230855193645e-07 0.7581313010100689 5.063232032989716e-07 0.7596352654099263 5.063233316974594e-07 0.7612620174900669 \
5.063234740211609e-07 0.7630496612437514 5.063235904103157e-07 0.7644991888858087 5.063237361339775e-07 0.7662987831554334 5.063238579138671e-07 0.7677897310961733 \
5.06323976478797e-07 0.7692300520321635 5.063240990922458e-07 0.7707078417740018 5.063242255436292e-07 0.77221964326554 5.06324335666584e-07 0.7735261258099556 \
5.063244611887263e-07 0.7750039859681491 5.06324566849672e-07 0.7762386743660952 5.063247020268293e-07 0.7778058706872942 5.063248256373457e-07 0.7792267957652825 \
5.06324955634725e-07 0.7807078764205345 5.06325068606223e-07 0.7819831642610904 5.063251765001111e-07 0.7831908181350914 5.063253130307933e-07 0.7847046126527283 \
5.063254631517019e-07 0.7863508260127218 5.063256054160057e-07 0.7878933964149381 5.063257249975189e-07 0.7891771019825847 5.063258618086489e-07 0.7906313890246753 \
5.063259843124129e-07 0.7919206245676671 5.063261289843411e-07 0.7934276941869095 5.063262697694143e-07 0.794878360380241 5.063263965852094e-07 0.796171745508174 \
5.063265156326018e-07 0.7973744708066829 5.063266278955628e-07 0.7984986270115709 5.063267322833333e-07 0.7995352562746869 5.063268275603949e-07 0.8004739840425704 \
5.063269639028913e-07 0.8018044219089175 5.063270807679598e-07 0.8029326473252685 5.063272003644895e-07 0.8040757482679398 5.063273222502994e-07 0.8052288531124292 \
5.063274448385593e-07 0.8063765489401953 5.06327572579618e-07 0.8075599074701925 5.06327697362526e-07 0.8087035441861687 5.063278278629006e-07 0.8098867241643505 \
5.063279542295969e-07 0.8110199871086299 5.06328081578389e-07 0.8121498004723215 5.063281867911793e-07 0.8130740322933268 5.063282914951838e-07 0.8139855427426806 \
5.063283830253901e-07 0.8147757515715357 5.063285063983601e-07 0.8158311616195392 5.063285933524084e-07 0.8165684017534872 5.063286922082447e-07 0.8173999442793862 \
5.063288367108844e-07 0.8186029267949408 5.063289730365725e-07 0.8197243345631372 5.063290824450085e-07 0.8206145128367788 5.06329228461948e-07 0.821788834531623 \
5.063293802030074e-07 0.8229927727264784 5.063295061195854e-07 0.8239792970156907 5.063296505686489e-07 0.8250971468990039 5.063297752648172e-07 0.8260503472050121 \
5.063299258788342e-07 0.8271873005969326 5.063300612493022e-07 0.8281959289694237 5.063301864729373e-07 0.8291179217777711 5.063303041288969e-07 0.8299746468143927 \
5.063304499105104e-07 0.8310230722388168 5.063306163942599e-07 0.8322027532553667 5.063307472150236e-07 0.8331167337813133 5.063309206750455e-07 0.834311196379941 \
5.063310887878414e-07 0.8354501125721271 5.063312586689692e-07 0.8365827385393307 5.063314395126276e-07 0.8377685497174457 5.063315827046921e-07 0.8386931238161603 \
5.063316968221893e-07 0.8394210074154138 5.063318268737995e-07 0.8402408682651782 5.063319287535162e-07 0.8408758513273116 5.063320456411388e-07 0.841596551294542 \
5.063321827868591e-07 0.8424315815669623 5.063323806960722e-07 0.8436167827761205 5.063325725154114e-07 0.8447436440637145 5.063327818661576e-07 0.8459494874145237 \
5.06332964017768e-07 0.8469786287449077 5.063331611039906e-07 0.8480715276019779 5.063333343567189e-07 0.8490148531186206 5.063335174509634e-07 0.8499943787178993 \
5.063336885824299e-07 0.8508936588199895 5.063338632702718e-07 0.8517955326875627 5.063340385042873e-07 0.8526841769874772 5.063342146411542e-07 0.8535614892404448 \
5.063344050084937e-07 0.8544920815553035 5.063345955808446e-07 0.8554057038167108 5.063347959768378e-07 0.8563474066245403 5.063349885664634e-07 0.8572344253714166 \
5.06335199466375e-07 0.858185963363946 5.063354273418618e-07 0.8591913103610016 5.063356934247181e-07 0.8603357477151101 5.063359919268544e-07 0.8615822374427254 \
5.063362678163234e-07 0.8627000332972231 5.063365520834926e-07 0.8638181192989086 5.063368262214432e-07 0.8648650323418529 5.06337098522366e-07 0.8658754039994767 \
5.063373686785625e-07 0.8668495780678541 5.063376258626989e-07 0.8677515347235455 5.063378984216134e-07 0.8686810999091764 5.063381744693315e-07 0.8695957110915412 \
5.063384445895985e-07 0.8704649939918846 5.063387444494889e-07 0.8714007440816277 5.063391154301144e-07 0.8725171209518352 5.063394103525362e-07 0.8733732402027278 \
5.063396646282708e-07 0.8740897163373675 5.06339962841735e-07 0.8749052413925265 5.063402364113466e-07 0.8756305047096297 5.063404725347486e-07 0.8762394088953867 \
5.063407128598864e-07 0.8768433401198644 5.063409351938211e-07 0.8773882060838187 5.063411292002539e-07 0.8778530214284207 5.063414589096812e-07 0.8786208714695904 \
5.063416140810901e-07 0.87897283049042 5.063419317234907e-07 0.8796750328643211 5.063421106040349e-07 0.8800599154915705 5.063424530647979e-07 0.8807759898408113 \
5.063426372672098e-07 0.8811501695110489 5.063431122965131e-07 0.8820806183873429 5.06343279683462e-07 0.8823969901232691 5.063437454598435e-07 0.8832471741583867 \
5.063439262991872e-07 0.8835657112976044 5.063444203088052e-07 0.8844044135654346 5.063445616237109e-07 0.8846360992458032 5.063451678673266e-07 0.8855901496945974 \
5.063453199425257e-07 0.8858196526512701 5.063459666625989e-07 0.8867549368993356 5.063460949492666e-07 0.8869330782847171 5.063467431586864e-07 0.8877977435561634 \
5.06346872882985e-07 0.8879638504720397 5.063476413020526e-07 0.8888993076310558 5.063477710739033e-07 0.8890488273083775 5.063486247365088e-07 0.8899738047157748 \
5.063487677615613e-07 0.8901192131187072 5.063497540670479e-07 0.8910487927319016 5.063499755535999e-07 0.8912403904783051 5.063511183781384e-07 0.8921548233216382 \
5.063512482580762e-07 0.8922544308366913 5.06352600758498e-07 0.8932425879319322 5.063527510414313e-07 0.8933452769452155 5.063542315756977e-07 0.8942627870546499 \
5.063544704854918e-07 0.8943950258099049 5.063562525184327e-07 0.8952625983306248 5.063566382658602e-07 0.895426813549116 5.063590404240788e-07 0.8963023915260389 \
5.063595153600486e-07 0.8964490046842035 5.063634332871647e-07 0.8974035634625627 5.063639032474093e-07 0.8974927205890085 5.063722720353867e-07 0.8984807567386782 \
5.063724925457144e-07 0.8984960697096243 5.064170720742926e-07 0.8994905034760702 5.064182734601916e-07 0.8995076493514624 5.065540832686942e-07 0.9004821828323031 \
5.065542622454192e-07 0.9005421539807538 5.065577071203374e-07 0.8996085030263692 5.065578799041917e-07 0.8994755022453073 5.065592062238996e-07 0.8985168769831137 \
5.06559392989208e-07 0.8983970610744239 5.065611771942332e-07 0.8974304740967198 5.065613893245152e-07 0.8973403978332656 5.065747300202991e-07 0.8983331062395279 \
5.065748433081446e-07 0.8983517458922662 5.065835466612413e-07 0.8993273409280406 5.0658409447182e-07 0.8993637478389299 5.070766218437148e-07 0.9003542216796759 \
5.070767175825666e-07 0.9004233209197793 5.070776601319424e-07 0.9014023545001312 5.070778225852538e-07 0.9016297223302431 5.070783892915005e-07 0.9025464066367429 \
5.070784964622122e-07 0.9027401250447874 5.07078889770564e-07 0.9035002370985188 5.07079022567928e-07 0.9037710185404622 5.070794021690343e-07 0.9045728679206633 \
5.070795323837805e-07 0.9048512534150681 5.070799937900729e-07 0.9057878278182891 5.070801130371311e-07 0.9060008176934132 5.070815426461655e-07 0.9050557440230738 \
5.070816263162926e-07 0.9046580283931719 5.07081751622122e-07 0.9039622140338933 5.070818594362906e-07 0.9032622438705011 5.070819784306371e-07 0.9023800387125585 \
5.070820938028541e-07 0.9014106868475621 5.070821838997508e-07 0.900578017289966 5.070822953474548e-07 0.8994526603282017 5.070823814266029e-07 0.8985125975436928 \
5.070824873922515e-07 0.8972736935213672 5.070825871606176e-07 0.8960214106762436 5.070826681562277e-07 0.8949470092681954 5.070827778041954e-07 0.8934133399212493 \
5.070828633916056e-07 0.8921520042367302 5.070829555142148e-07 0.8907345325087322 5.07083043733598e-07 0.8893220116766375 5.070831525083507e-07 0.8875100775672261 \
5.070832354013856e-07 0.8860780350921965 5.070833439750573e-07 0.8841400608632336 5.070834362012525e-07 0.8824412727986957 5.070835208217502e-07 0.8808423775446282 \
5.0708360666218e-07 0.8791839877465467 5.0708368587706e-07 0.8776224824828824 5.070837619650304e-07 0.8760960492665846 5.070838543013987e-07 0.874210837196514 \
5.070839141777347e-07 0.8729702140710593 5.070839715660191e-07 0.8717685933706794 5.070840335611921e-07 0.8704574090763495 5.070840968400434e-07 0.8691057216070059 \
5.070841469113811e-07 0.8680269866686803 5.070841963535335e-07 0.8669542389500936 5.070842600232402e-07 0.8655623656543436 5.070843359706592e-07 0.8638877358586781 \
5.070843848016709e-07 0.8628032002737418 5.070844333256242e-07 0.8617197496806845 5.07084509037347e-07 0.8600184098866027 5.070845762461248e-07 0.8584975010852487 \
5.070846189526311e-07 0.8575263577286506 5.070846628552044e-07 0.8565244243916033 5.070847506603508e-07 0.8545103166059256 5.070848135135196e-07 0.8530605771626394 \
5.070848721831768e-07 0.8517018597088126 5.070849083617784e-07 0.8508614974547222 5.07084943180258e-07 0.8500510151036469 5.070849782062432e-07 0.8492340038666518 \
5.070850482582133e-07 0.8475953578585981 5.07085096728698e-07 0.8464581214772323 5.070851406734992e-07 0.8454248116355969 5.070851861912554e-07 0.8443523575543517 \
5.070852500921663e-07 0.8428433081697474 5.070853162185396e-07 0.8412777165526386 5.07085421348608e-07 0.8387809254526315 5.070855092832832e-07 0.8366857089760468 \
5.070855882285649e-07 0.834800137446173 5.070856763936022e-07 0.8326899670047023 5.070857632095988e-07 0.8306078985741704 5.070858511012833e-07 0.8284959280419055 \
5.070859423503732e-07 0.8262996967350639 5.070860451122408e-07 0.8238226494465998 5.070861436157165e-07 0.8214450402687625 5.070862559486315e-07 0.8187302447322098 \
5.070863689227677e-07 0.8159967029774419 5.070864902106627e-07 0.8130591602364435 5.070866207178167e-07 0.8098958628758253 5.070867497637196e-07 0.8067658935936169 \
5.070869032393199e-07 0.8030416153605923 5.070870685235405e-07 0.799029304640783 5.070872362647446e-07 0.7949567682299736 5.070874327883338e-07 0.7901857478752816 \
5.07087637550659e-07 0.7852160332972318 5.070878502277153e-07 0.7800563994093253 5.070880508476619e-07 0.7751902022758907 5.070882517063895e-07 0.7703212856706637 \
5.070884017284074e-07 0.766686939713112 5.070885322635739e-07 0.7635264252913375 5.070886666810141e-07 0.7602735436595947 5.070887728765445e-07 0.7577048602246427 \
5.070889061828773e-07 0.754482067181252 5.070890132158029e-07 0.7518959494812111 5.070891562917044e-07 0.7484409822837247 5.070893207978459e-07 0.7444713482725677 \
5.070894416150925e-07 0.74155777711076 5.070896127217564e-07 0.7374334100931738 5.070897736123089e-07 0.733558046396253 5.070899902049297e-07 0.7283457217000903 \
5.070901834606309e-07 0.7236999380850822 5.07090362395765e-07 0.7194029726762079 5.070905292123874e-07 0.7154015770462002 5.070907154183522e-07 0.7109395231330657 \
5.070909033515934e-07 0.7064416825495208 5.070910692736986e-07 0.7024749886985119 5.07091261631787e-07 0.6978803202016938 5.07091402988682e-07 0.6945068232011449 \
5.070915599964439e-07 0.6907636199298515 5.07091755976089e-07 0.6860965106368763 5.070919184101942e-07 0.6822325558671515 5.070920795863762e-07 0.6784034260021697 \
5.070922718945738e-07 0.6738409413562468 5.070924895564538e-07 0.6686845685784016 5.070927375777557e-07 0.6628199086538362 5.07092915635219e-07 0.6586162961343578 \
5.070931641790282e-07 0.6527567611811057 5.070933667862709e-07 0.6479896840619462 5.07093536596938e-07 0.6440011601507294 5.07093695213124e-07 0.6402799599229552 \
5.070938337435587e-07 0.637035894415233 5.070939699513215e-07 0.6338503464729111 5.070940962626978e-07 0.6309003762865483 5.070942257219331e-07 0.6278810604265532 \
5.070943540536725e-07 0.6248911458464299 5.070944853836027e-07 0.6218374290191309 5.070946174102147e-07 0.6187713222160208 5.070947615700951e-07 0.6154276788919771 \
5.070949057786871e-07 0.6120888358645944 5.070950534337911e-07 0.6086753592300279 5.070952004901491e-07 0.6052842859263143 5.070953583041756e-07 0.6016504852589418 \
5.070954909098278e-07 0.5986039825107707 5.070956223747947e-07 0.5955897059985247 5.070957418045935e-07 0.5928552647156846 5.070958778732863e-07 0.5897484304797134 \
5.070959928015483e-07 0.5871283594046445 5.070961439122688e-07 0.5836892419704927 5.070962585613367e-07 0.5810871834776226 5.070963764990063e-07 0.5784138884735546 \
5.070964662802944e-07 0.576381560286313 5.070965565996887e-07 0.5743415774978985 5.070966232905592e-07 0.5728373329037385 5.070966888523724e-07 0.5713590910263378 \
5.070967398944957e-07 0.5702089751121119 5.070968015962151e-07 0.5688198806440578 5.070968646860707e-07 0.5674025889664359 5.070969290444246e-07 0.5659586381304559 \
5.070969824382236e-07 0.5647616504486359 5.070970750808062e-07 0.5626864159088959 5.070971516880784e-07 0.5609719030357503 5.070972075131406e-07 0.5597256439368602 \
5.070972765672667e-07 0.5581857825097393 5.070973834553926e-07 0.5558054549196561 5.070974611990176e-07 0.5540764009223496 5.070975620491174e-07 0.5518382286767042 \
5.070976877299716e-07 0.5490568313009737 5.070977879716568e-07 0.5468419758621708 5.070978998893402e-07 0.5443739014182352 5.070980031552469e-07 0.5421024366463116 \
5.070981229045887e-07 0.5394737463112931 5.070982246374689e-07 0.5372436950013484 5.070983401572132e-07 0.5347185748314579 5.070984551922987e-07 0.5322102907975605 \
5.07098581673211e-07 0.529456475824718 5.070987070470086e-07 0.5267350629320526 5.070988538629319e-07 0.5235577714138258 5.070989894263807e-07 0.5206304261698983 \
5.070991471246342e-07 0.5172373565578411 5.070993094436886e-07 0.5137528589513558 5.070994902675847e-07 0.5098871206809381 5.070996827159054e-07 0.5057874350093188 \
5.070998956212086e-07 0.5012700264709963 5.071001278026081e-07 0.4963634062180514 5.071003850931866e-07 0.4909555076455908 5.071006247190101e-07 0.4859407514401474 \
5.071009264344461e-07 0.479662588092526 5.071012143537997e-07 0.4737079198104491 5.071015272426188e-07 0.4672821326282255 5.071018469808238e-07 0.4607585360408045 \
5.071021865759847e-07 0.4538766993710576 5.071025134784829e-07 0.4472977926730654 5.071028490368641e-07 0.4405887635920606 5.071031661327867e-07 0.4342949501181722 \
5.071035003705415e-07 0.4277061431972559 5.071038518016635e-07 0.4208322784122511 5.071041663278176e-07 0.4147233751108969 5.071044895053079e-07 0.4084912998479469 \
5.071049306200656e-07 0.400057814108821 5.071052727361034e-07 0.3935812134363078 5.071055726806328e-07 0.3879522399691127 5.071059478116385e-07 0.3809760137481454 \
5.071062775558776e-07 0.3749002425561211 5.071065607988036e-07 0.3697269896098562 5.071068609450588e-07 0.3642865787664632 5.071071405472531e-07 0.3592589179584539 \
5.071073643233647e-07 0.3552676761685443 5.071075761036954e-07 0.3515151294490645 5.071077785371594e-07 0.3479514629380864 5.071079796284271e-07 0.3444362246481504 \
5.071081853428453e-07 0.3408632458568372 5.071084529657171e-07 0.3362478643926977 5.071086918970113e-07 0.3321601360780691 5.07108925403074e-07 0.3281974319442653 \
5.071091388684736e-07 0.3246000376975314 5.071093602460465e-07 0.3208952602338652 5.071095602096931e-07 0.3175728982722026 5.07109764482006e-07 0.3142073831356898 \
5.071099618288778e-07 0.3109812293225088 5.071101472014048e-07 0.3079732989686547 5.071103433077958e-07 0.3048147723336881 5.071105455849362e-07 0.3015820927993307 \
5.071107212432327e-07 0.2988007390096292 5.0711090711339e-07 0.295878328903569 5.071111140927825e-07 0.2926488196724605 5.071112994143739e-07 0.2897857719971084 \
5.071114946411816e-07 0.2867989994419413 5.07111650415531e-07 0.28443329608414 5.071118291723129e-07 0.2817356906084737 5.071120102032329e-07 0.2790344478478936 \
5.071121601003467e-07 0.2768142575519123 5.071123611437743e-07 0.273859574769726 5.071125102589039e-07 0.2716833853889438 5.071126487983334e-07 0.2696726034832688 \
5.071128006734089e-07 0.2674956304896134 5.071129151475376e-07 0.2658586287383957 5.071130466774683e-07 0.2639823142040156 5.071131724359563e-07 0.2622048582339201 \
5.071132767763623e-07 0.2607341604582348 5.071133897557217e-07 0.2591418073851619 5.071135060842464e-07 0.2575033437579446 5.071136490116675e-07 0.2554974228347739 \
5.071137622731725e-07 0.2539102348881249 5.071138964299053e-07 0.2520298733123076 5.071140069027097e-07 0.2504818583075984 5.071141623352847e-07 0.2483006006477398 \
5.071143032203835e-07 0.2463217957442577 5.071144546129539e-07 0.2441928603691365 5.071146097750345e-07 0.2420086586735095 5.071147391842834e-07 0.2401849910837116 \
5.071148738963765e-07 0.2382868210192302 5.071150115942015e-07 0.2363478190565156 5.071151293462172e-07 0.2346905900295477 5.071152886704099e-07 0.2324499447852502 \
5.071154259326364e-07 0.2305210708572645 5.071155666789934e-07 0.2285488733964877 5.071156724701667e-07 0.2270688194984586 5.071158024115645e-07 0.2252532503786337 \
5.071159029480281e-07 0.2238506847401111 5.071160052817357e-07 0.2224250970611539 5.071160790103171e-07 0.2214012665004395 5.071161582442603e-07 0.2203047212273054 \
5.071162292155075e-07 0.2193236206014474 5.071162806785351e-07 0.218612902325451 5.071163336269882e-07 0.2178825126218075 5.071164127819908e-07 0.2167921001391954 \
5.071164550546259e-07 0.2162104926182252 5.071164948991708e-07 0.2156628374086678 5.071165381228204e-07 0.2150692779925967 5.071165790298224e-07 0.2145080585354088 \
5.071166491522843e-07 0.2135474129702876 5.071166828372557e-07 0.2130867492099046 5.071167276666377e-07 0.212477723463 5.071167865237998e-07 0.2116792343136102 \
5.071168513092604e-07 0.2108017053965978 5.071169087900245e-07 0.2100241135398916 5.071169692190328e-07 0.209207737948094 5.071170662554631e-07 0.2078991976528634 \
5.07117150945123e-07 0.2067595417901527 5.071172598558851e-07 0.2052972881712416 5.071173562566921e-07 0.2040065614180294 5.071174512733293e-07 0.2027428333585779 \
5.071175547051275e-07 0.2013717100485363 5.071176496344727e-07 0.2001158751783069 5.071177526548994e-07 0.198757993281026 5.071178577373321e-07 0.1973779917312911 \
5.071179670461462e-07 0.1959482000350934 5.07118077489628e-07 0.1945091075764383 5.071181937799036e-07 0.1929996650696684 5.071183037098964e-07 0.1915811184357085 \
5.071184133723204e-07 0.1901717999899754 5.071185150889654e-07 0.1888694322720079 5.071186080436791e-07 0.1876837490531375 5.07118700772569e-07 0.1865049219968967 \
5.07118774458125e-07 0.1855719169757668 5.071188572993398e-07 0.1845269810791141 5.071189318853365e-07 0.1835895008849975 5.071190016086783e-07 0.1827150226754214 \
5.071190683270854e-07 0.1818808699270075 5.071191641704113e-07 0.1806871657728035 5.071192468771838e-07 0.1796611249561687 5.071193404410075e-07 0.1785035608809835 \
5.071194353370949e-07 0.1773351434884491 5.071195467074052e-07 0.1759704596301353 5.071196883497589e-07 0.1742450478777388 5.071198035966122e-07 0.1728486436789435 \
5.071199481442513e-07 0.1711076225712051 5.071200597399285e-07 0.1697708811114609 5.071202009589021e-07 0.1680898955975501 5.071203166961755e-07 0.1667201145354908 \
5.071204226568608e-07 0.1654722325850081 5.071205214164775e-07 0.164314417410061 5.071206177596498e-07 0.1631901152369615 5.071207064174022e-07 0.1621596955203892 \
5.071208317516728e-07 0.1607099933926625 5.071209262770884e-07 0.1596224416957933 5.071210240160401e-07 0.1585042187118262 5.071211321109171e-07 0.1572745454417887 \
5.071212267786047e-07 0.1562036643369483 5.071213342264514e-07 0.1549951394274829 5.071214253154951e-07 0.1539767092330788 5.071215320872068e-07 0.1527896463435911 \
5.071216354804728e-07 0.1516469620792683 5.071217465609577e-07 0.1504267727114754 5.071218357869394e-07 0.1494522115900035 5.071219212668682e-07 0.1485231035185812 \
5.071220051920548e-07 0.1476157397758405 5.071220748986192e-07 0.1468658175993407 5.071221535366968e-07 0.1460232248551682 5.071222318479541e-07 0.1451880611912267 \
5.071223024838273e-07 0.1444378248611795 5.071223879746948e-07 0.1435337156153706 5.071224753636722e-07 0.1426139614481139 5.071225569511858e-07 0.1417594571206545 \
5.071226542701372e-07 0.1407454482154784 5.071227349596596e-07 0.139910090776864 5.071228257446906e-07 0.1389752404035735 5.07122947088963e-07 0.1377336220260025 \
5.071230361386038e-07 0.13682812281983 5.071231346554539e-07 0.1358318692385875 5.071232217417229e-07 0.1349560640726983 5.071233321526109e-07 0.1338550874529322 \
5.071234206114333e-07 0.1329791517134813 5.071235213400266e-07 0.1319874611681985 5.071236261295802e-07 0.1309622419763913 5.071237205198131e-07 0.1300442429014473 \
5.07123817024605e-07 0.1291112112475518 5.071239165112583e-07 0.1281591654439075 5.071240029124292e-07 0.1273384721630967 5.071240978925598e-07 0.1264411177628728 \
5.071242020813879e-07 0.1254629331099751 5.071243112001386e-07 0.124445178694 5.071244055505945e-07 0.1235704029653004 5.07124517846343e-07 0.1225411084520107 \
5.071246133096966e-07 0.1216733466577494 5.071247175205873e-07 0.1207311846737792 5.071248068659445e-07 0.1199276649878674 5.071248772532174e-07 0.1192980345746366 \
5.071249526392512e-07 0.1186268760051257 5.071250287714207e-07 0.1179522201461119 5.071250977489184e-07 0.1173458504859956 5.071251802680909e-07 0.1166263596898966 \
5.071252522115779e-07 0.1160015972854393 5.071253342903043e-07 0.1152916772467617 5.0712541862478e-07 0.1145654108773922 5.07125496418619e-07 0.113898375935255 \
5.071255891835211e-07 0.1131065723182637 5.071257047873425e-07 0.1121254933399327 5.071258106929114e-07 0.1112341778178403 5.071258883498311e-07 0.1105854195321705 \
5.071259766463023e-07 0.1098504899494786 5.071260567033545e-07 0.1091866403929743 5.071261536294793e-07 0.1083861389179563 5.07126248864964e-07 0.1076031391441806 \
5.071263374361587e-07 0.1068780200140514 5.071264387442599e-07 0.1060523297458165 5.071265442899472e-07 0.1051963702337609 5.071266534843118e-07 0.1043160928234657 \
5.071267616019328e-07 0.1034503663302994 5.071268815196938e-07 0.1024949450012773 5.071269828815214e-07 0.1016914181115986 5.071270888911509e-07 0.100855068690839 \
5.071272146827803e-07 0.09986840123414902 5.071273442400856e-07 0.09885896724496235 5.071274799154405e-07 0.09780904711780367 5.071276559873036e-07 0.09645781830037269 \
5.071278197878237e-07 0.09521257997344186 5.071279826125652e-07 0.09398642071914091 5.071280677512003e-07 0.09334985726464029 5.07128137589223e-07 0.09282999162688726 \
5.071282070848284e-07 0.09231474740697931 5.071282810434879e-07 0.09176875214326782 5.071283771983754e-07 0.09106241641841166 5.071284516137408e-07 0.09051841344162129 \
5.071285296033096e-07 0.08995079828656057 5.071286060521395e-07 0.08939693755534793 5.071286935462239e-07 0.08876614459792892 5.071287957229341e-07 0.08803382885421264 \
5.071288842873223e-07 0.08740269463919083 5.071289939528099e-07 0.08662585268124241 5.071291100092175e-07 0.08580942306245626 5.07129251558034e-07 0.0848216759818637 \
5.071293844270175e-07 0.08390253510334872 5.071295251873282e-07 0.08293727564630923 5.071296748969478e-07 0.08192024575105315 5.071298106088348e-07 0.08100683753927941 \
5.071299521257171e-07 0.08006309454860433 5.071300872475907e-07 0.07917070961097784 5.071302285200282e-07 0.07824718349428782 5.071303756129204e-07 0.07729532867436953 \
5.07130527122786e-07 0.07632524417621221 5.071306924984999e-07 0.07527819040792309 5.071308562596902e-07 0.07425356708383206 5.071310323896319e-07 0.07316505371836476 \
5.071312215286099e-07 0.07201151367936541 5.071314322022336e-07 0.07074528708793332 5.071316517688555e-07 0.06944624562626683 5.071318865352622e-07 0.06808094281860989 \
5.071321449277002e-07 0.06660616301228137 5.071324395923604e-07 0.06496103773121734 5.071327436716829e-07 0.06330286177969326 5.071331045821629e-07 0.06138472526627536 \
5.071334404990351e-07 0.05964719353945821 5.071338806764061e-07 0.05743991201668189 5.071342590438092e-07 0.05560437501227136 5.071347015027716e-07 0.05352996728430704 \
5.071350555229165e-07 0.05192508193542229 5.071354420396718e-07 0.05022502935509546 5.071357866437289e-07 0.04875485597254389 5.071361086186649e-07 0.04741934964807833 \
5.07136412152492e-07 0.04619304551845941 5.071367070734883e-07 0.04503122626702559 5.071369895557667e-07 0.04394770877170886 5.071372666361775e-07 0.04291147062934708 \
5.071375323636684e-07 0.04194013461971725 5.071378035943552e-07 0.0409708748276704 5.071380798533722e-07 0.04000619535229137 5.071383697525942e-07 0.03901828782233653 \
5.071385981289875e-07 0.03825741181922668 5.071389030130544e-07 0.03726495139513845 5.071391196849105e-07 0.03657573971894532 5.071393110416373e-07 0.03597943984071691 \
5.071395096361558e-07 0.03537298232318693 5.071398395514967e-07 0.03438820140908775 5.071400814971701e-07 0.03368375433354889 5.071403968092222e-07 0.03278771666975258 \
5.071406669292072e-07 0.03203957074185158 5.071409233008807e-07 0.03134567005659093 5.071412033128806e-07 0.03060515313352298 5.071414489686567e-07 0.02997014710356035 \
5.071416817043017e-07 0.02938120249260199 5.07141924434299e-07 0.02878348292867495 5.071421611615635e-07 0.02821317433052753 5.071423898079744e-07 0.0276732289298247 \
5.071428070936345e-07 0.02671456010533928 5.071430022743284e-07 0.02627749693639509 5.071433834414109e-07 0.02544369227895442 5.071435606942329e-07 0.02506446942885681 \
5.071439031456878e-07 0.02434654114125227 5.0714405641412e-07 0.02403127656358269 5.071444314325841e-07 0.02327616399748992 5.071445690667252e-07 0.02300530455388665 \
5.071450533333593e-07 0.02207084195640928 5.071451729527604e-07 0.02184403312078184 5.071455899915635e-07 0.02106026682208277 5.07145733393791e-07 0.02079332360769017 \
5.071462546051726e-07 0.01984598817089831 5.071463823790427e-07 0.0196205814374062 5.071469667914166e-07 0.01863359713481367 5.071471392268229e-07 0.01835589372257288 \
5.071477433235728e-07 0.01743644241612937 5.071479047552142e-07 0.01720262545858322 5.071485447014338e-07 0.01631831686205014 5.071487230176005e-07 0.016083210242981 \
5.071493710016487e-07 0.01526127675881721 5.071495362552397e-07 0.01505930898173208 5.071502725571753e-07 0.01419381259610907 5.071504068332254e-07 0.01404154276213586 \
5.071512039327433e-07 0.01317592498067951 5.071513445303545e-07 0.01302934089458718 5.071523098735771e-07 0.0120661300044765 5.071524742123827e-07 0.01190857475316222 \
5.071534749435119e-07 0.01099048917119646 5.071536122133689e-07 0.01087009009405628 5.071547509078863e-07 0.009949273443646761 5.071548650857871e-07 0.009863136028526375 \
5.071562457306217e-07 0.008889755784408603 5.071564000878327e-07 0.00878832203975914 5.071579465820611e-07 0.00781340401000951 5.071580309437644e-07 0.007760176032106158 \
5.07159716371082e-07 0.006770348169342283 5.071598398995725e-07 0.00670487246831437 5.071618897141387e-07 0.005720970231232756 5.071620861142965e-07 0.005634691917282852 \
5.071644047936537e-07 0.004698942116576918 5.071648654079885e-07 0.004530544077955615 5.071676055035305e-07 0.003639937533647344 5.071681236485673e-07 0.00349159181499799 \
5.071722742898753e-07 0.002502201117031859 5.071728121398825e-07 0.002396807933581942 5.0717889437533e-07 0.001421603691354927 5.071791533557405e-07 0.001378272220758726 \
5.071844761190904e-07 0.0003814093765652445 5.071845892761344e-07 0.0003711807182531981 5.098307063923701e-07 -0.0004615907568095335 5.098308688313385e-07 -0.0006852153244161934 \
5.098313698328069e-07 -0.001554404032531494 5.098314540153697e-07 -0.001725199767551738 5.098318555381937e-07 -0.002626792336557519 5.098319448731606e-07 -0.002845673237760077 \
5.098322314649697e-07 -0.0035898660494722 5.098323590334992e-07 -0.003937855927128601 5.098326777451613e-07 -0.004830400105952924 5.098327919463135e-07 -0.00515011308870196 \
5.098330743466382e-07 -0.005887653497963378 5.098332045728569e-07 -0.006177415671381139 5.098341829257541e-07 -0.005220113099403402 5.098343702332871e-07 -0.004004368716724641 \
5.098345016776888e-07 -0.002901539130564616 5.098346071052425e-07 -0.001869327786897239 5.098346928227261e-07 -0.0009323217369615201 5.098347747492128e-07 4.151965372454519e-05 \
5.098348957860361e-07 0.001618129410352471 5.098349947146828e-07 0.003024565667809575 5.098351531113568e-07 0.005482561958548801 5.098353705585866e-07 0.00923691162542661 \
5.098355517808096e-07 0.0126653356758144 5.09835763874906e-07 0.01697021734206094 5.098359268985627e-07 0.02046388365739064 5.098360875209785e-07 0.02403759527126768 \
5.09836241061221e-07 0.02755862871109176 5.098363891179022e-07 0.031036270750196 5.098365381988111e-07 0.03460722192241437 5.098366927287224e-07 0.03837091703902212 \
5.098368533795379e-07 0.04234026030123839 5.098370180342185e-07 0.04645786783841532 5.098371945751168e-07 0.05091770581196236 5.098373735379687e-07 0.05547793877747508 \
5.098375642811338e-07 0.0603721650098247 5.09837769062163e-07 0.06565647483694508 5.098379895344492e-07 0.07137203566208646 5.098382223941741e-07 0.0774299331224613 \
5.098384715816505e-07 0.08392829098722057 5.098387444237776e-07 0.09105513637423955 5.098390411275777e-07 0.09880974921055499 5.098393684539683e-07 0.1073623706929605 \
5.098397381053549e-07 0.11701033799881 5.098401329771689e-07 0.1273002725707723 5.098405908154096e-07 0.1392030195235975 5.098411226222497e-07 0.1529832553757746 \
5.09841747860046e-07 0.1691182447448397 5.098424336075175e-07 0.1867241161332086 5.098432360033912e-07 0.2071957342970069 5.09844134802183e-07 0.2299563735557614 \
5.098449404156324e-07 0.2501946571168963 5.098456541669657e-07 0.2679877251922811 5.098462837288478e-07 0.2835633151515627 5.098468540922982e-07 0.2975737963344939 \
5.098473850476804e-07 0.3105173405876944 5.098478868351306e-07 0.3226580892822354 5.098483661296844e-07 0.3341673054699896 5.098488316851033e-07 0.3452566901045974 \
5.098492954815109e-07 0.3562094254686541 5.098497512295407e-07 0.3668794056881832 5.098502114496752e-07 0.3775613305945491 5.098507497336462e-07 0.3899285626759094 \
5.098512505841795e-07 0.4013172511919189 5.098516508068632e-07 0.4103337945930838 5.09852157667644e-07 0.421642452039157 5.098526436338564e-07 0.4323669409017459 \
5.098530431485677e-07 0.4410997362599856 5.098534537606271e-07 0.4500002277813482 5.098538826870602e-07 0.4592207708982954 5.098542842014423e-07 0.4677760623951868 \
5.098545915918887e-07 0.4742753916877908 5.098549418336473e-07 0.4816249679276425 5.098552950738506e-07 0.4889795533930016 5.0985554824443e-07 0.4942125642332652 \
5.098557811883199e-07 0.4989990073547648 5.098560228316108e-07 0.5039392821429431 5.098562478222295e-07 0.5085102868389438 5.098564398583375e-07 0.5123881070394828 \
5.098566246700343e-07 0.5161059569497825 5.098568469603498e-07 0.5205538992744256 5.098570136717574e-07 0.5238726938135662 5.098572308883525e-07 0.5281726418673847 \
5.098574339672442e-07 0.5321820613122353 5.098576113786994e-07 0.5356681922482178 5.098577994510862e-07 0.5393528234657015 5.098580354832655e-07 0.5439555888699217 \
5.098583013652895e-07 0.5491186112539347 5.098585231271783e-07 0.5534070305875756 5.098588031850331e-07 0.5588091140818973 5.098590461848179e-07 0.5634839438879177 \
5.09859321538161e-07 0.5687575845994758 5.098595665335016e-07 0.5734440561015828 5.098598068277205e-07 0.5780305526007354 5.098600478670233e-07 0.5826153106864888 \
5.09860305457841e-07 0.5874946531182738 5.098605408246178e-07 0.5919209497705462 5.09860772126727e-07 0.5962518282209535 5.098609946534482e-07 0.6003950532231523 \
5.098612030130559e-07 0.6042587207462122 5.098614408548706e-07 0.6086392006348278 5.098616517150854e-07 0.612499186772883 5.09861907322267e-07 0.617151767543529 \
5.098621060500327e-07 0.620751700070918 5.098623816826772e-07 0.6257066023742009 5.098626044387981e-07 0.6296824120643636 5.098628978099215e-07 0.6348814180513288 \
5.098631305799232e-07 0.6389753720667986 5.098633507813091e-07 0.6428252659334456 5.098635520519211e-07 0.6463216644290061 5.098637693407936e-07 0.6500784077528632 \
5.098639440567036e-07 0.6530842133917786 5.098641303213334e-07 0.6562672470877895 5.098643090603858e-07 0.6593113758161715 5.098644717643993e-07 0.6620700940033843 \
5.098646370334099e-07 0.6648583661366954 5.098647803012238e-07 0.6672607123132118 5.098649195316479e-07 0.669583864918244 5.098650593322145e-07 0.6719085596965743 \
5.098651941074222e-07 0.6741424479378803 5.098653216016632e-07 0.6762463034350935 5.098654545557747e-07 0.6784344250006583 5.098655761601248e-07 0.680430207161383 \
5.098657045733663e-07 0.6825336955632141 5.098658203404209e-07 0.6844241240890321 5.098659183815937e-07 0.686020684362688 5.098660190776997e-07 0.687656981754083 \
5.098661288314626e-07 0.689434454762776 5.098662455994179e-07 0.6913211166705923 5.098663368261915e-07 0.6927889453402305 5.098664460316049e-07 0.6945396927028351 \
5.098665471403262e-07 0.6961566646470493 5.098666425406181e-07 0.6976767415743361 5.098667520226425e-07 0.6994136821864276 5.098668864742773e-07 0.7015344809028976 \
5.098670354932137e-07 0.7038694457768003 5.098671644232324e-07 0.7058755144243859 5.09867311083691e-07 0.7081418729260142 5.098674378680718e-07 0.7100885084081828 \
5.098675624659611e-07 0.7119899232102255 5.098676743197281e-07 0.7136874821928206 5.098677872756922e-07 0.7153928249203609 5.098678878290893e-07 0.716903336497302 \
5.098680251105924e-07 0.7189542886859326 5.098681449794518e-07 0.7207346491296758 5.09868264162204e-07 0.7224952472954583 5.098683911643136e-07 0.7243608783177121 \
5.098685157126647e-07 0.726179956024653 5.098686393836757e-07 0.7279757435764195 5.09868765971953e-07 0.7298035010246171 5.098688965411881e-07 0.7316777339938921 \
5.098690190562223e-07 0.7334262671520465 5.098691552997129e-07 0.7353588786631546 5.098692567424861e-07 0.7367901064855561 5.098693627659689e-07 0.7382789144707947 \
5.098694532971524e-07 0.7395446819117977 5.098695671233782e-07 0.7411267287627761 5.098696547849604e-07 0.742338113895605 5.098697606802377e-07 0.7437932991468792 \
5.098698910335325e-07 0.7455718205320391 5.098700016011402e-07 0.7470699275523445 5.098701062716115e-07 0.7484790865773925 5.098702302331429e-07 0.7501360792234356 \
5.098703787905969e-07 0.752105598322839 5.098705004731933e-07 0.7537054667443914 5.098706145848825e-07 0.7551949470168074 5.098707550054835e-07 0.7570132059451244 \
5.098708965335436e-07 0.7588296197226846 5.098710143228134e-07 0.7603289862386273 5.098711425226351e-07 0.7619481626911874 5.098712845904683e-07 0.7637269294216019 \
5.098714014655762e-07 0.7651780119234867 5.098715471393621e-07 0.7669714049983392 5.098716688778096e-07 0.7684572223066155 5.098717875183015e-07 0.7698939375992205 \
5.098719099845945e-07 0.7713653733660819 5.098720367016846e-07 0.7728756341192486 5.098721466036787e-07 0.7741754302862822 5.098722722190223e-07 0.7756497674172792 \
5.098723780294307e-07 0.7768823528242577 5.098725141995534e-07 0.7784559787239111 5.098726385466015e-07 0.7798807766277074 5.098727659718769e-07 0.7813271999647126 \
5.098728805279563e-07 0.7826155184370988 5.098729872082258e-07 0.7838050786084815 5.098731251508229e-07 0.785328674235108 5.098732746003193e-07 0.7869612315653352 \
5.098734194525364e-07 0.7885256944569791 5.098735388882871e-07 0.7898026796320731 5.098736743131599e-07 0.7912364721526877 5.09873795807481e-07 0.7925100718437531 \
5.098739391665555e-07 0.7939977458315933 5.09874082600237e-07 0.7954699260458764 5.098742084112467e-07 0.7967479640295563 5.098743274579285e-07 0.7979459892863545 \
5.098744394715731e-07 0.7990632136113104 5.098745442634543e-07 0.8000996927221937 5.098746394563032e-07 0.8010335634530776 5.098747758668286e-07 0.8023587211299719 \
5.098748926790049e-07 0.8034813603122919 5.098750121402484e-07 0.8046180202255495 5.098751341806002e-07 0.8057672874017472 5.098752570806968e-07 0.8069126780167393 \
5.098753842000532e-07 0.8080849010520604 5.098755093419151e-07 0.8092265787736463 5.098756398931422e-07 0.8104047139317369 5.09875765969389e-07 0.811530109085512 \
5.098758939660489e-07 0.8126603425876329 5.09875999427297e-07 0.8135823118114501 5.098761026965977e-07 0.814477091043954 5.098761953499458e-07 0.8152732203909091 \
5.098763190441811e-07 0.8163262937528154 5.098764066640956e-07 0.8170655553659417 5.098765053301514e-07 0.8178914289762149 5.098766488771538e-07 0.819080619224994 \
5.098767844633065e-07 0.8201904093102529 5.09876893653288e-07 0.8210742465492874 5.09877041102747e-07 0.8222539401850584 5.09877191506449e-07 0.8234410273756358 \
5.098773169754118e-07 0.8244188977545531 5.098774611413952e-07 0.8255287290252299 5.098775854299598e-07 0.8264738611628292 5.098777359002563e-07 0.8276038147969816 \
5.098778715066145e-07 0.8286089145501508 5.098779966016159e-07 0.8295251220930787 5.098781143174533e-07 0.8303776282987162 5.098782602030521e-07 0.8314210189912619 \
5.098784266961482e-07 0.8325942517713072 5.098785575628508e-07 0.833503494447128 5.098787310074617e-07 0.8346911703335461 5.098788991402022e-07 0.8358239212093587 \
5.098790689939496e-07 0.8369500705213252 5.098792498869552e-07 0.838129582835239 5.098793930212162e-07 0.8390486258646698 5.098795071191619e-07 0.8397723391454259 \
5.098796372463218e-07 0.8405879656882547 5.098797391021787e-07 0.8412191375388212 5.098798559475988e-07 0.8419354178465567 5.098799929193963e-07 0.84276453896487 \
5.098801907591422e-07 0.843942473808897 5.098803824446297e-07 0.8450620046306492 5.09880591850993e-07 0.8462610422160779 5.098807738618767e-07 0.8472832413425977 \
5.098809709773334e-07 0.8483697584184032 5.098811442904469e-07 0.8493077402131245 5.098813273256562e-07 0.8502809338042043 5.098814984787831e-07 0.8511747489972419 \
5.098816731317363e-07 0.8520708361396651 5.098818483828913e-07 0.8529540285731302 5.098820245303913e-07 0.8538259128238825 5.098822148367787e-07 0.8547503816925358 \
5.098824054277478e-07 0.8556583881771193 5.098826059797908e-07 0.8565949481971697 5.098827985825885e-07 0.8574764650234362 5.098830093312883e-07 0.8584213553684483 \
5.098832373621856e-07 0.8594210644592908 5.098835032419522e-07 0.8605573106989262 5.098838018200941e-07 0.8617960322792503 5.098840779837292e-07 0.8629075153790151 \
5.098843622302292e-07 0.8640180616030438 5.098846364142308e-07 0.8650581816846495 5.098849086694401e-07 0.8660616517296992 5.098851788589146e-07 0.8670295451208139 \
5.098854360232381e-07 0.8679256252637404 5.098857085969722e-07 0.8688492356117473 5.098859846024351e-07 0.8697577927663542 5.09886254710518e-07 0.8706213441784563 \
5.098865545689379e-07 0.8715508809746347 5.098869255828164e-07 0.8726599440782473 5.09887220515529e-07 0.873510245983525 5.098874748008955e-07 0.8742218447789023 \
5.098877730441707e-07 0.8750318897722944 5.098880466409288e-07 0.8757523113099853 5.098882827679075e-07 0.8763571312809064 5.098885231072055e-07 0.876957042728428 \
5.098887454408612e-07 0.8774982514557473 5.098889394467937e-07 0.8779599514934209 5.098892691652286e-07 0.8787226653583874 5.09889424338019e-07 0.8790722725343518 \
5.098897420714095e-07 0.8797700114458387 5.098899209390604e-07 0.880152324917399 5.09890263400534e-07 0.8808637455080008 5.098904475523682e-07 0.8812353200296749 \
5.098909224784184e-07 0.8821594045029107 5.098910898716537e-07 0.8824737723885729 5.098915556929605e-07 0.8833186808430151 5.098917365204472e-07 0.883635209600208 \
5.098922305497856e-07 0.8844687288968743 5.098923718877728e-07 0.8846990198924604 5.098929782491027e-07 0.8856473543416146 5.098931303209552e-07 0.8858754372639542 \
5.098937770089477e-07 0.8868048391838264 5.09893905303109e-07 0.8869818633102416 5.098945534965822e-07 0.8878410756373726 5.098946832451334e-07 0.8880061989117775 \
5.09895451498601e-07 0.8889361126992519 5.098955812406254e-07 0.8890847997417872 5.098964346975574e-07 0.8900046759307325 5.098965779246734e-07 0.8901495209380393 \
5.098975641580769e-07 0.8910738355210844 5.09897785636141e-07 0.8912643084423501 5.098989286536885e-07 0.8921737958641509 5.098990586319893e-07 0.8922730011388891 \
5.099004103389882e-07 0.8932565980587214 5.099005606923423e-07 0.8933589605607284 5.09902041315768e-07 0.8942730372387374 5.0990228021907e-07 0.8944047337041336 \
5.099040613442277e-07 0.8952702388217941 5.099044473255946e-07 0.8954343910560414 5.099068488716344e-07 0.896309305076933 5.099073238084202e-07 0.8964562995603377 \
5.099111419701395e-07 0.8973944547681553 5.099116244593364e-07 0.897487269196476 5.099195104748493e-07 0.898471373493449 5.099201266375397e-07 0.8985180228791175 \
5.100152826123789e-07 0.899508178894561 5.100167732145567e-07 0.8995204306067698 5.101280612887407e-07 0.9005118233983579 5.101282376257435e-07 0.9005706457326812 \
5.10131860757067e-07 0.8996048713171836 5.101320419550936e-07 0.8994654179496379 5.101333530765704e-07 0.8985275682722235 5.101335349539762e-07 0.8984123497545736 \
5.101353579441702e-07 0.8974436520388238 5.101355178574243e-07 0.8973766233009967 5.101486686887231e-07 0.8983720910457982 5.101487796702765e-07 0.8983905835035384 \
5.101576012543832e-07 0.8993863063850064 5.101581480238466e-07 0.8994226481040219 5.106507199766804e-07 0.9003987622903815 5.106507897691656e-07 0.9004496773542636 \
5.106516224219291e-07 0.9012853800543292 5.10651748468094e-07 0.9014513953152168 5.106523289889575e-07 0.9023435091985418 5.106524699532118e-07 0.9025895326188698 \
5.106528690912907e-07 0.9033428289365844 5.106530192408316e-07 0.9036449200440446 5.106534623221535e-07 0.9045762589490434 5.106536194942561e-07 0.9049121924877023 \
5.106540651209874e-07 0.9058152254958243 5.106541635773263e-07 0.9059929146639856 5.106555802587203e-07 0.9052304871087643 5.10655711415865e-07 0.904616184869324 \
5.106558804230411e-07 0.9036290332250884 5.106560457149166e-07 0.9024406226812831 5.106561519806978e-07 0.9015554774641358 5.106562554175281e-07 0.9006052096506509 \
5.106563411842469e-07 0.8997486040545581 5.106564306782332e-07 0.8987887485205278 5.106565549226324e-07 0.8973492764100613 5.106566730035805e-07 0.8958624931586439 \
5.106567602196721e-07 0.8946938835082598 5.106568845267161e-07 0.8929289312882503 5.106569915106439e-07 0.8913158670103165 5.106570913423478e-07 0.8897378501708729 \
5.106572176331742e-07 0.8876466417139378 5.106573858217853e-07 0.884705368138502 5.106575415215381e-07 0.8818365157686672 5.106577381263672e-07 0.8780362649814708 \
5.106579217476167e-07 0.8743271923380105 5.106581332550105e-07 0.8698916163736473 5.106583140648105e-07 0.8659808238081558 5.106584986458582e-07 0.8618945354625286 \
5.106586716498537e-07 0.8579913311618118 5.106588570505038e-07 0.8537436868396935 5.106590361336512e-07 0.8495884889292737 5.106592197227131e-07 0.8452850234109005 \
5.106593864844182e-07 0.8413449312544377 5.10659554574996e-07 0.8373487193315756 5.10659717684167e-07 0.8334514816705533 5.106598728704026e-07 0.829729402178684 \
5.10660045969282e-07 0.8255639501984255 5.106602319597377e-07 0.8210763864673301 5.106603965802215e-07 0.8170961425007568 5.106605614501323e-07 0.8131038678717658 \
5.106607367821645e-07 0.8088537582860886 5.10660901208668e-07 0.8048648186953292 5.106610698442787e-07 0.8007719922541914 5.106612606476452e-07 0.7961398815555145 \
5.106614461718184e-07 0.7916360074082958 5.106616551006281e-07 0.7865651471012967 5.10661879917618e-07 0.7811107659751856 5.106620697327054e-07 0.77650678233121 \
5.106622715901883e-07 0.7716133355283564 5.106624158608268e-07 0.76811790639139 5.106625575043926e-07 0.7646880872338248 5.106626852021022e-07 0.7615975116975136 \
5.106627962479435e-07 0.7589113686396982 5.106629248105796e-07 0.7558028559024855 5.106630573760869e-07 0.7525995467138866 5.106631706977832e-07 0.7498629233610832 \
5.106633070324095e-07 0.7465723252212872 5.106634134316607e-07 0.7440058350410135 5.106635726504468e-07 0.7401674766516904 5.106637450281421e-07 0.7360137588823189 \
5.10663907275386e-07 0.7321074183421575 5.106640796243437e-07 0.7279612819449855 5.106642390105271e-07 0.7241302920521341 5.106644468157139e-07 0.7191408067115369 \
5.106646073553789e-07 0.7152908836069264 5.106647998447152e-07 0.7106793324906435 5.10664985361064e-07 0.7062404417184839 5.106651552371093e-07 0.7021802791355866 \
5.106653471069472e-07 0.6975984806629684 5.106654933309623e-07 0.6941099299715526 5.106656536173094e-07 0.6902897983225644 5.10665856006145e-07 0.6854719661536142 \
5.106660372946089e-07 0.681161582477689 5.106662061160357e-07 0.6771536053116509 5.106663919619109e-07 0.6727470762459599 5.106665978927512e-07 0.6678715161770782 \
5.10666765819558e-07 0.6639016226084196 5.106669260812615e-07 0.6601182542089066 5.106671649337354e-07 0.65448589698252 5.106673326948486e-07 0.6505369020837752 \
5.10667513768288e-07 0.6462813620835641 5.106676749231988e-07 0.642499550819208 5.106678211904597e-07 0.6390715923276049 5.106679598785689e-07 0.6358268652274862 \
5.106680892356149e-07 0.6328040340451749 5.106682186201702e-07 0.6297855584526113 5.106683469414899e-07 0.6267952385336898 5.106684771436295e-07 0.6237652412672913 \
5.106686061600736e-07 0.6207683673242944 5.10668744735633e-07 0.6175525629501428 5.1066889281122e-07 0.6141227553162802 5.106690791385051e-07 0.60981438109949 \
5.106692268222044e-07 0.6064079319686639 5.106694619864099e-07 0.600995965122186 5.106696544341406e-07 0.5965821560879089 5.106698950039548e-07 0.5910808370261941 \
5.106700640513256e-07 0.587228367631822 5.1067020171775e-07 0.5840969866928536 5.106703298227265e-07 0.581191110277254 5.106704434094219e-07 0.5786182870235701 \
5.106705347742257e-07 0.5765512826027382 5.106706241961132e-07 0.5745328691003393 5.106706914578463e-07 0.573016830490748 5.106707574780488e-07 0.5715297341779608 \
5.106708095317241e-07 0.5703577032508095 5.106708737705931e-07 0.5689124506700958 5.106709353071159e-07 0.5675311492520995 5.106709995886598e-07 0.5660899724818867 \
5.106710527797555e-07 0.5648985048860162 5.106711451255398e-07 0.5628316153148989 5.106712217014408e-07 0.5611191615154557 5.10671277545091e-07 0.5598732849310241 \
5.106713468881998e-07 0.5583285932816697 5.106714527394756e-07 0.5559733466166974 5.1067153043128e-07 0.5542469170533902 5.106716310298676e-07 0.5520159549745236 \
5.106717590630782e-07 0.5491849411292137 5.106718585604598e-07 0.5469885705929382 5.106719711258113e-07 0.544508366501287 5.106720741701315e-07 0.5422442603473754 \
5.106721942190172e-07 0.5396115972585003 5.106722958334261e-07 0.5373863339265779 5.10672411457693e-07 0.5348611538529422 5.106725265738741e-07 0.5323536236546169 \
5.106726530109181e-07 0.529604142030661 5.106727785251858e-07 0.5268822104345234 5.106729252048618e-07 0.5237112381511962 5.106730608755697e-07 0.5207845659358002 \
5.106732186414087e-07 0.5173942078023266 5.106733810633495e-07 0.5139116507621072 5.106735619718178e-07 0.5100482739823553 5.106737545639722e-07 0.5059503908118104 \
5.106739675557428e-07 0.5014368974673542 5.106741999884594e-07 0.4965308659362653 5.106744575093731e-07 0.49112491222925 5.106746974735513e-07 0.4861095397820235 \
5.106749986779056e-07 0.4798501326413723 5.106752869755342e-07 0.4738957353990632 5.106756000618611e-07 0.4674739717793394 5.106759195881406e-07 0.4609631488871989 \
5.106762590854062e-07 0.4540919149088484 5.106765852755183e-07 0.4475353831519197 5.106769217567802e-07 0.4408159131180407 5.106772384675872e-07 0.4345373385230166 \
5.106775725526604e-07 0.4279587671099637 5.106779242615286e-07 0.4210864038135054 5.106782387463783e-07 0.4149846225409808 5.106785621928357e-07 0.4087533091618546 \
5.106790031209485e-07 0.400331870031168 5.106793449160247e-07 0.3938679283557566 5.106796443500685e-07 0.3882534014213259 5.10680018872672e-07 0.3812944595528024 \
5.106803482503896e-07 0.375233915169682 5.10680631354694e-07 0.3700684563936956 5.106809310997049e-07 0.3646408765157301 5.106812105955488e-07 0.3596219010422631 \
5.10681434267487e-07 0.3556377385586224 5.106816459791946e-07 0.3518907610576284 5.106818484819268e-07 0.3483292724130969 5.10682049543475e-07 0.3448190020587957 \
5.106822552213836e-07 0.3412518188287665 5.106824735968597e-07 0.3374887625241871 5.106827173592566e-07 0.3333167726275162 5.106829441158294e-07 0.3294678078423895 \
5.106831640268007e-07 0.3257615367192951 5.106833824514083e-07 0.3221060038181086 5.106835864764178e-07 0.318715141566024 5.106837883342075e-07 0.3153870758963987 \
5.106839886575955e-07 0.3121102802474151 5.106841752715021e-07 0.309079115007194 5.106843725731086e-07 0.3058982938882217 5.10684581156335e-07 0.3025606704206737 \
5.106847867910569e-07 0.2992974534031506 5.106850115231367e-07 0.2957609785165763 5.106852284189794e-07 0.2923771984023277 5.106854360983307e-07 0.2891642611511841 \
5.106856671491776e-07 0.2856239464683982 5.10685841949429e-07 0.2829684481899911 5.10686021147604e-07 0.2802647299798244 5.106861900221201e-07 0.2777348429135014 \
5.106864183453934e-07 0.274348458173166 5.106865950826614e-07 0.2717528218126659 5.106867633653918e-07 0.2693020894036587 5.106869358321621e-07 0.2668230333489093 \
5.106870699344411e-07 0.264903804409765 5.10687215894446e-07 0.2628277003548514 5.106873545899465e-07 0.2608803500812688 5.106874768715512e-07 0.2591684246570544 \
5.106876109903814e-07 0.2572942758553639 5.106877400914858e-07 0.2554978336754472 5.106878595252204e-07 0.2538430842138498 5.106879863604196e-07 0.2520939183506197 \
5.106881060014414e-07 0.2504447954274527 5.106882556176352e-07 0.2483797066042054 5.106883904811462e-07 0.2465170278296022 5.106885200385602e-07 0.2447289494531232 \
5.106886771033789e-07 0.2425624627506451 5.106888010990138e-07 0.2408491463446025 5.106889412471492e-07 0.2389135279283614 5.106890711400503e-07 0.2371200701944942 \
5.106891917576704e-07 0.2354534357320198 5.106893542306008e-07 0.2332087289724075 5.106895002846996e-07 0.2311905595759856 5.106896386054839e-07 0.2292825126447264 \
5.106897465327019e-07 0.2277949627009887 5.106898773176093e-07 0.225993474229161 5.106899758236256e-07 0.22463752857886 5.106900799069717e-07 0.2232056532573264 \
5.106901527838363e-07 0.2222046546567725 5.10690234937313e-07 0.2210804129356655 5.106903023463979e-07 0.2201585377209549 5.106903490506606e-07 0.2195201149856669 \
5.106903984680203e-07 0.2188449488487562 5.10690489422163e-07 0.2176035744446363 5.106905558165761e-07 0.2166983392055156 5.106906027798693e-07 0.2160586379972232 \
5.106906530910749e-07 0.2153737902794619 5.106907122404248e-07 0.2145693142997165 5.106907550863284e-07 0.2139870779821451 5.10690798893629e-07 0.2133941263688522 \
5.106908684238941e-07 0.2124566309962414 5.106909553407081e-07 0.2112864027023158 5.106910365295632e-07 0.2101949018929156 5.106911224290263e-07 0.2090416531541652 \
5.106912165752074e-07 0.2077796428137634 5.10691308329081e-07 0.2065517647617813 5.106914036255171e-07 0.2052788208685862 5.106915001042083e-07 0.2039945431316728 \
5.106916009294901e-07 0.2026602783061639 5.106916968855022e-07 0.2013924147365721 5.10691799571213e-07 0.2000377255165624 5.106919026075665e-07 0.1986831378210229 \
5.10692012697906e-07 0.1972405340748948 5.106921214497938e-07 0.1958206085628783 5.106922411717489e-07 0.1942631948714586 5.106923516146512e-07 0.1928328887741874 \
5.106924596174588e-07 0.1914411844406488 5.10692584973803e-07 0.1898318066870429 5.106926779079788e-07 0.1886434908940876 5.106927562787551e-07 0.1876443873000938 \
5.10692832918829e-07 0.1866698667869858 5.106929154301432e-07 0.1856249297118943 5.106929849397591e-07 0.1847473639743596 5.106930508953873e-07 0.1839166514106665 \
5.106931151627221e-07 0.1831089953192083 5.106932271462069e-07 0.1817072258029639 5.106933212001736e-07 0.1805353135896268 5.106934288419354e-07 0.1791985758407087 \
5.106935353149933e-07 0.1778827552324552 5.106936553069198e-07 0.1764073736674057 5.106937933595456e-07 0.174720142305475 5.106939095201005e-07 0.1733081217455876 \
5.106940716169029e-07 0.1713503924599185 5.106941867054195e-07 0.1699688234017716 5.106943266910192e-07 0.1682987764548305 5.106944438970947e-07 0.1669083002780509 \
5.106945548164474e-07 0.1655990025649634 5.106946524449328e-07 0.1644521190704843 5.106947472954812e-07 0.1633427224865242 5.106948633498935e-07 0.161991523106341 \
5.106949548984438e-07 0.1609305136382055 5.106950510074198e-07 0.1598214181625073 5.106951452255533e-07 0.1587403933520305 5.106952387261563e-07 0.1576732160104884 \
5.106953323234783e-07 0.1566104070550305 5.106954280050165e-07 0.1555300824433628 5.106955185929211e-07 0.1545132165873678 5.106956096060781e-07 0.1534969984004868 \
5.106957051545556e-07 0.1524358767948732 5.106957958202681e-07 0.1514342506187442 5.106958988926308e-07 0.1503020548964867 5.106959713440796e-07 0.1495100717445464 \
5.106960504448726e-07 0.148649146151682 5.106961249930915e-07 0.1478424742503694 5.106961960245004e-07 0.1470770917224498 5.106962687889816e-07 0.1462962409077327 \
5.106963434061566e-07 0.1454990959398698 5.106964133891184e-07 0.1447543557055888 5.106964875500381e-07 0.143968261688537 5.106965412953772e-07 0.1434005634796054 \
5.106965945789318e-07 0.1428396203849428 5.106966597746903e-07 0.1421555039833398 5.106967310807313e-07 0.141411576573238 5.106967954507931e-07 0.1407432786314442 \
5.106968688027537e-07 0.1399847409254479 5.106969294203206e-07 0.1393607073002494 5.106970154538046e-07 0.1384787080092832 5.106970914048206e-07 0.1377037134581418 \
5.106971813727261e-07 0.1367902106004182 5.106972630996836e-07 0.1359645165492482 5.106973457896614e-07 0.1351360437760365 5.106974283459693e-07 0.1343145513298757 \
5.106975339081247e-07 0.1332698421778018 5.106976157754082e-07 0.1324642397250402 5.106977131428679e-07 0.1315110876582503 5.106978031437286e-07 0.130634908321232 \
5.106978911139876e-07 0.1297829978838479 5.106979740438425e-07 0.1289892226181523 5.106980482809344e-07 0.1282822873521282 5.106981479319927e-07 0.1273377645104763 \
5.106982436870517e-07 0.1264350619688987 5.106983305344565e-07 0.1256206895242312 5.106984205359939e-07 0.1247808744623497 5.106985008686745e-07 0.1240346855852102 \
5.10698587562703e-07 0.1232365419604467 5.106986863930319e-07 0.1223331159004786 5.106987764751698e-07 0.1215131568528167 5.106988867184272e-07 0.1205141992263624 \
5.106989739498662e-07 0.1197275966302077 5.106990425230002e-07 0.1191120727131645 5.106991271853926e-07 0.1183553887582162 5.106991936928737e-07 0.1177634990399222 \
5.106992651487993e-07 0.1171309945267847 5.10699334822604e-07 0.1165184920865242 5.106994121596921e-07 0.1158409171037389 5.106995079029744e-07 0.1150054407698888 \
5.106995791578869e-07 0.1143861389207103 5.106996465274203e-07 0.1138025718558601 5.106997149641909e-07 0.113211685696446 5.106997905545423e-07 0.1125613765304429 \
5.106998812963886e-07 0.1117840233035959 5.106999640001163e-07 0.1110788257213999 5.107000775991873e-07 0.1101151050704521 5.107001874748992e-07 0.1091895325357105 \
5.107002796742131e-07 0.1084169374841771 5.107004036235445e-07 0.1073835127717347 5.107004919878672e-07 0.1066505015902263 5.107006314468373e-07 0.1055001025916527 \
5.107007307435382e-07 0.1046863788921388 5.107008233935897e-07 0.1039306459201802 5.10700933598102e-07 0.1030359883605075 5.107010188925421e-07 0.1023467905686673 \
5.107011037933452e-07 0.101663637589173 5.107011867443086e-07 0.1009989740617136 5.107013092542103e-07 0.1000225794851696 5.107014311960625e-07 0.09905761200121259 \
5.10701557818349e-07 0.09806258992746317 5.107016706304718e-07 0.09718220909187772 5.107018152059564e-07 0.09606278874246346 5.107019529198845e-07 0.09500564015228773 \
5.107020696106743e-07 0.09411672853020667 5.107021973542415e-07 0.0931507147971556 5.107022970187578e-07 0.09240236948627445 5.107023764526374e-07 0.09180921593916676 \
5.107024751879353e-07 0.09107599640376031 5.107025530632389e-07 0.09050081472416407 5.107026345291548e-07 0.08990210528957472 5.107027092464628e-07 0.0893557072655629 \
5.107027897762006e-07 0.08876971652456604 5.107029086085258e-07 0.08791061481419053 5.107029982690621e-07 0.08726673116015753 5.107031031831091e-07 0.08651800316437093 \
5.107032346576667e-07 0.08558693768262025 5.107033957658019e-07 0.08445695903909305 5.107035359474972e-07 0.08348350561263763 5.107036844501031e-07 0.08246223579158835 \
5.10703821170292e-07 0.08153124812726546 5.107039611820024e-07 0.08058696725890066 5.10704098179202e-07 0.07967195061625794 5.107042367898133e-07 0.07875532825288725 \
5.107043812626999e-07 0.07780967510081127 5.107045288089374e-07 0.07685421131041187 5.107046863126477e-07 0.07584560580436887 5.107048507078841e-07 0.07480523464991846 \
5.107050187999819e-07 0.07375451744755303 5.10705199799341e-07 0.07263751640721161 5.107053985126234e-07 0.07142823309373261 5.10705611921415e-07 0.07014922396308329 \
5.107058380853001e-07 0.06881630383186611 5.107060786456226e-07 0.06742468841361035 5.107063562065354e-07 0.06585179211508728 5.107066534109385e-07 0.06420523370201831 \
5.107069717116618e-07 0.06248365192299224 5.10707361695962e-07 0.06043183534616462 5.107077605227481e-07 0.05839861031494715 5.10708202994687e-07 0.05621846258761681 \
5.107085879755897e-07 0.05438828987170503 5.107090000221824e-07 0.05249218901100536 5.10709351759698e-07 0.05092353490091287 5.107096872643497e-07 0.04946969867921969 \
5.107099977632445e-07 0.04816021644386199 5.107102917000643e-07 0.04695194805701195 5.107105844309969e-07 0.04577883625507727 5.107108592742044e-07 0.04470700909733757 \
5.107111331179271e-07 0.04366353526031765 5.107113988076876e-07 0.04267398813878486 5.107116741167033e-07 0.04167180388267511 5.107119586736206e-07 0.04066026046469497 \
5.107122549717361e-07 0.03963283340811159 5.107125138471216e-07 0.03875659098599576 5.107127418035276e-07 0.03800131046948733 5.107129605287219e-07 0.03729095380188759 \
5.107131803834488e-07 0.03659437723507575 5.107135212495135e-07 0.03554043311314246 5.107137972903942e-07 0.03470953269536187 5.107140907211692e-07 0.03384790442147732 \
5.107143732890922e-07 0.03303898052111545 5.107146281985287e-07 0.03232625790162248 5.107149088829883e-07 0.03155947796597136 5.107151547163818e-07 0.03090318379665042 \
5.107153868776701e-07 0.03029616297556957 5.10715627215008e-07 0.02968398395812225 5.107158628518432e-07 0.02909722707395018 5.107160910630208e-07 0.0285403787496557 \
5.107165078357495e-07 0.02755138287878544 5.107167023611269e-07 0.02710176794309662 5.107170886015322e-07 0.02623051698020805 5.10717267770925e-07 0.0258356865503758 \
5.107176189981086e-07 0.02507792837274256 5.107177869041566e-07 0.0247229612172224 5.107181711668123e-07 0.02392944198669211 5.107182864485406e-07 0.02369675911063252 \
5.107187284963782e-07 0.02282172072611499 5.107189503116517e-07 0.02239223679446916 5.107194739313108e-07 0.02139838041889957 5.107196292938196e-07 0.02110714647916685 \
5.107201469998876e-07 0.02015295207761772 5.10720272033152e-07 0.01992792118872039 5.107207962346589e-07 0.01901759738223179 5.107209324540342e-07 0.01879045572456909 \
5.107215387304897e-07 0.01783210191617334 5.107217057396231e-07 0.01758082406519646 5.107223489472666e-07 0.01666064795441237 5.107225280915353e-07 0.0164167113061686 \
5.107232182502689e-07 0.01551958953683085 5.107233818701531e-07 0.01531511209162885 5.107241423508397e-07 0.01440332854054019 5.107242893929629e-07 0.01423371673427115 \
5.107251072646214e-07 0.01333087949608782 5.107252268131343e-07 0.01320411419549955 5.107261426746556e-07 0.01227329163592313 5.107262840275722e-07 0.01213544173166964 \
5.107272325031483e-07 0.01124488043697059 5.107273911425863e-07 0.01110230805801717 5.1072857354363e-07 0.01011356759191894 5.107286716440201e-07 0.01003725601038859 \
5.107299332554799e-07 0.009120360285939955 5.107300676693304e-07 0.009028655389366201 5.107316082406548e-07 0.008043892937307966 5.107316892739986e-07 0.007992925041580451 \
5.107332778679313e-07 0.007023242357651564 5.10733410759078e-07 0.006948518507451114 5.107353874624202e-07 0.005952856104192286 5.107355692005682e-07 0.005869662958407677 \
5.107376715542283e-07 0.004980929874643355 5.107381123459968e-07 0.004810448874467742 5.107407675608551e-07 0.003892108290451164 5.107412441403943e-07 0.003745909362026665 \
5.107448822226149e-07 0.00279447349697209 5.107454077460605e-07 0.002678838783887205 5.107510138108453e-07 0.001700248310874221 5.107513248985468e-07 0.001653333728976835 \
5.107564592262458e-07 0.0006858192122199529 5.107566532060193e-07 0.0006440832883579712 5.134045769148618e-07 -0.0002037173203380238 5.134047411152831e-07 -0.0003889174928863678 \
5.134053144580911e-07 -0.001270938904608877 5.134053893922784e-07 -0.001411855863724778 5.134058499760551e-07 -0.002393592696522268 5.134059619168068e-07 -0.002660411672198376 \
5.134062151887948e-07 -0.003300974950034667 5.134063815720996e-07 -0.003745951779090856 5.134066765678696e-07 -0.004566571567208835 5.134067880554425e-07 -0.00488071790655901 \
5.134070674282164e-07 -0.005641221413069743 5.134071883865554e-07 -0.005938820066262044 5.134082823393885e-07 -0.005180465225493313 5.134084064716309e-07 -0.004410796826645887 \
5.134085308790492e-07 -0.003456122327429311 5.134086504354286e-07 -0.002364170815481491 5.13408748579805e-07 -0.001341064316055312 5.13408855004127e-07 -0.0001052154991983786 \
5.134089672399721e-07 0.001336046702817826 5.134091021958209e-07 0.003249882807978809 5.134092247823306e-07 0.005149402351921401 5.134094136442457e-07 0.008353592055059769 \
5.134095548265784e-07 0.01094873860302964 5.134097081879224e-07 0.01393943619118621 5.134098515614267e-07 0.01687898420971235 5.13410005752867e-07 0.02017576688295359 \
5.134101618928252e-07 0.02363796584892512 5.134103176188778e-07 0.02719811802828209 5.134104651125568e-07 0.03065407560139007 5.134106137843234e-07 0.03420778369279751 \
5.134107691144076e-07 0.03798436241030867 5.134109277402875e-07 0.04189786275883118 5.134110926734479e-07 0.0460171220807938 5.134112670963364e-07 0.05041857973200652 \
5.134114460857363e-07 0.05497510627343041 5.134116353855968e-07 0.05982852266675163 5.134118383936028e-07 0.06506368941101938 5.134120578706689e-07 0.07075025585284363 \
5.134122889353304e-07 0.07675903373893865 5.134125359956494e-07 0.08319974270080552 5.134128064206373e-07 0.0902619122132732 5.134130999843244e-07 0.09793335781011638 \
5.13413424033306e-07 0.1064001814721126 5.134137882548562e-07 0.1159066558703892 5.134141808063258e-07 0.1261372395632307 5.134146303042508e-07 0.1378252442462487 \
5.134151530964837e-07 0.1513754922073403 5.134157666942191e-07 0.1672157090591849 5.134164444550933e-07 0.184625848284817 5.134172327202124e-07 0.2047487967247964 \
5.134181155530716e-07 0.22712469896725 5.134189338390288e-07 0.2476994923478653 5.13419661268608e-07 0.2658503723959502 5.134203013816358e-07 0.2817009601644404 \
5.134208756853502e-07 0.2958213763442377 5.134214132513172e-07 0.3089396094373287 5.134219172487761e-07 0.3211464104224903 5.134223933714299e-07 0.3325930942309646 \
5.134228712594449e-07 0.3439912352478621 5.134233245925507e-07 0.3547121966731367 5.134237958852586e-07 0.3657614311162562 5.134242385610847e-07 0.3760518588326446 \
5.134247570598719e-07 0.3879885572071845 5.134252842219919e-07 0.3999987293386327 5.134256631316234e-07 0.4085537955782026 5.134261930471663e-07 0.4204060347738258 \
5.13426622963746e-07 0.429919877745455 5.134270766645208e-07 0.4398653393542544 5.134275433780368e-07 0.4500002271552926 5.134279810592672e-07 0.4594210430579985 \
5.134283890215308e-07 0.468120704286539 5.134287084545646e-07 0.4748816926501604 5.134290805898365e-07 0.4826992142337162 5.134293155719776e-07 0.4876010339127531 \
5.13429549178225e-07 0.4924491904621348 5.134297971906479e-07 0.4975647713404599 5.134300955920778e-07 0.5036796627825791 5.134303519484798e-07 0.5088948470128004 \
5.134305642417897e-07 0.5131878547336713 5.134307582598616e-07 0.5170959594548015 5.134309052463942e-07 0.5200432695146362 5.134310592244046e-07 0.523118600542271 \
5.134312771061538e-07 0.5274469616807909 5.134315302104803e-07 0.5324525256580425 5.134317400493245e-07 0.5365797337241586 5.134319515026335e-07 0.5407247601751553 \
5.134322337095338e-07 0.5462280430697679 5.134324632548168e-07 0.5506821559930507 5.134326791510235e-07 0.5548604062613707 5.134329613725408e-07 0.560308769190463 \
5.134332126802682e-07 0.5651538146135803 5.134335103411598e-07 0.5708625224168123 5.134337605680606e-07 0.5756519166658941 5.134340169315557e-07 0.5805516059354519 \
5.134342573415698e-07 0.585116682128892 5.134345155213862e-07 0.5900038400537884 5.134347391135916e-07 0.5942175703762435 5.134349776231627e-07 0.5986919452581434 \
5.134351852078614e-07 0.6025689278491061 5.134354017304865e-07 0.6065904171332736 5.134356510330919e-07 0.6111939272561876 5.134358561065347e-07 0.6149609706257601 \
5.134361073788606e-07 0.6195555361399968 5.134363106008859e-07 0.6232455818254186 5.134365074727914e-07 0.6267987644955494 5.134367007643072e-07 0.630267737067843 \
5.134369555427622e-07 0.6348113783570861 5.13437185753374e-07 0.638887973644319 5.134374031071848e-07 0.6427143472883045 5.134377015129076e-07 0.6479268061885751 \
5.134379169157571e-07 0.6516657345437264 5.134381181394756e-07 0.6551344108237934 5.134382930609835e-07 0.6581323437428509 5.13438458126254e-07 0.6609495238976936 \
5.134386275947745e-07 0.6638251431769452 5.134387797316125e-07 0.666392827642013 5.134389176422984e-07 0.6687037209181631 5.134390664784122e-07 0.6711867545200138 \
5.134391945930142e-07 0.6733159837320549 5.134393378158276e-07 0.6756849429836936 5.134394590900776e-07 0.6776819274526149 5.134395966887617e-07 0.6799401191146522 \
5.13439716069216e-07 0.6818929034138137 5.134398631769623e-07 0.6842914131385206 5.134399803786278e-07 0.6861933934268433 5.13440073884205e-07 0.6877071857403232 \
5.13440164873897e-07 0.6891752279197846 5.134402676159613e-07 0.6908280855439021 5.134403691335248e-07 0.6924555900607121 5.134404875166308e-07 0.6943444167618776 \
5.134405996372169e-07 0.6961264383846065 5.13440717192718e-07 0.6979868779962457 5.134409023430049e-07 0.7008959348649784 5.134410335352131e-07 0.7029413755586562 \
5.134411697037527e-07 0.7050491462541959 5.13441291222456e-07 0.7069171228306749 5.134414311454678e-07 0.7090538254196674 5.134415350881169e-07 0.7106315721465845 \
5.134416462491006e-07 0.712309798010818 5.134417505089649e-07 0.7138759052437967 5.134418801470564e-07 0.7158124745844324 5.134419770777692e-07 0.7172526339884565 \
5.134421160000042e-07 0.7193052800722975 5.134422355492926e-07 0.7210612846995991 5.134423551218654e-07 0.7228080613301419 5.134424808972429e-07 0.7246353354365959 \
5.134426076155856e-07 0.7264656873164689 5.134427296554369e-07 0.728218443613998 5.134428578038805e-07 0.7300486655261287 5.13442987872205e-07 0.7318956587421809 \
5.134431088632273e-07 0.7336041830685722 5.134432496338107e-07 0.7355801168346318 5.134433506033799e-07 0.7369898206659778 5.134434522042367e-07 0.7384020079314992 \
5.13443548224548e-07 0.7397310783624924 5.134436591374028e-07 0.7412570822736337 5.134437467850298e-07 0.7424563811251772 5.134438466394007e-07 0.7438154404043728 \
5.134439814045385e-07 0.7456370856934184 5.13444097699018e-07 0.747198032089633 5.13444201190815e-07 0.7485782798032956 5.134443254462628e-07 0.7502239458264747 \
5.134444703592029e-07 0.7521280942578691 5.134445883397714e-07 0.753666143975803 5.134447072708787e-07 0.7552056331692281 5.134448468504184e-07 0.7569980918234445 \
5.134449912028081e-07 0.7588357421297242 5.134451092636163e-07 0.7603265096672839 5.134452340853355e-07 0.7618908200857619 5.134453739165311e-07 0.7636286950759973 \
5.134454986794279e-07 0.7651662633748356 5.134456421928986e-07 0.7669199865864609 5.134457628783765e-07 0.7683824344671055 5.13445883722124e-07 0.7698356273746885 \
5.134460033670484e-07 0.7712633747646481 5.134461330746873e-07 0.7727989859455529 5.134462418184901e-07 0.7740766298596218 5.134463644662266e-07 0.7755070372682662 \
5.134464742429112e-07 0.7767778749889983 5.13446603267025e-07 0.7782599816788072 5.134467350433437e-07 0.7797610257751375 5.134468483559198e-07 0.7810403609326458 \
5.134469694418617e-07 0.7823954393038701 5.134470733144949e-07 0.7835479431998941 5.134472155975174e-07 0.785111775748914 5.134473638006659e-07 0.7867227488076519 \
5.134475226942011e-07 0.7884297907063792 5.134476428872233e-07 0.7897074707829422 5.134477924539297e-07 0.7912811323018302 5.134479165691468e-07 0.7925734175081853 \
5.134480422734439e-07 0.7938699048627912 5.134481452190108e-07 0.7949224966762399 5.134482595901654e-07 0.7960823495211882 5.134483720644089e-07 0.7972131756542409 \
5.134484623369832e-07 0.7981137961420948 5.134485516778793e-07 0.7989989930139054 5.134486769038167e-07 0.800229513878344 5.134487846751798e-07 0.8012785338618679 \
5.134489143429785e-07 0.8025281307685926 5.134490357222573e-07 0.8036855380110038 5.134491522780568e-07 0.8047859282369955 5.134492730834528e-07 0.80591497746663 \
5.134494057087579e-07 0.8071413435168892 5.134495275023783e-07 0.8082555056211007 5.13449654106103e-07 0.8094015704683005 5.134497797196214e-07 0.8105266036187198 \
5.13449899211046e-07 0.8115857443778658 5.134500374092988e-07 0.8127973981963581 5.134501469085475e-07 0.8137473213416323 5.134502310566626e-07 0.8144713378799666 \
5.134503518607202e-07 0.8155017394983226 5.134504473695572e-07 0.8163089346032877 5.134505836603603e-07 0.8174496006492775 5.134507264244139e-07 0.8186303638797883 \
5.13450860857535e-07 0.8197292014569521 5.13450970729519e-07 0.8206175763825388 5.134511146291366e-07 0.8217677661037901 5.134512679567201e-07 0.8229768690765377 \
5.134513958055741e-07 0.8239722812379519 5.134515362029048e-07 0.8250521595273246 5.134516621078439e-07 0.8260088941474263 5.134518167240102e-07 0.8271688948348412 \
5.134519490793395e-07 0.8281489842609937 5.134520753461681e-07 0.8290730392392056 5.134521930066954e-07 0.8299245984162376 5.134523414090921e-07 0.8309852945996649 \
5.134525086032604e-07 0.8321626230293395 5.134526413805716e-07 0.8330844501529713 5.134528142817687e-07 0.8342675727345584 5.134529826990627e-07 0.8354015168591284 \
5.134531521935363e-07 0.8365246342267009 5.134533336304179e-07 0.8377070668209077 5.134534761865593e-07 0.8386219603417975 5.134535900974499e-07 0.8393441765511721 \
5.134537209736585e-07 0.8401643924869071 5.134538225966329e-07 0.8407940582489307 5.134539390368715e-07 0.8415078269750864 5.134540743300576e-07 0.8423269142909066 \
5.134542715951592e-07 0.8435017451489455 5.134544621144827e-07 0.844614933042255 5.13454672039296e-07 0.8458175693076773 5.134548528178267e-07 0.8468334846981137 \
5.134550501858462e-07 0.8479221976595614 5.134552240443405e-07 0.8488638701886076 5.134554065585833e-07 0.8498353939890455 5.134555779026935e-07 0.8507314120859523 \
5.13455752248258e-07 0.8516272398309612 5.134559276512583e-07 0.8525125793730954 5.134561038964483e-07 0.8533864315694911 5.134562936653265e-07 0.8543099749208749 \
5.134564844233442e-07 0.8552205033559714 5.1345668621255e-07 0.8561646193034282 5.134568789161161e-07 0.8570482883232282 5.134570883567926e-07 0.8579892478796384 \
5.134573180985592e-07 0.8589986827500428 5.134575835675109e-07 0.8601360945383778 5.134578822138556e-07 0.8613786760148464 5.134581606012222e-07 0.8625023989005415 \
5.134584447911769e-07 0.8636161469557806 5.134587192857839e-07 0.8646608622318305 5.134589913772806e-07 0.8656672252055042 5.134592615937268e-07 0.8666387059277968 \
5.134595187619145e-07 0.8675381145236246 5.134597913209795e-07 0.8684653318325959 5.1346006734232e-07 0.8693777905953765 5.13460337484171e-07 0.8702455402709716 \
5.134606372319547e-07 0.8711796653984102 5.134610081058124e-07 0.872294745819888 5.134613030287966e-07 0.8731503023941 5.134615572848448e-07 0.8738665406311316 \
5.134618555155771e-07 0.8746822274488602 5.134621291339016e-07 0.8754080260278182 5.134623652695491e-07 0.8760175227551726 5.134626056214058e-07 0.876622281264788 \
5.134628279637853e-07 0.8771680781109068 5.134630219681284e-07 0.8776338860468618 5.134633516912074e-07 0.8784037109613512 5.1346350686397e-07 0.8787567114621292 \
5.134638246164967e-07 0.879461652496718 5.134640034818579e-07 0.8798480920375044 5.134643459433237e-07 0.8805675499479563 5.134645300848474e-07 0.8809434933546246 \
5.134650049902839e-07 0.8818790560183651 5.134651723847029e-07 0.8821975058309585 5.134656382161285e-07 0.8830540251881659 5.134658190409674e-07 0.8833751042472839 \
5.134663130743469e-07 0.8842212008576973 5.134664544170556e-07 0.884455124402366 5.13467060806836e-07 0.8854193259359495 5.134672128789829e-07 0.8856514227360587 \
5.134678595574705e-07 0.8865980751852495 5.134679878538246e-07 0.8867785329419297 5.13468635979926e-07 0.8876550049536978 5.134687657724472e-07 0.8878236738033012 \
5.134695440340947e-07 0.8887860366092379 5.134696590259732e-07 0.8889208282599539 5.134705147583919e-07 0.8898661633196656 5.134706600215368e-07 0.8900169066926564 \
5.134716457777221e-07 0.8909664261264102 5.134718668828627e-07 0.8911622482549515 5.134730119973067e-07 0.8921020388386462 5.134731432072641e-07 0.8922053928944147 \
5.134743308657994e-07 0.8931033243919096 5.134744844860915e-07 0.8932130731307282 5.13475894522803e-07 0.8941348173026452 5.134761173296219e-07 0.8942660193790342 \
5.134777980203303e-07 0.8951452796684343 5.134781256415096e-07 0.8952966652167414 5.134803555826309e-07 0.8961896554712738 5.134809084965924e-07 0.8963788593752812 \
5.134844767111233e-07 0.8973573335043913 5.134848002235382e-07 0.8974284307984646 5.134911566318258e-07 0.8984120886469452 5.134917055346727e-07 0.8984686671268907 \
5.13544207609024e-07 0.8994658645395698 5.135448506378864e-07 0.8994692460188505 5.137369893085194e-07 0.9004073346715066 5.137371907224907e-07 0.9004708280105613 \
5.137411505004318e-07 0.8995366825576255 5.137413345272296e-07 0.8993953949813248 5.137426511245044e-07 0.8984641879157507 5.137428231683587e-07 0.8983566564859006 \
5.137447195446537e-07 0.8973720929359315 5.137448932508418e-07 0.897304621671452 5.137574671778748e-07 0.8982933655523699 5.137575523681118e-07 0.8983081509245614 \
5.137658192411513e-07 0.8993078551592517 5.137662939605718e-07 0.8993433667976791 5.142597948700116e-07 0.9002974142054325 5.142599143497356e-07 0.9003767372269074 \
5.142608071727864e-07 0.9012336455299185 5.142609534294226e-07 0.901423267690772 5.142615483221009e-07 0.9023325668564308 5.142616832929176e-07 0.9025673929107925 \
5.142621879687069e-07 0.9035294259428087 5.142623205796079e-07 0.9038000271808221 5.142627212069726e-07 0.9046475051114249 5.142628655723708e-07 0.9049556543240072 \
5.142632886935801e-07 0.9058123566484279 5.142633841506385e-07 0.9059850892484415 5.142648087094547e-07 0.9052205906349737 5.142649337473087e-07 0.9046352442223391 \
5.14265060157898e-07 0.9039223775493039 5.142651628066418e-07 0.9032486771507763 5.142652900219319e-07 0.9022944222362175 5.142654088677579e-07 0.9012801950564071 \
5.142655065202371e-07 0.9003603330664713 5.142655885222584e-07 0.8995243596151602 5.142656681858213e-07 0.8986589236008835 5.142657789639895e-07 0.8973708307079206 \
5.142658801400035e-07 0.8961049472956977 5.142659630844751e-07 0.8950067229086057 5.142660715298925e-07 0.8934921260891034 5.1426617999385e-07 0.8918872687155874 \
5.14266275049989e-07 0.8904106867557802 5.142663959226416e-07 0.8884444419111864 5.14266516699262e-07 0.8863849482818795 5.142666297444327e-07 0.8843763393508186 \
5.142667329151817e-07 0.8824794505619851 5.142668185153381e-07 0.8808620855018965 5.142668929893991e-07 0.8794251273161163 5.142669873129417e-07 0.8775673968166831 \
5.142670757738577e-07 0.8757888800524039 5.142671548468696e-07 0.8741711975775893 5.142672488342246e-07 0.872216793437976 5.142673301795292e-07 0.8704993514258973 \
5.14267425093555e-07 0.8684673705816817 5.14267518136275e-07 0.8664480751909672 5.142676149220692e-07 0.8643215060814092 5.142677382174414e-07 0.8615778533848952 \
5.142678516644525e-07 0.859022019682563 5.142679775164912e-07 0.8561558571929792 5.142681008446355e-07 0.8533196845306243 5.142682300229265e-07 0.850323637950593 \
5.14268370619783e-07 0.8470370034914 5.142684793995045e-07 0.8444782910716596 5.142686144592575e-07 0.8412850455921466 5.142687241195659e-07 0.8386804253780991 \
5.142688532993453e-07 0.8356002443501571 5.14268979483175e-07 0.8325812421138936 5.142691065735304e-07 0.8295317031556502 5.142692355958039e-07 0.826427745883674 \
5.142693446760448e-07 0.8237985689995477 5.142694845267009e-07 0.8204223029647078 5.142696239548932e-07 0.8170507778356514 5.142697567085239e-07 0.8138366863616762 \
5.142698867771992e-07 0.8106848159989707 5.142700104726457e-07 0.8076853837479523 5.142701474270357e-07 0.8043627031572629 5.142702611388824e-07 0.8016030849198694 \
5.142703886159226e-07 0.7985086235398901 5.14270499416994e-07 0.7958187897651571 5.142706186034521e-07 0.7929254985494992 5.142707319825085e-07 0.7901733724735396 \
5.142708662929012e-07 0.7869138859547327 5.142709733871686e-07 0.7843152933129034 5.142710894043116e-07 0.7815009627552112 5.142712185952754e-07 0.778367508739124 \
5.142713162077106e-07 0.7760002683782802 5.142714217871509e-07 0.773440790716327 5.142715304693198e-07 0.7708069008430674 5.142716328855832e-07 0.7683258101021144 \
5.142717262792412e-07 0.7660641808432364 5.142718458350171e-07 0.7631702213567544 5.142719383073787e-07 0.7609327305817616 5.14272030945494e-07 0.7586922094322426 \
5.142721293703097e-07 0.7563124992069843 5.142722373479616e-07 0.7537030947613649 5.142723336164742e-07 0.7513778334636231 5.142724198728768e-07 0.7492952979736797 \
5.142725227366661e-07 0.7468128004450286 5.14272601580994e-07 0.744910856519283 5.142727023870358e-07 0.7424801602439853 5.142728369152764e-07 0.7392377693660663 \
5.142729741401358e-07 0.7359316755186537 5.142731176199872e-07 0.7324773442723981 5.142732660441767e-07 0.7289066083419234 5.142734093054719e-07 0.7254625447335662 \
5.142735493824514e-07 0.7220977259655398 5.142737058083174e-07 0.7183435968963056 5.142738302100673e-07 0.715360858370426 5.14273951271848e-07 0.7124600029613375 \
5.1427410478411e-07 0.7087850045121084 5.142742395660554e-07 0.7055614325718365 5.142743656650877e-07 0.7025479112911024 5.142745088393713e-07 0.6991289103945657 \
5.142746289211628e-07 0.6962626602560111 5.142747581554913e-07 0.6931807499479741 5.142748646405391e-07 0.6906432840523983 5.142749769163615e-07 0.6879696524977363 \
5.142750732516477e-07 0.6856773754336868 5.142751760613402e-07 0.683232326200841 5.14275270865193e-07 0.6809792012818872 5.142753761871231e-07 0.6784784437814733 \
5.14275484625777e-07 0.6759058899658261 5.142755836350576e-07 0.673558569590366 5.142757003916503e-07 0.6707929011939652 5.142758084769278e-07 0.6682347329991606 \
5.142759184831366e-07 0.6656332609774134 5.142760045709786e-07 0.6635992664604092 5.142761341661182e-07 0.6605400273835189 5.142762267673658e-07 0.6583552307294462 \
5.142763225550924e-07 0.6560965362104854 5.142764075070784e-07 0.6540950852804182 5.142765268016021e-07 0.6512869789851043 5.142766140715398e-07 0.6492343850333612 \
5.142767047785614e-07 0.6471030993779646 5.14276805943536e-07 0.6447280068361273 5.142768857743593e-07 0.6428551652550211 5.142769745601937e-07 0.6407732405330839 \
5.142770522504205e-07 0.6389536101386547 5.142771140193683e-07 0.6375081226244841 5.142771777840134e-07 0.6360167668935747 5.142772410182331e-07 0.634538653569437 \
5.142772802588059e-07 0.6336218002627473 5.142773208978281e-07 0.6326726453797233 5.142774009823624e-07 0.6308039353694699 5.142774708865426e-07 0.6291742390428672 \
5.142775215232567e-07 0.6279942052995945 5.142775602728994e-07 0.6270914175114127 5.142775992678787e-07 0.6261832343283663 5.142776438826266e-07 0.6251445623164014 \
5.142776867390832e-07 0.6241478292286105 5.142777370536867e-07 0.6229782634938205 5.142777889908641e-07 0.6217719122409077 5.142778740584486e-07 0.6197972300178722 \
5.142779340388659e-07 0.6184052992407258 5.142780238260749e-07 0.61632338076978 5.142781002901565e-07 0.6145529519516876 5.142781798544472e-07 0.6127119801362371 \
5.142782608910593e-07 0.6108383709630588 5.142783501053817e-07 0.6087775861620425 5.142784409653938e-07 0.6066826282541496 5.142785281841023e-07 0.6046739453334793 \
5.142786219572931e-07 0.6025158549334848 5.142787236427564e-07 0.6001788642681311 5.142788232408485e-07 0.5978941858483342 5.142789350958888e-07 0.5953317151711254 \
5.14279051129026e-07 0.5926772450523136 5.142791727501318e-07 0.5899020947998995 5.142792771339459e-07 0.5875236635596754 5.142794219241658e-07 0.5842296531729801 \
5.142795345841267e-07 0.5816734289694181 5.14279643596094e-07 0.5792035939892568 5.142797360755373e-07 0.5771100174076607 5.142798295261765e-07 0.5749994714793375 \
5.142799218520404e-07 0.5729181236728181 5.142799944387413e-07 0.571283073141143 5.142800503929671e-07 0.5700232888304386 5.142801114612485e-07 0.5686498830286455 \
5.142802099507645e-07 0.5664400707212188 5.142802731622084e-07 0.5650238531380825 5.142803335881769e-07 0.5636708824310654 5.142804105365601e-07 0.5619492451093103 \
5.142804736951014e-07 0.5605380106414651 5.142805620087099e-07 0.558569506627369 5.14280633210033e-07 0.5569845302974165 5.14280719745787e-07 0.555060151797141 \
5.142808410985601e-07 0.5523665438352664 5.142809690278082e-07 0.5495364947125975 5.142810671584391e-07 0.5473694328713704 5.142811802824346e-07 0.5448752016832871 \
5.14281282350254e-07 0.5426314425864434 5.142814012991245e-07 0.5400217272291628 5.142815043868321e-07 0.5377630705755105 5.142816185939864e-07 0.5352670017334624 \
5.142817320096582e-07 0.532794946211756 5.14281859080713e-07 0.5300302694710822 5.142819829008019e-07 0.5273426867079006 5.142821276896071e-07 0.5242103332418484 \
5.142822635131097e-07 0.5212782585303676 5.142824185679684e-07 0.5179428401013338 5.142825794198527e-07 0.5144913885072363 5.142827581493005e-07 0.5106699876709851 \
5.1428294832834e-07 0.5066200804011861 5.142831582303622e-07 0.5021665212646098 5.142833869363468e-07 0.4973332357952056 5.142836408642853e-07 0.4919960258408594 \
5.142838817977506e-07 0.4869529241725989 5.142841779602358e-07 0.4807889695952298 5.14284467957623e-07 0.4747910561470179 5.142847742009557e-07 0.4684976697011882 \
5.142850948768875e-07 0.4619520863481486 5.142854227440541e-07 0.4553041925245184 5.142857629891091e-07 0.4484521981997251 5.142860884146544e-07 0.4419418052309769 \
5.142864103218021e-07 0.4355465312739703 5.142867405359072e-07 0.4290298934287748 5.142870965284996e-07 0.4220583188787752 5.142874154069286e-07 0.4158579595363656 \
5.14287752858691e-07 0.4093433989943853 5.142881807254075e-07 0.4011531841887147 5.142885294373556e-07 0.3945419525178304 5.142888370733193e-07 0.388759214407489 \
5.142892168998106e-07 0.3816861832573664 5.142895480893721e-07 0.3755780492082042 5.142898316974524e-07 0.370391509977049 5.142901425163967e-07 0.3647512908748707 \
5.142904218330045e-07 0.3597258263082204 5.142906483291526e-07 0.3556836811642302 5.142908640115379e-07 0.3518598964090484 5.142910612955428e-07 0.3483842179544538 \
5.142912662800023e-07 0.3447988491770444 5.142914785019664e-07 0.3411119200457455 5.142917338071541e-07 0.33670771290924 5.142919753294026e-07 0.3325734463267218 \
5.14292206706731e-07 0.3286464933807047 5.142924215592308e-07 0.3250253651850565 5.142926421183882e-07 0.3213332986541765 5.142928435443551e-07 0.3179852906236645 \
5.142930466126061e-07 0.3146379646143546 5.142932445082156e-07 0.3114011111455273 5.142934314693022e-07 0.3083651674074345 5.142936252695217e-07 0.3052406640298299 \
5.142938291861339e-07 0.3019773030815858 5.142940082554677e-07 0.2991336297844484 5.142942438463241e-07 0.2954229173226265 5.142944446504233e-07 0.2922868215109002 \
5.142946458293147e-07 0.2891696385850206 5.142948696390574e-07 0.2857334090862961 5.142950342018032e-07 0.2832271910241367 5.142952111291889e-07 0.2805503385691353 \
5.14295396922194e-07 0.2777610713150803 5.142955787376701e-07 0.2750538970423583 5.142957577624632e-07 0.2724132377985424 5.142959251076164e-07 0.2699606650006489 \
5.142960855365337e-07 0.2676371805838822 5.142962081102854e-07 0.2658719571410424 5.142963578748139e-07 0.2637236906090554 5.142964855719403e-07 0.2619099339733745 \
5.14296592880312e-07 0.2603957336038235 5.142967088809744e-07 0.2587625259947361 5.142968191895705e-07 0.2572125806747212 5.142969450687671e-07 0.2554509781935611 \
5.142970605506182e-07 0.2538402638894013 5.142971951315211e-07 0.2519757335310172 5.142973071947753e-07 0.2504255755821768 5.142974575341346e-07 0.2483447107137444 \
5.142975971599892e-07 0.2464124269747185 5.142977430518096e-07 0.2444035064209518 5.142978760124476e-07 0.2425734862730615 5.14297999574161e-07 0.2408709992523319 \
5.142981467838532e-07 0.2388417729476062 5.142982633706824e-07 0.2372355665500016 5.142984028258316e-07 0.23532008003217 5.142985370003013e-07 0.2334768281602104 \
5.142986629767574e-07 0.2317465561243653 5.142987823761605e-07 0.2301094434087779 5.142988772305854e-07 0.2288105340759602 5.142989903681845e-07 0.2272617792622066 \
5.142990706846421e-07 0.2261626001158484 5.142991582496985e-07 0.2249657246820506 5.142992837868356e-07 0.2232507767215072 5.142993894805428e-07 0.2218101326756785 \
5.142994791350539e-07 0.2205921574607158 5.14299549986253e-07 0.2196300825522397 5.142995930147826e-07 0.2190460135436258 5.142996353053263e-07 0.2184724035808872 \
5.142996776470424e-07 0.2178984240735344 5.142997498424615e-07 0.2169203674089526 5.142997922358173e-07 0.2163464205126744 5.14299827490656e-07 0.2158693585303403 \
5.142998716822395e-07 0.2152716287340076 5.142999412904664e-07 0.2143309212991285 5.142999756337965e-07 0.2138672544767182 5.143000200933248e-07 0.2132698436071631 \
5.143000877718061e-07 0.2123628126304402 5.143001741990649e-07 0.2112058698236149 5.143002488356675e-07 0.2102078598594563 5.143003301376756e-07 0.2091219706754807 \
5.143004270150594e-07 0.2078300362310651 5.143005529985482e-07 0.2061528795789772 5.143006555333841e-07 0.2047906894256944 5.143007570169014e-07 0.2034500128132261 \
5.143008580825969e-07 0.202119416354989 5.143009546968166e-07 0.2008491615811921 5.143010566612396e-07 0.1995112314821507 5.143011633834836e-07 0.1981153840927639 \
5.143012717886237e-07 0.1967018790395962 5.143013837827796e-07 0.1952465002768531 5.143014962499069e-07 0.1937897263683151 5.143016083232463e-07 0.1923454332378671 \
5.143017162157206e-07 0.1909603537828802 5.143018175986493e-07 0.1896629368444172 5.143019092360985e-07 0.1884941330679491 5.143020032117073e-07 0.1872990757663449 \
5.143020744780721e-07 0.1863957871745983 5.143021511533599e-07 0.1854271890400033 5.143022548124749e-07 0.184122202819407 5.143023284795955e-07 0.1831974022686171 \
5.143024018254956e-07 0.1822796569444652 5.143025152158449e-07 0.1808667181969195 5.143026030744852e-07 0.1797760932362061 5.143026869231621e-07 0.1787387947787487 \
5.143028158855897e-07 0.1771515524267008 5.143029177720844e-07 0.1759040172436072 5.143030234727908e-07 0.1746156056808686 5.143031251208657e-07 0.1733818993219825 \
5.143032559825841e-07 0.1718019019596718 5.143033631792215e-07 0.1705140034701537 5.14303492508118e-07 0.168969083715685 5.143036042046102e-07 0.167642098072289 \
5.143037045351886e-07 0.1664555496840579 5.143038003357432e-07 0.1653276075899142 5.143039111480153e-07 0.1640289617085985 5.143039985482962e-07 0.1630090521997956 \
5.143041098694133e-07 0.1617156184952586 5.143042028212722e-07 0.1606409001560029 5.143042903941501e-07 0.1596330843918451 5.143043920250233e-07 0.1584700928658864 \
5.143044764790781e-07 0.1575086241734052 5.143045515834575e-07 0.1566573095634876 5.143046294056998e-07 0.1557789554714152 5.143047097635688e-07 0.1548759612316424 \
5.143048108183989e-07 0.1537464547857493 5.143048932519626e-07 0.1528311848879565 5.143049855565143e-07 0.1518114053368895 5.143050624909871e-07 0.150965812476358 \
5.143051454135576e-07 0.1500585909391909 5.143052169442981e-07 0.1492793026301012 5.143053133277974e-07 0.1482344968214558 5.143053835562832e-07 0.1474766665551334 \
5.143054665365612e-07 0.1465853655470201 5.143055279788246e-07 0.1459298106834085 5.143055996612094e-07 0.1451677491870439 5.14305668289752e-07 0.1444408762699853 \
5.143057185582615e-07 0.1439102090153988 5.143057661380673e-07 0.143409423336876 5.143058201874179e-07 0.1428423132663369 5.143058795295158e-07 0.1422216078256897 \
5.143059475649228e-07 0.1415124633834424 5.14306023828345e-07 0.1407207186008814 5.143060921081446e-07 0.1400161356079559 5.143061868943229e-07 0.1390460813732662 \
5.143062764481352e-07 0.1381341561933974 5.143063481336088e-07 0.1374075731330657 5.143064320850176e-07 0.1365606113096345 5.143064973974727e-07 0.1359045398875483 \
5.143065588405982e-07 0.1352895588344758 5.143066331170967e-07 0.1345490408254265 5.143066953273574e-07 0.1339328028964004 5.143067632983656e-07 0.133265236037424 \
5.143068225054055e-07 0.1326856657519672 5.143068951778785e-07 0.1319767402814105 5.143069701979877e-07 0.1312477270463112 5.143070556514107e-07 0.1304208267333309 \
5.143071417517503e-07 0.1295914604616623 5.143072418772051e-07 0.1286317929389105 5.143073231668748e-07 0.127857435971709 5.143074249342227e-07 0.1268981149578782 \
5.143075091821821e-07 0.1261072369695883 5.143076079989111e-07 0.1251836587365037 5.143076808394557e-07 0.1245055382686853 5.143077608655429e-07 0.1237631876254407 \
5.14307831351338e-07 0.1231117958237987 5.143079038817605e-07 0.1224439308288319 5.143079813507563e-07 0.1217331219782777 5.143080887021039e-07 0.1207554316575004 \
5.143081893401196e-07 0.1198442997624752 5.143082619276736e-07 0.1191899427853172 5.143083307595137e-07 0.1185715582611356 5.143083965463339e-07 0.1179824683205609 \
5.143084661751317e-07 0.1173610347366148 5.143085365588769e-07 0.1167350538439435 5.143086117372495e-07 0.1160688810594495 5.143087159914846e-07 0.1151493019715505 \
5.143087911261386e-07 0.114489769343061 5.14308860041223e-07 0.1138870655592168 5.143089232460945e-07 0.1133369146236164 5.143089927874599e-07 0.1127339156958381 \
5.14309050088964e-07 0.1122385190692166 5.14309121730019e-07 0.1116210355509516 5.143091795650925e-07 0.1111240709857579 5.143092516865272e-07 0.1105063809580559 \
5.1430931410261e-07 0.1099736279351742 5.143093984241316e-07 0.1092565349771765 5.143094660201e-07 0.1086842173446869 5.143095748160323e-07 0.1077671916889585 \
5.143096791265638e-07 0.1068924975608609 5.14309758614772e-07 0.1062289053282379 5.143098461831824e-07 0.1055008617114655 5.143099096395349e-07 0.1049752776433979 \
5.143099713506517e-07 0.10446579874651 5.14310075190416e-07 0.103612238268202 5.143101578711175e-07 0.1029362225408096 5.143102563391439e-07 0.1021348761715451 \
5.14310340785582e-07 0.101450818648051 5.143104572630618e-07 0.1005121841703865 5.143105919965077e-07 0.09943411943161744 5.143107280660444e-07 0.0983541971400249 \
5.143108423854515e-07 0.09745369041838402 5.143109278525961e-07 0.09678457778867394 5.143110381342688e-07 0.09592640631053104 5.143111189226223e-07 0.09530159220710262 \
5.143112184734934e-07 0.09453592511176086 5.143113084215428e-07 0.09384821103094763 5.14311380924943e-07 0.09329669945188329 5.143114626670093e-07 0.09267796846073476 \
5.143115907872446e-07 0.09171467366828615 5.143116721993079e-07 0.09110674702409056 5.143117466312152e-07 0.09055373306570065 5.143118216050993e-07 0.08999936228352182 \
5.143119010240744e-07 0.08941505746347288 5.143120096849317e-07 0.08862052380504259 5.143121040449035e-07 0.08793517800096999 5.143121934400264e-07 0.08728987318634121 \
5.143123002057425e-07 0.086524181682867 5.143124187081826e-07 0.08568073755029131 5.143125602332527e-07 0.08468224831562859 5.143126933716762e-07 0.08375174214918565 \
5.143128342170073e-07 0.08277682112810406 5.143129832689884e-07 0.08175525972387458 5.143131190667175e-07 0.08083369778093191 5.143132605232322e-07 0.0798830809748103 \
5.143133957831475e-07 0.07898330517332906 5.143135371649882e-07 0.07805242629322809 5.143136842327612e-07 0.07709434677344783 5.143138359609018e-07 0.07611680364043326 \
5.143140013092032e-07 0.07506403321855706 5.143141651767208e-07 0.07403332863189842 5.143143414906486e-07 0.07293832728335037 5.143145309257506e-07 0.07177777688466977 \
5.14314741692455e-07 0.07050569389938771 5.143149614649522e-07 0.06920150027616521 5.143151964331044e-07 0.06783224552442871 5.143154553336539e-07 0.06635227408830123 \
5.14315750264117e-07 0.06470266364809808 5.143160546101784e-07 0.06304001691994518 5.143164165564573e-07 0.06111393619706453 5.143167326842125e-07 0.05947639552636011 \
5.143171740066774e-07 0.0572596911373907 5.143174875727195e-07 0.05573556853365672 5.14317911072189e-07 0.0537382660685313 5.143182550240425e-07 0.05216649213267931 \
5.143185952653102e-07 0.05065508790922631 5.143189061028998e-07 0.04931137323461653 5.143192005748017e-07 0.04807062469528345 5.143194942742994e-07 0.04686392507224969 \
5.143197691455356e-07 0.04576537019482012 5.143200446857014e-07 0.04468949010490332 5.143203097762298e-07 0.04367785045825667 5.143205865333108e-07 0.04264571401740119 \
5.143208698014357e-07 0.04161414314527601 5.143211677947347e-07 0.04055545327485047 5.143214272801311e-07 0.03965542606183669 5.143216573035691e-07 0.03887446236327848 \
5.143218769951559e-07 0.03814321686473518 5.14322101935296e-07 0.0374128399305801 5.1432242218897e-07 0.0363978329183388 5.143227099868201e-07 0.03550963653148703 \
5.143229863821537e-07 0.03467738358988744 5.143232702012828e-07 0.03384352473043348 5.143235083105866e-07 0.03315996078327022 5.143237926213707e-07 0.03236211345273886 \
5.143240345332207e-07 0.03169864947531036 5.143242696733945e-07 0.03106710921041438 5.143245113809233e-07 0.03043352335444016 5.143247483338566e-07 0.02982731501219571 \
5.143249786762739e-07 0.02925002048968134 5.143251924268523e-07 0.02872465224286764 5.143253982738151e-07 0.02822791768061097 5.143257906108381e-07 0.02730524204782691 \
5.143259790028487e-07 0.02687312495148303 5.143263546143072e-07 0.02603163971789 5.143265290810819e-07 0.02564950258131362 5.143269530155409e-07 0.02474274850847508 \
5.14327073769958e-07 0.02449086781212801 5.143275440207215e-07 0.02353384026002922 5.143276932357865e-07 0.02323677291035493 5.143280868679981e-07 0.02246740853134286 \
5.143282578943424e-07 0.02213909006726131 5.143287451732744e-07 0.02121869533024997 5.143288872209832e-07 0.02095326544309953 5.143294202372519e-07 0.01997576278857772 \
5.14329542401289e-07 0.01975737097014436 5.143300645590335e-07 0.01885981776906158 5.143302351373363e-07 0.01857989792133653 5.143307224503993e-07 0.01781360777737795 \
5.143308939733226e-07 0.01755501440977742 5.143315137600803e-07 0.01666567753024489 5.143316846844061e-07 0.0164316648397145 5.143323902353963e-07 0.01551160061118263 \
5.14332552852409e-07 0.01530799450170666 5.143333097458993e-07 0.01439879525764199 5.143334506625442e-07 0.01423641007536438 5.143343506613842e-07 0.01324361033368418 \
5.143344380106346e-07 0.01315122959105692 5.14335342363989e-07 0.01223321097894121 5.143354795559379e-07 0.01209984223734439 5.14336450212214e-07 0.01118944790767422 \
5.14336578130092e-07 0.01107451071402888 5.143377285400387e-07 0.01011008206277823 5.143378223420747e-07 0.01003687265682024 5.143390783878875e-07 0.009120584045805383 \
5.143392159292007e-07 0.009026502753623255 5.14340774683602e-07 0.008029670037698805 5.143408584862873e-07 0.007977066150721189 5.143424638651059e-07 0.00699828665725172 \
5.143425747634502e-07 0.006935886594503895 5.143445070098238e-07 0.005959177461785255 5.143446867147596e-07 0.005876661013304485 5.143467985058761e-07 0.004981749118765498 \
5.143471412910116e-07 0.004848482978762325 5.143496544570452e-07 0.003966891390423618 5.143501241787149e-07 0.003819799497680527 5.143537644949896e-07 0.002847564273158896 \
5.143542802321751e-07 0.002731633924241866 5.143596220620139e-07 0.001773027297371861 5.143599073822989e-07 0.001729522787584184 5.143651360301289e-07 0.0007540451492352357 \
5.143653101766958e-07 0.0007162692714263865 5.170136987690021e-07 -0.0001123232525192561 5.170138717942902e-07 -0.0002901710972538241 5.170144915460445e-07 -0.001202022686018724 \
5.170145801152216e-07 -0.001365806793032466 5.170149410863549e-07 -0.002110727959526865 5.1701506578065e-07 -0.002395793696299351 5.170154296225314e-07 -0.003299857180474864 \
5.170156008981996e-07 -0.003758114451912169 5.170158948960377e-07 -0.004576312838821549 5.170160051044431e-07 -0.004886880824040592 5.170162833584409e-07 -0.005643955697619643 \
5.170164046322499e-07 -0.00594200199557267 5.170174982543479e-07 -0.00517389603226481 5.170176213582281e-07 -0.004409713243767066 5.170177448263029e-07 -0.003462788751204457 \
5.170178649920999e-07 -0.002366010162083454 5.170179628537677e-07 -0.001346276287748183 5.170180695561039e-07 -0.0001076498664581183 5.170181813974884e-07 0.001328007358939307 \
5.170183173718548e-07 0.003256083960376262 5.170184394010113e-07 0.00514709866632534 5.170186278172891e-07 0.008343062029134115 5.170187688058191e-07 0.01093380316938193 \
5.170189215775225e-07 0.01391176330477175 5.170190642801506e-07 0.01683596409946878 5.170192186323876e-07 0.02013443377634912 5.170193744260432e-07 0.02358734537610087 \
5.170195304833402e-07 0.02715365164079262 5.170196778877403e-07 0.03060642997674319 5.170198265044852e-07 0.03415780069914553 5.170199819257017e-07 0.03793559522944389 \
5.170201403115321e-07 0.04184227512730877 5.170203052511541e-07 0.04596085539464361 5.170204795004229e-07 0.05035714787605008 5.170206584435391e-07 0.05491177248689325 \
5.170208475830321e-07 0.0597604232635115 5.170210503636104e-07 0.06498910043066243 5.170212697356368e-07 0.07067233091134768 5.170215005721334e-07 0.07667464705993039 \
5.170217473839692e-07 0.0831083675499642 5.1702201751608e-07 0.09016243555275107 5.170223107041881e-07 0.0978236474935409 5.170226343596258e-07 0.1062798466079799 \
5.17022997926912e-07 0.1157689210849182 5.170233902204302e-07 0.1259925151671456 5.170238386999148e-07 0.1376538644086695 5.170243603994003e-07 0.1511757390224034 \
5.170249727720439e-07 0.1669844191341421 5.170256494173591e-07 0.1843663871188266 5.170264363276496e-07 0.2044554566749352 5.170273175487439e-07 0.2267919980918504 \
5.170281372923844e-07 0.2474048556006221 5.170288657453285e-07 0.2655829647002126 5.17029507221317e-07 0.2814688958417333 5.170300831444853e-07 0.2956305456066151 \
5.170306204013019e-07 0.3087428400511723 5.17031124292597e-07 0.3209487846516751 5.17031601896145e-07 0.3324328152479784 5.170320800193788e-07 0.343838772307344 \
5.170325321182285e-07 0.3545331600964184 5.170330038845194e-07 0.365596737404158 5.170334475813599e-07 0.3759140547845509 5.170339695498976e-07 0.3879344734281669 \
5.170344970878305e-07 0.399956933836353 5.170348766025743e-07 0.4085271910771138 5.170354055641745e-07 0.4203606102508351 5.170358748832553e-07 0.4307444005277802 \
5.17036310038791e-07 0.4402814026247405 5.170367575161174e-07 0.4500002273945978 5.170371975395924e-07 0.4594737646471725 5.170376008413354e-07 0.4680814138276727 \
5.170379192411013e-07 0.4748254127722248 5.170382892190147e-07 0.4826007100982719 5.17038525472097e-07 0.4875314737878706 5.170387605434932e-07 0.4924129045770672 \
5.170390118828311e-07 0.4975994385012801 5.170393182698655e-07 0.5038799449729535 5.170395752283189e-07 0.5091120301871851 5.170397837026154e-07 0.5133309170973237 \
5.170399840849048e-07 0.5173683849445317 5.170401264786059e-07 0.5202244049244739 5.170402754030717e-07 0.5231993726577677 5.170404869493287e-07 0.5274019882470222 \
5.170407130069516e-07 0.5318780389403845 5.170409075493335e-07 0.5357103559602913 5.170410966812289e-07 0.539423417888626 5.170413261282768e-07 0.5439012399750046 \
5.170415086340828e-07 0.5474563135343053 5.170417459969519e-07 0.5520623276458133 5.1704201499126e-07 0.5572695987004129 5.170422639017101e-07 0.5620706638085723 \
5.170425079185314e-07 0.5667633705755619 5.170427802737437e-07 0.5719926523718327 5.170430416698736e-07 0.5769928369418796 5.170432993012793e-07 0.5819084237686675 \
5.17043546144628e-07 0.586601202059797 5.170437918903538e-07 0.5912552023551558 5.170440184678743e-07 0.5955288021520931 5.170442496200641e-07 0.5998646534936181 \
5.170444559004441e-07 0.6037202012184053 5.170446840212041e-07 0.6079592993751251 5.170449064011852e-07 0.6120725203834017 5.17045133377667e-07 0.6162454422471376 \
5.170453484306168e-07 0.6201823359462864 5.170455778001903e-07 0.6243500782103125 5.170458468230648e-07 0.6292041961704016 5.170460698367118e-07 0.6331993632081415 \
5.170462820912892e-07 0.6369772451758789 5.170464934888789e-07 0.6407176358819484 5.17046693558109e-07 0.644236566349866 5.170469231519586e-07 0.6482486956559365 \
5.170471639888863e-07 0.6524328529570182 5.170473457382733e-07 0.6555667906748446 5.170475342864999e-07 0.6588018260593631 5.170476873661394e-07 0.6614154033769962 \
5.170478593744213e-07 0.6643352515471471 5.170480095472396e-07 0.6668697017322168 5.170481460645293e-07 0.6691578850264722 5.170482956937163e-07 0.6716547631652277 \
5.170484234340851e-07 0.673777752640997 5.170485630202226e-07 0.6760856948620949 5.170486872589102e-07 0.6781310478824312 5.170488184087496e-07 0.6802827752320969 \
5.170489428500932e-07 0.6823179209931315 5.170490800809157e-07 0.6845542421253382 5.170492003290863e-07 0.6865048414796368 5.170493416605295e-07 0.6887891282595083 \
5.170494419916407e-07 0.6904033553735033 5.170495631093426e-07 0.6923460943304175 5.170496538868777e-07 0.6937948943079848 5.170497511453436e-07 0.6953408241330762 \
5.170498473532237e-07 0.6968660703265798 5.170499359670681e-07 0.6982647859968389 5.170500332550912e-07 0.6997938110311075 5.170501657237294e-07 0.7018622871835729 \
5.170503209139279e-07 0.7042674555997347 5.170504587918793e-07 0.7063866855441746 5.170506036461533e-07 0.7085960165693863 5.170507307079098e-07 0.7105202221428537 \
5.170508553934701e-07 0.7123960184768648 5.170509680988463e-07 0.7140814553427599 5.170510798891907e-07 0.7157437310299281 5.170511806678399e-07 0.7172341607972841 \
5.170513179462954e-07 0.7192525454101454 5.170514376303672e-07 0.7210013704967912 5.170515570598379e-07 0.7227365757678518 5.170516839430602e-07 0.7245692610776365 \
5.170518083607121e-07 0.7263556789600311 5.170519320935366e-07 0.728121726658988 5.170520586890634e-07 0.7299181396522603 5.170521890744641e-07 0.7317573312219798 \
5.170523118842844e-07 0.7334798522758219 5.170524473200596e-07 0.7353678990088863 5.170525486098379e-07 0.7367723836293941 5.170526562323338e-07 0.7382576460517265 \
5.170527457604157e-07 0.7394878879617913 5.170528603087849e-07 0.7410528648863303 5.170529483370413e-07 0.7422487366778059 5.170530554151068e-07 0.7436953530868765 \
5.170531854801004e-07 0.7454403311053276 5.170532967597954e-07 0.7469230742113165 5.170534013783547e-07 0.7483084058091373 5.170535254613402e-07 0.7499400420429273 \
5.170536737621685e-07 0.7518749696944975 5.170537951620328e-07 0.7534462209622173 5.170539096027802e-07 0.7549170836379747 5.170540499400977e-07 0.7567069362027918 \
5.170541917029811e-07 0.7584995177563068 5.170543095039188e-07 0.759977341175643 5.170544374807853e-07 0.761570846386187 5.170545791832092e-07 0.7633205808366864 \
5.170546966945226e-07 0.7647599110190483 5.170548422997917e-07 0.7665289162262866 5.170549639940994e-07 0.7679951561698679 5.170550827247088e-07 0.7694149786178283 \
5.170552050113037e-07 0.7708662727382939 5.170553320558196e-07 0.77236234268503 5.170554416997921e-07 0.7736439866494906 5.170555673867047e-07 0.7751025186690397 \
5.170556734018051e-07 0.776323977486031 5.170558089877718e-07 0.7778743028704433 5.170559339507686e-07 0.7792913979962601 5.170560598569209e-07 0.7807070123991936 \
5.17056175124167e-07 0.7819915514687489 5.170562814286401e-07 0.7831664991275713 5.17056419833432e-07 0.7846822315516878 5.170565691298821e-07 0.7862997378875561 \
5.170567146373276e-07 0.7878588534534761 5.170568340418389e-07 0.7891257303126159 5.170569691346634e-07 0.7905455128963393 5.170570903878263e-07 0.7918076974797237 \
5.170572333811048e-07 0.7932816011184505 5.170573775854105e-07 0.7947523458802197 5.170575031222391e-07 0.7960199014141693 5.170576221686118e-07 0.7972110037065316 \
5.170577341044954e-07 0.7983213107123885 5.170578389760473e-07 0.7993531099923881 5.170579342264591e-07 0.8002831901653534 5.170580705697047e-07 0.8016020813281191 \
5.170581873938354e-07 0.8027203407102198 5.170583067984452e-07 0.803852171037294 5.170584289052493e-07 0.8049980820693966 5.170585518602505e-07 0.8061401395390313 \
5.17058678828951e-07 0.8073073595000361 5.170588040685604e-07 0.8084467645495962 5.17058934640955e-07 0.8096220968518901 5.170590606314733e-07 0.8107441738369082 \
5.170591888173857e-07 0.8118738099374113 5.170592943471138e-07 0.8127947795787664 5.170593972188868e-07 0.8136847278655364 5.17059490214057e-07 0.8144826950388273 \
5.170596140106596e-07 0.8155354283166244 5.170597019789174e-07 0.8162769513478326 5.170598007099885e-07 0.8171027376706747 5.170599439751418e-07 0.8182889948057973 \
5.170600792538271e-07 0.8193962136425846 5.170601883684495e-07 0.8202800249700468 5.17060336451758e-07 0.8214657808291811 5.170604862226849e-07 0.8226492530953341 \
5.170606114572855e-07 0.8236267526687548 5.170607554487031e-07 0.8247372275730155 5.170608795047738e-07 0.8256825756473101 5.170610299680322e-07 0.8268152483647575 \
5.170611656788839e-07 0.8278240064655301 5.170612906973921e-07 0.828742521381556 5.170614084523219e-07 0.8295983347934622 5.170615544291349e-07 0.8306466023667578 \
5.170617209384522e-07 0.8318251482734692 5.170618518610281e-07 0.8327390940956469 5.170620252884657e-07 0.8339327615268647 5.170621934353481e-07 0.8350717495747054 \
5.170623632702772e-07 0.8362042975620877 5.170625441950479e-07 0.8373912937861997 5.170626872933069e-07 0.8383160748488641 5.170628013791983e-07 0.8390446117604563 \
5.170629315531841e-07 0.8398665237782376 5.170630333942664e-07 0.8405024977857931 5.170631502136154e-07 0.8412243379523001 5.170632870780449e-07 0.8420597162999857 \
5.170634848766686e-07 0.8432475311273343 5.170636764807397e-07 0.8443767279905872 5.170638859212216e-07 0.8455874169714939 5.170640678468519e-07 0.8466193100105236 \
5.170642649799575e-07 0.8477171434207121 5.170644383298479e-07 0.8486653666163242 5.170646213292317e-07 0.8496493024239481 5.17064792495495e-07 0.8505537352954988 \
5.170649671272818e-07 0.8514606693963016 5.170651423896692e-07 0.8523550102558151 5.170653185417845e-07 0.8532381479010797 5.170655088128237e-07 0.8541746551565574 \
5.170656994147745e-07 0.85509499218684 5.170659000624008e-07 0.8560449689899254 5.170660926729659e-07 0.8569390259424264 5.170663033306522e-07 0.8578972157030333 \
5.170665314560509e-07 0.8589122247267402 5.170667972133685e-07 0.8600655879592763 5.170670958378129e-07 0.8613244245924475 5.170673721693317e-07 0.862454900702886 \
5.170676564023905e-07 0.8635842083919951 5.17067930614306e-07 0.8646423892283146 5.170682028423722e-07 0.8656634505877856 5.170684730511913e-07 0.8666487272755322 \
5.170687302040671e-07 0.8675609437488442 5.170690027863351e-07 0.868501515423508 5.170692787713349e-07 0.8694269133137555 5.170695488729115e-07 0.8703069289141475 \
5.170698487348628e-07 0.8712546000783432 5.170702197689933e-07 0.8723856543073821 5.170705147067536e-07 0.8732530157608677 5.170707689975357e-07 0.8739790309043101 \
5.170710672549513e-07 0.8748056771600844 5.170713408634847e-07 0.8755409825400007 5.170715769915496e-07 0.8761583495732972 5.170718173369303e-07 0.876770807053994 \
5.170720396702121e-07 0.8773233906735478 5.170722336759598e-07 0.8777948466981503 5.17072563398506e-07 0.8785737911727464 5.170727185719444e-07 0.8789308835864816 \
5.170730363474729e-07 0.8796437246174529 5.1707321520917e-07 0.8800342982281311 5.170735576710472e-07 0.8807611334253193 5.170737417995192e-07 0.8811407335605206 \
5.170742166778565e-07 0.8820849466541889 5.170743840740528e-07 0.8824061830950772 5.170748499154564e-07 0.8832696475595492 5.170750307376651e-07 0.8835931319180218 \
5.170755247759143e-07 0.8844450822729043 5.170756661243274e-07 0.8846804878101884 5.170762724573853e-07 0.8856498028150036 5.170764245267248e-07 0.8858829444029697 \
5.170770712152002e-07 0.8868329272509302 5.170771995097231e-07 0.8870138524519416 5.170778476269279e-07 0.8878919388991984 5.170779774257915e-07 0.8880607713689423 \
5.17078755627481e-07 0.8890227771434612 5.170788706844142e-07 0.8891574578072456 5.170797263428482e-07 0.8901003239091128 5.170798717076157e-07 0.8902505899439886 \
5.1708085746403e-07 0.8911948786459364 5.170810785690402e-07 0.8913892999646706 5.170822236960191e-07 0.8923206810037944 5.170823549126185e-07 0.892422953350996 \
5.170836961242674e-07 0.8934189515818408 5.170838475232108e-07 0.8935240845833778 5.170853289614591e-07 0.8944568913393511 5.170855678408922e-07 0.8945912088657246 \
5.170873371610739e-07 0.8954685138428928 5.170877263108405e-07 0.895637400736999 5.170901199766275e-07 0.896526474291006 5.170905956894498e-07 0.8966764365754722 \
5.17094011699057e-07 0.8975478548673914 5.170946588490716e-07 0.8976786076740833 5.171021370136781e-07 0.8986646932675814 5.171028095907965e-07 0.8987192862546014 \
5.171952539953667e-07 0.8997188196574962 5.171959172280509e-07 0.8997241906476866 5.17385126389945e-07 0.900686595210158 5.173852884627892e-07 0.9007292695325627 \
5.173879339836764e-07 0.8998161167154269 5.173881025331538e-07 0.8996881690130656 5.173893792855451e-07 0.8987393243250013 5.173895814518808e-07 0.8986030018074492 \
5.173911895612674e-07 0.8976721249252815 5.173913816671926e-07 0.8975774045828077 5.174064950498387e-07 0.8985726115129884 5.174066831087563e-07 0.8986004060702872 \
5.174179880377677e-07 0.8995874924221801 5.174183614235164e-07 0.8996034751727418 5.17907373786698e-07 0.9005892719715856 5.179074845548976e-07 0.9006868984798269 \
5.179082372272589e-07 0.9015617873136611 5.179083390219455e-07 0.9017086238768567 5.179088744204902e-07 0.9025814930725723 5.179089769296628e-07 0.9027670217776843 \
5.179093691484816e-07 0.9035254014384071 5.17909509991429e-07 0.9038129158713877 5.179099510288813e-07 0.9047472953155866 5.179101365144842e-07 0.9051402477015744 \
5.179106528276013e-07 0.9061269394579334 5.17910737502694e-07 0.9062564181617988 5.179119721747438e-07 0.9053011091537977 5.179121293881559e-07 0.9045688862145235 \
5.179123212048176e-07 0.9034162411061901 5.179124880453484e-07 0.9021712267446264 5.179126350037463e-07 0.9008824031243315 5.179127491199424e-07 0.8997575350477262 \
5.179128789920323e-07 0.8983446880789033 5.179129901095502e-07 0.8970273815442567 5.179130829140294e-07 0.8958483937359277 5.17913171236719e-07 0.8946639786015808 \
5.179132744174779e-07 0.8932058048613533 5.179133666254135e-07 0.8918333298588224 5.179134541956102e-07 0.8904732289418564 5.179135681890766e-07 0.8886245408236838 \
5.179137299935004e-07 0.8858564722885236 5.179139149921176e-07 0.8825005184224666 5.179141071517853e-07 0.8788219124347386 5.179143085991386e-07 0.874780227084481 \
5.17914515009728e-07 0.8704697801294994 5.179147001816806e-07 0.8664790122147591 5.179148846894051e-07 0.862405115500708 5.179150578412963e-07 0.8585071391690239 \
5.179152428873213e-07 0.8542751393552932 5.179154202615245e-07 0.8501657390392787 5.179155970079552e-07 0.8460284987362284 5.179157631666058e-07 0.8421077870518131 \
5.179159252110445e-07 0.8382599993991456 5.179160917839251e-07 0.8342839555277276 5.179162504376617e-07 0.8304816347052207 5.179164413136869e-07 0.8258903812682129 \
5.179166162972586e-07 0.8216694867670907 5.179167862433925e-07 0.8175615830390965 5.179169514195675e-07 0.8135626411663678 5.179171246116744e-07 0.8093650119631921 \
5.179172956738769e-07 0.8052155696745213 5.179174637749139e-07 0.801136095357175 5.179176541098627e-07 0.7965156511928794 5.179178376918066e-07 0.7920591698039 \
5.179180456827317e-07 0.7870113041480956 5.179182682592422e-07 0.7816114142545842 5.17918457674258e-07 0.7770174196885687 5.17918650984654e-07 0.7723312127316435 \
5.179187944302406e-07 0.7688556734481145 5.179189438535907e-07 0.7652374066097742 5.179190630060629e-07 0.7623536300085233 5.179191757225445e-07 0.7596269484184472 \
5.179192849974512e-07 0.7569846861296079 5.179194210272094e-07 0.753697254849378 5.179195338230239e-07 0.750972995067179 5.1791965602098e-07 0.7480232093637929 \
5.179197676057526e-07 0.7453311011793381 5.179198923122156e-07 0.7423241425761796 5.179200466941668e-07 0.7386034578119585 5.179202134782327e-07 0.7345862494782525 \
5.179204306429212e-07 0.7293605768817599 5.179206252035101e-07 0.7246835946359503 5.179207855343955e-07 0.7208333202545074 5.179209609599985e-07 0.7166251500492028 \
5.179211507235728e-07 0.7120779400724765 5.179213394518973e-07 0.7075610435995559 5.179215212732643e-07 0.7032145396962334 5.179217058706759e-07 0.6988062725207448 \
5.179218429538112e-07 0.6955348514212173 5.179219962420495e-07 0.6918805091472418 5.179221916137951e-07 0.6872279990818534 5.179223477705467e-07 0.6835136309588888 \
5.179225057227664e-07 0.6797605476340507 5.179227039740297e-07 0.6750570282453686 5.179228973199278e-07 0.6704763548785364 5.179231338252739e-07 0.6648822204491218 \
5.179233200303777e-07 0.6604858901039825 5.179235576526979e-07 0.6548824851665868 5.179237444514521e-07 0.6504854738275335 5.179239250092116e-07 0.6462424706993735 \
5.179240880851561e-07 0.6424159959781919 5.179242326967206e-07 0.6390271817202816 5.179243732990706e-07 0.6357379642635244 5.179245001086568e-07 0.632774906490579 \
5.179246322451931e-07 0.6296924762754078 5.179247584891446e-07 0.6267508340255646 5.179248897527744e-07 0.6236963630311418 5.179250188505141e-07 0.6206978048938425 \
5.179251582761787e-07 0.6174624210713571 5.179253066461711e-07 0.6140261568477932 5.179255012030603e-07 0.6095278574984737 5.179256446489367e-07 0.6062198040692683 \
5.179258791091827e-07 0.6008245134060309 5.179260510074948e-07 0.5968818013610552 5.179262639280334e-07 0.5920102583789468 5.179264363946513e-07 0.5880775912131976 \
5.179265667191976e-07 0.5851108450968721 5.179266982755174e-07 0.5821241897920357 5.179268085055991e-07 0.5796262478458715 5.179269041598466e-07 0.5774603558442819 \
5.179270033938061e-07 0.5752182923213994 5.179270863119074e-07 0.5733484809858778 5.179271652275342e-07 0.5715706040143225 5.179272281563093e-07 0.5701535626562365 \
5.179272936647861e-07 0.5686800671140783 5.179273741508387e-07 0.5668736364148982 5.179274240168465e-07 0.5657560592102344 5.179274732056154e-07 0.5646541775062763 \
5.179275346754008e-07 0.5632780399140616 5.179275825969294e-07 0.5622058085646952 5.179276334416479e-07 0.5610687758404553 5.179276925419032e-07 0.5597501790023616 \
5.1792775115623e-07 0.5584442118409422 5.179278267823233e-07 0.5567607189607793 5.17927897341035e-07 0.5551915720267918 5.179279864710419e-07 0.5532116467156011 \
5.1792807569462e-07 0.5512351177508077 5.179281609982305e-07 0.5493490637975145 5.17928248625197e-07 0.5474138635528197 5.179283456271202e-07 0.545274424894262 \
5.179284499728913e-07 0.5429792414815097 5.179285662643155e-07 0.5404269323775457 5.17928672601932e-07 0.5380963700835184 5.179287843108152e-07 0.5356536306660374 \
5.179288966052949e-07 0.5332047801427824 5.179290238028543e-07 0.5304364255197962 5.17929146572528e-07 0.5277698476303582 5.179292887969246e-07 0.5246912237717902 \
5.179294251600566e-07 0.5217463069543907 5.179295773811234e-07 0.5184691491721333 5.179297370173294e-07 0.5150420887864461 5.179299129925215e-07 0.5112761258030903 \
5.179301015011087e-07 0.5072591542828934 5.179303085676897e-07 0.5028616940969075 5.179305335096623e-07 0.4981043078903621 5.179307849056188e-07 0.4928144328841237 \
5.17931021331185e-07 0.4878598554762091 5.179313184949192e-07 0.4816683149127979 5.179316091722113e-07 0.4756487143466775 5.17931917027196e-07 0.469313240945046 \
5.179322308529534e-07 0.4628991126846517 5.179325599943131e-07 0.4562163541974347 5.179328933724197e-07 0.4494927613461197 5.179332249990283e-07 0.4428490490857003 \
5.179335465484253e-07 0.4364504708187015 5.179338742242378e-07 0.4299742838549845 5.179342218438604e-07 0.4231546934710667 5.179345550651742e-07 0.4166645133789623 \
5.179349009744022e-07 0.4099771621835854 5.179353463882216e-07 0.4014400148089548 5.179357041780922e-07 0.3946500490499754 5.179360183349117e-07 0.3887397205534429 \
5.179364027453916e-07 0.3815756289527631 5.179367327200364e-07 0.3754830843203271 5.179370179301253e-07 0.3702633801070484 5.179373262203821e-07 0.3646649204592909 \
5.179376060174434e-07 0.3596257204303125 5.179378320117929e-07 0.3555880084110294 5.179380468497475e-07 0.3517755993421203 5.179382452848198e-07 0.3482769933469286 \
5.179384492243371e-07 0.3447071465415313 5.179386597603963e-07 0.3410461989361561 5.179389167345214e-07 0.3366091000429626 5.179391579951288e-07 0.3324763702393667 \
5.179393895688451e-07 0.3285420159269506 5.179396042222911e-07 0.3249208057821749 5.17939825046275e-07 0.3212218866489027 5.179400262928671e-07 0.3178749657716667 \
5.179402293821204e-07 0.3145250552959265 5.179404272269914e-07 0.3112865758726304 5.179406140799367e-07 0.3082497660855442 5.179408080166626e-07 0.3051208532403978 \
5.179410117613171e-07 0.30185834615803 5.179411904885829e-07 0.2990186060348319 5.179414281343783e-07 0.2952727068736475 5.179416278966111e-07 0.2921508861588616 \
5.179418295254275e-07 0.2890253490052915 5.179420549918856e-07 0.285561995332 5.17942221086285e-07 0.2830312764183137 5.179423997053871e-07 0.2803277612349699 \
5.179425814095884e-07 0.2775983111934518 5.179427700433049e-07 0.2747882307029562 5.179429474665079e-07 0.2721695222189568 5.179431246596455e-07 0.2695724116247911 \
5.179432847315606e-07 0.2672552081803913 5.179434051322385e-07 0.2655193337608355 5.179435529583031e-07 0.2633957862580221 5.179436815880755e-07 0.2615692882062232 \
5.179437837936585e-07 0.2601227034409412 5.179439020289393e-07 0.2584516051170885 5.179440224822997e-07 0.2567534139348401 5.179441461906177e-07 0.2550183706610066 \
5.179442644426428e-07 0.2533694204037282 5.179443922957733e-07 0.2515887492000971 5.179445125816039e-07 0.249915736161692 5.179446652612099e-07 0.2477917697339537 \
5.179448001739884e-07 0.2459264316518071 5.179449288134099e-07 0.2441493177932957 5.17945086528788e-07 0.2419705448111171 5.179452132100908e-07 0.2402201997919771 \
5.179453485361584e-07 0.2383592392624043 5.179454874487268e-07 0.2364550510890953 5.179456052210312e-07 0.2348405558720491 5.179457644918496e-07 0.2326580599570062 \
5.179459010137043e-07 0.2307878375452989 5.179460422456503e-07 0.2288626996658652 5.179461480586929e-07 0.2274220928889542 5.179462784016402e-07 0.2256484734765637 \
5.17946378112453e-07 0.2242944442559471 5.179464809338881e-07 0.2228991027388591 5.179465543495424e-07 0.2219046249368765 5.17946634181104e-07 0.2208265149641777 \
5.179467042283352e-07 0.2198809561195558 5.179467546314264e-07 0.2192009305305119 5.179468068832254e-07 0.2184966408607167 5.179468861207428e-07 0.2174292050927151 \
5.179469279646958e-07 0.2168658036437602 5.179469673046481e-07 0.216336351877609 5.179470103400575e-07 0.2157575332679269 5.179470545074838e-07 0.2151638767852215 \
5.179471282732236e-07 0.2141731338947761 5.179471637852206e-07 0.2136967174286463 5.179472115000211e-07 0.2130606706933813 5.17947272229561e-07 0.2122518321687151 \
5.179473404867867e-07 0.2113438957752176 5.179474130085659e-07 0.2103801801047663 5.179474856831929e-07 0.2094152724966429 5.179475939991808e-07 0.2079788886429202 \
5.179476916703231e-07 0.20668564243436 5.179478032218192e-07 0.2052110974836689 5.179479017572531e-07 0.2039136008387587 5.179480052503929e-07 0.2025572972554956 \
5.179481011521277e-07 0.2013021587886929 5.17948203780057e-07 0.1999606878451601 5.179483066031699e-07 0.1986207062101238 5.179484167227972e-07 0.1971897063011611 \
5.179485254183531e-07 0.1957815523781236 5.179486450955817e-07 0.1942360962608612 5.179487553732606e-07 0.192818053470401 5.179488634364806e-07 0.1914343471929882 \
5.179489885351485e-07 0.1898375077741012 5.179490785049817e-07 0.1886931806549971 5.179491571919347e-07 0.1876950225942949 5.17949234476806e-07 0.1867173468865102 \
5.179493209853825e-07 0.1856271834369256 5.179494199345929e-07 0.1843848109964498 5.179494904434582e-07 0.1835017733581451 5.179495618945114e-07 0.1826096997732476 \
5.179496670398458e-07 0.1813018727451555 5.179497462794755e-07 0.1803200401832796 5.179498273633695e-07 0.1793174195483187 5.179499208553101e-07 0.1781663090788374 \
5.179500216312847e-07 0.1769308188703378 5.179501713433884e-07 0.175105380089017 5.179502871327037e-07 0.1737009932372819 5.179504381380806e-07 0.1718807311127691 \
5.179505492465001e-07 0.1705485445502526 5.179506913729584e-07 0.168854666407182 5.179508090313791e-07 0.167460358327668 5.179509139359749e-07 0.1662230887079887 \
5.179510089985733e-07 0.1651069099307241 5.179511024298279e-07 0.1640147999883682 5.179512034764903e-07 0.1628388413495604 5.179512998233979e-07 0.1617223204899406 \
5.179513969756437e-07 0.1606011553546776 5.179514800242163e-07 0.1596469772300165 5.179515900618698e-07 0.1583897228513109 5.179516723644316e-07 0.1574542248873526 \
5.179517773641412e-07 0.156267858580057 5.179518550602102e-07 0.1553950893374849 5.179519378796887e-07 0.1544690878994293 5.179520195415937e-07 0.1535604570452941 \
5.179521088908843e-07 0.152571060794856 5.1795218460332e-07 0.1517364980793458 5.179522671659343e-07 0.1508307726525361 5.179523437473671e-07 0.1499942554682341 \
5.179524120352535e-07 0.1492531084507001 5.179525054022655e-07 0.1482449401818621 5.179525745556768e-07 0.1475015570698688 5.179526501800083e-07 0.1466917482325688 \
5.179527117291285e-07 0.1460354497178591 5.179527789778923e-07 0.1453208357145237 5.179528500398917e-07 0.1445684785944268 5.179529255373203e-07 0.143772322008306 \
5.179529844488598e-07 0.1431546944759192 5.179530611224699e-07 0.1423563022825049 5.179531414432115e-07 0.1415233898163201 5.179532145945195e-07 0.1407682091691316 \
5.179533087509408e-07 0.139800669784813 5.179533803551247e-07 0.1390684367429364 5.179534538159004e-07 0.1383201464810226 5.179535373276515e-07 0.1374732033664194 \
5.179536268067954e-07 0.1365744208092838 5.179536918717002e-07 0.1359252211013016 5.179538039977228e-07 0.1348115665849295 5.179538691838634e-07 0.1341670699454539 \
5.179539392221084e-07 0.1334770515823289 5.179539995271633e-07 0.1328849371768329 5.179540545379868e-07 0.1323464455745446 5.17954142654965e-07 0.1314871014507438 \
5.179541834412595e-07 0.131090685705856 5.179542871440105e-07 0.1300923774523848 5.179543304565801e-07 0.1296773144713907 5.17954391675178e-07 0.1290920262082728 \
5.179544365118974e-07 0.1286643765206081 5.179545241079233e-07 0.127831527987147 5.179545656618794e-07 0.1274377589706847 5.179546255233895e-07 0.1268718307679372 \
