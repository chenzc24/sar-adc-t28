1.528091214026983e-06 0.7027960765825516 1.528091346256499e-06 0.7048392108129343 1.528091459433897e-06 0.7065756917706891 1.528091613866752e-06 0.708927873976708 \
1.528091744646745e-06 0.7109048231498766 1.528091867315455e-06 0.7127465601965561 1.528091973583711e-06 0.7143329262278221 1.528092095963735e-06 0.7161490373358268 \
1.528092197817232e-06 0.7176517022913665 1.528092331955131e-06 0.7196190116794019 1.528092452648172e-06 0.7213783352064487 1.528092571789971e-06 0.7231049829175343 \
1.528092696807985e-06 0.7249059312823601 1.528092826647791e-06 0.7267645120560844 1.528092946459962e-06 0.7284691779696002 1.528093075453213e-06 0.730293808329565 \
1.528093207560277e-06 0.7321507998840678 1.528093325866095e-06 0.7338038328985433 1.528093469126786e-06 0.7357927618453034 1.528093571581473e-06 0.7372070005703254 \
1.528093667788359e-06 0.7385290937783453 1.52809377280598e-06 0.7399656334130889 1.528093883577511e-06 0.7414708009413548 1.528093985256052e-06 0.7428439364018735 \
1.528094088217507e-06 0.7442258341871242 1.52809420514366e-06 0.7457850038572696 1.528094333903937e-06 0.747489965072781 1.528094435062908e-06 0.7488201182152049 \
1.528094583931952e-06 0.7507626302114226 1.528094731611489e-06 0.75267249971878 1.528094850976855e-06 0.7542038164026367 1.5280949974607e-06 0.7560679527984652 \
1.52809512063619e-06 0.7576223900169708 1.528095261439865e-06 0.7593848990234215 1.528095398032531e-06 0.7610800595258669 1.528095520190381e-06 0.7625841275516777 \
1.528095632846779e-06 0.7639610711610054 1.52809577457292e-06 0.7656796138775311 1.52809590073942e-06 0.767196844592689 1.528096016156724e-06 0.768574452686535 \
1.528096146464904e-06 0.7701179991486644 1.528096262177572e-06 0.7714782821591826 1.52809638500186e-06 0.7729116492687436 1.528096502846128e-06 0.7742769236963016 \
1.528096608476118e-06 0.7754922619072108 1.528096723849553e-06 0.7768108638983861 1.528096829112716e-06 0.7780056027231214 1.528096940062529e-06 0.7792565499870431 \
1.528097026467031e-06 0.7802246528436213 1.528097130500851e-06 0.7813823422463088 1.528097244396594e-06 0.7826398494046257 1.528097347430013e-06 0.7837684443710583 \
1.528097455512714e-06 0.7849432998269023 1.52809756376437e-06 0.7861107422109641 1.528097699181616e-06 0.7875582910536544 1.528097811855724e-06 0.7887521292973186 \
1.528097936279784e-06 0.7900592323105087 1.528098054252648e-06 0.7912877959129118 1.528098198720603e-06 0.7927781272271259 1.528098316389742e-06 0.7939806363584788 \
1.528098452269581e-06 0.7953567374150946 1.528098587013954e-06 0.7967081403609936 1.528098698084933e-06 0.7978123285366109 1.528098797974273e-06 0.7987978371087655 \
1.528098899654231e-06 0.7997937268659365 1.528099032867897e-06 0.8010867894381996 1.528099151240716e-06 0.8022243628210853 1.52809927278179e-06 0.8033812848148773 \
1.528099392145442e-06 0.8045065422543012 1.528099513276819e-06 0.80563739819571 1.528099644976236e-06 0.8068544426691319 1.528099767984513e-06 0.8079795872959963 \
1.52809989582812e-06 0.8091371804586788 1.52810002673464e-06 0.8103101881504271 1.528100150327798e-06 0.8114062915203997 1.528100257500303e-06 0.8123479140825919 \
1.528100364929502e-06 0.8132835730547656 1.52810044759862e-06 0.8139979974227743 1.52810056531038e-06 0.8150069815425507 1.528100655915986e-06 0.8157770472204025 \
1.528100786569431e-06 0.8168774959419571 1.528100930959301e-06 0.8180800468042847 1.528101064133715e-06 0.8191766687328477 1.528101174025107e-06 0.8200725423139092 \
1.528101317623992e-06 0.8212302325252553 1.528101471014683e-06 0.8224508494407716 1.528101599092908e-06 0.8234574467428303 1.528101738880276e-06 0.8245431382086058 \
1.528101865129839e-06 0.8255122018650548 1.528102019728392e-06 0.8266841987320058 1.528102151939368e-06 0.8276738265999063 1.528102278166151e-06 0.8286078934539939 \
1.528102395913874e-06 0.8294698388787296 1.528102544986668e-06 0.8305480062617677 1.52810271231822e-06 0.8317406852496945 1.528102845539497e-06 0.8326770812274722 \
1.52810301832082e-06 0.8338744310092966 1.528103186826194e-06 0.8350236380668206 1.528103356205492e-06 0.8361608866600232 1.528103537840761e-06 0.8373606451951652 \
1.528103680174083e-06 0.8382866867625347 1.528103794011069e-06 0.8390185116470331 1.528103925192579e-06 0.8398522525089582 1.528104026724794e-06 0.8404903982372576 \
1.528104143009054e-06 0.8412135669902132 1.528104277643808e-06 0.8420406924792603 1.528104474666644e-06 0.8432316292878405 1.528104664772186e-06 0.8443592803112207 \
1.528104874895499e-06 0.8455816023960827 1.528105055213604e-06 0.8466107566581813 1.528105252676705e-06 0.8477171937062282 1.52810542674582e-06 0.8486750118570332 \
1.52810560906524e-06 0.8496608982186138 1.528105780480376e-06 0.8505716849290491 1.528105954593653e-06 0.8514808063694008 1.528106130324621e-06 0.8523822271368225 \
1.528106306436321e-06 0.8532696099472232 1.528106496054173e-06 0.8542074684498208 1.52810668683567e-06 0.8551330189126392 1.528106888431747e-06 0.8560917259710515 \
1.528107081166005e-06 0.856990088884472 1.528107290037826e-06 0.8579439907476532 1.528107520740263e-06 0.8589743400177088 1.528107785183227e-06 0.8601259267840322 \
1.528108084005915e-06 0.8613896125360476 1.528108363960216e-06 0.8625380186322354 1.528108648086082e-06 0.8636694076724545 1.528108922855057e-06 0.8647317823994775 \
1.528109194712217e-06 0.8657531067718063 1.528109465089334e-06 0.8667403371654003 1.528109722167856e-06 0.8676533221001362 1.528109994792687e-06 0.868594905839151 \
1.528110270759836e-06 0.8695208838709013 1.528110540864093e-06 0.8704012674911344 1.528110840740104e-06 0.8713491368600049 1.528111211801162e-06 0.8724801680184872 \
1.52811150674079e-06 0.8733472453740196 1.528111761036548e-06 0.8740729094291386 1.528112059297474e-06 0.8748989982677786 1.528112332904015e-06 0.8756336613858092 \
1.528112569029958e-06 0.876250392688866 1.528112809374056e-06 0.8768621356511911 1.528113031706182e-06 0.8774140071409635 1.528113225712247e-06 0.8778848105679672 \
1.528113555434997e-06 0.8786625669521169 1.528113710608526e-06 0.8790190643519731 1.528114028387606e-06 0.879730644938159 1.528114207248864e-06 0.8801204696806418 \
1.528114549710761e-06 0.8808457867651537 1.528114733837363e-06 0.8812245477320809 1.528115208711942e-06 0.8821665346129511 1.528115376108352e-06 0.8824869809105039 \
1.528115841951854e-06 0.883348261932613 1.528116022773548e-06 0.8836708855253055 1.528116516812651e-06 0.8845204537290557 1.528116658162059e-06 0.8847551796839913 \
1.528117264500122e-06 0.8857215808967022 1.528117416569336e-06 0.8859539944113424 1.528118063256356e-06 0.8869009218298172 1.528118191551239e-06 0.8870812460539503 \
1.528118839667745e-06 0.8879562712787433 1.528118969467641e-06 0.8881245027440973 1.52811974767834e-06 0.8890830197250962 1.528119862725472e-06 0.8892171882189283 \
1.528120718396314e-06 0.8901564861234483 1.528120863744077e-06 0.8903061494816453 1.528121849499649e-06 0.8912466483555094 1.528122070607711e-06 0.8914402669210102 \
1.528123215727714e-06 0.892367747196105 1.528123346939159e-06 0.8924695935232408 1.528124688211624e-06 0.8934615053489913 1.5281248396029e-06 0.8935661991834861 \
1.52812632105512e-06 0.8944951400107031 1.528126559934816e-06 0.8946288932334222 1.528128329356654e-06 0.895502508848118 1.528128718477945e-06 0.895670668133377 \
1.528131112210654e-06 0.8965556062201232 1.528131587750592e-06 0.8967047758494365 1.528135650819818e-06 0.8977025964496719 1.528136142295654e-06 0.8977953148389237 \
1.528144458892796e-06 0.8987880790885289 1.528145378794248e-06 0.8988514070442593 1.528299242370168e-06 0.8998485708192639 1.528302885496457e-06 0.8998628537402877 \
1.528529614276672e-06 0.8989664306490068 1.528529844616583e-06 0.8988008565867064 1.528531459536881e-06 0.897804750401333 1.528531637269166e-06 0.8977103535805105 \
1.528548403669271e-06 0.8986978311584225 1.528548539768403e-06 0.8987160394686986 1.528563710608672e-06 0.8997133888183054 1.528563987713508e-06 0.899719468756186 \
1.529048028906422e-06 0.9005852143835333 1.529048202241039e-06 0.9007408621809421 1.529048862730638e-06 0.9015135064485434 1.52904902879582e-06 0.9017527716291757 \
1.529049555130528e-06 0.9026184054967997 1.529049746244447e-06 0.9029704910143604 1.5290501104655e-06 0.9036902342402512 1.529050289664921e-06 0.9040628043424317 \
1.529050651551594e-06 0.9048333795345931 1.529050846661164e-06 0.9052442844328937 1.529051379059525e-06 0.9062266394381637 1.529051561413164e-06 0.9064623886473868 \
1.529052553393556e-06 0.905594670761786 1.529052714934123e-06 0.9049318860608667 1.529052882926576e-06 0.9040378649110347 1.529053042758061e-06 0.9029782421366458 \
1.529053180254799e-06 0.9018984154159868 1.529053313162111e-06 0.9007052793196499 1.529053439587579e-06 0.8994328447569792 1.529053546986819e-06 0.8982475863895881 \
1.529053651483477e-06 0.8970047013543965 1.529053765533147e-06 0.8955451342423859 1.529053855502734e-06 0.8943225684615312 1.529053960321373e-06 0.8928208677113324 \
1.529054049769612e-06 0.891473284704788 1.529054132145393e-06 0.8901820884368528 1.529054223238393e-06 0.8887006634027688 1.529054360574471e-06 0.8863657732814155 \
1.529054459067403e-06 0.8846195012157601 1.529054571141153e-06 0.8825649218508906 1.529054702024186e-06 0.880080778639088 1.529054838495216e-06 0.8774018563482072 \
1.529054991949379e-06 0.8742910281085086 1.529055151043747e-06 0.8709679977889497 1.529055315327649e-06 0.867445283300377 1.529055471995751e-06 0.8640104344288071 \
1.529055624086531e-06 0.860615744772629 1.529055777800206e-06 0.857132398554192 1.529055937362381e-06 0.853469801378647 1.529056092451083e-06 0.8498714074018293 \
1.529056266130401e-06 0.8458039138600054 1.529056429161269e-06 0.8419559450883216 1.529056590803684e-06 0.8381170660338335 1.529056753450421e-06 0.8342344554797501 \
1.529056914868927e-06 0.8303657475978833 1.529057083463406e-06 0.8263109424305363 1.529057266356504e-06 0.8219002364007665 1.529057434185218e-06 0.8178440888239877 \
1.529057602471033e-06 0.8137703061148112 1.529057773299085e-06 0.8096302849976138 1.529057945473642e-06 0.8054541271740473 1.529058113235561e-06 0.8013830614994394 \
1.529058296865018e-06 0.7969255463994016 1.529058468271496e-06 0.7927646873948894 1.529058653714802e-06 0.7882638003278283 1.529058820385454e-06 0.7842196820467244 \
1.529058989271585e-06 0.7801233737411432 1.529059173427882e-06 0.7756572567105651 1.529059368037911e-06 0.7709405333854473 1.529059515293241e-06 0.7673736106648734 \
1.529059641923832e-06 0.7643079795643375 1.529059783780644e-06 0.7608754495129878 1.529059888184422e-06 0.7583505812556488 1.529060020577074e-06 0.7551502542766809 \
1.529060130161271e-06 0.7525028097975122 1.529060263325923e-06 0.7492875979647342 1.529060419507685e-06 0.7455190770546114 1.529060532737112e-06 0.7427887939149777 \
1.529060695258476e-06 0.7388718945951063 1.529060867439292e-06 0.7347246296492568 1.529061063444044e-06 0.7300078517193382 1.529061227834023e-06 0.7260553905833119 \
1.529061380230704e-06 0.7223944885043934 1.529061543905858e-06 0.718466402706526 1.529061711831558e-06 0.7144406657912139 1.529061891671936e-06 0.7101336212543717 \
1.529062067965886e-06 0.7059164985576465 1.529062239040521e-06 0.7018286413152719 1.529062407358697e-06 0.6978099102718778 1.529062560624829e-06 0.6941537154717222 \
1.529062722508398e-06 0.6902960245155986 1.529062901459938e-06 0.6860364417190952 1.52906303567149e-06 0.6828448068431195 1.529063139177788e-06 0.6803854168085423 \
1.5290632384622e-06 0.6780286039046017 1.529063339916677e-06 0.6756220912380299 1.529063432373276e-06 0.6734303711245889 1.529063516962075e-06 0.6714267031582685 \
1.529063610539411e-06 0.6692114082407524 1.529063727081631e-06 0.6664546942583044 1.529063836559192e-06 0.6638675763958631 1.529063949672203e-06 0.6611971533414394 \
1.52906407279097e-06 0.6582923426231613 1.529064197017283e-06 0.6553636581362478 1.529064367777427e-06 0.6513432847262797 1.529064526226014e-06 0.6476181700514572 \
1.529064698513837e-06 0.6435738126612673 1.529064844491904e-06 0.6401512360303271 1.52906498628512e-06 0.6368325564797357 1.529065117883574e-06 0.6337564355289309 \
1.529065248046859e-06 0.630718219665797 1.5290653735718e-06 0.6277924818644975 1.529065505354707e-06 0.6247239543970449 1.529065635278203e-06 0.6217046839485236 \
1.529065771586778e-06 0.6185408917806742 1.529065916200345e-06 0.615188962872713 1.529066075692536e-06 0.611499189008522 1.529066249152652e-06 0.6074939486938447 \
1.529066420159954e-06 0.6035554342946753 1.529066651528522e-06 0.5982402936372396 1.529066894990528e-06 0.5926661367297537 1.529067069111016e-06 0.5886942528256315 \
1.529067215383093e-06 0.5853638081576373 1.529067349755311e-06 0.58231230528805 1.529067466850207e-06 0.5796585826255305 1.529067562614553e-06 0.5774900935424465 \
1.529067661461096e-06 0.5752566196463251 1.529067745438414e-06 0.5733628024369305 1.529067823052463e-06 0.571614165956722 1.529067884377937e-06 0.5702331258704825 \
1.529067949058575e-06 0.5687779664863769 1.529068030366711e-06 0.5669528575016536 1.529068080436707e-06 0.5658306078972934 1.529068129757269e-06 0.5647256890740617 \
1.529068191677069e-06 0.5633393552914843 1.529068239508894e-06 0.5622690492396486 1.529068290013679e-06 0.5611395143522533 1.529068350075717e-06 0.559799205480933 \
1.529068409358512e-06 0.5584782058326896 1.529068484415226e-06 0.5568072508052372 1.529068554097883e-06 0.5552574373576753 1.529068639686449e-06 0.5533559356568912 \
1.529068726753821e-06 0.5514265885063823 1.529068810416341e-06 0.5495763264044081 1.529068896561366e-06 0.5476734676082877 1.529068992265987e-06 0.5455621222678217 \
1.529069096550939e-06 0.5432673229847179 1.529069211218113e-06 0.5407497407899529 1.529069319936574e-06 0.5383664115638558 1.529069429508814e-06 0.5359693749054023 \
1.529069541813574e-06 0.5335193270114367 1.529069668589195e-06 0.530759392645703 1.529069790866427e-06 0.5281021910076299 1.529069930952405e-06 0.5250685463469849 \
1.529070067969763e-06 0.5221084647952599 1.529070218271135e-06 0.5188705764247719 1.529070377166376e-06 0.5154582091324615 1.529070551500259e-06 0.5117250894133971 \
1.529070738517481e-06 0.5077378180012799 1.529070943835486e-06 0.5033745272871338 1.529071155677679e-06 0.498891131759938 1.529071408479721e-06 0.4935662239713107 \
1.52907161056737e-06 0.4893264048484654 1.529071845160675e-06 0.4844277613141263 1.529072081275272e-06 0.4795194943790256 1.529072334451769e-06 0.474283574581623 \
1.529072644981732e-06 0.4679020429045382 1.52907286303971e-06 0.4634451779596257 1.529073036485344e-06 0.4599153839204358 1.529073212977781e-06 0.4563351808422506 \
1.529073492459578e-06 0.4506930409909046 1.529073724703484e-06 0.4460279192631412 1.529074011797073e-06 0.44029020239849 1.529074229643181e-06 0.435960758243863 \
1.529074439695769e-06 0.4318042429497612 1.529074640893605e-06 0.4278406951573778 1.529074823313766e-06 0.4242617300271556 1.529074997208751e-06 0.4208637793449936 \
1.529075162072867e-06 0.4176529694331993 1.52907532082684e-06 0.4145718140694327 1.529075487073787e-06 0.4113577680628809 1.529075635718993e-06 0.4084923702366076 \
1.529075788087249e-06 0.4055658186126443 1.529075930150432e-06 0.4028468403491589 1.52907609952631e-06 0.3996150665462138 1.52907621990823e-06 0.3973276483660343 \
1.529076329881494e-06 0.3952449223617059 1.529076444806895e-06 0.3930732253581283 1.529076597048475e-06 0.3902080468194818 1.52907670926954e-06 0.3881039677199808 \
1.529076816462041e-06 0.386098874836553 1.52907696899029e-06 0.383254723448244 1.529077097137419e-06 0.380874963946598 1.529077219985412e-06 0.3786015923730871 \
1.529077399083788e-06 0.375299968600122 1.52907754816842e-06 0.3725653942578417 1.529077715875808e-06 0.3695018296724824 1.529077871273442e-06 0.3666748141177644 \
1.529077995440288e-06 0.3644243980538668 1.529078109332156e-06 0.3623666676050148 1.529078230775526e-06 0.3601804966264144 1.529078410927293e-06 0.3569532670533712 \
1.529078577415113e-06 0.3539878629329621 1.529078767834223e-06 0.3506138544217919 1.529078959590819e-06 0.3472380408565978 1.529079142640212e-06 0.344035729794033 \
1.529079291612277e-06 0.3414435189591631 1.529079411552182e-06 0.3393660536257183 1.529079534213665e-06 0.3372483242714233 1.529079657244151e-06 0.3351324902755385 \
1.529079802148562e-06 0.3326515017845288 1.529079905461337e-06 0.3308907757076019 1.529079999190846e-06 0.3292979229163631 1.529080089851148e-06 0.3277620998585528 \
1.529080200972602e-06 0.3258853746017661 1.529080308145579e-06 0.3240820510456246 1.52908040642023e-06 0.3224338250618513 1.529080518824776e-06 0.3205545940512134 \
1.529080682764676e-06 0.3178277446588927 1.529080844402555e-06 0.3151576097143818 1.529080992189301e-06 0.3127316247504084 1.529081154434516e-06 0.3100832165115083 \
1.529081314465073e-06 0.3074868334344322 1.529081466728372e-06 0.3050304870660137 1.529081620100242e-06 0.3025703731928215 1.529081778808771e-06 0.3000411640344692 \
1.5290819432579e-06 0.297437246442505 1.529082110484976e-06 0.2948063590562646 1.529082263596513e-06 0.292412731930112 1.52908244669444e-06 0.2895700146919417 \
1.529082637002178e-06 0.2866380344427262 1.529082785905236e-06 0.2843603072871506 1.529082959842542e-06 0.2817165165722222 1.52908313671993e-06 0.2790484233348025 \
1.529083284317148e-06 0.2768363681311815 1.529083473948849e-06 0.2740172295061162 1.529083623950767e-06 0.2718052906662373 1.529083761060958e-06 0.2697943906627059 \
1.529083902591401e-06 0.2677397479842996 1.52908401605027e-06 0.2661005451260196 1.529084152340596e-06 0.2641384584581135 1.529084282417217e-06 0.2622807416655737 \
1.52908440067147e-06 0.2606037730704709 1.529084518527066e-06 0.2589348966568543 1.529084649420877e-06 0.2570853888657079 1.529084789659635e-06 0.2551145527343576 \
1.529084905154221e-06 0.2534976852533538 1.529085034005598e-06 0.2516957519945816 1.52908514915158e-06 0.2500885525459272 1.529085302462547e-06 0.2479513765689386 \
1.529085440316308e-06 0.2460367343642474 1.52908557977796e-06 0.2441002375748529 1.529085735245815e-06 0.2419427021952501 1.52908586002843e-06 0.2402176526454788 \
1.529085999893338e-06 0.2382916534360561 1.529086128595514e-06 0.2365220787132559 1.529086249554366e-06 0.234860341242685 1.529086366599666e-06 0.2332541163798121 \
1.52908649260073e-06 0.2315368940272461 1.529086589320323e-06 0.2302195772445239 1.529086681409196e-06 0.2289683907689286 1.529086795826667e-06 0.2274152998827935 \
1.529086894197314e-06 0.2260807986508055 1.529087011344108e-06 0.2244933520241092 1.529087114435226e-06 0.2231010305483718 1.529087219949952e-06 0.2216798666278746 \
1.529087300868012e-06 0.2205933880575098 1.529087374539197e-06 0.2196046443759679 1.529087417268434e-06 0.2190314036349237 1.529087460398579e-06 0.2184540235451489 \
1.529087511196061e-06 0.217774515685755 1.529087548370939e-06 0.217277430841393 1.529087589041954e-06 0.2167338127731004 1.529087631833756e-06 0.2161620985357572 \
1.529087668244897e-06 0.2156758299561118 1.529087710169888e-06 0.2151161507306283 1.529087764712098e-06 0.2143884526296278 1.529087803170857e-06 0.2138756926875936 \
1.529087842797626e-06 0.2133496230586122 1.529087904630128e-06 0.212531488259555 1.529087966356579e-06 0.2117156525305126 1.529088022493854e-06 0.210974237875411 \
1.529088086149084e-06 0.210134110843225 1.529088180240117e-06 0.2088936328424611 1.529088267048376e-06 0.2077505933124353 1.52908836100502e-06 0.2065146061917991 \
1.529088459047254e-06 0.2052266823513323 1.529088560634619e-06 0.2038976009052371 1.529088661543568e-06 0.2025832113009377 1.529088758279377e-06 0.2013244528083448 \
1.529088860404348e-06 0.1999972806373927 1.529088963735905e-06 0.1986583046056677 1.529089073618507e-06 0.1972379690671278 1.529089182560765e-06 0.1958337611883887 \
1.529089302395885e-06 0.1942937175364915 1.529089412679751e-06 0.1928822800638286 1.529089520558496e-06 0.191507108810815 1.529089646621254e-06 0.1899051957406391 \
1.529089736488961e-06 0.1887671190866151 1.5290898469673e-06 0.1873723090993208 1.529089924500249e-06 0.1863971337376019 1.529090008823992e-06 0.1853400660204312 \
1.52909009641205e-06 0.1842452710069853 1.529090184204644e-06 0.18315095174413 1.529090265924515e-06 0.1821357652581398 1.529090363486193e-06 0.1809282658474054 \
1.529090470197344e-06 0.1796118512064394 1.529090570679026e-06 0.178377576484793 1.529090694850238e-06 0.1768595317522179 1.529090828741761e-06 0.1752320886156309 \
1.529090947653953e-06 0.1737937102924047 1.529091098054147e-06 0.1719851742607024 1.52909120888924e-06 0.1706594030660365 1.529091348655982e-06 0.168997130456427 \
1.52909146718129e-06 0.1675953052211382 1.529091572608521e-06 0.1663548750207849 1.52909166731838e-06 0.1652455210322802 1.529091760628154e-06 0.1641568522804657 \
1.52909186153427e-06 0.1629842804551663 1.529091956952102e-06 0.1618800504313296 1.529092054143025e-06 0.1607598891027116 1.529092135704507e-06 0.1598237474547246 \
1.529092241020952e-06 0.1586229753023833 1.529092324500659e-06 0.1576763029943549 1.52909242602995e-06 0.1565306813704828 1.529092503260486e-06 0.1556635090415242 \
1.529092594132523e-06 0.154647919213242 1.529092663483833e-06 0.1538765336840219 1.529092748067884e-06 0.1529397840535594 1.529092822461091e-06 0.1521208717489242 \
1.529092901831293e-06 0.151251902275755 1.529092976418964e-06 0.1504388356812226 1.529093045640521e-06 0.1496871728711989 1.529093140321328e-06 0.1486640077242138 \
1.529093210087093e-06 0.1479134441579097 1.529093294531656e-06 0.147008717574758 1.529093356097002e-06 0.1463518850554192 1.529093430139493e-06 0.1455673550676988 \
1.529093503525017e-06 0.1447940960774066 1.529093584960259e-06 0.1439395015691976 1.529093654409405e-06 0.1432139999234875 1.529093729511102e-06 0.1424323701137583 \
1.529093819423173e-06 0.1415006120834361 1.529093896506793e-06 0.1407052977810757 1.529093995617377e-06 0.1396885207473417 1.52909406515744e-06 0.138983077430453 \
1.529094146475915e-06 0.1381612812129989 1.529094216644325e-06 0.1374549162714094 1.529094295612438e-06 0.1366629455350578 1.52909437459072e-06 0.1358740351737466 \
1.52909444691251e-06 0.1351544405911459 1.529094516277969e-06 0.1344667589602006 1.529094564981977e-06 0.1339854049281765 1.529094655744348e-06 0.1330945614011112 \
1.529094687765876e-06 0.1327823711724506 1.529094775869844e-06 0.131925672678654 1.529094808363886e-06 0.1316105445757083 1.529094907031543e-06 0.1306564447580443 \
1.529094950687519e-06 0.130235859061297 1.529095028669336e-06 0.1294866595045693 1.529095066000294e-06 0.1291289430202982 1.529095168151694e-06 0.128153223240932 \
1.529095235595654e-06 0.1275115375392494 1.529095300748612e-06 0.1268935577290946 1.529095366654626e-06 0.1262729746041904 1.529095437806609e-06 0.1256052797936485 \
1.52909552074397e-06 0.1248293808775363 1.529095606139451e-06 0.1240331657139879 1.529095682226844e-06 0.1233259817834828 1.529095762687521e-06 0.1225806238777534 \
1.529095820771462e-06 0.1220441728027253 1.529095892104936e-06 0.1213870835332726 1.529095976893369e-06 0.1206085709991845 1.529096038048402e-06 0.1200487744399507 \
1.529096108134853e-06 0.1194096117168642 1.529096170640142e-06 0.1188419501154776 1.52909623664509e-06 0.1182453094891599 1.529096305417857e-06 0.1176255789053269 \
1.529096374874481e-06 0.1170017375875525 1.529096458038731e-06 0.1162574953874909 1.529096531156255e-06 0.1156056107435251 1.529096601870241e-06 0.1149774116339468 \
1.529096661221924e-06 0.1144518657417393 1.529096766519136e-06 0.1135239342411639 1.52909681238663e-06 0.1131212254602471 1.529096899340683e-06 0.1123603821649216 \
1.529096942354464e-06 0.1119852310621949 1.529096987221211e-06 0.1115947726395539 1.529097076954706e-06 0.1108164664143028 1.529097147839057e-06 0.110204256460374 \
1.529097226692571e-06 0.109525796983828 1.529097289470346e-06 0.1089876103666232 1.529097349464702e-06 0.1084750215669379 1.529097460462474e-06 0.1075310013968523 \
1.52909754121676e-06 0.1068475792877216 1.529097653680086e-06 0.1059005796323111 1.529097704824629e-06 0.1054717782906781 1.529097787809798e-06 0.1047785948356612 \
1.529097845974503e-06 0.1042945647727652 1.529097960212503e-06 0.1033482075721767 1.52909801011597e-06 0.1029366076865433 1.529098095857569e-06 0.1022320954501846 \
1.529098144889019e-06 0.1018307629303728 1.529098227455441e-06 0.101157455862875 1.529098298387777e-06 0.1005815064560546 1.529098366538127e-06 0.1000302812267231 \
1.529098444148443e-06 0.0994053199805509 1.529098516491814e-06 0.09882546240595018 1.529098594067778e-06 0.09820656846618626 1.529098682738439e-06 0.09750287271560702 \
1.529098756553227e-06 0.09692010793638871 1.529098838144235e-06 0.09627924899616347 1.529098916282703e-06 0.09566870926115327 1.529099002032494e-06 0.09500229249765579 \
1.529099089729402e-06 0.09432453920671229 1.529099183638967e-06 0.09360304191323381 1.529099280098285e-06 0.09286661217778783 1.529099358728946e-06 0.09226977907248698 \
1.529099461452546e-06 0.09149473120661993 1.529099545280196e-06 0.09086620530027881 1.529099666032378e-06 0.08996702094116031 1.529099795302029e-06 0.08901247130467421 \
1.529099951190493e-06 0.08787237469953549 1.529100106290076e-06 0.08675000010972149 1.529100263305882e-06 0.08562614142917294 1.529100443326735e-06 0.08435280068725284 \
1.529100593847602e-06 0.08330035525696428 1.529100742221624e-06 0.08227363395463329 1.529100879838855e-06 0.08133079092382095 1.529101019758505e-06 0.08038162993974078 \
1.529101156365493e-06 0.07946425488810546 1.529101295092791e-06 0.07854214404995859 1.529101440403653e-06 0.07758663187171365 1.529101588151466e-06 0.07662571164688473 \
1.529101746748333e-06 0.07560598447141591 1.529101911000851e-06 0.07456266320243836 1.529102080017927e-06 0.07350246718885647 1.529102261906921e-06 0.07237646636762114 \
1.529102462529019e-06 0.07115268999588262 1.529102676406562e-06 0.0698691158856425 1.529102904040694e-06 0.0685263410462881 1.529103145626235e-06 0.06712722147996912 \
1.529103427215414e-06 0.06552977831071743 1.529103724369534e-06 0.06388229915275011 1.529104047802611e-06 0.06213267023812474 1.529104438962031e-06 0.0600758559534558 \
1.529104840456333e-06 0.05803293250078725 1.529105217397059e-06 0.05617754872181892 1.529105584510791e-06 0.05442503025024555 1.529105934627471e-06 0.05280240270907886 \
1.529106253933125e-06 0.05136309724710254 1.529106558257407e-06 0.05002640192327024 1.529106855163312e-06 0.04875503464657577 1.529107137163639e-06 0.04757867888787161 \
1.529107417596943e-06 0.04643900623749339 1.529107682320567e-06 0.04538777697325767 1.529107958218279e-06 0.04431704973151576 1.529108232683143e-06 0.04327654260273706 \
1.529108531102423e-06 0.04217254828989973 1.52910875761848e-06 0.04135316230013186 1.529109069531318e-06 0.04025053053625379 1.529109289786109e-06 0.03948972371590862 \
1.529109507050863e-06 0.03875470657060948 1.529109716773513e-06 0.03806113111453101 1.5291100269559e-06 0.03705828856757609 1.529110249553778e-06 0.03635538859683734 \
1.529110496919279e-06 0.03559019656168042 1.529110769325655e-06 0.03476651972027592 1.529110989958209e-06 0.03411384091885184 1.52911127423846e-06 0.03329124852897781 \
1.529111512151752e-06 0.0326183788879464 1.529111750241164e-06 0.03195887699386461 1.529111985496492e-06 0.03132132139405813 1.529112214275199e-06 0.03071728735992773 \
1.529112447005948e-06 0.03011490821398154 1.529112666308989e-06 0.02955843195412813 1.529112870252059e-06 0.02905055018162466 1.529113269161796e-06 0.02808303002558106 \
1.529113456316051e-06 0.02764052191221165 1.529113828521772e-06 0.0267814187683372 1.529114015473295e-06 0.02635997027055515 1.529114384827242e-06 0.02554620807076183 \
1.52911453848041e-06 0.02521471147941385 1.529114954694564e-06 0.02434161493068329 1.529115160182381e-06 0.02392065165079968 1.529115499190341e-06 0.02323955384462723 \
1.529115681885069e-06 0.02287916718068597 1.529116138978978e-06 0.02199597290476789 1.529116268719714e-06 0.02174967209293581 1.529116722140138e-06 0.02089828923199067 \
1.52911686451243e-06 0.0206336680476187 1.52911739407919e-06 0.01967289368906444 1.529117520286198e-06 0.01945139161001456 1.529118082520635e-06 0.01850749734048266 \
1.529118245259022e-06 0.01824627541187189 1.529118809439087e-06 0.01738327200207762 1.529118961183154e-06 0.01716165742474803 1.529119662862638e-06 0.01618760396393164 \
1.529119832951728e-06 0.01596324388168 1.529120488009604e-06 0.01513221026437959 1.529120654523916e-06 0.01492874613340729 1.529121387637676e-06 0.01406966818047924 \
1.529121520900854e-06 0.01391906482409888 1.529122372558029e-06 0.01299647369571925 1.529122510500477e-06 0.01285324185793544 1.529123450559967e-06 0.0119198170026788 \
1.529123614321604e-06 0.01176347583728811 1.529124601555038e-06 0.01085909507266535 1.529124736144114e-06 0.0107410715025141 1.529125877583545e-06 0.009819907073012045 \
1.529125985822443e-06 0.009738548299709823 1.529127309069827e-06 0.00880579379490502 1.529127441815525e-06 0.008718202093769473 1.52912896431665e-06 0.007760835273143199 \
1.529129076858719e-06 0.007690148685505111 1.529130769150306e-06 0.00669558715138598 1.529130909416892e-06 0.00662113250846694 1.529132982426194e-06 0.005629132576249021 \
1.52913317498771e-06 0.005545002188831318 1.529135385197559e-06 0.004656096148610405 1.529135791984232e-06 0.004507219767123045 1.529138613724209e-06 0.003590578528330178 \
1.529139135019959e-06 0.00344214578404881 1.529143347121009e-06 0.002447529662748036 1.529143899683877e-06 0.002340875287107731 1.529149782973417e-06 0.001359168649576994 \
1.529150032246415e-06 0.001311490127959886 1.529163182367465e-06 0.0003136950974005476 1.529163299150435e-06 0.0003112730584132499 1.558990000000011e-06 3.042397160644726e-06 \
1.602746667027013e-06 -0.0009024818035526668 1.60274673944263e-06 -0.001022682652537627 1.602747175467347e-06 -0.001858525046639076 1.60274726236173e-06 -0.002046124893065343 \
1.602747617065043e-06 -0.00288168582347465 1.602747716611644e-06 -0.003135075204051477 1.602747976881349e-06 -0.003828199033013717 1.60274811720375e-06 -0.004216406518003108 \
1.602748344689832e-06 -0.004856871791621592 1.602748481897271e-06 -0.005239031028659006 1.60274886679612e-06 -0.006187559915121 1.602748998893307e-06 -0.006423332025500122 \
1.602749687336335e-06 -0.005917035979538006 1.602749844265069e-06 -0.005202654566481615 1.602749971914231e-06 -0.004414133290428114 1.602750099456021e-06 -0.003433350487145549 \
1.602750217130234e-06 -0.002355902309038119 1.60275031626992e-06 -0.001320627313728655 1.60275042165263e-06 -9.507383675133965e-05 1.602750535559933e-06 0.001369964538583592 \
1.602750666615329e-06 0.003229572948258866 1.602750791978548e-06 0.005172303930030842 1.602750983820411e-06 0.008432154569684791 1.602751127490204e-06 0.01107975669588844 \
1.602751285472018e-06 0.01417105828876112 1.602751434071664e-06 0.01723098336859398 1.602751587122593e-06 0.02051714008521248 1.602751746187569e-06 0.02405720796424875 \
1.602751899257778e-06 0.02756764950178633 1.602752047604842e-06 0.03105219347129199 1.602752196711284e-06 0.03462388853332505 1.602752351275713e-06 0.03838854885099419 \
1.602752511961677e-06 0.04235886888523473 1.602752676640863e-06 0.04647718198980624 1.602752853163807e-06 0.05093664320808645 1.602753032175606e-06 0.05549818742091989 \
1.602753222948448e-06 0.0603932190016783 1.6027534277958e-06 0.06567927942044927 1.602753648293053e-06 0.07139554989571946 1.602753881211021e-06 0.07745499876455469 \
1.602754130458799e-06 0.08395499695136356 1.602754403380327e-06 0.09108394918256098 1.602754700173384e-06 0.09884095133633181 1.602755027609896e-06 0.1073964775374675 \
1.602755397423695e-06 0.1170487607486894 1.602755792369976e-06 0.1273407304921971 1.602756250458528e-06 0.1392499850125259 1.602756782558388e-06 0.1530377249371455 \
1.602757408110397e-06 0.169180864038255 1.602758094102463e-06 0.1867931863309214 1.602758896945878e-06 0.2072766958045763 1.60275979625821e-06 0.2300508264895909 \
1.602760696698323e-06 0.2526618731709107 1.602761498589855e-06 0.2726215666318766 1.602762194096996e-06 0.2897857674353052 1.602762826931282e-06 0.3052728323588638 \
1.602763422339774e-06 0.3197161646377594 1.602763969382815e-06 0.3328722959176427 1.602764503143162e-06 0.3455929446372428 1.602765022382586e-06 0.3578476146335662 \
1.602765529774049e-06 0.3697097539883151 1.602766033395218e-06 0.3813674725871593 1.602766545138114e-06 0.3930934709428262 1.602767052299123e-06 0.404595334768291 \
1.602767582595137e-06 0.4164962117964878 1.602768068708626e-06 0.4272847049163567 1.602768546816947e-06 0.437781779057129 1.602768986249071e-06 0.4473362978389137 \
1.602769109408535e-06 0.4500002106608159 1.602769355727463e-06 0.4553046876287923 1.602769698999459e-06 0.4626558934952216 1.602770010436459e-06 0.4692815017887791 \
1.602770261147724e-06 0.4745855323881177 1.602770531976868e-06 0.480281321066213 1.602770868458777e-06 0.4873122872019196 1.602771224467388e-06 0.4946959640027882 \
1.602771541737556e-06 0.5012322602315481 1.602771780618105e-06 0.506122906570856 1.602772021646287e-06 0.5110269393752048 1.602772273577991e-06 0.5161276795544476 \
1.602772513731835e-06 0.5209621749612534 1.602772736483296e-06 0.5254248476203834 1.602772925040944e-06 0.5291850880529715 1.602773139790987e-06 0.5334523706207774 \
1.602773354339378e-06 0.5376948565446859 1.60277361310367e-06 0.5427871977552768 1.602773863931242e-06 0.5477009885064807 1.602774119350104e-06 0.5526782776843104 \
1.602774470392629e-06 0.5594898819265107 1.602774735000954e-06 0.5645984056527484 1.60277500141751e-06 0.569709962982798 1.60277526193182e-06 0.5746801970751495 \
1.602775529021882e-06 0.5797469183389945 1.602775772159963e-06 0.5843213438768613 1.602776027852189e-06 0.5890994944692448 1.602776255671159e-06 0.5933243819692556 \
1.602776493215979e-06 0.5976999800355528 1.602776704606466e-06 0.6015679915939678 1.602776916747225e-06 0.6054277082074113 1.602777105936602e-06 0.6088479815213901 \
1.60277723709492e-06 0.6112112531841202 1.602777369391478e-06 0.6135871094428261 1.602777554614204e-06 0.6169015645304802 1.602777716636591e-06 0.6197943209800671 \
1.602777875055755e-06 0.6226100751126036 1.602778009167622e-06 0.6249846001944386 1.602778181488729e-06 0.6280247049765127 1.602778310427531e-06 0.6302937061188456 \
1.602778430805044e-06 0.6324061607157294 1.602778571333915e-06 0.634864734791624 1.602778764419407e-06 0.6382321981637986 1.602778914230185e-06 0.6408363654380513 \
1.60277908153778e-06 0.6437327988167145 1.602779262592003e-06 0.6468572757970242 1.602779465918433e-06 0.6503523798695617 1.602779648771588e-06 0.6534819287355287 \
1.602779819395834e-06 0.6563879501053153 1.602779996860074e-06 0.6594029650344411 1.602780162839025e-06 0.6622113135173925 1.602780320075814e-06 0.6648594636266301 \
1.602780460561866e-06 0.6672075432495704 1.602780604291995e-06 0.6695987751186935 1.602780737338985e-06 0.6718055529208897 1.602780879311128e-06 0.6741523780906628 \
1.602780999371661e-06 0.6761293215200647 1.602781144309748e-06 0.6785098354674278 1.602781260306798e-06 0.6804095298668216 1.602781379886685e-06 0.6823647593763783 \
1.60278147884666e-06 0.68397755359623 1.602781597355079e-06 0.6859039329668146 1.60278168439936e-06 0.6873150904607619 1.60278180641018e-06 0.6892866586554622 \
1.602781905332791e-06 0.6908817703737582 1.602781997228166e-06 0.6923536807698466 1.602782097196706e-06 0.6939486118486815 1.602782195442366e-06 0.6955126686751646 \
1.602782287156128e-06 0.6969676095571918 1.60278239128907e-06 0.698613189139943 1.602782527015812e-06 0.7007470979739818 1.602782681624274e-06 0.7031613517373301 \
1.602782816731986e-06 0.7052558942641604 1.602782963068532e-06 0.7075085519458914 1.602783091536073e-06 0.7094732734147607 1.602783215720207e-06 0.7113609898537658 \
1.602783325624507e-06 0.7130225953369277 1.602783442207576e-06 0.7147759898693785 1.602783542385407e-06 0.7162749667021007 1.602783679474216e-06 0.7183149847558421 \
1.602783799463242e-06 0.7200901405411056 1.60278391857669e-06 0.7218426783097279 1.602784045072077e-06 0.723693513465353 1.602784170939449e-06 0.7255245570057045 \
1.602784293560468e-06 0.7272980597885179 1.602784421177992e-06 0.7291334326655684 1.602784551426783e-06 0.7309957624152177 1.602784673019733e-06 0.73272442801297 \
1.602784811788425e-06 0.7346853525547948 1.602784912196869e-06 0.7360963845229137 1.602785015584257e-06 0.7375412410987998 1.6027851092447e-06 0.7388443755773992 \
1.602785220866297e-06 0.7403895158541485 1.6027853073349e-06 0.7415798421827293 1.60278540819801e-06 0.7429609798983192 1.602785540294733e-06 0.7447573558536402 \
1.602785649496034e-06 0.7462323422761349 1.602785754027664e-06 0.747635567415085 1.602785877674145e-06 0.7492836897664436 1.60278602637058e-06 0.7512497161812216 \
1.602786148251239e-06 0.7528480713857697 1.602786261855803e-06 0.7543274008692354 1.602786402375488e-06 0.7561429069656862 1.60278654356493e-06 0.7579511824827749 \
1.602786661311106e-06 0.7594470562859095 1.602786790000766e-06 0.7610693809796742 1.602786932555413e-06 0.7628512182523866 1.602787048411964e-06 0.7642872416835913 \
1.60278719417523e-06 0.7660789429779771 1.602787316007677e-06 0.7675637574673733 1.602787434476374e-06 0.7689965471136999 1.602787557264006e-06 0.7704700089613156 \
1.602787683416889e-06 0.7719718272910862 1.602787793785939e-06 0.7732757954107932 1.602787919217035e-06 0.7747465774777432 1.602788024698746e-06 0.775974259539018 \
1.602788157865176e-06 0.7775122819577122 1.602788280546631e-06 0.7789173428708996 1.602788415309674e-06 0.7804473432620218 1.602788525980963e-06 0.7816923373676121 \
1.602788635302591e-06 0.7829118427552927 1.602788770435026e-06 0.7844048889494442 1.60278892121405e-06 0.7860523747618094 1.602789061582958e-06 0.7875692293014268 \
1.602789181294483e-06 0.7888502570533434 1.602789319548824e-06 0.7903153082715967 1.602789442919159e-06 0.7916096503654788 1.602789588017784e-06 0.7931164937536124 \
1.602789727758043e-06 0.7945521172774316 1.602789854939467e-06 0.7958455533278409 1.60278997397922e-06 0.7970449251022731 1.602790086337411e-06 0.7981670522831598 \
1.602790190566191e-06 0.79919939674296 1.602790285905002e-06 0.8001364844871954 1.602790422193112e-06 0.8014634245741865 1.602790539085656e-06 0.8025894467082511 \
1.602790658725145e-06 0.8037305025474466 1.602790780606717e-06 0.8048811831579785 1.602790902985054e-06 0.8060245537852575 1.602791031013733e-06 0.8072081965553952 \
1.602791155658532e-06 0.8083483262222385 1.602791286157279e-06 0.8095291977395493 1.602791412617707e-06 0.8106611567088965 1.602791539743675e-06 0.8117869190804841 \
1.602791644861151e-06 0.8127087429624065 1.60279175011134e-06 0.8136235164943317 1.602791841251591e-06 0.8144090748259969 1.602791964669625e-06 0.8154632009865571 \
1.602792051748274e-06 0.8162003374872545 1.602792151070959e-06 0.8170344894488412 1.602792295992703e-06 0.8182390501293432 1.602792432261206e-06 0.8193582434421302 \
1.602792541723485e-06 0.8202477434185359 1.602792687843586e-06 0.8214214001843773 1.602792839202198e-06 0.8226208465286928 1.60279296500612e-06 0.8236052915965452 \
1.602793109416779e-06 0.824721541823094 1.60279323401773e-06 0.8256729463037898 1.602793384729791e-06 0.8268094083523665 1.60279352010105e-06 0.8278169867326588 \
1.602793645303979e-06 0.8287379047458127 1.602793762973362e-06 0.829593908450195 1.602793908801339e-06 0.8306418458276996 1.60279407529732e-06 0.8318207857986918 \
1.602794206154408e-06 0.8327345044534114 1.602794379603848e-06 0.833928356718921 1.602794547722323e-06 0.8350667646575466 1.602794717596125e-06 0.8361988603660855 \
1.602794898450754e-06 0.8373843006762304 1.602795041633135e-06 0.8383085120571983 1.602795155746479e-06 0.8390361588138326 1.60279528581247e-06 0.8398559950134801 \
1.602795387687706e-06 0.8404909448220066 1.602795504566998e-06 0.8412116130393378 1.602795641678929e-06 0.8420465258793415 1.602795839559572e-06 0.843231707656198 \
1.602796031345765e-06 0.8443585547012582 1.602796240708829e-06 0.8455646258450146 1.602796422822406e-06 0.846593677725298 1.602796619917178e-06 0.8476867969181797 \
1.602796793185875e-06 0.8486305714188691 1.602796976264561e-06 0.8496104335327738 1.602797147401587e-06 0.8505103231661706 1.602797322080438e-06 0.8514128411730317 \
1.602797497318728e-06 0.8523022053693007 1.602797673458367e-06 0.8531802340241421 1.602797863809624e-06 0.8541115036082744 1.60279805438677e-06 0.855025905954957 \
1.602798254818193e-06 0.8559685891497206 1.602798447410669e-06 0.8568563992305701 1.602798658273807e-06 0.8578086227668252 1.602798886187182e-06 0.8588150784816577 \
1.602799152217719e-06 0.8599606428795262 1.602799450738801e-06 0.8612090806949765 1.602799726692482e-06 0.8623286542354505 1.602800010954596e-06 0.8634483918036945 \
1.602800285103046e-06 0.8644969441068078 1.602800557392313e-06 0.8655088801415273 1.602800827558089e-06 0.8664846790737442 1.602801084736186e-06 0.8673881555543895 \
1.602801357299353e-06 0.868319368003445 1.602801633304697e-06 0.8692355072818493 1.602801903418629e-06 0.870106770567397 1.602802203245002e-06 0.8710447971670072 \
1.602802574222291e-06 0.8721640818024149 1.602802869154012e-06 0.8730224021943973 1.602803123432376e-06 0.873740732376842 1.602803421677207e-06 0.8745584461000401 \
1.602803695285219e-06 0.8752856917963749 1.602803931415444e-06 0.8758961959341748 1.602804171760979e-06 0.8765017794770257 1.602804394097168e-06 0.8770481951318053 \
1.602804588102451e-06 0.8775144010549708 1.602804917823794e-06 0.8782846129827527 1.60280507299682e-06 0.8786376896881318 1.602805390752408e-06 0.8793424631377607 \
1.602805569616983e-06 0.8797286397841958 1.602805912078462e-06 0.8804474051285093 1.602806096217817e-06 0.880822800830328 1.602806571118475e-06 0.881756283451624 \
1.602806738513154e-06 0.8820737784441692 1.6028072043462e-06 0.8829272622221894 1.602807385170493e-06 0.8832470363605239 1.602807879204793e-06 0.8840891816604841 \
1.602808020548669e-06 0.8843218944112644 1.602808626940586e-06 0.8852805359894154 1.602808779011766e-06 0.8855111592597558 1.602809425691436e-06 0.8864506941541785 \
1.602809553987642e-06 0.8866295550025313 1.602810202164815e-06 0.8874976172723908 1.602810331923675e-06 0.8876644392549727 1.602811100144497e-06 0.8886037370453904 \
1.602811229881009e-06 0.8887539063021698 1.602812083306654e-06 0.8896836309705964 1.602812226565088e-06 0.8898301468060963 1.602813212785821e-06 0.890764641901611 \
1.602813434267227e-06 0.8909571971396437 1.602814577308628e-06 0.8918770673440963 1.602814707298117e-06 0.8919774876506176 1.602816058923389e-06 0.8929731820841386 \
1.60281620928357e-06 0.89307657739048 1.602817689916169e-06 0.8939986636922405 1.602817928817934e-06 0.8941315911431026 1.602819693311633e-06 0.894999985510941 \
1.602820000994978e-06 0.8951330875684044 1.602822522266181e-06 0.8960612226716312 1.602822959317422e-06 0.8961978289811912 1.602826862729643e-06 0.8971619289239613 \
1.60282710951145e-06 0.8972094058147089 1.602834686001284e-06 0.8981998139535015 1.602834801913031e-06 0.8982099955090975 1.602853900445735e-06 0.8992062631372056 \
1.602854297888509e-06 0.8992194728667773 1.60300471332359e-06 0.9002121614362558 1.603004979381947e-06 0.9002436812458944 1.603010247532015e-06 0.8993470931706574 \
1.603010453902933e-06 0.899191170936528 1.603011932015743e-06 0.8982046351054961 1.603012112466399e-06 0.8981003355419954 1.603014334948061e-06 0.8971299612768925 \
1.603014541040576e-06 0.897079983173831 1.603024949306681e-06 0.8980580240048047 1.603025087164257e-06 0.8980839755683444 1.603031884513298e-06 0.8990685088718567 \
1.603032070084766e-06 0.8990874390200084 1.603528299258968e-06 0.9000706848616691 1.603528359054814e-06 0.9000975977971888 1.603529612605432e-06 0.9010828413531861 \
1.603529718298036e-06 0.9012097231395001 1.603530376428752e-06 0.9021613947651476 1.603530513611021e-06 0.9023918767045529 1.603531036637641e-06 0.9033649777562528 \
1.603531099501233e-06 0.9034908765919824 1.603531572096783e-06 0.904476514442582 1.603531623410595e-06 0.9045863669199017 1.603532089373931e-06 0.9055619780118375 \
1.603532121578392e-06 0.9056252631670594 1.603532838677129e-06 0.9066212416280413 1.603532923113402e-06 0.9066528951765993 1.603533523179781e-06 0.9059679814895146 \
1.603533643037393e-06 0.9055903401525059 1.603533774200172e-06 0.9050640446667092 1.603533909019925e-06 0.9043926011431642 1.603534057154984e-06 0.9034897747335404 \
1.603534194714335e-06 0.902493211317788 1.603534334926095e-06 0.9013135799985507 1.603534433588205e-06 0.9003872218501816 1.603534519272014e-06 0.8995148096066522 \
1.603534601836213e-06 0.8986166894493001 1.603534716618842e-06 0.8972773101170661 1.603534797717086e-06 0.8962642459447687 1.603534877134364e-06 0.8952218112132616 \
1.603534982588892e-06 0.8937633947192651 1.603535105230195e-06 0.8919606744930825 1.603535204954275e-06 0.890414036797163 1.603535375148685e-06 0.8876203405523397 \
1.603535521333777e-06 0.8850727273800474 1.603535689551925e-06 0.8819879035815887 1.603535861713021e-06 0.8786780617039783 1.603536046099114e-06 0.8749807502679057 \
1.603536230665458e-06 0.8711418063496947 1.603536414912944e-06 0.8671917613865908 1.603536600248607e-06 0.8631174608718694 1.603536774636335e-06 0.8592060069639053 \
1.603536957340272e-06 0.8550405244181323 1.603537132687366e-06 0.8509893565349284 1.603537315016877e-06 0.8467313026054767 1.603537505330306e-06 0.8422468264612591 \
1.603537675660435e-06 0.838204894125699 1.603537842184074e-06 0.8342320488410089 1.603538004754937e-06 0.830337741667393 1.60353815461616e-06 0.8267359097041467 \
1.603538305792179e-06 0.8230937075736249 1.603538494937653e-06 0.8185270080344306 1.603538640655707e-06 0.8150026134285653 1.603538815646674e-06 0.8107652770601156 \
1.603538964118218e-06 0.807166938184282 1.603539136005683e-06 0.8029987283123258 1.603539305073922e-06 0.7988973224349885 1.603539469252632e-06 0.7949140139776875 \
1.603539628580169e-06 0.7910485911592836 1.603539789029776e-06 0.7871568543472617 1.603539990849158e-06 0.7822630953020117 1.603540139296892e-06 0.7786646206504594 \
1.603540293464276e-06 0.77492821376164 1.603540430547636e-06 0.7716074476660475 1.603540539933082e-06 0.7689587163513494 1.603540645866538e-06 0.7663946531324515 \
1.603540772880886e-06 0.7633217481666642 1.603540887243854e-06 0.7605561828888391 1.603540990091676e-06 0.7580702160470256 1.603541111681993e-06 0.7551325442760125 \
1.603541222459267e-06 0.7524575925939972 1.603541339308092e-06 0.7496376180588871 1.603541450092818e-06 0.7469652567786068 1.603541568458919e-06 0.7441116745915923 \
1.603541693286014e-06 0.7411038668912771 1.60354184584781e-06 0.7374292753756717 1.603541979744798e-06 0.7342062928952946 1.603542100776238e-06 0.7312947572377408 \
1.603542264973752e-06 0.7273475399259534 1.603542442334699e-06 0.7230877912371642 1.603542624545108e-06 0.7187161681757385 1.603542805542373e-06 0.7143786395952922 \
1.603542986206316e-06 0.7100537072471783 1.603543176357883e-06 0.7055071781827296 1.603543364117777e-06 0.7010230964996226 1.603543564650882e-06 0.696237807975249 \
1.603543773336343e-06 0.6912646166759551 1.603543980979908e-06 0.6863227581165517 1.603544208547776e-06 0.6809140411171237 1.60354440082261e-06 0.6763521085712711 \
1.603544638087858e-06 0.6707310800019505 1.603544831366122e-06 0.6661595641347996 1.603545064098869e-06 0.6606646229758047 1.603545269656336e-06 0.6558174602470968 \
1.603545502009757e-06 0.6503484594495911 1.603545697011728e-06 0.6457674053103037 1.603545900240336e-06 0.6410004262200759 1.603546080092881e-06 0.6367906205544323 \
1.603546259199312e-06 0.6326052789263827 1.603546422576526e-06 0.628795088826817 1.60354659462593e-06 0.6247880828503264 1.603546758118769e-06 0.6209892715878097 \
1.603546933908588e-06 0.6169100951581823 1.603547115847573e-06 0.6126978430086294 1.603547304331306e-06 0.6083422542008314 1.603547510763727e-06 0.6035858951323969 \
1.60354769007839e-06 0.5994633272559844 1.603547887257257e-06 0.5949432360761027 1.603548096345398e-06 0.5901646611556908 1.60354830209466e-06 0.5854760387944159 \
1.603548542605348e-06 0.5800160304866983 1.60354871573345e-06 0.5760958285528379 1.603548880627452e-06 0.5723746772837877 1.603549061488027e-06 0.5683014035092815 \
1.603549218774123e-06 0.5647722902613652 1.603549387756918e-06 0.5609879409349005 1.603549567863379e-06 0.5569709657351898 1.603549720846506e-06 0.5535669615732179 \
1.603549852560951e-06 0.5506462283231492 1.603549999948651e-06 0.5473865746199473 1.603550087374242e-06 0.5454560063082221 1.603550172245482e-06 0.5435860258811447 \
1.603550270874694e-06 0.5414171943998213 1.603550342966855e-06 0.5398340751058975 1.603550440057874e-06 0.5377039800781129 1.603550525648258e-06 0.5358302678688993 \
1.603550590729134e-06 0.5344081412607664 1.603550714329502e-06 0.5317121235594142 1.603550808753772e-06 0.52965475734789 1.603550906276994e-06 0.5275349985745696 \
1.603551079137645e-06 0.5237893654184622 1.603551214133166e-06 0.5208709659121862 1.603551368316628e-06 0.5175498113398643 1.603551542781984e-06 0.5138002600288881 \
1.60355169458797e-06 0.510550000123414 1.603551840818953e-06 0.5074290310664136 1.603551984717826e-06 0.5043644611166801 1.603552127739669e-06 0.5013276181140283 \
1.603552223349518e-06 0.499301733014788 1.603552317793473e-06 0.4973032961550828 1.603552438849414e-06 0.4947494705229025 1.60355253372771e-06 0.4927525559781179 \
1.603552649558553e-06 0.4903172469328811 1.603552736822402e-06 0.4884854516151125 1.603552819252848e-06 0.4867593351188191 1.603552914660802e-06 0.484765406725184 \
1.603553015371081e-06 0.4826639978995959 1.603553112231473e-06 0.4806459052877932 1.603553250961225e-06 0.4777646955734051 1.603553386666086e-06 0.4749532752442271 \
1.603553587150809e-06 0.4708139964547478 1.603553802464962e-06 0.4663911383470885 1.603553984040267e-06 0.462674698484628 1.603554183012236e-06 0.4586189944293299 \
1.603554353577757e-06 0.455154096457448 1.603554527931445e-06 0.4516251957269069 1.603554696864699e-06 0.4482170126441485 1.60355486946186e-06 0.4447467276163349 \
1.60355505206819e-06 0.4410867902598327 1.603555240617055e-06 0.4373240875354826 1.603555434084593e-06 0.4334777823509549 1.603555642405232e-06 0.4293535036700135 \
1.603555856750462e-06 0.4251286740881063 1.603556082455792e-06 0.4207018662297695 1.603556308999161e-06 0.4162771402745992 1.603556571175911e-06 0.4111844468197049 \
1.603556820209735e-06 0.4063709766754009 1.603557121308433e-06 0.4005865607947761 1.60355741072925e-06 0.3950673729298416 1.603557718243529e-06 0.3892455819062323 \
1.603558040439925e-06 0.3831936848847286 1.603558368170407e-06 0.3770882112794804 1.603558700600163e-06 0.3709500980558715 1.603559030329171e-06 0.3649083177186754 \
1.603559351558758e-06 0.3590729273462687 1.603559682375082e-06 0.3531219177045733 1.603560024730645e-06 0.3470224718704957 1.603560324371677e-06 0.3417374346434491 \
1.603560654159242e-06 0.3359723367088904 1.603560981053185e-06 0.3303128110141857 1.603561319032532e-06 0.3245206193888226 1.603561628003696e-06 0.3192755432624759 \
1.603561952801669e-06 0.31382336954194 1.603562268431866e-06 0.3085864885517507 1.603562573419032e-06 0.3035810258414895 1.603562828757678e-06 0.2994330834535801 \
1.603563093620834e-06 0.295170851203172 1.603563380703519e-06 0.2905978071194348 1.603563603673298e-06 0.2870801635277143 1.603563803212567e-06 0.2839591363066187 \
1.60356401286858e-06 0.2807045410859125 1.603564193125121e-06 0.2779290029372279 1.603564355469842e-06 0.2754463208250681 1.603564505904816e-06 0.2731629026725527 \
1.603564656910124e-06 0.2708866524077067 1.603564853800715e-06 0.2679392949564011 1.603564984945479e-06 0.2659970646012914 1.603565109682018e-06 0.2641561221543183 \
1.60356526127406e-06 0.2619266655689588 1.603565357242231e-06 0.2605306204207966 1.6035654537936e-06 0.2591282589302421 1.603565578413389e-06 0.2573209601776467 \
1.603565720989924e-06 0.255257422470362 1.603565879923458e-06 0.25296979123958 1.603566012589525e-06 0.251062957019046 1.603566196158294e-06 0.2484301322588876 \
1.60356637739346e-06 0.2458327969660818 1.603566588907565e-06 0.2428051031600066 1.603566791497399e-06 0.2399069804317323 1.603566958053847e-06 0.2375282895552967 \
1.603567168273059e-06 0.2345337828133105 1.603567341690945e-06 0.2320692345528927 1.603567570533673e-06 0.2288260787734411 1.603567791168424e-06 0.2257162440502939 \
1.603567966830138e-06 0.2232503232699662 1.603568147290643e-06 0.2207258962977968 1.603568318047021e-06 0.2183528725291195 1.603568498243287e-06 0.2158619697278009 \
1.603568664973905e-06 0.2135675266585953 1.603568814095326e-06 0.2115251542210239 1.603568969905344e-06 0.2094125291275523 1.60356910508577e-06 0.2075875692769576 \
1.603569255167197e-06 0.2055694209972212 1.603569387612823e-06 0.2037957203154137 1.603569528157359e-06 0.2019220745191926 1.603569645226124e-06 0.2003748851744883 \
1.60356977493373e-06 0.1986681706274326 1.603569896991199e-06 0.1970700654731777 1.603570019534635e-06 0.1954731161836187 1.603570137553958e-06 0.1939418157697267 \
1.603570272576731e-06 0.1921981789937757 1.603570417201182e-06 0.1903420634523806 1.603570545551681e-06 0.1887049708672087 1.603570669186156e-06 0.1871351133418249 \
1.603570766736279e-06 0.1859021016257166 1.603570881809208e-06 0.1844539912642748 1.603570975507888e-06 0.1832809848801438 1.603571074292012e-06 0.1820493959460708 \
1.603571197226553e-06 0.1805230483556907 1.603571292980556e-06 0.1793400249325384 1.603571422068107e-06 0.177753298391591 1.603571524533477e-06 0.1764993061988986 \
1.603571622786974e-06 0.1753029542432101 1.603571742874187e-06 0.1738483570896001 1.603571845423405e-06 0.1726127298531683 1.603571955881064e-06 0.1712877101305652 \
1.603572084370928e-06 0.1697552709290656 1.603572175855769e-06 0.1686698090598139 1.603572280340358e-06 0.1674358120019214 1.603572355277094e-06 0.1665544493622226 \
1.603572444845591e-06 0.1655049734124585 1.6035724954106e-06 0.164914347906921 1.603572545388976e-06 0.1643318187475747 1.603572610358061e-06 0.163576534137217 \
1.603572645872029e-06 0.1631646263336159 1.603572718071202e-06 0.162329174921529 1.603572785200298e-06 0.1615546732967998 1.603572844430032e-06 0.160873195114598 \
1.60357288817563e-06 0.1603710314414745 1.603572935822459e-06 0.1598254649913795 1.603573006202993e-06 0.1590230739426561 1.603573088541159e-06 0.1580883269013631 \
1.603573166712759e-06 0.1572048664554128 1.603573248765709e-06 0.1562816770844126 1.603573341469331e-06 0.1552436243401225 1.603573464249495e-06 0.153877370231325 \
1.603573563395588e-06 0.1527810927807017 1.603573664895936e-06 0.1516651170047695 1.603573766171127e-06 0.1505582666538253 1.603573862662911e-06 0.1495093242781697 \
1.603573962080946e-06 0.1484346886615803 1.603574046381569e-06 0.1475281828465028 1.603574139320259e-06 0.1465342051547719 1.6035742219212e-06 0.1456551508734999 \
1.603574330687285e-06 0.1445034822456445 1.603574436330265e-06 0.1433917535370727 1.603574517989855e-06 0.1425365900703354 1.603574611735024e-06 0.1415598856352903 \
1.603574705302971e-06 0.1405903867550886 1.603574788187462e-06 0.139735765814107 1.603574876346636e-06 0.1388313836440244 1.603574956132722e-06 0.1380170907865772 \
1.603575049728122e-06 0.1370669869522621 1.603575139660646e-06 0.1361590166429519 1.603575210211042e-06 0.1354501541392388 1.603575279971219e-06 0.1347521119166949 \
1.603575394120126e-06 0.1336164586193709 1.60357547609874e-06 0.1328058651355588 1.603575563704043e-06 0.1319440719770354 1.603575663205239e-06 0.1309710196939938 \
1.603575772385241e-06 0.1299110174488692 1.603575874550573e-06 0.1289256009328031 1.603575982010779e-06 0.1278959836800649 1.603576102045057e-06 0.1267549558890445 \
1.603576196253092e-06 0.1258657925752028 1.603576327232195e-06 0.1246390638240933 1.603576426659896e-06 0.1237164070883829 1.603576535781582e-06 0.1227104370444639 \
1.60357664463475e-06 0.1217138859540913 1.603576736944154e-06 0.120874257454373 1.603576849784484e-06 0.1198547128626846 1.603576946796524e-06 0.118986084968971 \
1.603577051062872e-06 0.1180628196869088 1.603577160029803e-06 0.1171053395831002 1.603577259569368e-06 0.1162371554254778 1.603577376562078e-06 0.1152245300989246 \
1.603577463662869e-06 0.1144761644999183 1.60357757295452e-06 0.1135478691973115 1.603577654479583e-06 0.1128618460838699 1.603577754254576e-06 0.1120273350449922 \
1.603577871679726e-06 0.1110526766231405 1.603577973464844e-06 0.1102143708571793 1.603578061203792e-06 0.1094962336869811 1.6035781420033e-06 0.1088432886892514 \
1.603578228954319e-06 0.1081456845520918 1.603578309740945e-06 0.1075007757815706 1.603578399947511e-06 0.1067842832273628 1.603578490898266e-06 0.1060655611559195 \
1.60357857956879e-06 0.1053685613006139 1.603578678583611e-06 0.1045946508745568 1.603578772289787e-06 0.1038723470842792 1.603578866149063e-06 0.1031520741219857 \
1.603578966976511e-06 0.1023817709659086 1.603579071607409e-06 0.1015861061604995 1.603579195570165e-06 0.1006484085638475 1.603579292969478e-06 0.09991551135558702 \
1.603579413227425e-06 0.09901872452754552 1.603579524095301e-06 0.09819831936474602 1.603579628568336e-06 0.09742874659471555 1.603579745805045e-06 0.09656937225591002 \
1.603579847599366e-06 0.09582695326576983 1.603579945574917e-06 0.09511577589263259 1.603580086079407e-06 0.09410164141823299 1.603580191157203e-06 0.09334832721827611 \
1.603580289770019e-06 0.09264549593674179 1.603580382484827e-06 0.09198739948435641 1.603580468683212e-06 0.09137785861853052 1.603580562596188e-06 0.09071637432184691 \
1.603580659696934e-06 0.09003559055802626 1.603580769117988e-06 0.08927317549644689 1.603580870101537e-06 0.08857281843916648 1.603580963759483e-06 0.08792605868920525 \
1.603581037934155e-06 0.08741581771673042 1.603581175834007e-06 0.08647193599618339 1.603581248191011e-06 0.08597917321277694 1.603581383512214e-06 0.08506274029062395 \
1.603581469423819e-06 0.08448410751389913 1.603581614152054e-06 0.08351486081643937 1.603581710382619e-06 0.0828744112740944 1.603581798218398e-06 0.08229260392026354 \
1.603581914017306e-06 0.08152964121883956 1.603582029145758e-06 0.08077575264951149 1.60358214291219e-06 0.08003553900012179 1.603582283169683e-06 0.0791300282244784 \
1.603582424545716e-06 0.07822490276368012 1.603582574181758e-06 0.07727536491519127 1.603582718670613e-06 0.07636690312463701 1.603582869844724e-06 0.07542565384097814 \
1.603583019215544e-06 0.07450459906593411 1.603583168562251e-06 0.0735926433331697 1.603583328517767e-06 0.07262574717347114 1.603583484664678e-06 0.07169171823582712 \
1.603583659153113e-06 0.07065947636250877 1.603583828862219e-06 0.0696671357044583 1.603584014041303e-06 0.0685979885997255 1.60358421076238e-06 0.06747763456279594 \
1.6035844212802e-06 0.06629631776014881 1.603584643312255e-06 0.06507007089066431 1.603584873524276e-06 0.0638195278444372 1.603585116035382e-06 0.06252626147401 \
1.603585376689467e-06 0.06116236403900636 1.603585656588531e-06 0.05972739422233359 1.603585950172255e-06 0.05825544847408989 1.603586265108239e-06 0.05671370145268265 \
1.603586607914165e-06 0.05507846134953124 1.603586957380758e-06 0.0534565727116736 1.603587366284915e-06 0.05161746230842366 1.603587712949942e-06 0.05010669351290297 \
1.603588100364996e-06 0.04846839895323611 1.603588444582788e-06 0.04705645202362623 1.603588768009047e-06 0.04576625679949029 1.603589073054809e-06 0.04458093278443617 \
1.603589365916806e-06 0.04347099288378908 1.603589650057723e-06 0.04242242262004604 1.603589926078015e-06 0.04142902112907627 1.603590192930566e-06 0.04049015932812138 \
1.603590461822789e-06 0.03956531631184226 1.603590737883211e-06 0.03863769040165695 1.603591025478782e-06 0.03769451689421055 1.603591265044408e-06 0.03692662498323904 \
1.603591554211835e-06 0.03602084344675294 1.603591770003438e-06 0.03535960341037672 1.603591957720476e-06 0.03479599077274986 1.603592155849583e-06 0.03421285035004928 \
1.603592518724446e-06 0.03317032497347058 1.603592776866276e-06 0.03244834222605905 1.60359308657919e-06 0.0316030971185694 1.603593352049329e-06 0.03089664771451467 \
1.603593620168408e-06 0.03019941363307669 1.603593899042439e-06 0.02949128999862272 1.603594145228876e-06 0.02888043298519722 1.603594375860285e-06 0.02832033800396738 \
1.603594614150204e-06 0.02775711540944564 1.603594849157568e-06 0.02721270742060762 1.603595076940031e-06 0.02669509678424227 1.603595485552303e-06 0.02579039168486155 \
1.603595661854632e-06 0.02540904040268441 1.603596016332316e-06 0.02465798827491217 1.603596200203288e-06 0.02427641469830137 1.60359653515201e-06 0.02359448510613503 \
1.603596699060728e-06 0.02326678168937357 1.603597091331304e-06 0.02249905491676728 1.603597247322069e-06 0.02220010404946675 1.603597678925427e-06 0.02138321689778962 \
1.603597816314806e-06 0.0211255367654138 1.603598333123589e-06 0.02017559010600388 1.603598458659483e-06 0.01995091418019728 1.603598915901008e-06 0.01915998482559782 \
1.603599075046989e-06 0.01889493739859509 1.603599682285467e-06 0.01793263500095189 1.603599816822955e-06 0.01772934138481063 1.603600480086948e-06 0.01678091027541291 \
1.603600673410379e-06 0.01651856846389665 1.60360134106704e-06 0.01565087920017967 1.603601502655887e-06 0.01544858341705342 1.60360225789114e-06 0.01454101846553843 \
1.603602407452107e-06 0.01436800730673201 1.603603297789931e-06 0.01338293844200974 1.603603396447817e-06 0.01327873262558703 1.603604353121314e-06 0.01230993787860994 \
1.603604474231022e-06 0.01219243157195396 1.60360546572373e-06 0.01126376273051215 1.60360562925246e-06 0.01111855113153209 1.603606759174536e-06 0.01018247077230436 \
1.603606871621774e-06 0.01009565848301377 1.603608249445262e-06 0.009103273453806031 1.603608388390533e-06 0.009009747578659758 1.603609942788869e-06 0.008018073335410726 \
1.60361005485534e-06 0.00794673960805117 1.60361169983817e-06 0.006958154532207958 1.603611807090665e-06 0.006899512253112593 1.603613751584152e-06 0.005937533026687714 \
1.60361395848211e-06 0.005843834961138424 1.603616297369853e-06 0.00487227039639981 1.603616721356264e-06 0.004712306502041247 1.60361949358946e-06 0.003780857497341114 \
1.603619941898552e-06 0.003647790772321777 1.603623582397237e-06 0.00272553831825111 1.603624079053072e-06 0.002619503085887757 1.603629830173496e-06 0.001650572925599863 \
1.603630116955383e-06 0.001609446887446839 1.603635471944067e-06 0.0006353228983793809 1.603635677300692e-06 0.0005920420449145349 1.606282712074508e-06 -0.0002718533828215428 \
1.606282867950111e-06 -0.0004579010352009555 1.606283416265203e-06 -0.001326296959495401 1.606283529048879e-06 -0.001543805653187533 1.606283963541019e-06 -0.002491429791030493 \
1.606284039366175e-06 -0.002673591589873599 1.606284396016773e-06 -0.003590195133438418 1.606284523065853e-06 -0.003936807634339821 1.606284801566247e-06 -0.004716444651655622 \
1.60628490965073e-06 -0.005020876868076652 1.606285253249855e-06 -0.00592430224391268 1.60628536024372e-06 -0.006162325733041658 1.606286259614116e-06 -0.005653094509861465 \
1.606286438047546e-06 -0.004687598829536962 1.60628654377096e-06 -0.003940993102967527 1.606286668833738e-06 -0.002883597584075996 1.606286762417834e-06 -0.001971418478057775 \
1.606286840257396e-06 -0.001132968824455395 1.606286920329395e-06 -0.0001977429743171 1.606287042702205e-06 0.001370578777960296 1.606287160958077e-06 0.003041212838230153 \
1.606287279607187e-06 0.004860750887681821 1.606287393089626e-06 0.006730904986417607 1.606287496532765e-06 0.008536402178002854 1.606287611192018e-06 0.01064190690353853 \
1.606287801775811e-06 0.0143607330143792 1.606287935565949e-06 0.01711819191720031 1.606288085819515e-06 0.02033933849841947 1.606288240988763e-06 0.02378599874269359 \
1.606288396380811e-06 0.0273434151175349 1.606288544088043e-06 0.03080849965087477 1.606288693077668e-06 0.03437359286003162 1.606288848068751e-06 0.03814545786868043 \
1.606289007439365e-06 0.04208062121327779 1.606289172372776e-06 0.04620305710844342 1.606289347319105e-06 0.0506208066052034 1.606289526449176e-06 0.05518387280380205 \
1.606289716238432e-06 0.06005265756871143 1.6062899199354e-06 0.06530840376289772 1.606290139745932e-06 0.07100650943730057 1.606290371497377e-06 0.07703584544314998 \
1.606290619322674e-06 0.08349927754587044 1.606290890643603e-06 0.09058756662233436 1.606291185356381e-06 0.09829181712822582 1.606291510614029e-06 0.106792896697727 \
1.606291876859735e-06 0.1163551101154179 1.606292270156448e-06 0.1266079356677421 1.606292722809344e-06 0.1383809089651769 1.606293248524511e-06 0.1520098384503803 \
1.606293867738049e-06 0.1679979965193872 1.606294548482366e-06 0.1854865650013753 1.606295342157321e-06 0.2057488551561759 1.606296230922953e-06 0.2282732214494322 \
1.606297044312215e-06 0.2487218262351868 1.606297766061792e-06 0.2667261628598245 1.606298401725801e-06 0.282460740414376 1.606298973442562e-06 0.2965101025186013 \
1.606299508996846e-06 0.3095696210007924 1.606300012355259e-06 0.3217495654069301 1.606300488682702e-06 0.3331878525640654 1.606300962606306e-06 0.3444754071334732 \
1.606301420078024e-06 0.3552759747331513 1.606301886058294e-06 0.3661792384270033 1.606302335046104e-06 0.376592601923634 1.606302831152646e-06 0.3879857357798637 \
1.606303350914508e-06 0.3998002499051578 1.606303730319152e-06 0.4083447473225827 1.606304170327876e-06 0.4181679450526055 1.606304640096814e-06 0.4285466970600206 \
1.606305125617752e-06 0.4391589006481625 1.606305565065858e-06 0.4486701556983262 1.606305626818807e-06 0.4500002248264944 1.606305750324704e-06 0.4526540461147197 \
1.606305997336498e-06 0.4579447795386873 1.606306249931409e-06 0.463325462421476 1.606306447502524e-06 0.467511453725808 1.606306673074272e-06 0.4722681264242033 \
1.606306994642268e-06 0.4790073975813253 1.606307263421497e-06 0.4846013351959894 1.60630748207297e-06 0.4891262574467725 1.606307692176936e-06 0.4934547887280634 \
1.606307918582462e-06 0.4980921872304203 1.606308127687652e-06 0.5023516957637455 1.606308317089911e-06 0.5061927337048852 1.606308441251129e-06 0.5086969563931187 \
1.606308568006226e-06 0.5112441466129884 1.606308728004704e-06 0.5144514110933732 1.606308975647656e-06 0.5193914248715521 1.606309154234115e-06 0.5229351592435862 \
1.606309325187692e-06 0.5263079149198099 1.606309586537288e-06 0.5314455197962068 1.60630981260887e-06 0.5358634945234868 1.606310015740537e-06 0.5398188128751134 \
1.606310180971268e-06 0.5430252218652345 1.606310337758288e-06 0.5460612552756139 1.606310526914905e-06 0.5497137532216215 1.606310728782659e-06 0.5535976061995346 \
1.606310952933981e-06 0.5578986282275192 1.606311191316346e-06 0.5624617013850463 1.606311426077985e-06 0.566941985223824 1.606311656348691e-06 0.5713275351537204 \
1.606311862141324e-06 0.5752375533958141 1.606312067125538e-06 0.5791255875933676 1.60631230994078e-06 0.5837094709690289 1.606312564698362e-06 0.588493349632063 \
1.606312792926793e-06 0.5927514274590796 1.606313030765665e-06 0.5971656109489694 1.606313243043101e-06 0.6010807441713891 1.606313454836505e-06 0.6049674646600495 \
1.606313708720774e-06 0.6095919957414236 1.606313913314301e-06 0.6132953190650409 1.606314165037654e-06 0.6178178328453598 1.606314352827174e-06 0.6211736970442716 \
1.606314605700251e-06 0.6256587164710262 1.606314804109613e-06 0.6291560967673944 1.606314983842284e-06 0.6323071487074056 1.606315254113091e-06 0.6370161336915187 \
1.606315471396857e-06 0.6407803561788556 1.606315651923236e-06 0.6438916924996977 1.606315853084131e-06 0.6473460740030906 1.606316021667513e-06 0.650231451944099 \
1.60631622602572e-06 0.6537144072723954 1.606316371688778e-06 0.6561873372238678 1.606316536247377e-06 0.6589728476742622 1.606316705716594e-06 0.6618316558839334 \
1.606316859256675e-06 0.664412775690417 1.606317000490202e-06 0.6667750288922751 1.606317144066014e-06 0.6691685747430841 1.606317277296139e-06 0.6713840140331436 \
1.60631741919646e-06 0.6737368819239464 1.606317539430086e-06 0.6757233098298149 1.606317684081139e-06 0.6781085120392751 1.606317800299844e-06 0.6800197521569988 \
1.606317919382163e-06 0.6819757159594566 1.606318017960477e-06 0.6835903813535821 1.606318135558183e-06 0.6855122399681081 1.606318222994146e-06 0.6869376986921233 \
1.606318347740232e-06 0.6889650632873403 1.606318447547296e-06 0.6905825000046129 1.606318540037093e-06 0.6920753042469043 1.606318641321177e-06 0.6937043390836264 \
1.606318739114283e-06 0.695273833970533 1.606318830385075e-06 0.6967333967490603 1.606318932842905e-06 0.6983656370917724 1.606319065752136e-06 0.7004728611232253 \
1.606319220767541e-06 0.7029137789397926 1.606319355649227e-06 0.7050222373350452 1.606319501145018e-06 0.7072806469370021 1.606319628999685e-06 0.709252249158637 \
1.606319753457981e-06 0.7111597484283609 1.606319864783685e-06 0.7128563623504806 1.606319978813713e-06 0.7145852226468989 1.60632007932493e-06 0.7161013069709498 \
1.606320216526077e-06 0.7181590832501857 1.606320336471979e-06 0.7199473375636642 1.606320455641778e-06 0.7217141075019444 1.606320582586792e-06 0.7235855504531626 \
1.60632070735421e-06 0.7254141264975077 1.606320830849597e-06 0.7272133847865295 1.60632095763087e-06 0.7290498056238117 1.606321088220355e-06 0.730930225429108 \
1.606321210432258e-06 0.7326797786847141 1.606321347490272e-06 0.7346298644824388 1.606321448705627e-06 0.7360619656663578 1.606321553674562e-06 0.7375401619041119 \
1.606321645165995e-06 0.7388229997694907 1.606321758241356e-06 0.7404001534680551 1.60632184554224e-06 0.7416107338190071 1.606321950005571e-06 0.7430512000342341 \
1.606322080768703e-06 0.7448411286358657 1.6063221906822e-06 0.7463352048609909 1.606322295341958e-06 0.7477488743938407 1.60632241917362e-06 0.7494094725133206 \
1.606322567926971e-06 0.751387874302702 1.606322689842132e-06 0.7529958494242643 1.606322803696393e-06 0.7544867042370438 1.60632294419585e-06 0.7563117925204224 \
1.606323085519365e-06 0.7581313010100689 1.606323203298972e-06 0.7596352654099263 1.606323331697459e-06 0.7612620174900669 1.606323474021161e-06 0.7630496612437514 \
1.606323590410316e-06 0.7644991888858087 1.606323736133978e-06 0.7662987831554334 1.606323857913867e-06 0.7677897310961733 1.606323976478797e-06 0.7692300520321635 \
1.606324099092246e-06 0.7707078417740018 1.606324225543629e-06 0.77221964326554 1.606324335666584e-06 0.7735261258099556 1.606324461188726e-06 0.7750039859681491 \
1.606324566849672e-06 0.7762386743660952 1.606324702026829e-06 0.7778058706872942 1.606324825637346e-06 0.7792267957652825 1.606324955634725e-06 0.7807078764205345 \
1.606325068606223e-06 0.7819831642610904 1.606325176500111e-06 0.7831908181350914 1.606325313030793e-06 0.7847046126527283 1.606325463151702e-06 0.7863508260127218 \
1.606325605416006e-06 0.7878933964149381 1.606325724997519e-06 0.7891771019825847 1.606325861808649e-06 0.7906313890246753 1.606325984312413e-06 0.7919206245676671 \
1.606326128984341e-06 0.7934276941869095 1.606326269769414e-06 0.794878360380241 1.606326396585209e-06 0.796171745508174 1.606326515632602e-06 0.7973744708066829 \
1.606326627895563e-06 0.7984986270115709 1.606326732283333e-06 0.7995352562746869 1.606326827560395e-06 0.8004739840425704 1.606326963902891e-06 0.8018044219089175 \
1.60632708076796e-06 0.8029326473252685 1.606327200364489e-06 0.8040757482679398 1.606327322250299e-06 0.8052288531124292 1.606327444838559e-06 0.8063765489401953 \
1.606327572579618e-06 0.8075599074701925 1.606327697362526e-06 0.8087035441861687 1.606327827862901e-06 0.8098867241643505 1.606327954229597e-06 0.8110199871086299 \
1.606328081578389e-06 0.8121498004723215 1.606328186791179e-06 0.8130740322933268 1.606328291495184e-06 0.8139855427426806 1.60632838302539e-06 0.8147757515715357 \
1.60632850639836e-06 0.8158311616195392 1.606328593352409e-06 0.8165684017534872 1.606328692208245e-06 0.8173999442793862 1.606328836710884e-06 0.8186029267949408 \
1.606328973036573e-06 0.8197243345631372 1.606329082445008e-06 0.8206145128367788 1.606329228461948e-06 0.821788834531623 1.606329380203007e-06 0.8229927727264784 \
1.606329506119585e-06 0.8239792970156907 1.606329650568649e-06 0.8250971468990039 1.606329775264817e-06 0.8260503472050121 1.606329925878834e-06 0.8271873005969326 \
1.606330061249302e-06 0.8281959289694237 1.606330186472937e-06 0.8291179217777711 1.606330304128897e-06 0.8299746468143927 1.60633044991051e-06 0.8310230722388168 \
1.60633061639426e-06 0.8322027532553667 1.606330747215024e-06 0.8331167337813133 1.606330920675046e-06 0.834311196379941 1.606331088787842e-06 0.8354501125721271 \
1.606331258668969e-06 0.8365827385393307 1.606331439512628e-06 0.8377685497174457 1.606331582704692e-06 0.8386931238161603 1.606331696822189e-06 0.8394210074154138 \
1.6063318268738e-06 0.8402408682651782 1.606331928753516e-06 0.8408758513273116 1.606332045641139e-06 0.841596551294542 1.606332182786859e-06 0.8424315815669623 \
1.606332380696072e-06 0.8436167827761205 1.606332572515411e-06 0.8447436440637145 1.606332781866158e-06 0.8459494874145237 1.606332964017768e-06 0.8469786287449077 \
1.606333161103991e-06 0.8480715276019779 1.606333334356719e-06 0.8490148531186206 1.606333517450963e-06 0.8499943787178993 1.60633368858243e-06 0.8508936588199895 \
1.606333863270272e-06 0.8517955326875627 1.606334038504287e-06 0.8526841769874772 1.606334214641154e-06 0.8535614892404448 1.606334405008494e-06 0.8544920815553035 \
1.606334595580845e-06 0.8554057038167108 1.606334795976838e-06 0.8563474066245403 1.606334988566464e-06 0.8572344253714166 1.606335199466375e-06 0.858185963363946 \
1.606335427341862e-06 0.8591913103610016 1.606335693424718e-06 0.8603357477151101 1.606335991926854e-06 0.8615822374427254 1.606336267816323e-06 0.8627000332972231 \
1.606336552083493e-06 0.8638181192989086 1.606336826221443e-06 0.8648650323418529 1.606337098522366e-06 0.8658754039994767 1.606337368678563e-06 0.8668495780678541 \
1.606337625862699e-06 0.8677515347235455 1.606337898421613e-06 0.8686810999091764 1.606338174469332e-06 0.8695957110915412 1.606338444589599e-06 0.8704649939918846 \
1.606338744449489e-06 0.8714007440816277 1.606339115430115e-06 0.8725171209518352 1.606339410352536e-06 0.8733732402027278 1.606339664628271e-06 0.8740897163373675 \
1.606339962841735e-06 0.8749052413925265 1.606340236411347e-06 0.8756305047096297 1.606340472534749e-06 0.8762394088953867 1.606340712859887e-06 0.8768433401198644 \
1.606340935193821e-06 0.8773882060838187 1.606341129200254e-06 0.8778530214284207 1.606341458909681e-06 0.8786208714695904 1.60634161408109e-06 0.87897283049042 \
1.606341931723491e-06 0.8796750328643211 1.606342110604035e-06 0.8800599154915705 1.606342453064798e-06 0.8807759898408113 1.60634263726721e-06 0.8811501695110489 \
1.606343112296513e-06 0.8820806183873429 1.606343279683462e-06 0.8823969901232691 1.606343745459844e-06 0.8832471741583867 1.606343926299187e-06 0.8835657112976044 \
1.606344420308805e-06 0.8844044135654346 1.606344561623711e-06 0.8846360992458032 1.606345167867327e-06 0.8855901496945974 1.606345319942526e-06 0.8858196526512701 \
1.606345966662599e-06 0.8867549368993356 1.606346094949267e-06 0.8869330782847171 1.606346743158686e-06 0.8877977435561634 1.606346872882985e-06 0.8879638504720397 \
1.606347641302053e-06 0.8888993076310558 1.606347771073903e-06 0.8890488273083775 1.606348624736509e-06 0.8899738047157748 1.606348767761561e-06 0.8901192131187072 \
1.606349754067048e-06 0.8910487927319016 1.6063499755536e-06 0.8912403904783051 1.606351118378138e-06 0.8921548233216382 1.606351248258076e-06 0.8922544308366913 \
1.606352600758498e-06 0.8932425879319322 1.606352751041431e-06 0.8933452769452155 1.606354231575698e-06 0.8942627870546499 1.606354470485492e-06 0.8943950258099049 \
1.606356252518433e-06 0.8952625983306248 1.60635663826586e-06 0.895426813549116 1.606359040424079e-06 0.8963023915260389 1.606359515360049e-06 0.8964490046842035 \
1.606363433287165e-06 0.8974035634625627 1.606363903247409e-06 0.8974927205890085 1.606372272035387e-06 0.8984807567386782 1.606372492545714e-06 0.8984960697096243 \
1.606417072074293e-06 0.8994905034760702 1.606418273460192e-06 0.8995076493514624 1.606554083268694e-06 0.9004821828323031 1.606554262245419e-06 0.9005421539807538 \
1.606557707120338e-06 0.8996085030263692 1.606557879904192e-06 0.8994755022453073 1.6065592062239e-06 0.8985168769831137 1.606559392989208e-06 0.8983970610744239 \
1.606561177194233e-06 0.8974304740967198 1.606561389324515e-06 0.8973403978332656 1.606574730020299e-06 0.8983331062395279 1.606574843308145e-06 0.8983517458922662 \
1.606583546661241e-06 0.8993273409280406 1.60658409447182e-06 0.8993637478389299 1.607076621843715e-06 0.9003542216796759 1.607076717582567e-06 0.9004233209197793 \
1.607077660131942e-06 0.9014023545001312 1.607077822585254e-06 0.9016297223302431 1.607078389291501e-06 0.9025464066367429 1.607078496462212e-06 0.9027401250447874 \
1.607078889770564e-06 0.9035002370985188 1.607079022567928e-06 0.9037710185404622 1.607079402169034e-06 0.9045728679206633 1.607079532383781e-06 0.9048512534150681 \
1.607079993790073e-06 0.9057878278182891 1.607080113037131e-06 0.9060008176934132 1.607081542646165e-06 0.9050557440230738 1.607081626316293e-06 0.9046580283931719 \
1.607081751622122e-06 0.9039622140338933 1.607081859436291e-06 0.9032622438705011 1.607081978430637e-06 0.9023800387125585 1.607082093802854e-06 0.9014106868475621 \
1.607082183899751e-06 0.900578017289966 1.607082295347455e-06 0.8994526603282017 1.607082381426603e-06 0.8985125975436928 1.607082487392252e-06 0.8972736935213672 \
1.607082587160618e-06 0.8960214106762436 1.607082668156228e-06 0.8949470092681954 1.607082777804195e-06 0.8934133399212493 1.607082863391606e-06 0.8921520042367302 \
1.607082955514215e-06 0.8907345325087322 1.607083043733598e-06 0.8893220116766375 1.607083152508351e-06 0.8875100775672261 1.607083235401386e-06 0.8860780350921965 \
1.607083343975057e-06 0.8841400608632336 1.607083436201253e-06 0.8824412727986957 1.60708352082175e-06 0.8808423775446282 1.60708360666218e-06 0.8791839877465467 \
1.60708368587706e-06 0.8776224824828824 1.60708376196503e-06 0.8760960492665846 1.607083854301399e-06 0.874210837196514 1.607083914177735e-06 0.8729702140710593 \
1.607083971566019e-06 0.8717685933706794 1.607084033561192e-06 0.8704574090763495 1.607084096840044e-06 0.8691057216070059 1.607084146911381e-06 0.8680269866686803 \
1.607084196353533e-06 0.8669542389500936 1.60708426002324e-06 0.8655623656543436 1.607084335970659e-06 0.8638877358586781 1.607084384801671e-06 0.8628032002737418 \
1.607084433325624e-06 0.8617197496806845 1.607084509037347e-06 0.8600184098866027 1.607084576246125e-06 0.8584975010852487 1.607084618952631e-06 0.8575263577286506 \
1.607084662855204e-06 0.8565244243916033 1.607084750660351e-06 0.8545103166059256 1.60708481351352e-06 0.8530605771626394 1.607084872183177e-06 0.8517018597088126 \
1.607084908361778e-06 0.8508614974547222 1.607084943180258e-06 0.8500510151036469 1.607084978206243e-06 0.8492340038666518 1.607085048258213e-06 0.8475953578585981 \
1.607085096728698e-06 0.8464581214772323 1.607085140673499e-06 0.8454248116355969 1.607085186191255e-06 0.8443523575543517 1.607085250092166e-06 0.8428433081697474 \
1.60708531621854e-06 0.8412777165526386 1.607085421348608e-06 0.8387809254526315 1.607085509283283e-06 0.8366857089760468 1.607085588228565e-06 0.834800137446173 \
1.607085676393602e-06 0.8326899670047023 1.607085763209599e-06 0.8306078985741704 1.607085851101283e-06 0.8284959280419055 1.607085942350373e-06 0.8262996967350639 \
1.607086045112241e-06 0.8238226494465998 1.607086143615717e-06 0.8214450402687625 1.607086255948632e-06 0.8187302447322098 1.607086368922768e-06 0.8159967029774419 \
1.607086490210663e-06 0.8130591602364435 1.607086620717817e-06 0.8098958628758253 1.60708674976372e-06 0.8067658935936169 1.60708690323932e-06 0.8030416153605923 \
1.607087068523541e-06 0.799029304640783 1.607087236264745e-06 0.7949567682299736 1.607087432788334e-06 0.7901857478752816 1.607087637550659e-06 0.7852160332972318 \
1.607087850227715e-06 0.7800563994093253 1.607088050847662e-06 0.7751902022758907 1.60708825170639e-06 0.7703212856706637 1.607088401728407e-06 0.766686939713112 \
1.607088532263574e-06 0.7635264252913375 1.607088666681014e-06 0.7602735436595947 1.607088772876545e-06 0.7577048602246427 1.607088906182877e-06 0.754482067181252 \
1.607089013215803e-06 0.7518959494812111 1.607089156291704e-06 0.7484409822837247 1.607089320797846e-06 0.7444713482725677 1.607089441615093e-06 0.74155777711076 \
1.607089612721757e-06 0.7374334100931738 1.607089773612309e-06 0.733558046396253 1.60708999020493e-06 0.7283457217000903 1.607090183460631e-06 0.7236999380850822 \
1.607090362395765e-06 0.7194029726762079 1.607090529212387e-06 0.7154015770462002 1.607090715418352e-06 0.7109395231330657 1.607090903351594e-06 0.7064416825495208 \
1.607091069273699e-06 0.7024749886985119 1.607091261631787e-06 0.6978803202016938 1.607091402988682e-06 0.6945068232011449 1.607091559996444e-06 0.6907636199298515 \
1.607091755976089e-06 0.6860965106368763 1.607091918410194e-06 0.6822325558671515 1.607092079586376e-06 0.6784034260021697 1.607092271894574e-06 0.6738409413562468 \
1.607092489556454e-06 0.6686845685784016 1.607092737577756e-06 0.6628199086538362 1.607092915635219e-06 0.6586162961343578 1.607093164179028e-06 0.6527567611811057 \
1.607093366786271e-06 0.6479896840619462 1.607093536596938e-06 0.6440011601507294 1.607093695213124e-06 0.6402799599229552 1.607093833743559e-06 0.637035894415233 \
1.607093969951322e-06 0.6338503464729111 1.607094096262698e-06 0.6309003762865483 1.607094225721933e-06 0.6278810604265532 1.607094354053673e-06 0.6248911458464299 \
1.607094485383603e-06 0.6218374290191309 1.607094617410215e-06 0.6187713222160208 1.607094761570095e-06 0.6154276788919771 1.607094905778687e-06 0.6120888358645944 \
1.607095053433791e-06 0.6086753592300279 1.607095200490149e-06 0.6052842859263143 1.607095358304176e-06 0.6016504852589418 1.607095490909828e-06 0.5986039825107707 \
1.607095622374795e-06 0.5955897059985247 1.607095741804594e-06 0.5928552647156846 1.607095877873286e-06 0.5897484304797134 1.607095992801548e-06 0.5871283594046445 \
1.607096143912269e-06 0.5836892419704927 1.607096258561337e-06 0.5810871834776226 1.607096376499006e-06 0.5784138884735546 1.607096466280294e-06 0.576381560286313 \
1.607096556599689e-06 0.5743415774978985 1.607096623290559e-06 0.5728373329037385 1.607096688852373e-06 0.5713590910263378 1.607096739894496e-06 0.5702089751121119 \
1.607096801596215e-06 0.5688198806440578 1.607096864686071e-06 0.5674025889664359 1.607096929044425e-06 0.5659586381304559 1.607096982438224e-06 0.5647616504486359 \
1.607097075080806e-06 0.5626864159088959 1.607097151688079e-06 0.5609719030357503 1.607097207513141e-06 0.5597256439368602 1.607097276567267e-06 0.5581857825097393 \
1.607097383455393e-06 0.5558054549196561 1.607097461199018e-06 0.5540764009223496 1.607097562049117e-06 0.5518382286767042 1.607097687729972e-06 0.5490568313009737 \
1.607097787971657e-06 0.5468419758621708 1.60709789988934e-06 0.5443739014182352 1.607098003155247e-06 0.5421024366463116 1.607098122904589e-06 0.5394737463112931 \
1.607098224637469e-06 0.5372436950013484 1.607098340157213e-06 0.5347185748314579 1.607098455192299e-06 0.5322102907975605 1.607098581673211e-06 0.529456475824718 \
1.607098707047009e-06 0.5267350629320526 1.607098853862932e-06 0.5235577714138258 1.607098989426381e-06 0.5206304261698983 1.607099147124634e-06 0.5172373565578411 \
1.607099309443689e-06 0.5137528589513558 1.607099490267585e-06 0.5098871206809381 1.607099682715905e-06 0.5057874350093188 1.607099895621209e-06 0.5012700264709963 \
1.607100127802608e-06 0.4963634062180514 1.607100385093187e-06 0.4909555076455908 1.60710062471901e-06 0.4859407514401474 1.607100926434446e-06 0.479662588092526 \
1.6071012143538e-06 0.4737079198104491 1.607101527242619e-06 0.4672821326282255 1.607101846980824e-06 0.4607585360408045 1.607102186575985e-06 0.4538766993710576 \
1.607102513478483e-06 0.4472977926730654 1.607102849036864e-06 0.4405887635920606 1.607103166132787e-06 0.4342949501181722 1.607103500370542e-06 0.4277061431972559 \
1.607103851801663e-06 0.4208322784122511 1.607104166327818e-06 0.4147233751108969 1.607104489505308e-06 0.4084912998479469 1.607104930620066e-06 0.400057814108821 \
1.607105272736103e-06 0.3935812134363078 1.607105572680633e-06 0.3879522399691127 1.607105947811639e-06 0.3809760137481454 1.607106277555878e-06 0.3749002425561211 \
1.607106560798804e-06 0.3697269896098562 1.607106860945059e-06 0.3642865787664632 1.607107140547253e-06 0.3592589179584539 1.607107364323365e-06 0.3552676761685443 \
1.607107576103695e-06 0.3515151294490645 1.607107778537159e-06 0.3479514629380864 1.607107979628427e-06 0.3444362246481504 1.607108185342845e-06 0.3408632458568372 \
1.607108452965717e-06 0.3362478643926977 1.607108691897011e-06 0.3321601360780691 1.607108925403074e-06 0.3281974319442653 1.607109138868474e-06 0.3246000376975314 \
1.607109360246046e-06 0.3208952602338652 1.607109560209693e-06 0.3175728982722026 1.607109764482006e-06 0.3142073831356898 1.607109961828878e-06 0.3109812293225088 \
1.607110147201405e-06 0.3079732989686547 1.607110343307796e-06 0.3048147723336881 1.607110545584936e-06 0.3015820927993307 1.607110721243233e-06 0.2988007390096292 \
1.60711090711339e-06 0.295878328903569 1.607111114092783e-06 0.2926488196724605 1.607111299414374e-06 0.2897857719971084 1.607111494641182e-06 0.2867989994419413 \
1.607111650415531e-06 0.28443329608414 1.607111829172313e-06 0.2817356906084737 1.607112010203233e-06 0.2790344478478936 1.607112160100347e-06 0.2768142575519123 \
1.607112361143774e-06 0.273859574769726 1.607112510258904e-06 0.2716833853889438 1.607112648798334e-06 0.2696726034832688 1.607112800673409e-06 0.2674956304896134 \
1.607112915147538e-06 0.2658586287383957 1.607113046677468e-06 0.2639823142040156 1.607113172435956e-06 0.2622048582339201 1.607113276776362e-06 0.2607341604582348 \
1.607113389755722e-06 0.2591418073851619 1.607113506084246e-06 0.2575033437579446 1.607113649011668e-06 0.2554974228347739 1.607113762273173e-06 0.2539102348881249 \
1.607113896429905e-06 0.2520298733123076 1.60711400690271e-06 0.2504818583075984 1.607114162335285e-06 0.2483006006477398 1.607114303220384e-06 0.2463217957442577 \
1.607114454612954e-06 0.2441928603691365 1.607114609775035e-06 0.2420086586735095 1.607114739184283e-06 0.2401849910837116 1.607114873896377e-06 0.2382868210192302 \
1.607115011594202e-06 0.2363478190565156 1.607115129346217e-06 0.2346905900295477 1.60711528867041e-06 0.2324499447852502 1.607115425932636e-06 0.2305210708572645 \
1.607115566678993e-06 0.2285488733964877 1.607115672470167e-06 0.2270688194984586 1.607115802411565e-06 0.2252532503786337 1.607115902948028e-06 0.2238506847401111 \
1.607116005281736e-06 0.2224250970611539 1.607116079010317e-06 0.2214012665004395 1.60711615824426e-06 0.2203047212273054 1.607116229215508e-06 0.2193236206014474 \
1.607116280678535e-06 0.218612902325451 1.607116333626988e-06 0.2178825126218075 1.607116412781991e-06 0.2167921001391954 1.607116455054626e-06 0.2162104926182252 \
1.607116494899171e-06 0.2156628374086678 1.607116538122821e-06 0.2150692779925967 1.607116579029822e-06 0.2145080585354088 1.607116649152284e-06 0.2135474129702876 \
1.607116682837256e-06 0.2130867492099046 1.607116727666638e-06 0.212477723463 1.6071167865238e-06 0.2116792343136102 1.60711685130926e-06 0.2108017053965978 \
1.607116908790025e-06 0.2100241135398916 1.607116969219033e-06 0.209207737948094 1.607117066255463e-06 0.2078991976528634 1.607117150945123e-06 0.2067595417901527 \
1.607117259855885e-06 0.2052972881712416 1.607117356256692e-06 0.2040065614180294 1.607117451273329e-06 0.2027428333585779 1.607117554705128e-06 0.2013717100485363 \
1.607117649634473e-06 0.2001158751783069 1.607117752654899e-06 0.198757993281026 1.607117857737332e-06 0.1973779917312911 1.607117967046146e-06 0.1959482000350934 \
1.607118077489628e-06 0.1945091075764383 1.607118193779904e-06 0.1929996650696684 1.607118303709896e-06 0.1915811184357085 1.60711841337232e-06 0.1901717999899754 \
1.607118515088966e-06 0.1888694322720079 1.607118608043679e-06 0.1876837490531375 1.607118700772569e-06 0.1865049219968967 1.607118774458125e-06 0.1855719169757668 \
1.60711885729934e-06 0.1845269810791141 1.607118931885337e-06 0.1835895008849975 1.607119001608678e-06 0.1827150226754214 1.607119068327086e-06 0.1818808699270075 \
1.607119164170411e-06 0.1806871657728035 1.607119246877184e-06 0.1796611249561687 1.607119340441008e-06 0.1785035608809835 1.607119435337095e-06 0.1773351434884491 \
1.607119546707405e-06 0.1759704596301353 1.607119688349759e-06 0.1742450478777388 1.607119803596612e-06 0.1728486436789435 1.607119948144251e-06 0.1711076225712051 \
1.607120059739928e-06 0.1697708811114609 1.607120200958902e-06 0.1680898955975501 1.607120316696176e-06 0.1667201145354908 1.607120422656861e-06 0.1654722325850081 \
1.607120521416477e-06 0.164314417410061 1.60712061775965e-06 0.1631901152369615 1.607120706417402e-06 0.1621596955203892 1.607120831751673e-06 0.1607099933926625 \
1.607120926277088e-06 0.1596224416957933 1.60712102401604e-06 0.1585042187118262 1.607121132110917e-06 0.1572745454417887 1.607121226778605e-06 0.1562036643369483 \
1.607121334226451e-06 0.1549951394274829 1.607121425315495e-06 0.1539767092330788 1.607121532087207e-06 0.1527896463435911 1.607121635480473e-06 0.1516469620792683 \
1.607121746560958e-06 0.1504267727114754 1.607121835786939e-06 0.1494522115900035 1.607121921266868e-06 0.1485231035185812 1.607122005192055e-06 0.1476157397758405 \
1.607122074898619e-06 0.1468658175993407 1.607122153536697e-06 0.1460232248551682 1.607122231847954e-06 0.1451880611912267 1.607122302483827e-06 0.1444378248611795 \
1.607122387974695e-06 0.1435337156153706 1.607122475363672e-06 0.1426139614481139 1.607122556951186e-06 0.1417594571206545 1.607122654270137e-06 0.1407454482154784 \
1.60712273495966e-06 0.139910090776864 1.607122825744691e-06 0.1389752404035735 1.607122947088963e-06 0.1377336220260025 1.607123036138604e-06 0.13682812281983 \
1.607123134655454e-06 0.1358318692385875 1.607123221741723e-06 0.1349560640726983 1.607123332152611e-06 0.1338550874529322 1.607123420611433e-06 0.1329791517134813 \
1.607123521340027e-06 0.1319874611681985 1.60712362612958e-06 0.1309622419763913 1.607123720519813e-06 0.1300442429014473 1.607123817024605e-06 0.1291112112475518 \
1.607123916511258e-06 0.1281591654439075 1.607124002912429e-06 0.1273384721630967 1.60712409789256e-06 0.1264411177628728 1.607124202081388e-06 0.1254629331099751 \
1.607124311200139e-06 0.124445178694 1.607124405550594e-06 0.1235704029653004 1.607124517846343e-06 0.1225411084520107 1.607124613309697e-06 0.1216733466577494 \
1.607124717520587e-06 0.1207311846737792 1.607124806865944e-06 0.1199276649878674 1.607124877253217e-06 0.1192980345746366 1.607124952639251e-06 0.1186268760051257 \
1.607125028771421e-06 0.1179522201461119 1.607125097748918e-06 0.1173458504859956 1.607125180268091e-06 0.1166263596898966 1.607125252211578e-06 0.1160015972854393 \
1.607125334290304e-06 0.1152916772467617 1.60712541862478e-06 0.1145654108773922 1.607125496418619e-06 0.113898375935255 1.607125589183521e-06 0.1131065723182637 \
1.607125704787342e-06 0.1121254933399327 1.607125810692911e-06 0.1112341778178403 1.607125888349831e-06 0.1105854195321705 1.607125976646302e-06 0.1098504899494786 \
1.607126056703354e-06 0.1091866403929743 1.607126153629479e-06 0.1083861389179563 1.607126248864964e-06 0.1076031391441806 1.607126337436159e-06 0.1068780200140514 \
1.60712643874426e-06 0.1060523297458165 1.607126544289947e-06 0.1051963702337609 1.607126653484312e-06 0.1043160928234657 1.607126761601933e-06 0.1034503663302994 \
1.607126881519694e-06 0.1024949450012773 1.607126982881521e-06 0.1016914181115986 1.607127088891151e-06 0.100855068690839 1.60712721468278e-06 0.09986840123414902 \
1.607127344240086e-06 0.09885896724496235 1.60712747991544e-06 0.09780904711780367 1.607127655987304e-06 0.09645781830037269 1.607127819787824e-06 0.09521257997344186 \
1.607127982612565e-06 0.09398642071914091 1.6071280677512e-06 0.09334985726464029 1.607128137589223e-06 0.09282999162688726 1.607128207084828e-06 0.09231474740697931 \
1.607128281043488e-06 0.09176875214326782 1.607128377198375e-06 0.09106241641841166 1.607128451613741e-06 0.09051841344162129 1.60712852960331e-06 0.08995079828656057 \
1.60712860605214e-06 0.08939693755534793 1.607128693546224e-06 0.08876614459792892 1.607128795722934e-06 0.08803382885421264 1.607128884287322e-06 0.08740269463919083 \
1.60712899395281e-06 0.08662585268124241 1.607129110009218e-06 0.08580942306245626 1.607129251558034e-06 0.0848216759818637 1.607129384427018e-06 0.08390253510334872 \
1.607129525187328e-06 0.08293727564630923 1.607129674896948e-06 0.08192024575105315 1.607129810608835e-06 0.08100683753927941 1.607129952125717e-06 0.08006309454860433 \
1.607130087247591e-06 0.07917070961097784 1.607130228520028e-06 0.07824718349428782 1.60713037561292e-06 0.07729532867436953 1.607130527122786e-06 0.07632524417621221 \
1.6071306924985e-06 0.07527819040792309 1.60713085625969e-06 0.07425356708383206 1.607131032389632e-06 0.07316505371836476 1.60713122152861e-06 0.07201151367936541 \
1.607131432202234e-06 0.07074528708793332 1.607131651768856e-06 0.06944624562626683 1.607131886535262e-06 0.06808094281860989 1.6071321449277e-06 0.06660616301228137 \
1.60713243959236e-06 0.06496103773121734 1.607132743671683e-06 0.06330286177969326 1.607133104582163e-06 0.06138472526627536 1.607133440499035e-06 0.05964719353945821 \
1.607133880676406e-06 0.05743991201668189 1.607134259043809e-06 0.05560437501227136 1.607134701502772e-06 0.05352996728430704 1.607135055522916e-06 0.05192508193542229 \
1.607135442039672e-06 0.05022502935509546 1.607135786643729e-06 0.04875485597254389 1.607136108618665e-06 0.04741934964807833 1.607136412152492e-06 0.04619304551845941 \
1.607136707073488e-06 0.04503122626702559 1.607136989555767e-06 0.04394770877170886 1.607137266636178e-06 0.04291147062934708 1.607137532363669e-06 0.04194013461971725 \
1.607137803594355e-06 0.0409708748276704 1.607138079853372e-06 0.04000619535229137 1.607138369752594e-06 0.03901828782233653 1.607138598128988e-06 0.03825741181922668 \
1.607138903013054e-06 0.03726495139513845 1.607139119684911e-06 0.03657573971894532 1.607139311041637e-06 0.03597943984071691 1.607139509636156e-06 0.03537298232318693 \
1.607139839551497e-06 0.03438820140908775 1.60714008149717e-06 0.03368375433354889 1.607140396809222e-06 0.03278771666975258 1.607140666929207e-06 0.03203957074185158 \
1.607140923300881e-06 0.03134567005659093 1.607141203312881e-06 0.03060515313352298 1.607141448968657e-06 0.02997014710356035 1.607141681704302e-06 0.02938120249260199 \
1.607141924434299e-06 0.02878348292867495 1.607142161161563e-06 0.02821317433052753 1.607142389807975e-06 0.0276732289298247 1.607142807093635e-06 0.02671456010533928 \
1.607143002274329e-06 0.02627749693639509 1.607143383441411e-06 0.02544369227895442 1.607143560694233e-06 0.02506446942885681 1.607143903145688e-06 0.02434654114125227 \
1.60714405641412e-06 0.02403127656358269 1.607144431432584e-06 0.02327616399748992 1.607144569066725e-06 0.02300530455388665 1.607145053333359e-06 0.02207084195640928 \
1.60714517295276e-06 0.02184403312078184 1.607145589991564e-06 0.02106026682208277 1.607145733393791e-06 0.02079332360769017 1.607146254605173e-06 0.01984598817089831 \
1.607146382379043e-06 0.0196205814374062 1.607146966791417e-06 0.01863359713481367 1.607147139226823e-06 0.01835589372257288 1.607147743323573e-06 0.01743644241612937 \
1.607147904755214e-06 0.01720262545858322 1.607148544701434e-06 0.01631831686205014 1.607148723017601e-06 0.016083210242981 1.607149371001649e-06 0.01526127675881721 \
1.60714953625524e-06 0.01505930898173208 1.607150272557175e-06 0.01419381259610907 1.607150406833226e-06 0.01404154276213586 1.607151203932743e-06 0.01317592498067951 \
1.607151344530355e-06 0.01302934089458718 1.607152309873577e-06 0.0120661300044765 1.607152474212383e-06 0.01190857475316222 1.607153474943512e-06 0.01099048917119646 \
1.607153612213369e-06 0.01087009009405628 1.607154750907886e-06 0.009949273443646761 1.607154865085787e-06 0.009863136028526375 1.607156245730622e-06 0.008889755784408603 \
1.607156400087833e-06 0.00878832203975914 1.607157946582061e-06 0.00781340401000951 1.607158030943764e-06 0.007760176032106158 1.607159716371082e-06 0.006770348169342283 \
1.607159839899572e-06 0.00670487246831437 1.607161889714139e-06 0.005720970231232756 1.607162086114296e-06 0.005634691917282852 1.607164404793654e-06 0.004698942116576918 \
1.607164865407989e-06 0.004530544077955615 1.607167605503531e-06 0.003639937533647344 1.607168123648567e-06 0.00349159181499799 1.607172274289875e-06 0.002502201117031859 \
1.607172812139883e-06 0.002396807933581942 1.60717889437533e-06 0.001421603691354927 1.607179153355741e-06 0.001378272220758726 1.60718447611909e-06 0.0003814093765652445 \
1.607184589276134e-06 0.0003711807182531981 1.60983070639237e-06 -0.0004615907568095335 1.609830868831338e-06 -0.0006852153244161934 1.609831369832807e-06 -0.001554404032531494 \
1.60983145401537e-06 -0.001725199767551738 1.609831855538194e-06 -0.002626792336557519 1.609831944873161e-06 -0.002845673237760077 1.60983223146497e-06 -0.0035898660494722 \
1.609832359033499e-06 -0.003937855927128601 1.609832677745161e-06 -0.004830400105952924 1.609832791946314e-06 -0.00515011308870196 1.609833074346638e-06 -0.005887653497963378 \
1.609833204572857e-06 -0.006177415671381139 1.609834182925754e-06 -0.005220113099403402 1.609834370233287e-06 -0.004004368716724641 1.609834501677689e-06 -0.002901539130564616 \
1.609834607105242e-06 -0.001869327786897239 1.609834692822726e-06 -0.0009323217369615201 1.609834774749213e-06 4.151965372454519e-05 1.609834895786036e-06 0.001618129410352471 \
1.609834994714683e-06 0.003024565667809575 1.609835153111357e-06 0.005482561958548801 1.609835370558587e-06 0.00923691162542661 1.60983555178081e-06 0.0126653356758144 \
1.609835763874906e-06 0.01697021734206094 1.609835926898563e-06 0.02046388365739064 1.609836087520979e-06 0.02403759527126768 1.609836241061221e-06 0.02755862871109176 \
1.609836389117902e-06 0.031036270750196 1.609836538198811e-06 0.03460722192241437 1.609836692728722e-06 0.03837091703902212 1.609836853379538e-06 0.04234026030123839 \
1.609837018034219e-06 0.04645786783841532 1.609837194575117e-06 0.05091770581196236 1.609837373537969e-06 0.05547793877747508 1.609837564281134e-06 0.0603721650098247 \
1.609837769062163e-06 0.06565647483694508 1.609837989534449e-06 0.07137203566208646 1.609838222394174e-06 0.0774299331224613 1.60983847158165e-06 0.08392829098722057 \
1.609838744423778e-06 0.09105513637423955 1.609839041127578e-06 0.09880974921055499 1.609839368453968e-06 0.1073623706929605 1.609839738105355e-06 0.11701033799881 \
1.609840132977169e-06 0.1273002725707723 1.60984059081541e-06 0.1392030195235975 1.60984112262225e-06 0.1529832553757746 1.609841747860046e-06 0.1691182447448397 \
1.609842433607518e-06 0.1867241161332086 1.609843236003391e-06 0.2071957342970069 1.609844134802183e-06 0.2299563735557614 1.609844940415632e-06 0.2501946571168963 \
1.609845654166966e-06 0.2679877251922811 1.609846283728848e-06 0.2835633151515627 1.609846854092298e-06 0.2975737963344939 1.60984738504768e-06 0.3105173405876944 \
1.609847886835131e-06 0.3226580892822354 1.609848366129684e-06 0.3341673054699896 1.609848831685103e-06 0.3452566901045974 1.609849295481511e-06 0.3562094254686541 \
1.609849751229541e-06 0.3668794056881832 1.609850211449675e-06 0.3775613305945491 1.609850749733646e-06 0.3899285626759094 1.60985125058418e-06 0.4013172511919189 \
1.609851650806863e-06 0.4103337945930838 1.609852157667644e-06 0.421642452039157 1.609852643633856e-06 0.4323669409017459 1.609853043148568e-06 0.4410997362599856 \
1.609853453760627e-06 0.4500002277813482 1.60985388268706e-06 0.4592207708982954 1.609854284201442e-06 0.4677760623951868 1.609854591591889e-06 0.4742753916877908 \
1.609854941833647e-06 0.4816249679276425 1.609855295073851e-06 0.4889795533930016 1.60985554824443e-06 0.4942125642332652 1.60985578118832e-06 0.4989990073547648 \
1.609856022831611e-06 0.5039392821429431 1.60985624782223e-06 0.5085102868389438 1.609856439858338e-06 0.5123881070394828 1.609856624670034e-06 0.5161059569497825 \
1.60985684696035e-06 0.5205538992744256 1.609857013671758e-06 0.5238726938135662 1.609857230888353e-06 0.5281726418673847 1.609857433967244e-06 0.5321820613122353 \
1.609857611378699e-06 0.5356681922482178 1.609857799451086e-06 0.5393528234657015 1.609858035483266e-06 0.5439555888699217 1.60985830136529e-06 0.5491186112539347 \
1.609858523127178e-06 0.5534070305875756 1.609858803185033e-06 0.5588091140818973 1.609859046184818e-06 0.5634839438879177 1.609859321538161e-06 0.5687575845994758 \
1.609859566533502e-06 0.5734440561015828 1.609859806827721e-06 0.5780305526007354 1.609860047867023e-06 0.5826153106864888 1.609860305457841e-06 0.5874946531182738 \
1.609860540824618e-06 0.5919209497705462 1.609860772126727e-06 0.5962518282209535 1.609860994653448e-06 0.6003950532231523 1.609861203013056e-06 0.6042587207462122 \
1.609861440854871e-06 0.6086392006348278 1.609861651715085e-06 0.612499186772883 1.609861907322267e-06 0.617151767543529 1.609862106050033e-06 0.620751700070918 \
1.609862381682677e-06 0.6257066023742009 1.609862604438798e-06 0.6296824120643636 1.609862897809922e-06 0.6348814180513288 1.609863130579923e-06 0.6389753720667986 \
1.609863350781309e-06 0.6428252659334456 1.609863552051921e-06 0.6463216644290061 1.609863769340794e-06 0.6500784077528632 1.609863944056704e-06 0.6530842133917786 \
1.609864130321334e-06 0.6562672470877895 1.609864309060386e-06 0.6593113758161715 1.609864471764399e-06 0.6620700940033843 1.60986463703341e-06 0.6648583661366954 \
1.609864780301224e-06 0.6672607123132118 1.609864919531648e-06 0.669583864918244 1.609865059332215e-06 0.6719085596965743 1.609865194107422e-06 0.6741424479378803 \
1.609865321601663e-06 0.6762463034350935 1.609865454555775e-06 0.6784344250006583 1.609865576160125e-06 0.680430207161383 1.609865704573366e-06 0.6825336955632141 \
1.609865820340421e-06 0.6844241240890321 1.609865918381594e-06 0.686020684362688 1.6098660190777e-06 0.687656981754083 1.609866128831463e-06 0.689434454762776 \
1.609866245599418e-06 0.6913211166705923 1.609866336826192e-06 0.6927889453402305 1.609866446031605e-06 0.6945396927028351 1.609866547140326e-06 0.6961566646470493 \
1.609866642540618e-06 0.6976767415743361 1.609866752022643e-06 0.6994136821864276 1.609866886474277e-06 0.7015344809028976 1.609867035493214e-06 0.7038694457768003 \
1.609867164423232e-06 0.7058755144243859 1.609867311083691e-06 0.7081418729260142 1.609867437868072e-06 0.7100885084081828 1.609867562465961e-06 0.7119899232102255 \
1.609867674319728e-06 0.7136874821928206 1.609867787275692e-06 0.7153928249203609 1.609867887829089e-06 0.716903336497302 1.609868025110592e-06 0.7189542886859326 \
1.609868144979452e-06 0.7207346491296758 1.609868264162204e-06 0.7224952472954583 1.609868391164314e-06 0.7243608783177121 1.609868515712665e-06 0.726179956024653 \
1.609868639383676e-06 0.7279757435764195 1.609868765971953e-06 0.7298035010246171 1.609868896541188e-06 0.7316777339938921 1.609869019056222e-06 0.7334262671520465 \
1.609869155299713e-06 0.7353588786631546 1.609869256742486e-06 0.7367901064855561 1.609869362765969e-06 0.7382789144707947 1.609869453297152e-06 0.7395446819117977 \
1.609869567123378e-06 0.7411267287627761 1.609869654784961e-06 0.742338113895605 1.609869760680238e-06 0.7437932991468792 1.609869891033533e-06 0.7455718205320391 \
1.60987000160114e-06 0.7470699275523445 1.609870106271612e-06 0.7484790865773925 1.609870230233143e-06 0.7501360792234356 1.609870378790597e-06 0.752105598322839 \
1.609870500473193e-06 0.7537054667443914 1.609870614584883e-06 0.7551949470168074 1.609870755005484e-06 0.7570132059451244 1.609870896533544e-06 0.7588296197226846 \
1.609871014322813e-06 0.7603289862386273 1.609871142522635e-06 0.7619481626911874 1.609871284590468e-06 0.7637269294216019 1.609871401465576e-06 0.7651780119234867 \
1.609871547139362e-06 0.7669714049983392 1.60987166887781e-06 0.7684572223066155 1.609871787518301e-06 0.7698939375992205 1.609871909984595e-06 0.7713653733660819 \
1.609872036701685e-06 0.7728756341192486 1.609872146603679e-06 0.7741754302862822 1.609872272219022e-06 0.7756497674172792 1.609872378029431e-06 0.7768823528242577 \
1.609872514199553e-06 0.7784559787239111 1.609872638546601e-06 0.7798807766277074 1.609872765971877e-06 0.7813271999647126 1.609872880527956e-06 0.7826155184370988 \
1.609872987208226e-06 0.7838050786084815 1.609873125150823e-06 0.785328674235108 1.609873274600319e-06 0.7869612315653352 1.609873419452537e-06 0.7885256944569791 \
1.609873538888287e-06 0.7898026796320731 1.60987367431316e-06 0.7912364721526877 1.609873795807481e-06 0.7925100718437531 1.609873939166556e-06 0.7939977458315933 \
1.609874082600237e-06 0.7954699260458764 1.609874208411247e-06 0.7967479640295563 1.609874327457929e-06 0.7979459892863545 1.609874439471573e-06 0.7990632136113104 \
1.609874544263454e-06 0.8000996927221937 1.609874639456303e-06 0.8010335634530776 1.609874775866829e-06 0.8023587211299719 1.609874892679005e-06 0.8034813603122919 \
1.609875012140248e-06 0.8046180202255495 1.6098751341806e-06 0.8057672874017472 1.609875257080697e-06 0.8069126780167393 1.609875384200053e-06 0.8080849010520604 \
1.609875509341915e-06 0.8092265787736463 1.609875639893142e-06 0.8104047139317369 1.609875765969389e-06 0.811530109085512 1.609875893966049e-06 0.8126603425876329 \
1.609875999427297e-06 0.8135823118114501 1.609876102696598e-06 0.814477091043954 1.609876195349946e-06 0.8152732203909091 1.609876319044181e-06 0.8163262937528154 \
1.609876406664096e-06 0.8170655553659417 1.609876505330151e-06 0.8178914289762149 1.609876648877154e-06 0.819080619224994 1.609876784463307e-06 0.8201904093102529 \
1.609876893653288e-06 0.8210742465492874 1.609877041102747e-06 0.8222539401850584 1.609877191506449e-06 0.8234410273756358 1.609877316975412e-06 0.8244188977545531 \
1.609877461141395e-06 0.8255287290252299 1.60987758542996e-06 0.8264738611628292 1.609877735900256e-06 0.8276038147969816 1.609877871506615e-06 0.8286089145501508 \
1.609877996601616e-06 0.8295251220930787 1.609878114317453e-06 0.8303776282987162 1.609878260203052e-06 0.8314210189912619 1.609878426696148e-06 0.8325942517713072 \
1.609878557562851e-06 0.833503494447128 1.609878731007462e-06 0.8346911703335461 1.609878899140202e-06 0.8358239212093587 1.60987906899395e-06 0.8369500705213252 \
1.609879249886955e-06 0.838129582835239 1.609879393021216e-06 0.8390486258646698 1.609879507119162e-06 0.8397723391454259 1.609879637246322e-06 0.8405879656882547 \
1.609879739102179e-06 0.8412191375388212 1.609879855947599e-06 0.8419354178465567 1.609879992919396e-06 0.84276453896487 1.609880190759142e-06 0.843942473808897 \
1.60988038244463e-06 0.8450620046306492 1.609880591850993e-06 0.8462610422160779 1.609880773861877e-06 0.8472832413425977 1.609880970977334e-06 0.8483697584184032 \
1.609881144290447e-06 0.8493077402131245 1.609881327325656e-06 0.8502809338042043 1.609881498478783e-06 0.8511747489972419 1.609881673131736e-06 0.8520708361396651 \
1.609881848382891e-06 0.8529540285731302 1.609882024530391e-06 0.8538259128238825 1.609882214836779e-06 0.8547503816925358 1.609882405427748e-06 0.8556583881771193 \
1.609882605979791e-06 0.8565949481971697 1.609882798582589e-06 0.8574764650234362 1.609883009331288e-06 0.8584213553684483 1.609883237362186e-06 0.8594210644592908 \
1.609883503241952e-06 0.8605573106989262 1.609883801820094e-06 0.8617960322792503 1.609884077983729e-06 0.8629075153790151 1.609884362230229e-06 0.8640180616030438 \
1.609884636414231e-06 0.8650581816846495 1.60988490866944e-06 0.8660616517296992 1.609885178858915e-06 0.8670295451208139 1.609885436023238e-06 0.8679256252637404 \
1.609885708596972e-06 0.8688492356117473 1.609885984602435e-06 0.8697577927663542 1.609886254710518e-06 0.8706213441784563 1.609886554568938e-06 0.8715508809746347 \
1.609886925582816e-06 0.8726599440782473 1.609887220515529e-06 0.873510245983525 1.609887474800896e-06 0.8742218447789023 1.609887773044171e-06 0.8750318897722944 \
1.609888046640929e-06 0.8757523113099853 1.609888282767907e-06 0.8763571312809064 1.609888523107206e-06 0.876957042728428 1.609888745440861e-06 0.8774982514557473 \
1.609888939446794e-06 0.8779599514934209 1.609889269165229e-06 0.8787226653583874 1.609889424338019e-06 0.8790722725343518 1.60988974207141e-06 0.8797700114458387 \
1.60988992093906e-06 0.880152324917399 1.609890263400534e-06 0.8808637455080008 1.609890447552368e-06 0.8812353200296749 1.609890922478419e-06 0.8821594045029107 \
1.609891089871654e-06 0.8824737723885729 1.609891555692961e-06 0.8833186808430151 1.609891736520447e-06 0.883635209600208 1.609892230549786e-06 0.8844687288968743 \
1.609892371887773e-06 0.8846990198924604 1.609892978249103e-06 0.8856473543416146 1.609893130320955e-06 0.8858754372639542 1.609893777008948e-06 0.8868048391838264 \
1.609893905303109e-06 0.8869818633102416 1.609894553496582e-06 0.8878410756373726 1.609894683245133e-06 0.8880061989117775 1.609895451498601e-06 0.8889361126992519 \
1.609895581240626e-06 0.8890847997417872 1.609896434697557e-06 0.8900046759307325 1.609896577924673e-06 0.8901495209380393 1.609897564158077e-06 0.8910738355210844 \
1.609897785636141e-06 0.8912643084423501 1.609898928653689e-06 0.8921737958641509 1.60989905863199e-06 0.8922730011388891 1.609900410338988e-06 0.8932565980587214 \
1.609900560692342e-06 0.8933589605607284 1.609902041315768e-06 0.8942730372387374 1.60990228021907e-06 0.8944047337041336 1.609904061344228e-06 0.8952702388217941 \
1.609904447325595e-06 0.8954343910560414 1.609906848871634e-06 0.896309305076933 1.60990732380842e-06 0.8964562995603377 1.60991114197014e-06 0.8973944547681553 \
1.609911624459337e-06 0.897487269196476 1.60991951047485e-06 0.898471373493449 1.60992012663754e-06 0.8985180228791175 1.610015282612379e-06 0.899508178894561 \
1.610016773214557e-06 0.8995204306067698 1.610128061288741e-06 0.9005118233983579 1.610128237625744e-06 0.9005706457326812 1.610131860757067e-06 0.8996048713171836 \
1.610132041955094e-06 0.8994654179496379 1.610133353076571e-06 0.8985275682722235 1.610133534953976e-06 0.8984123497545736 1.61013535794417e-06 0.8974436520388238 \
1.610135517857424e-06 0.8973766233009967 1.610148668688723e-06 0.8983720910457982 1.610148779670277e-06 0.8983905835035384 1.610157601254383e-06 0.8993863063850064 \
1.610158148023847e-06 0.8994226481040219 1.610650719976681e-06 0.9003987622903815 1.610650789769166e-06 0.9004496773542636 1.610651622421929e-06 0.9012853800543292 \
1.610651748468094e-06 0.9014513953152168 1.610652328988958e-06 0.9023435091985418 1.610652469953212e-06 0.9025895326188698 1.610652869091291e-06 0.9033428289365844 \
1.610653019240832e-06 0.9036449200440446 1.610653462322154e-06 0.9045762589490434 1.610653619494256e-06 0.9049121924877023 1.610654065120987e-06 0.9058152254958243 \
1.610654163577326e-06 0.9059929146639856 1.61065558025872e-06 0.9052304871087643 1.610655711415865e-06 0.904616184869324 1.610655880423041e-06 0.9036290332250884 \
1.610656045714917e-06 0.9024406226812831 1.610656151980698e-06 0.9015554774641358 1.610656255417528e-06 0.9006052096506509 1.610656341184247e-06 0.8997486040545581 \
1.610656430678233e-06 0.8987887485205278 1.610656554922632e-06 0.8973492764100613 1.610656673003581e-06 0.8958624931586439 1.610656760219672e-06 0.8946938835082598 \
1.610656884526716e-06 0.8929289312882503 1.610656991510644e-06 0.8913158670103165 1.610657091342348e-06 0.8897378501708729 1.610657217633174e-06 0.8876466417139378 \
1.610657385821785e-06 0.884705368138502 1.610657541521538e-06 0.8818365157686672 1.610657738126367e-06 0.8780362649814708 1.610657921747617e-06 0.8743271923380105 \
1.61065813325501e-06 0.8698916163736473 1.610658314064811e-06 0.8659808238081558 1.610658498645858e-06 0.8618945354625286 1.610658671649854e-06 0.8579913311618118 \
1.610658857050504e-06 0.8537436868396935 1.610659036133651e-06 0.8495884889292737 1.610659219722713e-06 0.8452850234109005 1.610659386484418e-06 0.8413449312544377 \
1.610659554574996e-06 0.8373487193315756 1.610659717684167e-06 0.8334514816705533 1.610659872870403e-06 0.829729402178684 1.610660045969282e-06 0.8255639501984255 \
1.610660231959738e-06 0.8210763864673301 1.610660396580222e-06 0.8170961425007568 1.610660561450132e-06 0.8131038678717658 1.610660736782165e-06 0.8088537582860886 \
1.610660901208668e-06 0.8048648186953292 1.610661069844279e-06 0.8007719922541914 1.610661260647645e-06 0.7961398815555145 1.610661446171819e-06 0.7916360074082958 \
1.610661655100628e-06 0.7865651471012967 1.610661879917618e-06 0.7811107659751856 1.610662069732705e-06 0.77650678233121 1.610662271590188e-06 0.7716133355283564 \
1.610662415860827e-06 0.76811790639139 1.610662557504393e-06 0.7646880872338248 1.610662685202102e-06 0.7615975116975136 1.610662796247944e-06 0.7589113686396982 \
1.61066292481058e-06 0.7558028559024855 1.610663057376087e-06 0.7525995467138866 1.610663170697783e-06 0.7498629233610832 1.610663307032409e-06 0.7465723252212872 \
1.610663413431661e-06 0.7440058350410135 1.610663572650447e-06 0.7401674766516904 1.610663745028142e-06 0.7360137588823189 1.610663907275386e-06 0.7321074183421575 \
1.610664079624344e-06 0.7279612819449855 1.610664239010527e-06 0.7241302920521341 1.610664446815714e-06 0.7191408067115369 1.610664607355379e-06 0.7152908836069264 \
1.610664799844715e-06 0.7106793324906435 1.610664985361064e-06 0.7062404417184839 1.610665155237109e-06 0.7021802791355866 1.610665347106947e-06 0.6975984806629684 \
1.610665493330962e-06 0.6941099299715526 1.610665653617309e-06 0.6902897983225644 1.610665856006145e-06 0.6854719661536142 1.610666037294609e-06 0.681161582477689 \
1.610666206116036e-06 0.6771536053116509 1.610666391961911e-06 0.6727470762459599 1.610666597892751e-06 0.6678715161770782 1.610666765819558e-06 0.6639016226084196 \
1.610666926081262e-06 0.6601182542089066 1.610667164933735e-06 0.65448589698252 1.610667332694849e-06 0.6505369020837752 1.610667513768288e-06 0.6462813620835641 \
1.610667674923199e-06 0.642499550819208 1.61066782119046e-06 0.6390715923276049 1.610667959878569e-06 0.6358268652274862 1.610668089235615e-06 0.6328040340451749 \
1.61066821862017e-06 0.6297855584526113 1.61066834694149e-06 0.6267952385336898 1.610668477143629e-06 0.6237652412672913 1.610668606160074e-06 0.6207683673242944 \
1.610668744735633e-06 0.6175525629501428 1.61066889281122e-06 0.6141227553162802 1.610669079138505e-06 0.60981438109949 1.610669226822204e-06 0.6064079319686639 \
1.61066946198641e-06 0.600995965122186 1.610669654434141e-06 0.5965821560879089 1.610669895003955e-06 0.5910808370261941 1.610670064051326e-06 0.587228367631822 \
1.61067020171775e-06 0.5840969866928536 1.610670329822727e-06 0.581191110277254 1.610670443409422e-06 0.5786182870235701 1.610670534774226e-06 0.5765512826027382 \
1.610670624196113e-06 0.5745328691003393 1.610670691457846e-06 0.573016830490748 1.610670757478049e-06 0.5715297341779608 1.610670809531724e-06 0.5703577032508095 \
1.610670873770593e-06 0.5689124506700958 1.610670935307116e-06 0.5675311492520995 1.61067099958866e-06 0.5660899724818867 1.610671052779756e-06 0.5648985048860162 \
1.61067114512554e-06 0.5628316153148989 1.610671221701441e-06 0.5611191615154557 1.610671277545091e-06 0.5598732849310241 1.6106713468882e-06 0.5583285932816697 \
1.610671452739476e-06 0.5559733466166974 1.61067153043128e-06 0.5542469170533902 1.610671631029868e-06 0.5520159549745236 1.610671759063078e-06 0.5491849411292137 \
1.61067185856046e-06 0.5469885705929382 1.610671971125811e-06 0.544508366501287 1.610672074170131e-06 0.5422442603473754 1.610672194219017e-06 0.5396115972585003 \
1.610672295833426e-06 0.5373863339265779 1.610672411457693e-06 0.5348611538529422 1.610672526573874e-06 0.5323536236546169 1.610672653010918e-06 0.529604142030661 \
1.610672778525186e-06 0.5268822104345234 1.610672925204862e-06 0.5237112381511962 1.61067306087557e-06 0.5207845659358002 1.610673218641409e-06 0.5173942078023266 \
1.61067338106335e-06 0.5139116507621072 1.610673561971818e-06 0.5100482739823553 1.610673754563972e-06 0.5059503908118104 1.610673967555743e-06 0.5014368974673542 \
1.610674199988459e-06 0.4965308659362653 1.610674457509373e-06 0.49112491222925 1.610674697473551e-06 0.4861095397820235 1.610674998677906e-06 0.4798501326413723 \
1.610675286975534e-06 0.4738957353990632 1.610675600061861e-06 0.4674739717793394 1.610675919588141e-06 0.4609631488871989 1.610676259085406e-06 0.4540919149088484 \
1.610676585275518e-06 0.4475353831519197 1.61067692175678e-06 0.4408159131180407 1.610677238467587e-06 0.4345373385230166 1.61067757255266e-06 0.4279587671099637 \
1.610677924261529e-06 0.4210864038135054 1.610678238746378e-06 0.4149846225409808 1.610678562192836e-06 0.4087533091618546 1.610679003120949e-06 0.400331870031168 \
1.610679344916025e-06 0.3938679283557566 1.610679644350069e-06 0.3882534014213259 1.610680018872672e-06 0.3812944595528024 1.61068034825039e-06 0.375233915169682 \
1.610680631354694e-06 0.3700684563936956 1.610680931099705e-06 0.3646408765157301 1.610681210595549e-06 0.3596219010422631 1.610681434267487e-06 0.3556377385586224 \
1.610681645979195e-06 0.3518907610576284 1.610681848481927e-06 0.3483292724130969 1.610682049543475e-06 0.3448190020587957 1.610682255221384e-06 0.3412518188287665 \
1.61068247359686e-06 0.3374887625241871 1.610682717359257e-06 0.3333167726275162 1.610682944115829e-06 0.3294678078423895 1.610683164026801e-06 0.3257615367192951 \
1.610683382451408e-06 0.3221060038181086 1.610683586476418e-06 0.318715141566024 1.610683788334208e-06 0.3153870758963987 1.610683988657596e-06 0.3121102802474151 \
1.610684175271502e-06 0.309079115007194 1.610684372573109e-06 0.3058982938882217 1.610684581156335e-06 0.3025606704206737 1.610684786791057e-06 0.2992974534031506 \
1.610685011523137e-06 0.2957609785165763 1.610685228418979e-06 0.2923771984023277 1.610685436098331e-06 0.2891642611511841 1.610685667149178e-06 0.2856239464683982 \
1.610685841949429e-06 0.2829684481899911 1.610686021147604e-06 0.2802647299798244 1.61068619002212e-06 0.2777348429135014 1.610686418345394e-06 0.274348458173166 \
1.610686595082661e-06 0.2717528218126659 1.610686763365392e-06 0.2693020894036587 1.610686935832162e-06 0.2668230333489093 1.610687069934441e-06 0.264903804409765 \
1.610687215894446e-06 0.2628277003548514 1.610687354589947e-06 0.2608803500812688 1.610687476871551e-06 0.2591684246570544 1.610687610990381e-06 0.2572942758553639 \
1.610687740091486e-06 0.2554978336754472 1.61068785952522e-06 0.2538430842138498 1.61068798636042e-06 0.2520939183506197 1.610688106001441e-06 0.2504447954274527 \
1.610688255617635e-06 0.2483797066042054 1.610688390481146e-06 0.2465170278296022 1.61068852003856e-06 0.2447289494531232 1.610688677103379e-06 0.2425624627506451 \
1.610688801099014e-06 0.2408491463446025 1.610688941247149e-06 0.2389135279283614 1.61068907114005e-06 0.2371200701944942 1.610689191757671e-06 0.2354534357320198 \
1.610689354230601e-06 0.2332087289724075 1.6106895002847e-06 0.2311905595759856 1.610689638605484e-06 0.2292825126447264 1.610689746532702e-06 0.2277949627009887 \
1.610689877317609e-06 0.225993474229161 1.610689975823626e-06 0.22463752857886 1.610690079906972e-06 0.2232056532573264 1.610690152783836e-06 0.2222046546567725 \
1.610690234937313e-06 0.2210804129356655 1.610690302346398e-06 0.2201585377209549 1.610690349050661e-06 0.2195201149856669 1.61069039846802e-06 0.2188449488487562 \
1.610690489422163e-06 0.2176035744446363 1.610690555816576e-06 0.2166983392055156 1.610690602779869e-06 0.2160586379972232 1.610690653091075e-06 0.2153737902794619 \
1.610690712240425e-06 0.2145693142997165 1.610690755086328e-06 0.2139870779821451 1.610690798893629e-06 0.2133941263688522 1.610690868423894e-06 0.2124566309962414 \
1.610690955340708e-06 0.2112864027023158 1.610691036529563e-06 0.2101949018929156 1.610691122429027e-06 0.2090416531541652 1.610691216575207e-06 0.2077796428137634 \
1.610691308329081e-06 0.2065517647617813 1.610691403625517e-06 0.2052788208685862 1.610691500104208e-06 0.2039945431316728 1.61069160092949e-06 0.2026602783061639 \
1.610691696885502e-06 0.2013924147365721 1.610691799571213e-06 0.2000377255165624 1.610691902607567e-06 0.1986831378210229 1.610692012697906e-06 0.1972405340748948 \
1.610692121449794e-06 0.1958206085628783 1.610692241171749e-06 0.1942631948714586 1.610692351614651e-06 0.1928328887741874 1.610692459617459e-06 0.1914411844406488 \
1.610692584973803e-06 0.1898318066870429 1.610692677907979e-06 0.1886434908940876 1.610692756278755e-06 0.1876443873000938 1.610692832918829e-06 0.1866698667869858 \
1.610692915430143e-06 0.1856249297118943 1.610692984939759e-06 0.1847473639743596 1.610693050895387e-06 0.1839166514106665 1.610693115162722e-06 0.1831089953192083 \
1.610693227146207e-06 0.1817072258029639 1.610693321200174e-06 0.1805353135896268 1.610693428841935e-06 0.1791985758407087 1.610693535314993e-06 0.1778827552324552 \
1.61069365530692e-06 0.1764073736674057 1.610693793359546e-06 0.174720142305475 1.610693909520101e-06 0.1733081217455876 1.610694071616903e-06 0.1713503924599185 \
1.61069418670542e-06 0.1699688234017716 1.610694326691019e-06 0.1682987764548305 1.610694443897095e-06 0.1669083002780509 1.610694554816447e-06 0.1655990025649634 \
1.610694652444933e-06 0.1644521190704843 1.610694747295481e-06 0.1633427224865242 1.610694863349894e-06 0.161991523106341 1.610694954898444e-06 0.1609305136382055 \
1.61069505100742e-06 0.1598214181625073 1.610695145225553e-06 0.1587403933520305 1.610695238726156e-06 0.1576732160104884 1.610695332323478e-06 0.1566104070550305 \
1.610695428005017e-06 0.1555300824433628 1.610695518592921e-06 0.1545132165873678 1.610695609606078e-06 0.1534969984004868 1.610695705154556e-06 0.1524358767948732 \
1.610695795820268e-06 0.1514342506187442 1.610695898892631e-06 0.1503020548964867 1.61069597134408e-06 0.1495100717445464 1.610696050444873e-06 0.148649146151682 \
1.610696124993092e-06 0.1478424742503694 1.6106961960245e-06 0.1470770917224498 1.610696268788982e-06 0.1462962409077327 1.610696343406157e-06 0.1454990959398698 \
1.610696413389118e-06 0.1447543557055888 1.610696487550038e-06 0.143968261688537 1.610696541295377e-06 0.1434005634796054 1.610696594578932e-06 0.1428396203849428 \
1.61069665977469e-06 0.1421555039833398 1.610696731080731e-06 0.141411576573238 1.610696795450793e-06 0.1407432786314442 1.610696868802754e-06 0.1399847409254479 \
1.610696929420321e-06 0.1393607073002494 1.610697015453805e-06 0.1384787080092832 1.610697091404821e-06 0.1377037134581418 1.610697181372726e-06 0.1367902106004182 \
1.610697263099684e-06 0.1359645165492482 1.610697345789662e-06 0.1351360437760365 1.610697428345969e-06 0.1343145513298757 1.610697533908125e-06 0.1332698421778018 \
1.610697615775408e-06 0.1324642397250402 1.610697713142868e-06 0.1315110876582503 1.610697803143729e-06 0.130634908321232 1.610697891113988e-06 0.1297829978838479 \
1.610697974043843e-06 0.1289892226181523 1.610698048280934e-06 0.1282822873521282 1.610698147931993e-06 0.1273377645104763 1.610698243687052e-06 0.1264350619688987 \
1.610698330534457e-06 0.1256206895242312 1.610698420535994e-06 0.1247808744623497 1.610698500868675e-06 0.1240346855852102 1.610698587562703e-06 0.1232365419604467 \
1.610698686393032e-06 0.1223331159004786 1.61069877647517e-06 0.1215131568528167 1.610698886718427e-06 0.1205141992263624 1.610698973949866e-06 0.1197275966302077 \
1.610699042523e-06 0.1191120727131645 1.610699127185393e-06 0.1183553887582162 1.610699193692874e-06 0.1177634990399222 1.610699265148799e-06 0.1171309945267847 \
1.610699334822604e-06 0.1165184920865242 1.610699412159692e-06 0.1158409171037389 1.610699507902974e-06 0.1150054407698888 1.610699579157887e-06 0.1143861389207103 \
1.61069964652742e-06 0.1138025718558601 1.610699714964191e-06 0.113211685696446 1.610699790554542e-06 0.1125613765304429 1.610699881296389e-06 0.1117840233035959 \
1.610699964000116e-06 0.1110788257213999 1.610700077599187e-06 0.1101151050704521 1.610700187474899e-06 0.1091895325357105 1.610700279674213e-06 0.1084169374841771 \
1.610700403623545e-06 0.1073835127717347 1.610700491987867e-06 0.1066505015902263 1.610700631446837e-06 0.1055001025916527 1.610700730743538e-06 0.1046863788921388 \
1.61070082339359e-06 0.1039306459201802 1.610700933598102e-06 0.1030359883605075 1.610701018892542e-06 0.1023467905686673 1.610701103793345e-06 0.101663637589173 \
1.610701186744309e-06 0.1009989740617136 1.61070130925421e-06 0.1000225794851696 1.610701431196063e-06 0.09905761200121259 1.610701557818349e-06 0.09806258992746317 \
1.610701670630472e-06 0.09718220909187772 1.610701815205956e-06 0.09606278874246346 1.610701952919885e-06 0.09500564015228773 1.610702069610674e-06 0.09411672853020667 \
1.610702197354242e-06 0.0931507147971556 1.610702297018758e-06 0.09240236948627445 1.610702376452637e-06 0.09180921593916676 1.610702475187936e-06 0.09107599640376031 \
1.610702553063239e-06 0.09050081472416407 1.610702634529155e-06 0.08990210528957472 1.610702709246463e-06 0.0893557072655629 1.610702789776201e-06 0.08876971652456604 \
1.610702908608526e-06 0.08791061481419053 1.610702998269062e-06 0.08726673116015753 1.610703103183109e-06 0.08651800316437093 1.610703234657667e-06 0.08558693768262025 \
1.610703395765802e-06 0.08445695903909305 1.610703535947497e-06 0.08348350561263763 1.610703684450103e-06 0.08246223579158835 1.610703821170292e-06 0.08153124812726546 \
1.610703961182002e-06 0.08058696725890066 1.610704098179202e-06 0.07967195061625794 1.610704236789813e-06 0.07875532825288725 1.6107043812627e-06 0.07780967510081127 \
1.610704528808937e-06 0.07685421131041187 1.610704686312648e-06 0.07584560580436887 1.610704850707884e-06 0.07480523464991846 1.610705018799982e-06 0.07375451744755303 \
1.610705199799341e-06 0.07263751640721161 1.610705398512623e-06 0.07142823309373261 1.610705611921415e-06 0.07014922396308329 1.6107058380853e-06 0.06881630383186611 \
1.610706078645623e-06 0.06742468841361035 1.610706356206536e-06 0.06585179211508728 1.610706653410938e-06 0.06420523370201831 1.610706971711662e-06 0.06248365192299224 \
1.610707361695962e-06 0.06043183534616462 1.610707760522748e-06 0.05839861031494715 1.610708202994687e-06 0.05621846258761681 1.61070858797559e-06 0.05438828987170503 \
1.610709000022182e-06 0.05249218901100536 1.610709351759698e-06 0.05092353490091287 1.61070968726435e-06 0.04946969867921969 1.610709997763245e-06 0.04816021644386199 \
1.610710291700064e-06 0.04695194805701195 1.610710584430997e-06 0.04577883625507727 1.610710859274204e-06 0.04470700909733757 1.610711133117927e-06 0.04366353526031765 \
1.610711398807688e-06 0.04267398813878486 1.610711674116703e-06 0.04167180388267511 1.610711958673621e-06 0.04066026046469497 1.610712254971736e-06 0.03963283340811159 \
1.610712513847122e-06 0.03875659098599576 1.610712741803528e-06 0.03800131046948733 1.610712960528722e-06 0.03729095380188759 1.610713180383449e-06 0.03659437723507575 \
1.610713521249514e-06 0.03554043311314246 1.610713797290394e-06 0.03470953269536187 1.610714090721169e-06 0.03384790442147732 1.610714373289092e-06 0.03303898052111545 \
1.610714628198529e-06 0.03232625790162248 1.610714908882988e-06 0.03155947796597136 1.610715154716382e-06 0.03090318379665042 1.61071538687767e-06 0.03029616297556957 \
1.610715627215008e-06 0.02968398395812225 1.610715862851843e-06 0.02909722707395018 1.610716091063021e-06 0.0285403787496557 1.61071650783575e-06 0.02755138287878544 \
1.610716702361127e-06 0.02710176794309662 1.610717088601532e-06 0.02623051698020805 1.610717267770925e-06 0.0258356865503758 1.610717618998109e-06 0.02507792837274256 \
1.610717786904157e-06 0.0247229612172224 1.610718171166812e-06 0.02392944198669211 1.610718286448541e-06 0.02369675911063252 1.610718728496378e-06 0.02282172072611499 \
1.610718950311652e-06 0.02239223679446916 1.610719473931311e-06 0.02139838041889957 1.61071962929382e-06 0.02110714647916685 1.610720146999888e-06 0.02015295207761772 \
1.610720272033152e-06 0.01992792118872039 1.610720796234659e-06 0.01901759738223179 1.610720932454034e-06 0.01879045572456909 1.61072153873049e-06 0.01783210191617334 \
1.610721705739623e-06 0.01758082406519646 1.610722348947267e-06 0.01666064795441237 1.610722528091535e-06 0.0164167113061686 1.610723218250269e-06 0.01551958953683085 \
1.610723381870153e-06 0.01531511209162885 1.61072414235084e-06 0.01440332854054019 1.610724289392963e-06 0.01423371673427115 1.610725107264621e-06 0.01333087949608782 \
1.610725226813134e-06 0.01320411419549955 1.610726142674656e-06 0.01227329163592313 1.610726284027572e-06 0.01213544173166964 1.610727232503148e-06 0.01124488043697059 \
1.610727391142586e-06 0.01110230805801717 1.61072857354363e-06 0.01011356759191894 1.61072867164402e-06 0.01003725601038859 1.61072993325548e-06 0.009120360285939955 \
1.610730067669331e-06 0.009028655389366201 1.610731608240655e-06 0.008043892937307966 1.610731689273999e-06 0.007992925041580451 1.610733277867931e-06 0.007023242357651564 \
1.610733410759078e-06 0.006948518507451114 1.61073538746242e-06 0.005952856104192286 1.610735569200568e-06 0.005869662958407677 1.610737671554228e-06 0.004980929874643355 \
1.610738112345997e-06 0.004810448874467742 1.610740767560855e-06 0.003892108290451164 1.610741244140394e-06 0.003745909362026665 1.610744882222615e-06 0.00279447349697209 \
1.61074540774606e-06 0.002678838783887205 1.610751013810845e-06 0.001700248310874221 1.610751324898547e-06 0.001653333728976835 1.610756459226246e-06 0.0006858192122199529 \
1.610756653206019e-06 0.0006440832883579712 1.613404576914862e-06 -0.0002037173203380238 1.613404741115283e-06 -0.0003889174928863678 1.613405314458091e-06 -0.001270938904608877 \
1.613405389392278e-06 -0.001411855863724778 1.613405849976055e-06 -0.002393592696522268 1.613405961916807e-06 -0.002660411672198376 1.613406215188795e-06 -0.003300974950034667 \
1.6134063815721e-06 -0.003745951779090856 1.61340667656787e-06 -0.004566571567208835 1.613406788055442e-06 -0.00488071790655901 1.613407067428216e-06 -0.005641221413069743 \
1.613407188386555e-06 -0.005938820066262044 1.613408282339389e-06 -0.005180465225493313 1.613408406471631e-06 -0.004410796826645887 1.613408530879049e-06 -0.003456122327429311 \
1.613408650435429e-06 -0.002364170815481491 1.613408748579805e-06 -0.001341064316055312 1.613408855004127e-06 -0.0001052154991983786 1.613408967239972e-06 0.001336046702817826 \
1.613409102195821e-06 0.003249882807978809 1.613409224782331e-06 0.005149402351921401 1.613409413644246e-06 0.008353592055059769 1.613409554826579e-06 0.01094873860302964 \
1.613409708187922e-06 0.01393943619118621 1.613409851561427e-06 0.01687898420971235 1.613410005752867e-06 0.02017576688295359 1.613410161892825e-06 0.02363796584892512 \
1.613410317618878e-06 0.02719811802828209 1.613410465112557e-06 0.03065407560139007 1.613410613784323e-06 0.03420778369279751 1.613410769114408e-06 0.03798436241030867 \
1.613410927740288e-06 0.04189786275883118 1.613411092673448e-06 0.0460171220807938 1.613411267096336e-06 0.05041857973200652 1.613411446085736e-06 0.05497510627343041 \
1.613411635385597e-06 0.05982852266675163 1.613411838393603e-06 0.06506368941101938 1.613412057870669e-06 0.07075025585284363 1.613412288935331e-06 0.07675903373893865 \
1.613412535995649e-06 0.08319974270080552 1.613412806420637e-06 0.0902619122132732 1.613413099984324e-06 0.09793335781011638 1.613413424033306e-06 0.1064001814721126 \
1.613413788254856e-06 0.1159066558703892 1.613414180806326e-06 0.1261372395632307 1.613414630304251e-06 0.1378252442462487 1.613415153096484e-06 0.1513754922073403 \
1.613415766694219e-06 0.1672157090591849 1.613416444455093e-06 0.184625848284817 1.613417232720213e-06 0.2047487967247964 1.613418115553072e-06 0.22712469896725 \
1.613418933839029e-06 0.2476994923478653 1.613419661268608e-06 0.2658503723959502 1.613420301381636e-06 0.2817009601644404 1.61342087568535e-06 0.2958213763442377 \
1.613421413251317e-06 0.3089396094373287 1.613421917248776e-06 0.3211464104224903 1.61342239337143e-06 0.3325930942309646 1.613422871259445e-06 0.3439912352478621 \
1.613423324592551e-06 0.3547121966731367 1.613423795885259e-06 0.3657614311162562 1.613424238561085e-06 0.3760518588326446 1.613424757059872e-06 0.3879885572071845 \
1.613425284221992e-06 0.3999987293386327 1.613425663131624e-06 0.4085537955782026 1.613426193047166e-06 0.4204060347738258 1.613426622963746e-06 0.429919877745455 \
1.613427076664521e-06 0.4398653393542544 1.613427543378037e-06 0.4500002271552926 1.613427981059267e-06 0.4594210430579985 1.613428389021531e-06 0.468120704286539 \
1.613428708454565e-06 0.4748816926501604 1.613429080589837e-06 0.4826992142337162 1.613429315571978e-06 0.4876010339127531 1.613429549178225e-06 0.4924491904621348 \
1.613429797190648e-06 0.4975647713404599 1.613430095592078e-06 0.5036796627825791 1.61343035194848e-06 0.5088948470128004 1.61343056424179e-06 0.5131878547336713 \
1.613430758259862e-06 0.5170959594548015 1.613430905246394e-06 0.5200432695146362 1.613431059224405e-06 0.523118600542271 1.613431277106154e-06 0.5274469616807909 \
1.61343153021048e-06 0.5324525256580425 1.613431740049324e-06 0.5365797337241586 1.613431951502634e-06 0.5407247601751553 1.613432233709534e-06 0.5462280430697679 \
1.613432463254817e-06 0.5506821559930507 1.613432679151024e-06 0.5548604062613707 1.613432961372541e-06 0.560308769190463 1.613433212680268e-06 0.5651538146135803 \
1.61343351034116e-06 0.5708625224168123 1.613433760568061e-06 0.5756519166658941 1.613434016931556e-06 0.5805516059354519 1.61343425734157e-06 0.585116682128892 \
1.613434515521386e-06 0.5900038400537884 1.613434739113592e-06 0.5942175703762435 1.613434977623163e-06 0.5986919452581434 1.613435185207862e-06 0.6025689278491061 \
1.613435401730487e-06 0.6065904171332736 1.613435651033092e-06 0.6111939272561876 1.613435856106535e-06 0.6149609706257601 1.613436107378861e-06 0.6195555361399968 \
1.613436310600886e-06 0.6232455818254186 1.613436507472791e-06 0.6267987644955494 1.613436700764307e-06 0.630267737067843 1.613436955542762e-06 0.6348113783570861 \
1.613437185753374e-06 0.638887973644319 1.613437403107185e-06 0.6427143472883045 1.613437701512908e-06 0.6479268061885751 1.613437916915757e-06 0.6516657345437264 \
1.613438118139476e-06 0.6551344108237934 1.613438293060984e-06 0.6581323437428509 1.613438458126254e-06 0.6609495238976936 1.613438627594775e-06 0.6638251431769452 \
1.613438779731612e-06 0.666392827642013 1.613438917642298e-06 0.6687037209181631 1.613439066478412e-06 0.6711867545200138 1.613439194593014e-06 0.6733159837320549 \
1.613439337815828e-06 0.6756849429836936 1.613439459090078e-06 0.6776819274526149 1.613439596688762e-06 0.6799401191146522 1.613439716069216e-06 0.6818929034138137 \
1.613439863176963e-06 0.6842914131385206 1.613439980378628e-06 0.6861933934268433 1.613440073884205e-06 0.6877071857403232 1.613440164873897e-06 0.6891752279197846 \
1.613440267615961e-06 0.6908280855439021 1.613440369133525e-06 0.6924555900607121 1.613440487516631e-06 0.6943444167618776 1.613440599637217e-06 0.6961264383846065 \
1.613440717192718e-06 0.6979868779962457 1.613440902343005e-06 0.7008959348649784 1.613441033535213e-06 0.7029413755586562 1.613441169703753e-06 0.7050491462541959 \
1.613441291222456e-06 0.7069171228306749 1.613441431145468e-06 0.7090538254196674 1.613441535088117e-06 0.7106315721465845 1.613441646249101e-06 0.712309798010818 \
1.613441750508965e-06 0.7138759052437967 1.613441880147057e-06 0.7158124745844324 1.613441977077769e-06 0.7172526339884565 1.613442116000004e-06 0.7193052800722975 \
1.613442235549293e-06 0.7210612846995991 1.613442355121865e-06 0.7228080613301419 1.613442480897243e-06 0.7246353354365959 1.613442607615586e-06 0.7264656873164689 \
1.613442729655437e-06 0.728218443613998 1.61344285780388e-06 0.7300486655261287 1.613442987872205e-06 0.7318956587421809 1.613443108863227e-06 0.7336041830685722 \
1.613443249633811e-06 0.7355801168346318 1.61344335060338e-06 0.7369898206659778 1.613443452204237e-06 0.7384020079314992 1.613443548224548e-06 0.7397310783624924 \
1.613443659137403e-06 0.7412570822736337 1.61344374678503e-06 0.7424563811251772 1.613443846639401e-06 0.7438154404043728 1.613443981404539e-06 0.7456370856934184 \
1.613444097699018e-06 0.747198032089633 1.613444201190815e-06 0.7485782798032956 1.613444325446263e-06 0.7502239458264747 1.613444470359203e-06 0.7521280942578691 \
1.613444588339771e-06 0.753666143975803 1.613444707270879e-06 0.7552056331692281 1.613444846850418e-06 0.7569980918234445 1.613444991202808e-06 0.7588357421297242 \
1.613445109263616e-06 0.7603265096672839 1.613445234085335e-06 0.7618908200857619 1.613445373916531e-06 0.7636286950759973 1.613445498679428e-06 0.7651662633748356 \
1.613445642192899e-06 0.7669199865864609 1.613445762878377e-06 0.7683824344671055 1.613445883722124e-06 0.7698356273746885 1.613446003367048e-06 0.7712633747646481 \
1.613446133074687e-06 0.7727989859455529 1.61344624181849e-06 0.7740766298596218 1.613446364466227e-06 0.7755070372682662 1.613446474242911e-06 0.7767778749889983 \
1.613446603267025e-06 0.7782599816788072 1.613446735043344e-06 0.7797610257751375 1.61344684835592e-06 0.7810403609326458 1.613446969441862e-06 0.7823954393038701 \
1.613447073314495e-06 0.7835479431998941 1.613447215597518e-06 0.785111775748914 1.613447363800666e-06 0.7867227488076519 1.613447522694201e-06 0.7884297907063792 \
1.613447642887224e-06 0.7897074707829422 1.61344779245393e-06 0.7912811323018302 1.613447916569147e-06 0.7925734175081853 1.613448042273444e-06 0.7938699048627912 \
1.613448145219011e-06 0.7949224966762399 1.613448259590165e-06 0.7960823495211882 1.613448372064409e-06 0.7972131756542409 1.613448462336983e-06 0.7981137961420948 \
1.613448551677879e-06 0.7989989930139054 1.613448676903817e-06 0.800229513878344 1.61344878467518e-06 0.8012785338618679 1.613448914342979e-06 0.8025281307685926 \
1.613449035722257e-06 0.8036855380110038 1.613449152278057e-06 0.8047859282369955 1.613449273083453e-06 0.80591497746663 1.613449405708758e-06 0.8071413435168892 \
1.613449527502378e-06 0.8082555056211007 1.613449654106103e-06 0.8094015704683005 1.613449779719621e-06 0.8105266036187198 1.613449899211046e-06 0.8115857443778658 \
1.613450037409299e-06 0.8127973981963581 1.613450146908548e-06 0.8137473213416323 1.613450231056663e-06 0.8144713378799666 1.61345035186072e-06 0.8155017394983226 \
1.613450447369557e-06 0.8163089346032877 1.61345058366036e-06 0.8174496006492775 1.613450726424414e-06 0.8186303638797883 1.613450860857535e-06 0.8197292014569521 \
1.613450970729519e-06 0.8206175763825388 1.613451114629137e-06 0.8217677661037901 1.61345126795672e-06 0.8229768690765377 1.613451395805574e-06 0.8239722812379519 \
1.613451536202905e-06 0.8250521595273246 1.613451662107844e-06 0.8260088941474263 1.61345181672401e-06 0.8271688948348412 1.61345194907934e-06 0.8281489842609937 \
1.613452075346168e-06 0.8290730392392056 1.613452193006695e-06 0.8299245984162376 1.613452341409092e-06 0.8309852945996649 1.61345250860326e-06 0.8321626230293395 \
1.613452641380572e-06 0.8330844501529713 1.613452814281769e-06 0.8342675727345584 1.613452982699063e-06 0.8354015168591284 1.613453152193536e-06 0.8365246342267009 \
1.613453333630418e-06 0.8377070668209077 1.613453476186559e-06 0.8386219603417975 1.61345359009745e-06 0.8393441765511721 1.613453720973659e-06 0.8401643924869071 \
1.613453822596633e-06 0.8407940582489307 1.613453939036872e-06 0.8415078269750864 1.613454074330058e-06 0.8423269142909066 1.613454271595159e-06 0.8435017451489455 \
1.613454462114483e-06 0.844614933042255 1.613454672039296e-06 0.8458175693076773 1.613454852817827e-06 0.8468334846981137 1.613455050185846e-06 0.8479221976595614 \
1.613455224044341e-06 0.8488638701886076 1.613455406558583e-06 0.8498353939890455 1.613455577902694e-06 0.8507314120859523 1.613455752248258e-06 0.8516272398309612 \
1.613455927651258e-06 0.8525125793730954 1.613456103896448e-06 0.8533864315694911 1.613456293665327e-06 0.8543099749208749 1.613456484423344e-06 0.8552205033559714 \
1.61345668621255e-06 0.8561646193034282 1.613456878916116e-06 0.8570482883232282 1.613457088356793e-06 0.8579892478796384 1.613457318098559e-06 0.8589986827500428 \
1.613457583567511e-06 0.8601360945383778 1.613457882213856e-06 0.8613786760148464 1.613458160601222e-06 0.8625023989005415 1.613458444791177e-06 0.8636161469557806 \
1.613458719285784e-06 0.8646608622318305 1.613458991377281e-06 0.8656672252055042 1.613459261593727e-06 0.8666387059277968 1.613459518761915e-06 0.8675381145236246 \
1.61345979132098e-06 0.8684653318325959 1.61346006734232e-06 0.8693777905953765 1.613460337484171e-06 0.8702455402709716 1.613460637231955e-06 0.8711796653984102 \
1.613461008105813e-06 0.872294745819888 1.613461303028797e-06 0.8731503023941 1.613461557284845e-06 0.8738665406311316 1.613461855515577e-06 0.8746822274488602 \
1.613462129133902e-06 0.8754080260278182 1.613462365269549e-06 0.8760175227551726 1.613462605621406e-06 0.876622281264788 1.613462827963785e-06 0.8771680781109068 \
1.613463021968128e-06 0.8776338860468618 1.613463351691208e-06 0.8784037109613512 1.61346350686397e-06 0.8787567114621292 1.613463824616497e-06 0.879461652496718 \
1.613464003481858e-06 0.8798480920375044 1.613464345943324e-06 0.8805675499479563 1.613464530084847e-06 0.8809434933546246 1.613465004990284e-06 0.8818790560183651 \
1.613465172384703e-06 0.8821975058309585 1.613465638216128e-06 0.8830540251881659 1.613465819040967e-06 0.8833751042472839 1.613466313074347e-06 0.8842212008576973 \
1.613466454417056e-06 0.884455124402366 1.613467060806836e-06 0.8854193259359495 1.613467212878983e-06 0.8856514227360587 1.613467859557471e-06 0.8865980751852495 \
1.613467987853825e-06 0.8867785329419297 1.613468635979926e-06 0.8876550049536978 1.613468765772447e-06 0.8878236738033012 1.613469544034095e-06 0.8887860366092379 \
1.613469659025973e-06 0.8889208282599539 1.613470514758392e-06 0.8898661633196656 1.613470660021537e-06 0.8900169066926564 1.613471645777722e-06 0.8909664261264102 \
1.613471866882863e-06 0.8911622482549515 1.613473011997307e-06 0.8921020388386462 1.613473143207264e-06 0.8922053928944147 1.6134743308658e-06 0.8931033243919096 \
1.613474484486092e-06 0.8932130731307282 1.613475894522803e-06 0.8941348173026452 1.613476117329622e-06 0.8942660193790342 1.613477798020331e-06 0.8951452796684343 \
1.61347812564151e-06 0.8952966652167414 1.613480355582631e-06 0.8961896554712738 1.613480908496592e-06 0.8963788593752812 1.613484476711123e-06 0.8973573335043913 \
1.613484800223538e-06 0.8974284307984646 1.613491156631826e-06 0.8984120886469452 1.613491705534673e-06 0.8984686671268907 1.613544207609024e-06 0.8994658645395698 \
1.613544850637886e-06 0.8994692460188505 1.61373698930852e-06 0.9004073346715066 1.613737190722491e-06 0.9004708280105613 1.613741150500432e-06 0.8995366825576255 \
1.61374133452723e-06 0.8993953949813248 1.613742651124504e-06 0.8984641879157507 1.613742823168359e-06 0.8983566564859006 1.613744719544654e-06 0.8973720929359315 \
1.613744893250842e-06 0.897304621671452 1.613757467177875e-06 0.8982933655523699 1.613757552368112e-06 0.8983081509245614 1.613765819241151e-06 0.8993078551592517 \
1.613766293960572e-06 0.8993433667976791 1.614259794870012e-06 0.9002974142054325 1.614259914349736e-06 0.9003767372269074 1.614260807172786e-06 0.9012336455299185 \
1.614260953429423e-06 0.901423267690772 1.614261548322101e-06 0.9023325668564308 1.614261683292918e-06 0.9025673929107925 1.614262187968707e-06 0.9035294259428087 \
1.614262320579608e-06 0.9038000271808221 1.614262721206973e-06 0.9046475051114249 1.614262865572371e-06 0.9049556543240072 1.61426328869358e-06 0.9058123566484279 \
1.614263384150639e-06 0.9059850892484415 1.614264808709455e-06 0.9052205906349737 1.614264933747309e-06 0.9046352442223391 1.614265060157898e-06 0.9039223775493039 \
1.614265162806642e-06 0.9032486771507763 1.614265290021932e-06 0.9022944222362175 1.614265408867758e-06 0.9012801950564071 1.614265506520237e-06 0.9003603330664713 \
1.614265588522259e-06 0.8995243596151602 1.614265668185821e-06 0.8986589236008835 1.614265778963989e-06 0.8973708307079206 1.614265880140004e-06 0.8961049472956977 \
1.614265963084475e-06 0.8950067229086057 1.614266071529893e-06 0.8934921260891034 1.61426617999385e-06 0.8918872687155874 1.614266275049989e-06 0.8904106867557802 \
1.614266395922642e-06 0.8884444419111864 1.614266516699262e-06 0.8863849482818795 1.614266629744433e-06 0.8843763393508186 1.614266732915182e-06 0.8824794505619851 \
1.614266818515338e-06 0.8808620855018965 1.614266892989399e-06 0.8794251273161163 1.614266987312942e-06 0.8775673968166831 1.614267075773858e-06 0.8757888800524039 \
1.61426715484687e-06 0.8741711975775893 1.614267248834225e-06 0.872216793437976 1.614267330179529e-06 0.8704993514258973 1.614267425093555e-06 0.8684673705816817 \
1.614267518136275e-06 0.8664480751909672 1.614267614922069e-06 0.8643215060814092 1.614267738217441e-06 0.8615778533848952 1.614267851664453e-06 0.859022019682563 \
1.614267977516491e-06 0.8561558571929792 1.614268100844635e-06 0.8533196845306243 1.614268230022927e-06 0.850323637950593 1.614268370619783e-06 0.8470370034914 \
1.614268479399505e-06 0.8444782910716596 1.614268614459257e-06 0.8412850455921466 1.614268724119566e-06 0.8386804253780991 1.614268853299345e-06 0.8356002443501571 \
1.614268979483175e-06 0.8325812421138936 1.61426910657353e-06 0.8295317031556502 1.614269235595804e-06 0.826427745883674 1.614269344676045e-06 0.8237985689995477 \
1.614269484526701e-06 0.8204223029647078 1.614269623954893e-06 0.8170507778356514 1.614269756708524e-06 0.8138366863616762 1.614269886777199e-06 0.8106848159989707 \
1.614270010472646e-06 0.8076853837479523 1.614270147427036e-06 0.8043627031572629 1.614270261138882e-06 0.8016030849198694 1.614270388615923e-06 0.7985086235398901 \
1.614270499416994e-06 0.7958187897651571 1.614270618603452e-06 0.7929254985494992 1.614270731982509e-06 0.7901733724735396 1.614270866292901e-06 0.7869138859547327 \
1.614270973387169e-06 0.7843152933129034 1.614271089404312e-06 0.7815009627552112 1.614271218595275e-06 0.778367508739124 1.614271316207711e-06 0.7760002683782802 \
1.614271421787151e-06 0.773440790716327 1.61427153046932e-06 0.7708069008430674 1.614271632885583e-06 0.7683258101021144 1.614271726279241e-06 0.7660641808432364 \
1.614271845835017e-06 0.7631702213567544 1.614271938307379e-06 0.7609327305817616 1.614272030945494e-06 0.7586922094322426 1.61427212937031e-06 0.7563124992069843 \
1.614272237347962e-06 0.7537030947613649 1.614272333616474e-06 0.7513778334636231 1.614272419872877e-06 0.7492952979736797 1.614272522736666e-06 0.7468128004450286 \
1.614272601580994e-06 0.744910856519283 1.614272702387036e-06 0.7424801602439853 1.614272836915276e-06 0.7392377693660663 1.614272974140136e-06 0.7359316755186537 \
1.614273117619987e-06 0.7324773442723981 1.614273266044177e-06 0.7289066083419234 1.614273409305472e-06 0.7254625447335662 1.614273549382451e-06 0.7220977259655398 \
1.614273705808317e-06 0.7183435968963056 1.614273830210067e-06 0.715360858370426 1.614273951271848e-06 0.7124600029613375 1.61427410478411e-06 0.7087850045121084 \
1.614274239566055e-06 0.7055614325718365 1.614274365665088e-06 0.7025479112911024 1.614274508839371e-06 0.6991289103945657 1.614274628921163e-06 0.6962626602560111 \
1.614274758155491e-06 0.6931807499479741 1.614274864640539e-06 0.6906432840523983 1.614274976916362e-06 0.6879696524977363 1.614275073251648e-06 0.6856773754336868 \
1.61427517606134e-06 0.683232326200841 1.614275270865193e-06 0.6809792012818872 1.614275376187123e-06 0.6784784437814733 1.614275484625777e-06 0.6759058899658261 \
1.614275583635058e-06 0.673558569590366 1.61427570039165e-06 0.6707929011939652 1.614275808476928e-06 0.6682347329991606 1.614275918483137e-06 0.6656332609774134 \
1.614276004570979e-06 0.6635992664604092 1.614276134166118e-06 0.6605400273835189 1.614276226767366e-06 0.6583552307294462 1.614276322555092e-06 0.6560965362104854 \
1.614276407507078e-06 0.6540950852804182 1.614276526801602e-06 0.6512869789851043 1.61427661407154e-06 0.6492343850333612 1.614276704778561e-06 0.6471030993779646 \
1.614276805943536e-06 0.6447280068361273 1.614276885774359e-06 0.6428551652550211 1.614276974560194e-06 0.6407732405330839 1.614277052250421e-06 0.6389536101386547 \
1.614277114019368e-06 0.6375081226244841 1.614277177784013e-06 0.6360167668935747 1.614277241018233e-06 0.634538653569437 1.614277280258806e-06 0.6336218002627473 \
1.614277320897828e-06 0.6326726453797233 1.614277400982362e-06 0.6308039353694699 1.614277470886543e-06 0.6291742390428672 1.614277521523257e-06 0.6279942052995945 \
1.614277560272899e-06 0.6270914175114127 1.614277599267879e-06 0.6261832343283663 1.614277643882627e-06 0.6251445623164014 1.614277686739083e-06 0.6241478292286105 \
1.614277737053687e-06 0.6229782634938205 1.614277788990864e-06 0.6217719122409077 1.614277874058449e-06 0.6197972300178722 1.614277934038866e-06 0.6184052992407258 \
1.614278023826075e-06 0.61632338076978 1.614278100290157e-06 0.6145529519516876 1.614278179854447e-06 0.6127119801362371 1.614278260891059e-06 0.6108383709630588 \
1.614278350105382e-06 0.6087775861620425 1.614278440965394e-06 0.6066826282541496 1.614278528184102e-06 0.6046739453334793 1.614278621957293e-06 0.6025158549334848 \
1.614278723642756e-06 0.6001788642681311 1.614278823240849e-06 0.5978941858483342 1.614278935095889e-06 0.5953317151711254 1.614279051129026e-06 0.5926772450523136 \
1.614279172750132e-06 0.5899020947998995 1.614279277133946e-06 0.5875236635596754 1.614279421924166e-06 0.5842296531729801 1.614279534584127e-06 0.5816734289694181 \
1.614279643596094e-06 0.5792035939892568 1.614279736075537e-06 0.5771100174076607 1.614279829526177e-06 0.5749994714793375 1.61427992185204e-06 0.5729181236728181 \
1.614279994438741e-06 0.571283073141143 1.614280050392967e-06 0.5700232888304386 1.614280111461249e-06 0.5686498830286455 1.614280209950764e-06 0.5664400707212188 \
1.614280273162208e-06 0.5650238531380825 1.614280333588177e-06 0.5636708824310654 1.61428041053656e-06 0.5619492451093103 1.614280473695101e-06 0.5605380106414651 \
1.61428056200871e-06 0.558569506627369 1.614280633210033e-06 0.5569845302974165 1.614280719745787e-06 0.555060151797141 1.61428084109856e-06 0.5523665438352664 \
1.614280969027808e-06 0.5495364947125975 1.614281067158439e-06 0.5473694328713704 1.614281180282435e-06 0.5448752016832871 1.614281282350254e-06 0.5426314425864434 \
1.614281401299125e-06 0.5400217272291628 1.614281504386832e-06 0.5377630705755105 1.614281618593986e-06 0.5352670017334624 1.614281732009658e-06 0.532794946211756 \
1.614281859080713e-06 0.5300302694710822 1.614281982900802e-06 0.5273426867079006 1.614282127689607e-06 0.5242103332418484 1.61428226351311e-06 0.5212782585303676 \
1.614282418567969e-06 0.5179428401013338 1.614282579419853e-06 0.5144913885072363 1.6142827581493e-06 0.5106699876709851 1.61428294832834e-06 0.5066200804011861 \
1.614283158230362e-06 0.5021665212646098 1.614283386936347e-06 0.4973332357952056 1.614283640864285e-06 0.4919960258408594 1.614283881797751e-06 0.4869529241725989 \
1.614284177960236e-06 0.4807889695952298 1.614284467957623e-06 0.4747910561470179 1.614284774200956e-06 0.4684976697011882 1.614285094876888e-06 0.4619520863481486 \
1.614285422744054e-06 0.4553041925245184 1.614285762989109e-06 0.4484521981997251 1.614286088414654e-06 0.4419418052309769 1.614286410321802e-06 0.4355465312739703 \
1.614286740535907e-06 0.4290298934287748 1.6142870965285e-06 0.4220583188787752 1.614287415406929e-06 0.4158579595363656 1.614287752858691e-06 0.4093433989943853 \
1.614288180725408e-06 0.4011531841887147 1.614288529437356e-06 0.3945419525178304 1.614288837073319e-06 0.388759214407489 1.614289216899811e-06 0.3816861832573664 \
1.614289548089372e-06 0.3755780492082042 1.614289831697452e-06 0.370391509977049 1.614290142516397e-06 0.3647512908748707 1.614290421833005e-06 0.3597258263082204 \
1.614290648329153e-06 0.3556836811642302 1.614290864011538e-06 0.3518598964090484 1.614291061295543e-06 0.3483842179544538 1.614291266280002e-06 0.3447988491770444 \
1.614291478501966e-06 0.3411119200457455 1.614291733807154e-06 0.33670771290924 1.614291975329403e-06 0.3325734463267218 1.614292206706731e-06 0.3286464933807047 \
1.614292421559231e-06 0.3250253651850565 1.614292642118388e-06 0.3213332986541765 1.614292843544355e-06 0.3179852906236645 1.614293046612606e-06 0.3146379646143546 \
1.614293244508216e-06 0.3114011111455273 1.614293431469302e-06 0.3083651674074345 1.614293625269522e-06 0.3052406640298299 1.614293829186134e-06 0.3019773030815858 \
1.614294008255468e-06 0.2991336297844484 1.614294243846324e-06 0.2954229173226265 1.614294444650423e-06 0.2922868215109002 1.614294645829315e-06 0.2891696385850206 \
1.614294869639057e-06 0.2857334090862961 1.614295034201803e-06 0.2832271910241367 1.614295211129189e-06 0.2805503385691353 1.614295396922194e-06 0.2777610713150803 \
1.61429557873767e-06 0.2750538970423583 1.614295757762463e-06 0.2724132377985424 1.614295925107616e-06 0.2699606650006489 1.614296085536534e-06 0.2676371805838822 \
1.614296208110286e-06 0.2658719571410424 1.614296357874814e-06 0.2637236906090554 1.61429648557194e-06 0.2619099339733745 1.614296592880312e-06 0.2603957336038235 \
1.614296708880974e-06 0.2587625259947361 1.614296819189571e-06 0.2572125806747212 1.614296945068767e-06 0.2554509781935611 1.614297060550618e-06 0.2538402638894013 \
1.614297195131521e-06 0.2519757335310172 1.614297307194775e-06 0.2504255755821768 1.614297457534135e-06 0.2483447107137444 1.614297597159989e-06 0.2464124269747185 \
1.61429774305181e-06 0.2444035064209518 1.614297876012448e-06 0.2425734862730615 1.614297999574161e-06 0.2408709992523319 1.614298146783853e-06 0.2388417729476062 \
1.614298263370682e-06 0.2372355665500016 1.614298402825832e-06 0.23532008003217 1.614298537000301e-06 0.2334768281602104 1.614298662976757e-06 0.2317465561243653 \
1.614298782376161e-06 0.2301094434087779 1.614298877230585e-06 0.2288105340759602 1.614298990368185e-06 0.2272617792622066 1.614299070684642e-06 0.2261626001158484 \
1.614299158249699e-06 0.2249657246820506 1.614299283786836e-06 0.2232507767215072 1.614299389480543e-06 0.2218101326756785 1.614299479135054e-06 0.2205921574607158 \
1.614299549986253e-06 0.2196300825522397 1.614299593014783e-06 0.2190460135436258 1.614299635305326e-06 0.2184724035808872 1.614299677647042e-06 0.2178984240735344 \
1.614299749842462e-06 0.2169203674089526 1.614299792235817e-06 0.2163464205126744 1.614299827490656e-06 0.2158693585303403 1.61429987168224e-06 0.2152716287340076 \
1.614299941290466e-06 0.2143309212991285 1.614299975633797e-06 0.2138672544767182 1.614300020093325e-06 0.2132698436071631 1.614300087771806e-06 0.2123628126304402 \
1.614300174199065e-06 0.2112058698236149 1.614300248835667e-06 0.2102078598594563 1.614300330137676e-06 0.2091219706754807 1.61430042701506e-06 0.2078300362310651 \
1.614300552998548e-06 0.2061528795789772 1.614300655533384e-06 0.2047906894256944 1.614300757016902e-06 0.2034500128132261 1.614300858082597e-06 0.202119416354989 \
1.614300954696817e-06 0.2008491615811921 1.61430105666124e-06 0.1995112314821507 1.614301163383484e-06 0.1981153840927639 1.614301271788624e-06 0.1967018790395962 \
1.61430138378278e-06 0.1952465002768531 1.614301496249907e-06 0.1937897263683151 1.614301608323246e-06 0.1923454332378671 1.614301716215721e-06 0.1909603537828802 \
1.61430181759865e-06 0.1896629368444172 1.614301909236099e-06 0.1884941330679491 1.614302003211707e-06 0.1872990757663449 1.614302074478072e-06 0.1863957871745983 \
1.61430215115336e-06 0.1854271890400033 1.614302254812475e-06 0.184122202819407 1.614302328479595e-06 0.1831974022686171 1.614302401825496e-06 0.1822796569444652 \
1.614302515215845e-06 0.1808667181969195 1.614302603074485e-06 0.1797760932362061 1.614302686923162e-06 0.1787387947787487 1.61430281588559e-06 0.1771515524267008 \
1.614302917772084e-06 0.1759040172436072 1.614303023472791e-06 0.1746156056808686 1.614303125120866e-06 0.1733818993219825 1.614303255982584e-06 0.1718019019596718 \
1.614303363179222e-06 0.1705140034701537 1.614303492508118e-06 0.168969083715685 1.61430360420461e-06 0.167642098072289 1.614303704535189e-06 0.1664555496840579 \
1.614303800335743e-06 0.1653276075899142 1.614303911148015e-06 0.1640289617085985 1.614303998548296e-06 0.1630090521997956 1.614304109869413e-06 0.1617156184952586 \
1.614304202821272e-06 0.1606409001560029 1.61430429039415e-06 0.1596330843918451 1.614304392025023e-06 0.1584700928658864 1.614304476479078e-06 0.1575086241734052 \
1.614304551583458e-06 0.1566573095634876 1.6143046294057e-06 0.1557789554714152 1.614304709763569e-06 0.1548759612316424 1.614304810818399e-06 0.1537464547857493 \
1.614304893251963e-06 0.1528311848879565 1.614304985556514e-06 0.1518114053368895 1.614305062490987e-06 0.150965812476358 1.614305145413558e-06 0.1500585909391909 \
1.614305216944298e-06 0.1492793026301012 1.614305313327797e-06 0.1482344968214558 1.614305383556283e-06 0.1474766665551334 1.614305466536561e-06 0.1465853655470201 \
1.614305527978825e-06 0.1459298106834085 1.614305599661209e-06 0.1451677491870439 1.614305668289752e-06 0.1444408762699853 1.614305718558262e-06 0.1439102090153988 \
1.614305766138067e-06 0.143409423336876 1.614305820187418e-06 0.1428423132663369 1.614305879529516e-06 0.1422216078256897 1.614305947564923e-06 0.1415124633834424 \
1.614306023828345e-06 0.1407207186008814 1.614306092108145e-06 0.1400161356079559 1.614306186894323e-06 0.1390460813732662 1.614306276448135e-06 0.1381341561933974 \
1.614306348133609e-06 0.1374075731330657 1.614306432085018e-06 0.1365606113096345 1.614306497397473e-06 0.1359045398875483 1.614306558840598e-06 0.1352895588344758 \
1.614306633117097e-06 0.1345490408254265 1.614306695327357e-06 0.1339328028964004 1.614306763298366e-06 0.133265236037424 1.614306822505406e-06 0.1326856657519672 \
1.614306895177878e-06 0.1319767402814105 1.614306970197988e-06 0.1312477270463112 1.614307055651411e-06 0.1304208267333309 1.61430714175175e-06 0.1295914604616623 \
1.614307241877205e-06 0.1286317929389105 1.614307323166875e-06 0.127857435971709 1.614307424934223e-06 0.1268981149578782 1.614307509182182e-06 0.1261072369695883 \
1.614307607998911e-06 0.1251836587365037 1.614307680839456e-06 0.1245055382686853 1.614307760865543e-06 0.1237631876254407 1.614307831351338e-06 0.1231117958237987 \
1.614307903881761e-06 0.1224439308288319 1.614307981350756e-06 0.1217331219782777 1.614308088702104e-06 0.1207554316575004 1.61430818934012e-06 0.1198442997624752 \
1.614308261927674e-06 0.1191899427853172 1.614308330759514e-06 0.1185715582611356 1.614308396546334e-06 0.1179824683205609 1.614308466175132e-06 0.1173610347366148 \
1.614308536558877e-06 0.1167350538439435 1.61430861173725e-06 0.1160688810594495 1.614308715991485e-06 0.1151493019715505 1.614308791126139e-06 0.114489769343061 \
1.614308860041223e-06 0.1138870655592168 1.614308923246095e-06 0.1133369146236164 1.61430899278746e-06 0.1127339156958381 1.614309050088964e-06 0.1122385190692166 \
1.614309121730019e-06 0.1116210355509516 1.614309179565093e-06 0.1111240709857579 1.614309251686527e-06 0.1105063809580559 1.61430931410261e-06 0.1099736279351742 \
1.614309398424132e-06 0.1092565349771765 1.6143094660201e-06 0.1086842173446869 1.614309574816032e-06 0.1077671916889585 1.614309679126564e-06 0.1068924975608609 \
1.614309758614772e-06 0.1062289053282379 1.614309846183183e-06 0.1055008617114655 1.614309909639535e-06 0.1049752776433979 1.614309971350652e-06 0.10446579874651 \
1.614310075190416e-06 0.103612238268202 1.614310157871118e-06 0.1029362225408096 1.614310256339144e-06 0.1021348761715451 1.614310340785582e-06 0.101450818648051 \
1.614310457263062e-06 0.1005121841703865 1.614310591996508e-06 0.09943411943161744 1.614310728066045e-06 0.0983541971400249 1.614310842385452e-06 0.09745369041838402 \
1.614310927852596e-06 0.09678457778867394 1.614311038134269e-06 0.09592640631053104 1.614311118922622e-06 0.09530159220710262 1.614311218473494e-06 0.09453592511176086 \
1.614311308421543e-06 0.09384821103094763 1.614311380924943e-06 0.09329669945188329 1.614311462667009e-06 0.09267796846073476 1.614311590787245e-06 0.09171467366828615 \
1.614311672199308e-06 0.09110674702409056 1.614311746631215e-06 0.09055373306570065 1.614311821605099e-06 0.08999936228352182 1.614311901024075e-06 0.08941505746347288 \
1.614312009684932e-06 0.08862052380504259 1.614312104044904e-06 0.08793517800096999 1.614312193440026e-06 0.08728987318634121 1.614312300205743e-06 0.086524181682867 \
1.614312418708183e-06 0.08568073755029131 1.614312560233253e-06 0.08468224831562859 1.614312693371676e-06 0.08375174214918565 1.614312834217007e-06 0.08277682112810406 \
1.614312983268988e-06 0.08175525972387458 1.614313119066718e-06 0.08083369778093191 1.614313260523232e-06 0.0798830809748103 1.614313395783148e-06 0.07898330517332906 \
1.614313537164988e-06 0.07805242629322809 1.614313684232761e-06 0.07709434677344783 1.614313835960902e-06 0.07611680364043326 1.614314001309203e-06 0.07506403321855706 \
1.614314165176721e-06 0.07403332863189842 1.614314341490649e-06 0.07293832728335037 1.614314530925751e-06 0.07177777688466977 1.614314741692455e-06 0.07050569389938771 \
1.614314961464952e-06 0.06920150027616521 1.614315196433104e-06 0.06783224552442871 1.614315455333654e-06 0.06635227408830123 1.614315750264117e-06 0.06470266364809808 \
1.614316054610178e-06 0.06304001691994518 1.614316416556457e-06 0.06111393619706453 1.614316732684213e-06 0.05947639552636011 1.614317174006677e-06 0.0572596911373907 \
1.61431748757272e-06 0.05573556853365672 1.614317911072189e-06 0.0537382660685313 1.614318255024043e-06 0.05216649213267931 1.61431859526531e-06 0.05065508790922631 \
1.6143189061029e-06 0.04931137323461653 1.614319200574802e-06 0.04807062469528345 1.614319494274299e-06 0.04686392507224969 1.614319769145536e-06 0.04576537019482012 \
1.614320044685701e-06 0.04468949010490332 1.61432030977623e-06 0.04367785045825667 1.614320586533311e-06 0.04264571401740119 1.614320869801436e-06 0.04161414314527601 \
1.614321167794735e-06 0.04055545327485047 1.614321427280131e-06 0.03965542606183669 1.614321657303569e-06 0.03887446236327848 1.614321876995156e-06 0.03814321686473518 \
1.614322101935296e-06 0.0374128399305801 1.61432242218897e-06 0.0363978329183388 1.61432270998682e-06 0.03550963653148703 1.614322986382154e-06 0.03467738358988744 \
1.614323270201283e-06 0.03384352473043348 1.614323508310587e-06 0.03315996078327022 1.614323792621371e-06 0.03236211345273886 1.614324034533221e-06 0.03169864947531036 \
1.614324269673395e-06 0.03106710921041438 1.614324511380923e-06 0.03043352335444016 1.614324748333857e-06 0.02982731501219571 1.614324978676274e-06 0.02925002048968134 \
1.614325192426852e-06 0.02872465224286764 1.614325398273815e-06 0.02822791768061097 1.614325790610838e-06 0.02730524204782691 1.614325979002849e-06 0.02687312495148303 \
1.614326354614307e-06 0.02603163971789 1.614326529081082e-06 0.02564950258131362 1.614326953015541e-06 0.02474274850847508 1.614327073769958e-06 0.02449086781212801 \
1.614327544020722e-06 0.02353384026002922 1.614327693235787e-06 0.02323677291035493 1.614328086867998e-06 0.02246740853134286 1.614328257894343e-06 0.02213909006726131 \
1.614328745173274e-06 0.02121869533024997 1.614328887220983e-06 0.02095326544309953 1.614329420237252e-06 0.01997576278857772 1.614329542401289e-06 0.01975737097014436 \
1.614330064559033e-06 0.01885981776906158 1.614330235137336e-06 0.01857989792133653 1.614330722450399e-06 0.01781360777737795 1.614330893973323e-06 0.01755501440977742 \
1.61433151376008e-06 0.01666567753024489 1.614331684684406e-06 0.0164316648397145 1.614332390235397e-06 0.01551160061118263 1.614332552852409e-06 0.01530799450170666 \
1.6143333097459e-06 0.01439879525764199 1.614333450662544e-06 0.01423641007536438 1.614334350661384e-06 0.01324361033368418 1.614334438010635e-06 0.01315122959105692 \
1.614335342363989e-06 0.01223321097894121 1.614335479555938e-06 0.01209984223734439 1.614336450212214e-06 0.01118944790767422 1.614336578130092e-06 0.01107451071402888 \
1.614337728540039e-06 0.01011008206277823 1.614337822342075e-06 0.01003687265682024 1.614339078387888e-06 0.009120584045805383 1.614339215929201e-06 0.009026502753623255 \
1.614340774683602e-06 0.008029670037698805 1.614340858486287e-06 0.007977066150721189 1.614342463865106e-06 0.00699828665725172 1.61434257476345e-06 0.006935886594503895 \
1.614344507009824e-06 0.005959177461785255 1.61434468671476e-06 0.005876661013304485 1.614346798505876e-06 0.004981749118765498 1.614347141291012e-06 0.004848482978762325 \
1.614349654457045e-06 0.003966891390423618 1.614350124178715e-06 0.003819799497680527 1.61435376449499e-06 0.002847564273158896 1.614354280232175e-06 0.002731633924241866 \
1.614359622062014e-06 0.001773027297371861 1.614359907382299e-06 0.001729522787584184 1.614365136030129e-06 0.0007540451492352357 1.614365310176696e-06 0.0007162692714263865 \
1.617013698769002e-06 -0.0001123232525192561 1.61701387179429e-06 -0.0002901710972538241 1.617014491546045e-06 -0.001202022686018724 1.617014580115222e-06 -0.001365806793032466 \
1.617014941086355e-06 -0.002110727959526865 1.61701506578065e-06 -0.002395793696299351 1.617015429622531e-06 -0.003299857180474864 1.6170156008982e-06 -0.003758114451912169 \
1.617015894896038e-06 -0.004576312838821549 1.617016005104443e-06 -0.004886880824040592 1.617016283358441e-06 -0.005643955697619643 1.61701640463225e-06 -0.00594200199557267 \
1.617017498254348e-06 -0.00517389603226481 1.617017621358228e-06 -0.004409713243767066 1.617017744826303e-06 -0.003462788751204457 1.6170178649921e-06 -0.002366010162083454 \
1.617017962853768e-06 -0.001346276287748183 1.617018069556104e-06 -0.0001076498664581183 1.617018181397488e-06 0.001328007358939307 1.617018317371855e-06 0.003256083960376262 \
1.617018439401011e-06 0.00514709866632534 1.617018627817289e-06 0.008343062029134115 1.617018768805819e-06 0.01093380316938193 1.617018921577523e-06 0.01391176330477175 \
1.617019064280151e-06 0.01683596409946878 1.617019218632388e-06 0.02013443377634912 1.617019374426043e-06 0.02358734537610087 1.61701953048334e-06 0.02715365164079262 \
1.61701967788774e-06 0.03060642997674319 1.617019826504485e-06 0.03415780069914553 1.617019981925702e-06 0.03793559522944389 1.617020140311532e-06 0.04184227512730877 \
1.617020305251154e-06 0.04596085539464361 1.617020479500423e-06 0.05035714787605008 1.617020658443539e-06 0.05491177248689325 1.617020847583032e-06 0.0597604232635115 \
1.61702105036361e-06 0.06498910043066243 1.617021269735637e-06 0.07067233091134768 1.617021500572133e-06 0.07667464705993039 1.617021747383969e-06 0.0831083675499642 \
1.61702201751608e-06 0.09016243555275107 1.617022310704188e-06 0.0978236474935409 1.617022634359626e-06 0.1062798466079799 1.617022997926912e-06 0.1157689210849182 \
1.61702339022043e-06 0.1259925151671456 1.617023838699915e-06 0.1376538644086695 1.6170243603994e-06 0.1511757390224034 1.617024972772044e-06 0.1669844191341421 \
1.617025649417359e-06 0.1843663871188266 1.61702643632765e-06 0.2044554566749352 1.617027317548744e-06 0.2267919980918504 1.617028137292384e-06 0.2474048556006221 \
1.617028865745329e-06 0.2655829647002126 1.617029507221317e-06 0.2814688958417333 1.617030083144486e-06 0.2956305456066151 1.617030620401302e-06 0.3087428400511723 \
1.617031124292597e-06 0.3209487846516751 1.617031601896145e-06 0.3324328152479784 1.617032080019379e-06 0.343838772307344 1.617032532118229e-06 0.3545331600964184 \
1.617033003884519e-06 0.365596737404158 1.61703344758136e-06 0.3759140547845509 1.617033969549898e-06 0.3879344734281669 1.617034497087831e-06 0.399956933836353 \
1.617034876602574e-06 0.4085271910771138 1.617035405564175e-06 0.4203606102508351 1.617035874883256e-06 0.4307444005277802 1.617036310038791e-06 0.4402814026247405 \
1.617036757516117e-06 0.4500002273945978 1.617037197539592e-06 0.4594737646471725 1.617037600841335e-06 0.4680814138276727 1.617037919241101e-06 0.4748254127722248 \
1.617038289219015e-06 0.4826007100982719 1.617038525472097e-06 0.4875314737878706 1.617038760543493e-06 0.4924129045770672 1.617039011882831e-06 0.4975994385012801 \
1.617039318269866e-06 0.5038799449729535 1.617039575228319e-06 0.5091120301871851 1.617039783702615e-06 0.5133309170973237 1.617039984084905e-06 0.5173683849445317 \
1.617040126478606e-06 0.5202244049244739 1.617040275403072e-06 0.5231993726577677 1.617040486949329e-06 0.5274019882470222 1.617040713006952e-06 0.5318780389403845 \
1.617040907549333e-06 0.5357103559602913 1.617041096681229e-06 0.539423417888626 1.617041326128277e-06 0.5439012399750046 1.617041508634083e-06 0.5474563135343053 \
1.617041745996952e-06 0.5520623276458133 1.61704201499126e-06 0.5572695987004129 1.61704226390171e-06 0.5620706638085723 1.617042507918531e-06 0.5667633705755619 \
1.617042780273744e-06 0.5719926523718327 1.617043041669874e-06 0.5769928369418796 1.617043299301279e-06 0.5819084237686675 1.617043546144628e-06 0.586601202059797 \
1.617043791890354e-06 0.5912552023551558 1.617044018467874e-06 0.5955288021520931 1.617044249620064e-06 0.5998646534936181 1.617044455900444e-06 0.6037202012184053 \
1.617044684021204e-06 0.6079592993751251 1.617044906401185e-06 0.6120725203834017 1.617045133377667e-06 0.6162454422471376 1.617045348430617e-06 0.6201823359462864 \
1.61704557780019e-06 0.6243500782103125 1.617045846823065e-06 0.6292041961704016 1.617046069836712e-06 0.6331993632081415 1.617046282091289e-06 0.6369772451758789 \
1.617046493488879e-06 0.6407176358819484 1.617046693558109e-06 0.644236566349866 1.617046923151959e-06 0.6482486956559365 1.617047163988886e-06 0.6524328529570182 \
1.617047345738273e-06 0.6555667906748446 1.6170475342865e-06 0.6588018260593631 1.61704768736614e-06 0.6614154033769962 1.617047859374421e-06 0.6643352515471471 \
1.61704800954724e-06 0.6668697017322168 1.617048146064529e-06 0.6691578850264722 1.617048295693716e-06 0.6716547631652277 1.617048423434085e-06 0.673777752640997 \
1.617048563020223e-06 0.6760856948620949 1.61704868725891e-06 0.6781310478824312 1.61704881840875e-06 0.6802827752320969 1.617048942850093e-06 0.6823179209931315 \
1.617049080080916e-06 0.6845542421253382 1.617049200329086e-06 0.6865048414796368 1.61704934166053e-06 0.6887891282595083 1.617049441991641e-06 0.6904033553735033 \
1.617049563109343e-06 0.6923460943304175 1.617049653886878e-06 0.6937948943079848 1.617049751145344e-06 0.6953408241330762 1.617049847353224e-06 0.6968660703265798 \
1.617049935967068e-06 0.6982647859968389 1.617050033255091e-06 0.6997938110311075 1.617050165723729e-06 0.7018622871835729 1.617050320913928e-06 0.7042674555997347 \
1.617050458791879e-06 0.7063866855441746 1.617050603646153e-06 0.7085960165693863 1.61705073070791e-06 0.7105202221428537 1.61705085539347e-06 0.7123960184768648 \
1.617050968098846e-06 0.7140814553427599 1.617051079889191e-06 0.7157437310299281 1.61705118066784e-06 0.7172341607972841 1.617051317946296e-06 0.7192525454101454 \
1.617051437630367e-06 0.7210013704967912 1.617051557059838e-06 0.7227365757678518 1.61705168394306e-06 0.7245692610776365 1.617051808360712e-06 0.7263556789600311 \
1.617051932093537e-06 0.728121726658988 1.617052058689064e-06 0.7299181396522603 1.617052189074464e-06 0.7317573312219798 1.617052311884284e-06 0.7334798522758219 \
1.61705244732006e-06 0.7353678990088863 1.617052548609838e-06 0.7367723836293941 1.617052656232334e-06 0.7382576460517265 1.617052745760416e-06 0.7394878879617913 \
1.617052860308785e-06 0.7410528648863303 1.617052948337041e-06 0.7422487366778059 1.617053055415107e-06 0.7436953530868765 1.6170531854801e-06 0.7454403311053276 \
1.617053296759795e-06 0.7469230742113165 1.617053401378355e-06 0.7483084058091373 1.61705352546134e-06 0.7499400420429273 1.617053673762168e-06 0.7518749696944975 \
1.617053795162033e-06 0.7534462209622173 1.61705390960278e-06 0.7549170836379747 1.617054049940098e-06 0.7567069362027918 1.617054191702981e-06 0.7584995177563068 \
1.617054309503919e-06 0.759977341175643 1.617054437480785e-06 0.761570846386187 1.617054579183209e-06 0.7633205808366864 1.617054696694523e-06 0.7647599110190483 \
1.617054842299792e-06 0.7665289162262866 1.617054963994099e-06 0.7679951561698679 1.617055082724709e-06 0.7694149786178283 1.617055205011304e-06 0.7708662727382939 \
1.61705533205582e-06 0.77236234268503 1.617055441699792e-06 0.7736439866494906 1.617055567386705e-06 0.7751025186690397 1.617055673401805e-06 0.776323977486031 \
1.617055808987772e-06 0.7778743028704433 1.617055933950769e-06 0.7792913979962601 1.617056059856921e-06 0.7807070123991936 1.617056175124167e-06 0.7819915514687489 \
1.61705628142864e-06 0.7831664991275713 1.617056419833432e-06 0.7846822315516878 1.617056569129882e-06 0.7862997378875561 1.617056714637328e-06 0.7878588534534761 \
1.617056834041839e-06 0.7891257303126159 1.617056969134663e-06 0.7905455128963393 1.617057090387826e-06 0.7918076974797237 1.617057233381105e-06 0.7932816011184505 \
1.617057377585411e-06 0.7947523458802197 1.617057503122239e-06 0.7960199014141693 1.617057622168612e-06 0.7972110037065316 1.617057734104495e-06 0.7983213107123885 \
1.617057838976047e-06 0.7993531099923881 1.617057934226459e-06 0.8002831901653534 1.617058070569705e-06 0.8016020813281191 1.617058187393835e-06 0.8027203407102198 \
1.617058306798445e-06 0.803852171037294 1.617058428905249e-06 0.8049980820693966 1.617058551860251e-06 0.8061401395390313 1.617058678828951e-06 0.8073073595000361 \
1.61705880406856e-06 0.8084467645495962 1.617058934640955e-06 0.8096220968518901 1.617059060631473e-06 0.8107441738369082 1.617059188817386e-06 0.8118738099374113 \
1.617059294347114e-06 0.8127947795787664 1.617059397218887e-06 0.8136847278655364 1.617059490214057e-06 0.8144826950388273 1.61705961401066e-06 0.8155354283166244 \
1.617059701978917e-06 0.8162769513478326 1.617059800709989e-06 0.8171027376706747 1.617059943975142e-06 0.8182889948057973 1.617060079253827e-06 0.8193962136425846 \
1.61706018836845e-06 0.8202800249700468 1.617060336451758e-06 0.8214657808291811 1.617060486222685e-06 0.8226492530953341 1.617060611457285e-06 0.8236267526687548 \
1.617060755448703e-06 0.8247372275730155 1.617060879504774e-06 0.8256825756473101 1.617061029968032e-06 0.8268152483647575 1.617061165678884e-06 0.8278240064655301 \
1.617061290697392e-06 0.828742521381556 1.617061408452322e-06 0.8295983347934622 1.617061554429135e-06 0.8306466023667578 1.617061720938452e-06 0.8318251482734692 \
1.617061851861028e-06 0.8327390940956469 1.617062025288466e-06 0.8339327615268647 1.617062193435348e-06 0.8350717495747054 1.617062363270277e-06 0.8362042975620877 \
1.617062544195048e-06 0.8373912937861997 1.617062687293307e-06 0.8383160748488641 1.617062801379198e-06 0.8390446117604563 1.617062931553184e-06 0.8398665237782376 \
1.617063033394267e-06 0.8405024977857931 1.617063150213615e-06 0.8412243379523001 1.617063287078045e-06 0.8420597162999857 1.617063484876669e-06 0.8432475311273343 \
1.61706367648074e-06 0.8443767279905872 1.617063885921222e-06 0.8455874169714939 1.617064067846852e-06 0.8466193100105236 1.617064264979958e-06 0.8477171434207121 \
1.617064438329848e-06 0.8486653666163242 1.617064621329232e-06 0.8496493024239481 1.617064792495495e-06 0.8505537352954988 1.617064967127282e-06 0.8514606693963016 \
1.617065142389669e-06 0.8523550102558151 1.617065318541785e-06 0.8532381479010797 1.617065508812824e-06 0.8541746551565574 1.617065699414775e-06 0.85509499218684 \
1.617065900062401e-06 0.8560449689899254 1.617066092672966e-06 0.8569390259424264 1.617066303330652e-06 0.8578972157030333 1.617066531456051e-06 0.8589122247267402 \
1.617066797213369e-06 0.8600655879592763 1.617067095837813e-06 0.8613244245924475 1.617067372169332e-06 0.862454900702886 1.617067656402391e-06 0.8635842083919951 \
1.617067930614306e-06 0.8646423892283146 1.617068202842372e-06 0.8656634505877856 1.617068473051191e-06 0.8666487272755322 1.617068730204067e-06 0.8675609437488442 \
1.617069002786335e-06 0.868501515423508 1.617069278771335e-06 0.8694269133137555 1.617069548872912e-06 0.8703069289141475 1.617069848734863e-06 0.8712546000783432 \
1.617070219768993e-06 0.8723856543073821 1.617070514706754e-06 0.8732530157608677 1.617070768997536e-06 0.8739790309043101 1.617071067254951e-06 0.8748056771600844 \
1.617071340863485e-06 0.8755409825400007 1.61707157699155e-06 0.8761583495732972 1.61707181733693e-06 0.876770807053994 1.617072039670212e-06 0.8773233906735478 \
1.61707223367596e-06 0.8777948466981503 1.617072563398506e-06 0.8785737911727464 1.617072718571944e-06 0.8789308835864816 1.617073036347473e-06 0.8796437246174529 \
1.61707321520917e-06 0.8800342982281311 1.617073557671047e-06 0.8807611334253193 1.617073741799519e-06 0.8811407335605206 1.617074216677857e-06 0.8820849466541889 \
1.617074384074053e-06 0.8824061830950772 1.617074849915456e-06 0.8832696475595492 1.617075030737665e-06 0.8835931319180218 1.617075524775914e-06 0.8844450822729043 \
1.617075666124327e-06 0.8846804878101884 1.617076272457385e-06 0.8856498028150036 1.617076424526725e-06 0.8858829444029697 1.6170770712152e-06 0.8868329272509302 \
1.617077199509723e-06 0.8870138524519416 1.617077847626928e-06 0.8878919388991984 1.617077977425792e-06 0.8880607713689423 1.617078755627481e-06 0.8890227771434612 \
1.617078870684414e-06 0.8891574578072456 1.617079726342848e-06 0.8901003239091128 1.617079871707616e-06 0.8902505899439886 1.61708085746403e-06 0.8911948786459364 \
1.61708107856904e-06 0.8913892999646706 1.617082223696019e-06 0.8923206810037944 1.617082354912619e-06 0.892422953350996 1.617083696124267e-06 0.8934189515818408 \
1.617083847523211e-06 0.8935240845833778 1.617085328961459e-06 0.8944568913393511 1.617085567840892e-06 0.8945912088657246 1.617087337161074e-06 0.8954685138428928 \
1.617087726310841e-06 0.895637400736999 1.617090119976628e-06 0.896526474291006 1.61709059568945e-06 0.8966764365754722 1.617094011699057e-06 0.8975478548673914 \
1.617094658849072e-06 0.8976786076740833 1.617102137013678e-06 0.8986646932675814 1.617102809590796e-06 0.8987192862546014 1.617195253995367e-06 0.8997188196574962 \
1.617195917228051e-06 0.8997241906476866 1.617385126389945e-06 0.900686595210158 1.617385288462789e-06 0.9007292695325627 1.617387933983676e-06 0.8998161167154269 \
1.617388102533154e-06 0.8996881690130656 1.617389379285545e-06 0.8987393243250013 1.617389581451881e-06 0.8986030018074492 1.617391189561267e-06 0.8976721249252815 \
1.617391381667193e-06 0.8975774045828077 1.617406495049839e-06 0.8985726115129884 1.617406683108756e-06 0.8986004060702872 1.617417988037768e-06 0.8995874924221801 \
1.617418361423516e-06 0.8996034751727418 1.617907373786698e-06 0.9005892719715856 1.617907484554898e-06 0.9006868984798269 1.617908237227259e-06 0.9015617873136611 \
1.617908339021945e-06 0.9017086238768567 1.61790887442049e-06 0.9025814930725723 1.617908976929663e-06 0.9027670217776843 1.617909369148482e-06 0.9035254014384071 \
1.617909509991429e-06 0.9038129158713877 1.617909951028881e-06 0.9047472953155866 1.617910136514484e-06 0.9051402477015744 1.617910652827601e-06 0.9061269394579334 \
1.617910737502694e-06 0.9062564181617988 1.617911972174744e-06 0.9053011091537977 1.617912129388156e-06 0.9045688862145235 1.617912321204818e-06 0.9034162411061901 \
1.617912488045348e-06 0.9021712267446264 1.617912635003746e-06 0.9008824031243315 1.617912749119943e-06 0.8997575350477262 1.617912878992032e-06 0.8983446880789033 \
1.61791299010955e-06 0.8970273815442567 1.617913082914029e-06 0.8958483937359277 1.617913171236719e-06 0.8946639786015808 1.617913274417478e-06 0.8932058048613533 \
1.617913366625414e-06 0.8918333298588224 1.61791345419561e-06 0.8904732289418564 1.617913568189077e-06 0.8886245408236838 1.617913729993501e-06 0.8858564722885236 \
1.617913914992118e-06 0.8825005184224666 1.617914107151785e-06 0.8788219124347386 1.617914308599139e-06 0.874780227084481 1.617914515009728e-06 0.8704697801294994 \
1.617914700181681e-06 0.8664790122147591 1.617914884689405e-06 0.862405115500708 1.617915057841297e-06 0.8585071391690239 1.617915242887321e-06 0.8542751393552932 \
1.617915420261525e-06 0.8501657390392787 1.617915597007955e-06 0.8460284987362284 1.617915763166606e-06 0.8421077870518131 1.617915925211044e-06 0.8382599993991456 \
1.617916091783925e-06 0.8342839555277276 1.617916250437662e-06 0.8304816347052207 1.617916441313687e-06 0.8258903812682129 1.617916616297259e-06 0.8216694867670907 \
1.617916786243393e-06 0.8175615830390965 1.617916951419568e-06 0.8135626411663678 1.617917124611674e-06 0.8093650119631921 1.617917295673877e-06 0.8052155696745213 \
1.617917463774914e-06 0.801136095357175 1.617917654109863e-06 0.7965156511928794 1.617917837691807e-06 0.7920591698039 1.617918045682732e-06 0.7870113041480956 \
1.617918268259242e-06 0.7816114142545842 1.617918457674258e-06 0.7770174196885687 1.617918650984654e-06 0.7723312127316435 1.617918794430241e-06 0.7688556734481145 \
1.617918943853591e-06 0.7652374066097742 1.617919063006063e-06 0.7623536300085233 1.617919175722545e-06 0.7596269484184472 1.617919284997451e-06 0.7569846861296079 \
1.617919421027209e-06 0.753697254849378 1.617919533823024e-06 0.750972995067179 1.61791965602098e-06 0.7480232093637929 1.617919767605753e-06 0.7453311011793381 \
1.617919892312216e-06 0.7423241425761796 1.617920046694167e-06 0.7386034578119585 1.617920213478233e-06 0.7345862494782525 1.617920430642921e-06 0.7293605768817599 \
1.61792062520351e-06 0.7246835946359503 1.617920785534396e-06 0.7208333202545074 1.617920960959999e-06 0.7166251500492028 1.617921150723573e-06 0.7120779400724765 \
1.617921339451897e-06 0.7075610435995559 1.617921521273265e-06 0.7032145396962334 1.617921705870676e-06 0.6988062725207448 1.617921842953811e-06 0.6955348514212173 \
1.61792199624205e-06 0.6918805091472418 1.617922191613795e-06 0.6872279990818534 1.617922347770547e-06 0.6835136309588888 1.617922505722766e-06 0.6797605476340507 \
1.61792270397403e-06 0.6750570282453686 1.617922897319928e-06 0.6704763548785364 1.617923133825274e-06 0.6648822204491218 1.617923320030378e-06 0.6604858901039825 \
1.617923557652698e-06 0.6548824851665868 1.617923744451452e-06 0.6504854738275335 1.617923925009212e-06 0.6462424706993735 1.617924088085156e-06 0.6424159959781919 \
1.617924232696721e-06 0.6390271817202816 1.617924373299071e-06 0.6357379642635244 1.617924500108657e-06 0.632774906490579 1.617924632245193e-06 0.6296924762754078 \
1.617924758489145e-06 0.6267508340255646 1.617924889752774e-06 0.6236963630311418 1.617925018850514e-06 0.6206978048938425 1.617925158276179e-06 0.6174624210713571 \
1.617925306646171e-06 0.6140261568477932 1.61792550120306e-06 0.6095278574984737 1.617925644648937e-06 0.6062198040692683 1.617925879109183e-06 0.6008245134060309 \
1.617926051007495e-06 0.5968818013610552 1.617926263928034e-06 0.5920102583789468 1.617926436394651e-06 0.5880775912131976 1.617926566719198e-06 0.5851108450968721 \
1.617926698275517e-06 0.5821241897920357 1.617926808505599e-06 0.5796262478458715 1.617926904159847e-06 0.5774603558442819 1.617927003393806e-06 0.5752182923213994 \
1.617927086311908e-06 0.5733484809858778 1.617927165227534e-06 0.5715706040143225 1.617927228156309e-06 0.5701535626562365 1.617927293664786e-06 0.5686800671140783 \
1.617927374150839e-06 0.5668736364148982 1.617927424016847e-06 0.5657560592102344 1.617927473205615e-06 0.5646541775062763 1.617927534675401e-06 0.5632780399140616 \
1.617927582596929e-06 0.5622058085646952 1.617927633441648e-06 0.5610687758404553 1.617927692541903e-06 0.5597501790023616 1.61792775115623e-06 0.5584442118409422 \
1.617927826782323e-06 0.5567607189607793 1.617927897341035e-06 0.5551915720267918 1.617927986471042e-06 0.5532116467156011 1.61792807569462e-06 0.5512351177508077 \
1.617928160998231e-06 0.5493490637975145 1.617928248625197e-06 0.5474138635528197 1.61792834562712e-06 0.545274424894262 1.617928449972891e-06 0.5429792414815097 \
1.617928566264316e-06 0.5404269323775457 1.617928672601932e-06 0.5380963700835184 1.617928784310815e-06 0.5356536306660374 1.617928896605295e-06 0.5332047801427824 \
1.617929023802854e-06 0.5304364255197962 1.617929146572528e-06 0.5277698476303582 1.617929288796925e-06 0.5246912237717902 1.617929425160057e-06 0.5217463069543907 \
1.617929577381123e-06 0.5184691491721333 1.617929737017329e-06 0.5150420887864461 1.617929912992522e-06 0.5112761258030903 1.617930101501109e-06 0.5072591542828934 \
1.61793030856769e-06 0.5028616940969075 1.617930533509662e-06 0.4981043078903621 1.617930784905619e-06 0.4928144328841237 1.617931021331185e-06 0.4878598554762091 \
1.617931318494919e-06 0.4816683149127979 1.617931609172211e-06 0.4756487143466775 1.617931917027196e-06 0.469313240945046 1.617932230852954e-06 0.4628991126846517 \
1.617932559994313e-06 0.4562163541974347 1.61793289337242e-06 0.4494927613461197 1.617933224999028e-06 0.4428490490857003 1.617933546548425e-06 0.4364504708187015 \
1.617933874224238e-06 0.4299742838549845 1.617934221843861e-06 0.4231546934710667 1.617934555065174e-06 0.4166645133789623 1.617934900974402e-06 0.4099771621835854 \
1.617935346388222e-06 0.4014400148089548 1.617935704178092e-06 0.3946500490499754 1.617936018334912e-06 0.3887397205534429 1.617936402745392e-06 0.3815756289527631 \
1.617936732720037e-06 0.3754830843203271 1.617937017930125e-06 0.3702633801070484 1.617937326220382e-06 0.3646649204592909 1.617937606017443e-06 0.3596257204303125 \
1.617937832011793e-06 0.3555880084110294 1.617938046849748e-06 0.3517755993421203 1.61793824528482e-06 0.3482769933469286 1.617938449224337e-06 0.3447071465415313 \
1.617938659760396e-06 0.3410461989361561 1.617938916734521e-06 0.3366091000429626 1.617939157995129e-06 0.3324763702393667 1.617939389568845e-06 0.3285420159269506 \
1.617939604222291e-06 0.3249208057821749 1.617939825046275e-06 0.3212218866489027 1.617940026292867e-06 0.3178749657716667 1.61794022938212e-06 0.3145250552959265 \
1.617940427226991e-06 0.3112865758726304 1.617940614079937e-06 0.3082497660855442 1.617940808016663e-06 0.3051208532403978 1.617941011761317e-06 0.30185834615803 \
1.617941190488583e-06 0.2990186060348319 1.617941428134378e-06 0.2952727068736475 1.617941627896611e-06 0.2921508861588616 1.617941829525427e-06 0.2890253490052915 \
1.617942054991886e-06 0.285561995332 1.617942221086285e-06 0.2830312764183137 1.617942399705387e-06 0.2803277612349699 1.617942581409588e-06 0.2775983111934518 \
1.617942770043305e-06 0.2747882307029562 1.617942947466508e-06 0.2721695222189568 1.617943124659646e-06 0.2695724116247911 1.617943284731561e-06 0.2672552081803913 \
1.617943405132239e-06 0.2655193337608355 1.617943552958303e-06 0.2633957862580221 1.617943681588075e-06 0.2615692882062232 1.617943783793659e-06 0.2601227034409412 \
1.617943902028939e-06 0.2584516051170885 1.6179440224823e-06 0.2567534139348401 1.617944146190618e-06 0.2550183706610066 1.617944264442643e-06 0.2533694204037282 \
1.617944392295773e-06 0.2515887492000971 1.617944512581604e-06 0.249915736161692 1.61794466526121e-06 0.2477917697339537 1.617944800173988e-06 0.2459264316518071 \
1.61794492881341e-06 0.2441493177932957 1.617945086528788e-06 0.2419705448111171 1.617945213210091e-06 0.2402201997919771 1.617945348536158e-06 0.2383592392624043 \
1.617945487448727e-06 0.2364550510890953 1.617945605221031e-06 0.2348405558720491 1.61794576449185e-06 0.2326580599570062 1.617945901013704e-06 0.2307878375452989 \
1.617946042245651e-06 0.2288626996658652 1.617946148058693e-06 0.2274220928889542 1.61794627840164e-06 0.2256484734765637 1.617946378112453e-06 0.2242944442559471 \
1.617946480933888e-06 0.2228991027388591 1.617946554349542e-06 0.2219046249368765 1.617946634181104e-06 0.2208265149641777 1.617946704228335e-06 0.2198809561195558 \
1.617946754631426e-06 0.2192009305305119 1.617946806883225e-06 0.2184966408607167 1.617946886120743e-06 0.2174292050927151 1.617946927964696e-06 0.2168658036437602 \
1.617946967304648e-06 0.216336351877609 1.617947010340058e-06 0.2157575332679269 1.617947054507484e-06 0.2151638767852215 1.617947128273224e-06 0.2141731338947761 \
1.617947163785221e-06 0.2136967174286463 1.617947211500021e-06 0.2130606706933813 1.617947272229561e-06 0.2122518321687151 1.617947340486787e-06 0.2113438957752176 \
1.617947413008566e-06 0.2103801801047663 1.617947485683193e-06 0.2094152724966429 1.617947593999181e-06 0.2079788886429202 1.617947691670323e-06 0.20668564243436 \
1.617947803221819e-06 0.2052110974836689 1.617947901757253e-06 0.2039136008387587 1.617948005250393e-06 0.2025572972554956 1.617948101152128e-06 0.2013021587886929 \
1.617948203780057e-06 0.1999606878451601 1.61794830660317e-06 0.1986207062101238 1.617948416722797e-06 0.1971897063011611 1.617948525418353e-06 0.1957815523781236 \
1.617948645095582e-06 0.1942360962608612 1.617948755373261e-06 0.192818053470401 1.617948863436481e-06 0.1914343471929882 1.617948988535148e-06 0.1898375077741012 \
1.617949078504982e-06 0.1886931806549971 1.617949157191935e-06 0.1876950225942949 1.617949234476806e-06 0.1867173468865102 1.617949320985383e-06 0.1856271834369256 \
1.617949419934593e-06 0.1843848109964498 1.617949490443458e-06 0.1835017733581451 1.617949561894511e-06 0.1826096997732476 1.617949667039846e-06 0.1813018727451555 \
1.617949746279476e-06 0.1803200401832796 1.61794982736337e-06 0.1793174195483187 1.61794992085531e-06 0.1781663090788374 1.617950021631285e-06 0.1769308188703378 \
1.617950171343388e-06 0.175105380089017 1.617950287132704e-06 0.1737009932372819 1.617950438138081e-06 0.1718807311127691 1.6179505492465e-06 0.1705485445502526 \
1.617950691372959e-06 0.168854666407182 1.617950809031379e-06 0.167460358327668 1.617950913935975e-06 0.1662230887079887 1.617951008998573e-06 0.1651069099307241 \
1.617951102429828e-06 0.1640147999883682 1.61795120347649e-06 0.1628388413495604 1.617951299823398e-06 0.1617223204899406 1.617951396975644e-06 0.1606011553546776 \
1.617951480024216e-06 0.1596469772300165 1.61795159006187e-06 0.1583897228513109 1.617951672364432e-06 0.1574542248873526 1.617951777364141e-06 0.156267858580057 \
1.61795185506021e-06 0.1553950893374849 1.617951937879689e-06 0.1544690878994293 1.617952019541594e-06 0.1535604570452941 1.617952108890884e-06 0.152571060794856 \
1.61795218460332e-06 0.1517364980793458 1.617952267165934e-06 0.1508307726525361 1.617952343747367e-06 0.1499942554682341 1.617952412035253e-06 0.1492531084507001 \
1.617952505402265e-06 0.1482449401818621 1.617952574555677e-06 0.1475015570698688 1.617952650180008e-06 0.1466917482325688 1.617952711729129e-06 0.1460354497178591 \
1.617952778977892e-06 0.1453208357145237 1.617952850039892e-06 0.1445684785944268 1.61795292553732e-06 0.143772322008306 1.61795298444886e-06 0.1431546944759192 \
1.61795306112247e-06 0.1423563022825049 1.617953141443211e-06 0.1415233898163201 1.61795321459452e-06 0.1407682091691316 1.617953308750941e-06 0.139800669784813 \
1.617953380355125e-06 0.1390684367429364 1.617953453815901e-06 0.1383201464810226 1.617953537327652e-06 0.1374732033664194 1.617953626806795e-06 0.1365744208092838 \
1.6179536918717e-06 0.1359252211013016 1.617953803997723e-06 0.1348115665849295 1.617953869183864e-06 0.1341670699454539 1.617953939222108e-06 0.1334770515823289 \
1.617953999527163e-06 0.1328849371768329 1.617954054537987e-06 0.1323464455745446 1.617954142654965e-06 0.1314871014507438 1.61795418344126e-06 0.131090685705856 \
1.617954287144011e-06 0.1300923774523848 1.61795433045658e-06 0.1296773144713907 1.617954391675178e-06 0.1290920262082728 1.617954436511897e-06 0.1286643765206081 \
1.617954524107923e-06 0.127831527987147 1.617954565661879e-06 0.1274377589706847 1.61795462552339e-06 0.1268718307679372 1.617954697367115e-06 0.1261946708524367 \
1.617954753579841e-06 0.1256664967939027 1.61795481606734e-06 0.125081039250218 1.617954890295323e-06 0.1243877959456236 1.617954964976328e-06 0.1236954937854857 \
1.617955052159541e-06 0.1228905551604285 1.617955120558092e-06 0.1222610287411191 1.617955201128775e-06 0.1215216597888775 1.617955282424256e-06 0.120778012781285 \
1.617955349340781e-06 0.1201677797529914 1.617955432157726e-06 0.1194156054679852 1.617955491346448e-06 0.1188799972037829 1.617955557267448e-06 0.1182853617472536 \
1.617955637141492e-06 0.1175675408705869 1.61795571363729e-06 0.1168828806096336 1.6179557950994e-06 0.1161574242846086 1.617955893570281e-06 0.1152852106851665 \
1.61795596868063e-06 0.114622623867465 1.61795607166842e-06 0.1137180076826871 1.617956145852371e-06 0.1130691786503039 1.617956243471825e-06 0.1122190343868764 \
1.61795633928278e-06 0.1113890351962442 1.617956435131205e-06 0.110562946039519 1.617956516069412e-06 0.1098685209805978 1.617956604452683e-06 0.1091134439098378 \
1.617956703052662e-06 0.108274944429282 1.617956775836866e-06 0.1076586405352824 1.617956865109775e-06 0.1069058608836731 1.617956927091788e-06 0.1063852406583179 \
1.617956989684956e-06 0.1058613310701875 1.617957074907104e-06 0.105150777260444 1.617957180369478e-06 0.1042758147594986 1.617957260199961e-06 0.1036167065755082 \
1.617957340914214e-06 0.1029530974056021 1.61795742352795e-06 0.1022768941101355 1.617957493972562e-06 0.1017026162492672 1.617957597231928e-06 0.1008648142128753 \
1.617957670072053e-06 0.1002767039768694 1.617957755712335e-06 0.09958839426015198 1.617957874514073e-06 0.09863954321822334 1.617957942151898e-06 0.09810250133474645 \
1.61795801190202e-06 0.09755100310752296 1.617958089237e-06 0.09694230106952094 1.617958181657254e-06 0.09621870517595056 1.617958253354782e-06 0.09566033062548993 \
1.617958339171942e-06 0.09499542738017568 1.617958441597192e-06 0.09420660575030523 1.617958534892083e-06 0.09349264652734962 1.617958631208556e-06 0.09276005482712441 \
1.617958708110818e-06 0.09217843893134048 1.617958801590805e-06 0.09147541043939374 1.617958880833232e-06 0.09088281005358793 1.617958995455426e-06 0.0900310686188453 \
1.617959125063686e-06 0.08907580221142102 1.617959258320877e-06 0.08810234090122065 1.617959402350766e-06 0.08705990691030199 1.61795955951891e-06 0.08593388720602639 \
1.617959709295387e-06 0.08487214151476249 1.617959871762979e-06 0.08373303262435308 1.617960014942984e-06 0.08273971668837025 1.617960167622107e-06 0.0816913199659166 \
1.617960301891878e-06 0.08077856892457436 1.617960443644156e-06 0.07982444400446118 1.617960578643816e-06 0.07892500874648442 1.617960720601214e-06 0.07798882638923543 \
1.617960867448644e-06 0.07703088995320664 1.617961019894053e-06 0.07604750978240994 1.617961185112776e-06 0.07499422991502351 1.617961349250621e-06 0.07396067809208305 \
1.617961526112024e-06 0.07286119333145537 1.61796171645358e-06 0.07169407515132428 1.617961927410093e-06 0.07042030845332216 1.617962147819232e-06 0.0691121699798517 \
1.617962383344393e-06 0.06773900533435212 1.617962643793767e-06 0.0662496528900723 1.617962939459177e-06 0.06459579389282195 1.617963244581463e-06 0.06292902455725519 \
1.617963609576024e-06 0.06098725515092194 1.617964004456839e-06 0.05894944116461652 1.617964410847493e-06 0.05692211719668253 1.617964826573035e-06 0.05491854459141238 \
1.617965189379358e-06 0.0532251207245777 1.617965533980648e-06 0.05166301626031383 1.61796584916051e-06 0.05027284652491828 1.617966144689875e-06 0.04900240867073854 \
1.617966442670383e-06 0.04775344010203557 1.617966718469173e-06 0.04662857640242725 1.617966997243768e-06 0.04551884372531381 1.617967261178638e-06 0.04449205559535935 \
1.617967537201377e-06 0.04344260531795661 1.61796781615763e-06 0.04240676967887352 1.617968129850963e-06 0.04127097799875453 1.61796836585125e-06 0.04043636567030678 \
1.617968621645988e-06 0.03955075129286261 1.617968881769487e-06 0.03867033103466553 1.61796915190476e-06 0.03778142289416799 1.617969431124747e-06 0.03688501536902895 \
1.617969712963396e-06 0.03600226561751176 1.617969989839066e-06 0.03515600409566183 1.617970268932665e-06 0.03432349610146775 1.617970501810273e-06 0.03364444121149882 \
1.617970785646989e-06 0.03283527291840588 1.617971025751924e-06 0.03216626441466421 1.617971265550746e-06 0.0315119836023277 1.61797150482792e-06 0.03087436846876356 \
1.617971740084942e-06 0.03026290129608995 1.617971971011964e-06 0.02967475842909434 1.617972186001007e-06 0.02913788335257221 1.61797258815546e-06 0.02816043724496065 \
1.617972786878278e-06 0.02768988489927659 1.617973160561295e-06 0.0268265706552881 1.617973347359617e-06 0.02640514011949098 1.617973694919304e-06 0.02563810810034544 \
1.617973816848767e-06 0.0253740445387235 1.617974199320208e-06 0.02456430406701914 1.617974370028237e-06 0.02421180751242828 1.617974827125621e-06 0.02328894863848502 \
1.617975012758007e-06 0.0229225623309489 1.61797537621526e-06 0.02221803970155307 1.617975596582613e-06 0.02179832126591805 1.61797605430897e-06 0.02093867417890744 \
1.617976189728599e-06 0.02068687731869814 1.617976719624047e-06 0.01972418011126781 1.617976838945017e-06 0.01951377505543128 1.617977404730696e-06 0.01856069823426573 \
1.617977569110437e-06 0.0182962226476828 1.617978187655734e-06 0.01735107502432094 1.617978357709933e-06 0.01710418363667701 1.617978889842166e-06 0.01636278834442301 \
1.617979086926142e-06 0.01610013864443424 1.617979810045215e-06 0.01517806887136661 1.617979974675381e-06 0.01497647803580381 1.617980723800768e-06 0.01409711804523418 \
1.61798085710012e-06 0.01394643716836554 1.617981717353759e-06 0.01301449210748497 1.617981852457379e-06 0.01287422877142914 1.61798279503482e-06 0.01193816285908547 \
1.617982958630574e-06 0.01178202925388569 1.617983959987201e-06 0.0108653384673985 1.617984097529988e-06 0.01074500730514941 1.617985319636371e-06 0.009765086624518643 \
1.617985426589084e-06 0.00968516078425012 1.617986830780577e-06 0.008707372520026449 1.617986935611284e-06 0.008639312158696611 1.617988470448246e-06 0.00767719340797631 \
1.617988565731548e-06 0.007617466071856052 1.617990174528868e-06 0.006680264535635283 1.617990308605608e-06 0.006609506832171614 1.617992405618559e-06 0.005610918814474722 \
1.617992636163191e-06 0.005510783990371394 1.617994959158435e-06 0.004586584533412417 1.617995440488638e-06 0.004413562233393853 1.617998278050269e-06 0.003511943147855551 \
1.617998822969955e-06 0.003360532104877318 1.618002947178352e-06 0.002408309874554541 1.618003490902011e-06 0.002305347543005144 1.618009362191237e-06 0.001333291345955189 \
1.618009605056421e-06 0.001286469439319215 1.618023932948772e-06 0.0002880570268237783 1.618024077507414e-06 0.0002853642807229123 1.620661356428513e-06 -0.0006859155495331031 \
1.62066149598365e-06 -0.000901903561740745 1.620662005077583e-06 -0.001859438188174024 1.620662094565085e-06 -0.002052812934985279 1.620662457959945e-06 -0.00291126965001638 \
1.620662548982016e-06 -0.003143482006111167 1.620662914420052e-06 -0.004127275145644371 1.620663024680619e-06 -0.004436819103926468 1.620663336727774e-06 -0.005309594399865315 \
1.620663439442621e-06 -0.005584800160857357 1.620663803290477e-06 -0.006384516484886619 1.620663968081209e-06 -0.006586298968823262 1.620664547677408e-06 -0.005791490933239759 \
1.620664722787551e-06 -0.004914057272375438 1.620664839479485e-06 -0.004132845175365214 1.620664966064091e-06 -0.003100877896798674 1.620665067873013e-06 -0.002132773363901063 \
1.620665188361723e-06 -0.0008283127610571584 1.620665278808799e-06 0.0002599396317828252 1.62066537669893e-06 0.001541559978017447 1.62066547576324e-06 0.002943971508909197 \
1.620665646570516e-06 0.005594911825788154 1.620665868338539e-06 0.00944046646559993 1.620666064242385e-06 0.01317281463966807 1.620666223123767e-06 0.01639870563256729 \
1.620666387552263e-06 0.01989779506365397 1.620666541918294e-06 0.02331070396473752 1.620666700690818e-06 0.02693200463312963 1.620666847428777e-06 0.03036422445567413 \
1.620666996052748e-06 0.0339113704936035 1.620667151667245e-06 0.03768995713197771 1.620667308909259e-06 0.04156499463828727 1.620667473802058e-06 0.04567927910670353 \
1.620667647221578e-06 0.05005184210758699 1.620667825915293e-06 0.05459761989277153 1.620668014531131e-06 0.05943075613080645 1.620668215431274e-06 0.06460909294799391 \
1.620668434888065e-06 0.0702927970720964 1.620668664434352e-06 0.07626037976612585 1.620668910133291e-06 0.08266408948881369 1.62066917869823e-06 0.08967663153997742 \
1.620669470040144e-06 0.09728936802005522 1.620669791708172e-06 0.1056939239977524 1.620670152022263e-06 0.1150987971742611 1.620670543001701e-06 0.1252892839303718 \
1.620670986416517e-06 0.1368209045172546 1.620671502729605e-06 0.1502062239570841 1.620672108934821e-06 0.16586000516691 1.620672780191848e-06 0.1831102247110778 \
1.620673559691505e-06 0.20301830483439 1.620674432001389e-06 0.2251413938832897 1.620675262336714e-06 0.2460320778586349 1.620675993667063e-06 0.264292249712138 \
1.620676641612843e-06 0.280346965484095 1.620677224923317e-06 0.29469740877147 1.620677760655584e-06 0.3077798509628869 1.620678263914169e-06 0.3199778888071559 \
1.62067874911767e-06 0.3316516836183861 1.620679228040376e-06 0.3430829066939081 1.620679674471008e-06 0.3536501814456421 1.620680148800718e-06 0.3647819492304352 \
1.620680597991712e-06 0.3752331958288908 1.62068108846397e-06 0.3865396207984229 1.620681617036723e-06 0.3985997842463301 1.620681988181062e-06 0.4069920784971888 \
1.620682515935418e-06 0.4188173133762567 1.620682978292178e-06 0.4290642331729484 1.620683450624318e-06 0.4394285229343968 1.620683932409041e-06 0.4498981261869666 \
1.620683965448159e-06 0.4506126593745911 1.620684003207152e-06 0.45142837879914 1.620684078725137e-06 0.4530572051633331 1.620684229761107e-06 0.4563088938659436 \
1.620684437280373e-06 0.460764549126051 1.620684625319184e-06 0.4647825567212808 1.620684844328398e-06 0.469441659996985 1.620685087159409e-06 0.4745824626509371 \
1.620685386935037e-06 0.4808894567257585 1.620685624728187e-06 0.4858624696070272 1.620685887949588e-06 0.4913374535260851 1.620686148847133e-06 0.4967277906005185 \
1.62068637840122e-06 0.5014431429135263 1.620686601461414e-06 0.506003872007333 1.620686803037404e-06 0.5100983586086808 1.620686951867463e-06 0.51310967141356 \
1.620687196178516e-06 0.5180317772556589 1.620687328783749e-06 0.5206893064287169 1.620687468140331e-06 0.5234717264876519 1.620687679105724e-06 0.5276623644271943 \
1.620687853979606e-06 0.5311266030493931 1.620688122027852e-06 0.5364094032095129 1.62068831705351e-06 0.5402319029111832 1.620688496615017e-06 0.5437361368949839 \
1.620688747571146e-06 0.5486228351952749 1.620689024979257e-06 0.5540035987981641 1.620689308928559e-06 0.5594901708581531 1.62068956456585e-06 0.5644152233389156 \
1.62068985554807e-06 0.570006772487656 1.620690115853754e-06 0.5749917787111524 1.620690384297874e-06 0.5801232573974072 1.620690627063004e-06 0.5847450403362237 \
1.620690883594205e-06 0.5896146675871002 1.620691109757648e-06 0.59388771440121 1.620691347099143e-06 0.5983512154742827 1.62069155648786e-06 0.6022720321566808 \
1.620691770260628e-06 0.6062574570422776 1.620692023713469e-06 0.6109557890491497 1.620692226567817e-06 0.6146943332140289 1.620692419372338e-06 0.6182333111593361 \
1.620692609677365e-06 0.6217090173923294 1.620692800335854e-06 0.6251694921350958 1.62069300291378e-06 0.6288260100903066 1.620693265662542e-06 0.6335359534764116 \
1.620693494630232e-06 0.6376100987349322 1.620693714577867e-06 0.6414991146358265 1.62069394026254e-06 0.6454625140719233 1.620694149149966e-06 0.6491091855837361 \
1.620694370803585e-06 0.652957810138281 1.620694555693011e-06 0.6561429680377227 1.620694745707565e-06 0.6594017273991298 1.620694895862686e-06 0.6619630641908443 \
1.620695070740593e-06 0.6649292185271485 1.62069521646131e-06 0.6673855496832628 1.620695352493842e-06 0.6696641287411549 1.620695500856121e-06 0.672138295335571 \
1.620695630303834e-06 0.6742883907026684 1.620695764169531e-06 0.6764996355878535 1.62069589251393e-06 0.6786115243545502 1.620696017902059e-06 0.6806677490053815 \
1.620696147367755e-06 0.6827843190971332 1.62069627834897e-06 0.6849171426143115 1.620696426722072e-06 0.6873221141612875 1.620696534784827e-06 0.6890667486235877 \
1.6206966633165e-06 0.6911333958680312 1.620696798756284e-06 0.6933004139195943 1.620696923690607e-06 0.6952876996714908 1.620697049447875e-06 0.6972799977491608 \
1.620697155963766e-06 0.6989584331773744 1.620697273081655e-06 0.7007929859467624 1.620697391621401e-06 0.7026383448210159 1.620697514924797e-06 0.704545102273978 \
1.620697618097696e-06 0.7061304255463237 1.620697769068859e-06 0.7084341141567283 1.620697885323065e-06 0.7101955266062138 1.620698015883454e-06 0.7121605601685687 \
1.620698134445982e-06 0.7139335830373704 1.620698240519852e-06 0.7155108922888329 1.620698340544792e-06 0.716990346352101 1.620698477870007e-06 0.719009255813789 \
1.620698596531362e-06 0.7207429633399333 1.620698718230586e-06 0.7225107522614664 1.620698843413151e-06 0.7243181860083944 1.620698965432965e-06 0.7260693242762759 \
1.620699093464719e-06 0.7278954552757622 1.620699217946458e-06 0.7296603419865877 1.620699346245781e-06 0.7314685590147565 1.620699473339584e-06 0.7332489547570846 \
1.620699599364423e-06 0.7350034830462163 1.62069970210311e-06 0.7364262918236342 1.620699816775856e-06 0.7380063527755659 1.620699898181918e-06 0.7391232259175492 \
1.620700017381438e-06 0.7407496908814458 1.620700110023778e-06 0.7420059782745783 1.620700248182835e-06 0.7438668850244906 1.620700379238335e-06 0.7456179978167152 \
1.620700509370502e-06 0.7473439783685625 1.620700614344577e-06 0.7487266533969134 1.620700753484419e-06 0.7505456565005918 1.620700907428719e-06 0.7525407731682957 \
1.620701029372999e-06 0.7541080835708853 1.620701176919359e-06 0.7559892974429111 1.620701298924537e-06 0.7575320275232224 1.620701447624467e-06 0.7593968175435225 \
1.620701581671092e-06 0.7610632318338031 1.620701703924347e-06 0.7625711443351471 1.620701816790257e-06 0.763953046884334 1.620701959641225e-06 0.7656882893306027 \
1.62070208636412e-06 0.7672149413549471 1.620702202168994e-06 0.7685995877768005 1.620702331910823e-06 0.7701390587657672 1.620702447649211e-06 0.7715019052061673 \
1.620702570601637e-06 0.7729391548276606 1.620702688317297e-06 0.7743051053122872 1.620702794287273e-06 0.7755262985206828 1.620702910698468e-06 0.7768586864857919 \
1.620703017316401e-06 0.7780703956921795 1.620703129515121e-06 0.7793369495935717 1.62070321618369e-06 0.7803089322889447 1.620703319569181e-06 0.7814603789665585 \
1.620703432733433e-06 0.7827108149434853 1.620703538380716e-06 0.783868819044773 1.620703647720273e-06 0.7850578567336689 1.620703754897288e-06 0.786214126597127 \
1.620703884303365e-06 0.7875981444497275 1.620703996720751e-06 0.7887899291890393 1.62070412010849e-06 0.7900869036018625 1.620704237558826e-06 0.7913106402786101 \
1.620704381085744e-06 0.7927918312347375 1.620704496005322e-06 0.7939667362870242 1.620704634727735e-06 0.7953719780830618 1.620704772759876e-06 0.7967562205547866 \
1.62070488225303e-06 0.7978444364842524 1.62070498327146e-06 0.7988406866985471 1.62070508435942e-06 0.7998302780396641 1.620705216746616e-06 0.8011146558616069 \
1.620705335472037e-06 0.8022550163876687 1.620705457256542e-06 0.8034134048507504 1.620705576346336e-06 0.8045351524060473 1.620705697550853e-06 0.8056657048884367 \
1.620705829194665e-06 0.8068811249615274 1.620705952212703e-06 0.8080052413861453 1.620706079823024e-06 0.8091594649786741 1.620706210891683e-06 0.8103325925767672 \
1.620706334212046e-06 0.8114249716726942 1.620706442136311e-06 0.8123719892944993 1.620706549931703e-06 0.8133095350680949 1.620706631652631e-06 0.8140147772069938 \
1.620706748520248e-06 0.815015186305849 1.620706839581256e-06 0.8157880755829442 1.620706973749888e-06 0.8169164295805346 1.62070711832076e-06 0.8181184617099191 \
1.620707251823127e-06 0.8192158725965917 1.620707361789038e-06 0.8201107352847025 1.620707505654698e-06 0.8212684563313245 1.620707658960262e-06 0.8224861772268215 \
1.620707786698555e-06 0.8234883060891934 1.620707927340891e-06 0.8245786478120171 1.620708053124456e-06 0.8255423809867173 1.620708207742427e-06 0.8267124309768116 \
1.620708340154194e-06 0.8277017767197102 1.620708466433798e-06 0.8286345641820314 1.620708584064113e-06 0.8294941055817234 1.620708732230976e-06 0.8305638349826423 \
1.620708899375221e-06 0.8317531470681401 1.620709031993881e-06 0.832683775428688 1.620709204938569e-06 0.8338803479528284 1.620709373325224e-06 0.8350269493631071 \
1.620709542859754e-06 0.8361634673386688 1.620709724228909e-06 0.8373596561587384 1.620709866861491e-06 0.8382862741713709 1.62070998079734e-06 0.8390176620397163 \
1.620710111571134e-06 0.8398476357987267 1.620710213225074e-06 0.8404856735008092 1.620710329718803e-06 0.8412091703399448 1.620710465236349e-06 0.8420405885319162 \
1.620710662580143e-06 0.8432318270427018 1.620710853245141e-06 0.8443612543037786 1.62071106310198e-06 0.8455804035625291 1.620711244039104e-06 0.8466117334714958 \
1.620711441374591e-06 0.8477160230260256 1.620711615161427e-06 0.8486711109012058 1.620711797742881e-06 0.8496572451898022 1.620711969062461e-06 0.850566499179887 \
1.620712143447508e-06 0.8514760798656241 1.620712318831052e-06 0.8523748177975867 1.62071249506321e-06 0.8532619682996843 1.620712684901452e-06 0.8542000584728613 \
1.620712875637665e-06 0.8551245802328369 1.620713077434399e-06 0.856083442102113 1.620713270127775e-06 0.8569809170305027 1.620713479756077e-06 0.857937542729613 \
1.62071370919384e-06 0.8589615588718806 1.62071397499048e-06 0.8601183337444025 1.620714273565708e-06 0.8613802063570262 1.620714551467221e-06 0.8625196921548358 \
1.620714835677695e-06 0.8636511027355716 1.620715110089482e-06 0.8647118800460076 1.620715382252364e-06 0.8657341977214618 1.620715652421456e-06 0.8667205537246333 \
1.620715909616139e-06 0.8676338760342862 1.62071618215581e-06 0.868575115807136 1.620716458190291e-06 0.8695013130444248 1.620716728342986e-06 0.8703818891200001 \
1.620717028049788e-06 0.8713292845176382 1.620717398867258e-06 0.8724597217497643 1.620717693785921e-06 0.8733269024855727 1.620717948030199e-06 0.8740525764960509 \
1.620718246254199e-06 0.8748787854419284 1.620718519878969e-06 0.8756137195941651 1.620718756017959e-06 0.8762307200963571 1.620718996373686e-06 0.8768427579093606 \
1.620719218719338e-06 0.8773949085683344 1.620719412723072e-06 0.877865919014753 1.620719742447196e-06 0.878644045115768 1.620719897619855e-06 0.8790007149587372 \
1.620720215373248e-06 0.879712598742095 1.620720394238605e-06 0.8801026384247937 1.620720736700094e-06 0.8808283583858193 1.620720920841293e-06 0.8812073588304842 \
1.620721395746114e-06 0.8821499412898334 1.620721563140601e-06 0.8824705695712217 1.620722028971889e-06 0.8833323038036038 1.620722209796771e-06 0.8836551183393088 \
1.620722703830028e-06 0.8845051821644966 1.620722845172603e-06 0.8847400410050358 1.620723451563118e-06 0.8857071861637142 1.620723603635685e-06 0.8859397703602404 \
1.620724250313758e-06 0.8868873789663725 1.620724378610247e-06 0.8870678433440622 1.620725026723245e-06 0.8879435266410994 1.620725156528524e-06 0.8881118897635528 \
1.620725934785608e-06 0.8890711781604964 1.620726049780423e-06 0.8892053868933587 1.620726905511062e-06 0.8901454611437621 1.620727050777629e-06 0.8902951528450479 \
1.620728036533732e-06 0.8912364417375994 1.620728257640946e-06 0.8914302300078862 1.620729402752027e-06 0.892358484239638 1.620729533960174e-06 0.8924604119362172 \
1.62073087526337e-06 0.8934531785430913 1.62073102665103e-06 0.8935579568409697 1.620732508109867e-06 0.8944876667405802 1.620732746990229e-06 0.894621531696939 \
1.620734516461986e-06 0.8954958910368339 1.620734905568824e-06 0.8956641700186337 1.620737299334232e-06 0.8965498195158238 1.620737774894223e-06 0.8966991754584082 \
1.620741837950387e-06 0.8976977719002629 1.620742329424408e-06 0.8977905759376156 1.620750645951487e-06 0.8987839664765119 1.620751565805377e-06 0.8988472044554419 \
1.620877770945903e-06 0.8998441026240215 1.620878784754255e-06 0.8998514601858095 1.621070497347411e-06 0.8990059056521554 1.621070727348974e-06 0.8988405173838494 \
1.621072342221535e-06 0.8978439928078279 1.621072519935389e-06 0.8977495532019018 1.621089285710429e-06 0.8987316330193963 1.621089421698825e-06 0.8987497732072308 \
1.621104884427939e-06 0.8997471920221268 1.621105152292531e-06 0.8997526389354535 1.621588977619799e-06 0.9006560548284696 1.621589098408999e-06 0.9007687033315858 \
1.621589886180038e-06 0.9017381658104292 1.621590020318757e-06 0.901943163319478 1.621590513933531e-06 0.9027850367016239 1.621590658833145e-06 0.9030569221572713 \
1.62159105464053e-06 0.9038490360455199 1.621591174436184e-06 0.9041001886668685 1.621591558609718e-06 0.9049189780371781 1.621591670731365e-06 0.9051556495331843 \
1.621592178052336e-06 0.9061253139956988 1.621592272051192e-06 0.90626859229291 1.621593430700898e-06 0.9055667778886739 1.621593533663832e-06 0.9051589876696525 \
1.621593617506701e-06 0.9047707260375384 1.621593751246752e-06 0.9040404158978201 1.621593851964133e-06 0.9033957423200318 1.621593959579919e-06 0.9026166239542108 \
1.621594077153173e-06 0.9016533104038295 1.621594165418223e-06 0.90085556431878 1.621594285051691e-06 0.8996698288011099 1.621594382373389e-06 0.8986166602050341 \
1.621594493390828e-06 0.8973222354192386 1.621594595500415e-06 0.8960407982554908 1.621594678931815e-06 0.8949326975987755 1.621594783112883e-06 0.8934749428758865 \
1.621594874199646e-06 0.8921321265381427 1.621594966740432e-06 0.8907058396397178 1.62159506189443e-06 0.8891776325191247 1.621595176449407e-06 0.88725933118288 \
1.621595265292509e-06 0.8857137884271823 1.621595363531691e-06 0.8839502506198179 1.621595448901865e-06 0.8823735982707064 1.621595529802107e-06 0.8808434949738935 \
1.6215956027634e-06 0.8794355441897157 1.621595669782045e-06 0.8781198554636557 1.621595738393124e-06 0.8767515715160701 1.621595821888036e-06 0.8750591081124355 \
1.621595884015366e-06 0.8737811510706814 1.621595946997964e-06 0.8724704924326797 1.621596042153715e-06 0.8704632161180945 1.621596142764353e-06 0.8683077530860182 \
1.621596222643545e-06 0.8665738309361769 1.621596306905814e-06 0.8647250601592834 1.621596386016074e-06 0.8629723295901451 1.621596448831519e-06 0.8615696597604833 \
1.621596536288554e-06 0.8596016864744445 1.621596602182084e-06 0.8581079708060287 1.621596670243626e-06 0.856556281928966 1.621596719556134e-06 0.8554267461646872 \
1.621596774792924e-06 0.85415654045335 1.621596815532529e-06 0.8532164928603474 1.621596861834283e-06 0.8521450198670055 1.621596892048343e-06 0.8514441160591502 \
1.621596921089625e-06 0.8507691938976955 1.62159695172822e-06 0.8500558939662993 1.62159701300541e-06 0.8486254874746039 1.621597066077972e-06 0.8473828229799116 \
1.621597119733165e-06 0.8461232012188223 1.621597182390447e-06 0.8446482873934593 1.621597245673395e-06 0.8431545995644786 1.621597336171269e-06 0.8410121009440262 \
1.62159743316905e-06 0.8387078554355326 1.62159751614655e-06 0.8367307351423475 1.621597598150906e-06 0.8347721678896715 1.621597687219307e-06 0.8326403548070889 \
1.621597771732643e-06 0.8306135893189693 1.621597862591523e-06 0.8284303722590877 1.621597954526378e-06 0.8262176456275642 1.621598056957309e-06 0.8237486178045141 \
1.62159815707534e-06 0.8213320995840899 1.621598271896223e-06 0.8185572053828121 1.62159838410276e-06 0.8158423448209959 1.621598509096305e-06 0.8128151787794674 \
1.621598640356713e-06 0.8096337870015397 1.621598785627755e-06 0.8061104108175116 1.621598940135368e-06 0.8023613213197434 1.621599111575989e-06 0.7981999722344618 \
1.621599275625781e-06 0.794217661721315 1.621599460041203e-06 0.7897413884478564 1.621599666533577e-06 0.7847307375046715 1.62159985602742e-06 0.7801344622909899 \
1.621600049421183e-06 0.775444374634302 1.621600249988037e-06 0.7705834242206392 1.621600397552439e-06 0.7670092004965298 1.62160052756389e-06 0.7638619034739171 \
1.621600662428303e-06 0.7605987503374771 1.621600768918754e-06 0.7580234999254772 1.621600900608547e-06 0.7548403390839162 1.621601007032976e-06 0.7522693550468039 \
1.621601150211605e-06 0.7488125398635642 1.621601311338716e-06 0.7449250928176189 1.621601429565533e-06 0.7420746008290786 1.621601599798354e-06 0.7379721584775248 \
1.621601765724624e-06 0.7339761998059781 1.621601985266954e-06 0.7286940862104242 1.621602178454078e-06 0.724050920820232 1.621602353368041e-06 0.719851304223293 \
1.621602520315139e-06 0.7158476177432674 1.6216027078061e-06 0.711355754450834 1.621602895234537e-06 0.7068709122373377 1.621603063571096e-06 0.7028473835914892 \
1.62160325640163e-06 0.6982428782038785 1.621603396451378e-06 0.694901318858167 1.621603552708666e-06 0.6911769338170629 1.621603746878113e-06 0.6865540563080536 \
1.621603905984602e-06 0.6827702245679255 1.621604064344632e-06 0.679008548037742 1.62160425966174e-06 0.6743756772263459 1.621604470090519e-06 0.6693917663527935 \
1.621604722792665e-06 0.6634173774538097 1.621604902460616e-06 0.6591769455535931 1.621605154037489e-06 0.6532475027332399 1.621605354410306e-06 0.6485340174553987 \
1.621605526064158e-06 0.6445032789616798 1.621605684756275e-06 0.6407814961122935 1.621605823964202e-06 0.637522316374186 1.621605960288252e-06 0.6343349641335875 \
1.621606087501276e-06 0.6313646237382058 1.621606216993834e-06 0.6283457899522861 1.621606344985121e-06 0.6253646753452949 1.62160647605963e-06 0.6223174651643489 \
1.621606606771705e-06 0.6192830747181834 1.621606749379758e-06 0.6159760732208495 1.621606892103236e-06 0.612672916206165 1.621607044651037e-06 0.6091471600588 \
1.621607189155025e-06 0.6058158037532523 1.621607353173272e-06 0.6020406322262999 1.621607490637933e-06 0.5988837056407329 1.621607625454949e-06 0.5957940466067043 \
1.621607746953592e-06 0.5930134750293682 1.621607885803897e-06 0.5898448108574432 1.621607999450713e-06 0.5872554148224447 1.621608150860886e-06 0.5838116422847746 \
1.62160826457956e-06 0.5812320812748947 1.621608383992651e-06 0.5785269636915771 1.621608472673178e-06 0.5765205397309219 1.62160856381827e-06 0.5744630259469776 \
1.621608629157145e-06 0.5729901393713442 1.621608693626847e-06 0.5715377831648228 1.621608744447459e-06 0.5703933076453638 1.621608803422399e-06 0.569066051987989 \
1.621608870867106e-06 0.5675516747474645 1.621608937959298e-06 0.5660472084764079 1.621608990879742e-06 0.5648615894615425 1.621609086527225e-06 0.5627204246953637 \
1.621609143708362e-06 0.5614413394337 1.621609197510978e-06 0.5602399192081799 1.621609259253083e-06 0.5588634520375642 1.621609345086214e-06 0.5569525037715509 \
1.621609427781862e-06 0.5551133137453282 1.621609553910589e-06 0.552313430559463 1.621609689009665e-06 0.5493247407981657 1.621609787329828e-06 0.5471534914294828 \
1.62160989990789e-06 0.5446716589975775 1.621610002452305e-06 0.5424173856211837 1.621610122561131e-06 0.5397821662853191 1.621610224248782e-06 0.5375541863492928 \
1.621610339752746e-06 0.5350300289250629 1.621610454643861e-06 0.5325260225312031 1.621610581121134e-06 0.5297740207092871 1.62161070633833e-06 0.5270565158317848 \
1.621610853184312e-06 0.5238798967507053 1.621610988642446e-06 0.5209557060405445 1.621611146203055e-06 0.5175672114705414 1.621611308357229e-06 0.5140875588169389 \
1.621611489068307e-06 0.5102248342695275 1.62161168131606e-06 0.5061308236654174 1.621611894038323e-06 0.5016182665703952 1.621612125943484e-06 0.4967183500883584 \
1.621612383137188e-06 0.4913135654247419 1.621612622690498e-06 0.4863004534671564 1.621612924620373e-06 0.4800178499336004 1.621613212386814e-06 0.4740665530855001 \
1.621613525189057e-06 0.4676409412178996 1.621613845020806e-06 0.4611139840073785 1.621614184657409e-06 0.4542292677834274 1.621614511873228e-06 0.4476411633207955 \
1.621614847034797e-06 0.4409363684817221 1.621615164291458e-06 0.4346351592989786 1.621615498111436e-06 0.4280489847791872 1.62161584979678e-06 0.4211625252737479 \
1.621616163864498e-06 0.4150547397555842 1.621616486893702e-06 0.4088175946446666 1.621616927873099e-06 0.4003732788922496 1.621617270275942e-06 0.3938810608698495 \
1.621617570723831e-06 0.3882325136127223 1.621617946053402e-06 0.3812375944419973 1.62161827612863e-06 0.3751439175705365 1.621618559406411e-06 0.3699597784791666 \
1.621618859913773e-06 0.3645020109013299 1.621619139561233e-06 0.3594637112692664 1.621619363423524e-06 0.3554634414471464 1.621619575274513e-06 0.35170280677964 \
1.621619777623114e-06 0.3481338771034005 1.621619978758139e-06 0.3446120049995081 1.621620184535657e-06 0.3410324794262659 1.621620445514371e-06 0.3365252478245505 \
1.621620685004553e-06 0.3324209773202946 1.621620917679624e-06 0.3284665339262754 1.621621131761216e-06 0.3248537323113044 1.621621352906983e-06 0.3211475567840967 \
1.621621553789873e-06 0.3178053707831449 1.621621757181075e-06 0.3144500223650613 1.621621954849488e-06 0.3112139453100684 1.621622141093175e-06 0.3081862077816076 \
1.621622336074257e-06 0.3050391973134606 1.621622539536502e-06 0.3017803754370622 1.621622717477408e-06 0.2989521325826759 1.621622953201112e-06 0.2952356640875101 \
1.621623151333966e-06 0.2921385263640672 1.621623352678033e-06 0.2890160050544278 1.62162357696723e-06 0.2855690750291008 1.621623741897129e-06 0.2830551950838826 \
1.621623919525814e-06 0.2803657404651576 1.621624103924961e-06 0.2775946687427531 1.621624287746307e-06 0.2748547260732712 1.621624466202979e-06 0.2722194282383935 \
1.621624638103246e-06 0.2696976713509589 1.621624798643653e-06 0.2673699088296289 1.621624920125712e-06 0.265617282026588 1.621625073047239e-06 0.2634201198254058 \
1.621625200480934e-06 0.2616085083773952 1.621625304654605e-06 0.2601317890528609 1.621625421559082e-06 0.2584775571399547 1.621625536570573e-06 0.2568557450124987 \
1.621625660932803e-06 0.2551103168403305 1.621625776507087e-06 0.2534925198640895 1.621625910614608e-06 0.2516172680784447 1.621626025601849e-06 0.2500177396912131 \
1.621626179351445e-06 0.2478798443778067 1.621626316154646e-06 0.2459790966208961 1.621626450740453e-06 0.2441094379339017 1.621626606604589e-06 0.2419575875351012 \
1.621626731253411e-06 0.2402378086535915 1.621626870468935e-06 0.2383186229544463 1.62162700069296e-06 0.236525770455347 1.621627121045801e-06 0.2348769158236033 \
1.621627256439085e-06 0.233027137746051 1.621627407644063e-06 0.2309620730808924 1.621627542400533e-06 0.2291249940296414 1.62162764708672e-06 0.2277003186426776 \
1.621627769622861e-06 0.2260366668203369 1.62162790456742e-06 0.2242086518061946 1.621627999683168e-06 0.2229209267876512 1.621628114943222e-06 0.2213657311907907 \
1.621628197476202e-06 0.2202562617028589 1.621628268681533e-06 0.2192992955643472 1.621628317389017e-06 0.2186449771734718 1.621628364583973e-06 0.2180112263680214 \
1.621628411132792e-06 0.2173864029843717 1.621628464521355e-06 0.2166701476649976 1.621628501898025e-06 0.2161690444847812 1.621628539283138e-06 0.2156680710113931 \
1.621628579604508e-06 0.2151283464800275 1.621628650854648e-06 0.2141753141901174 1.621628685068904e-06 0.2137180869447317 1.621628731463535e-06 0.2131018213873352 \
1.621628791907201e-06 0.2122998083652294 1.62162886091012e-06 0.2113853596849882 1.621628926205072e-06 0.210520730631805 1.621628994183195e-06 0.2096212333552783 \
1.621629110629525e-06 0.2080823984153433 1.621629200551714e-06 0.2068957989735914 1.62162930821762e-06 0.2054771097790837 1.621629404278935e-06 0.2042146625011118 \
1.621629507657509e-06 0.2028641889872041 1.621629604342544e-06 0.2016026287683381 1.621629707152397e-06 0.2002625524503448 1.621629807912368e-06 0.1989526210414513 \
1.621629919058035e-06 0.1975116692735505 1.621630026097529e-06 0.1961279675313261 1.621630144004064e-06 0.1946083430154048 1.621630252114387e-06 0.1932197128021231 \
1.621630361412988e-06 0.1918224631760269 1.621630482044739e-06 0.1902849927564414 1.621630576945331e-06 0.1890796997295432 1.62163070550625e-06 0.18745262875399 \
1.621630798541038e-06 0.1862801166370808 1.621630900937595e-06 0.1849947785893032 1.621630988904886e-06 0.1838942174288659 1.621631087175557e-06 0.182668828510528 \
1.621631183776179e-06 0.1814691026470878 1.621631270414693e-06 0.1803971466393716 1.621631356823704e-06 0.1793305247657973 1.621631452660814e-06 0.1781527189679156 \
1.621631557387689e-06 0.1768710765218302 1.621631703199975e-06 0.1750963017969037 1.621631819167907e-06 0.1736923427161618 1.621631975631711e-06 0.1718092975148396 \
1.62163208681163e-06 0.1704786474822015 1.621632227061631e-06 0.1688098560703619 1.621632350073035e-06 0.1673544160765056 1.621632456564034e-06 0.1661007559767333 \
1.621632552889492e-06 0.1649724583647661 1.621632650322959e-06 0.1638357962207703 1.621632754176237e-06 0.1626293386330815 1.62163284597681e-06 0.1615673458739011 \
1.621632944364525e-06 0.1604337426303964 1.62163302728317e-06 0.1594828374885931 1.621633122651503e-06 0.1583950132920943 1.621633205213852e-06 0.1574587876231885 \
1.621633307798537e-06 0.1563016192679324 1.621633384076854e-06 0.1554454316211293 1.621633472662479e-06 0.1544557264474612 1.621633544831984e-06 0.1536532700165102 \
1.621633626541473e-06 0.1527486200895024 1.621633700220281e-06 0.1519363404455653 1.621633780440409e-06 0.1510573496788611 1.621633852168484e-06 0.1502755532525617 \
1.621633920425463e-06 0.149534520573691 1.621634018141423e-06 0.1484788062294206 1.621634087591606e-06 0.147731872792437 1.621634170343085e-06 0.1468455801890639 \
1.621634230379995e-06 0.1462052652532956 1.621634300618659e-06 0.1454587420502366 1.621634372046193e-06 0.1447037411390827 1.621634452559695e-06 0.1438588888651768 \
1.621634515822599e-06 0.1431977449412327 1.621634593496578e-06 0.1423892845091393 1.621634682806343e-06 0.141463758692191 1.621634752169929e-06 0.1407479403162204 \
1.621634850118149e-06 0.1397418416088305 1.621634940462669e-06 0.1388188591118084 1.621635026242994e-06 0.1379520826379384 1.621635093896779e-06 0.1372719511642241 \
1.62163516020463e-06 0.1366075914250998 1.621635238824321e-06 0.1358227655030745 1.62163531951923e-06 0.135020537018139 1.621635377921894e-06 0.1344419857224206 \
1.621635438674417e-06 0.1338420332148588 1.621635532580729e-06 0.1329184183639811 1.621635574978232e-06 0.1325029080242558 1.621635654222426e-06 0.1317336600863391 \
1.621635694592585e-06 0.1313430593815061 1.621635784293464e-06 0.130477658168832 1.62163582324155e-06 0.1301029732927899 1.621635918857236e-06 0.1291862249441596 \
1.621635957741065e-06 0.1288146335111444 1.621636050975841e-06 0.1279263274670414 1.62163611931843e-06 0.1272775968534341 1.621636171639285e-06 0.1267823325594629 \
1.621636253739999e-06 0.1260075984242486 1.621636324903378e-06 0.1253406747583812 1.621636402856366e-06 0.1246136378429537 1.621636481976102e-06 0.1238779526756392 \
1.621636560619333e-06 0.1231489004754178 1.621636640654242e-06 0.122409328367501 1.621636702388658e-06 0.1218405706457005 1.62163677598364e-06 0.1211645344030958 \
1.621636859363458e-06 0.120401093559758 1.621636923460189e-06 0.1198161795466899 1.621636992898777e-06 0.119184869057559 1.621637065921716e-06 0.1185234239195788 \
1.621637150796627e-06 0.1177582144838446 1.621637230159479e-06 0.117046673033812 1.621637314893136e-06 0.1162898833629492 1.621637405604425e-06 0.1154830714735263 \
1.621637481187504e-06 0.1148135241260771 1.621637546915428e-06 0.1142333070693714 1.621637606975201e-06 0.1137047561823949 1.621637676580917e-06 0.1130943456353956 \
1.621637742999969e-06 0.1125141752866663 1.621637822411232e-06 0.1118230150855203 1.621637912674161e-06 0.1110406875128299 1.621637981718461e-06 0.1104447270551955 \
1.62163805627358e-06 0.1098035355921305 1.621638144757501e-06 0.1090456469739195 1.621638223865648e-06 0.1083709350695736 1.621638293734029e-06 0.1077773127978274 \
1.621638374743399e-06 0.1070920034756896 1.621638430948213e-06 0.106618206733547 1.621638493607492e-06 0.1060916009495399 1.621638558754098e-06 0.105545887371837 \
1.621638630089726e-06 0.1049504956797945 1.621638750386101e-06 0.1039516085561449 1.621638801939674e-06 0.103525508500865 1.621638857088742e-06 0.1030709598036589 \
1.621638947785926e-06 0.1023262935955709 1.621639030175778e-06 0.1016530765296615 1.621639125755586e-06 0.1008759670630478 1.621639232965152e-06 0.1000092507657299 \
1.621639336624559e-06 0.09917656019160864 1.621639422832161e-06 0.09848810438956324 1.621639509074386e-06 0.09780303991321163 1.621639588615461e-06 0.09717448010577609 \
1.621639668628333e-06 0.09654538840876434 1.621639759916661e-06 0.09583163072761708 1.62163984166208e-06 0.09519620281310773 1.621639930588917e-06 0.09450872319168514 \
1.621640020366224e-06 0.09381864801001834 1.621640097328872e-06 0.09323024625953365 1.621640187653689e-06 0.0925435244861572 1.621640251462415e-06 0.09206084550525626 \
1.621640323925983e-06 0.09151514907748673 1.621640388054635e-06 0.09103438864950099 1.621640466302011e-06 0.09045054736970405 1.621640566003292e-06 0.08971110930136832 \
1.621640640056444e-06 0.08916512281998501 1.621640726664979e-06 0.08852997392441805 1.621640872964685e-06 0.08746544055362569 1.621640983676948e-06 0.08666684197409438 \
1.621641093986626e-06 0.08587717033461532 1.621641236182269e-06 0.08486839672072237 1.62164137623472e-06 0.08388450488753585 1.621641518880534e-06 0.08289222299161547 \
1.621641667651249e-06 0.08186778387581196 1.621641804363935e-06 0.08093569403044946 1.621641946484565e-06 0.07997640434545976 1.621642081061545e-06 0.07907728405019222 \
1.621642221281423e-06 0.07814997945867638 1.621642369028229e-06 0.07718353387841098 1.621642518982415e-06 0.07621348085094087 1.621642683698247e-06 0.07516037195605636 \
1.621642847284364e-06 0.07412732798506308 1.621643021932716e-06 0.07303837372665309 1.621643208986408e-06 0.07188781219077654 1.621643418972926e-06 0.0706159374129187 \
1.621643637046174e-06 0.06931715807027321 1.621643870366328e-06 0.06795188046253516 1.621644124845882e-06 0.0664909822812602 1.62164441780254e-06 0.06484528303377844 \
1.621644719953089e-06 0.06318745987130532 1.621645057674792e-06 0.06138078634948794 1.621645452783393e-06 0.05932807220464856 1.621645820234636e-06 0.05747953410674719 \
1.621646237842402e-06 0.05544691527644593 1.621646582838376e-06 0.0538196438399016 1.621646933380665e-06 0.05221302159193914 1.621647248341029e-06 0.0508087490907442 \
1.621647547582396e-06 0.049508488261462 1.621647846948248e-06 0.04824029756235761 1.621648122190958e-06 0.04710512226277328 1.621648405654525e-06 0.04596497870754415 \
1.621648667254947e-06 0.04493681260994405 1.621648944707071e-06 0.04387103439794762 1.621649220766506e-06 0.04283531238677037 1.621649529036243e-06 0.04170718945545093 \
1.621649751468863e-06 0.0409114719535993 1.621650039009947e-06 0.03990505631995635 1.62165027524288e-06 0.0390969788355163 1.621650593704555e-06 0.03803800466874574 \
1.621650844115589e-06 0.03722710566490722 1.621651167100391e-06 0.03620720400565681 1.621651425436406e-06 0.03541203096995557 1.621651715410285e-06 0.03454066075983582 \
1.621651945205103e-06 0.0338658635512188 1.621652230100444e-06 0.03304787219836024 1.621652469846563e-06 0.03237513696606491 1.621652710481132e-06 0.03171392889024889 \
1.621652949599619e-06 0.03107212555077287 1.62165318553853e-06 0.03045460689686571 1.621653416367391e-06 0.02986254663395104 1.621653631393919e-06 0.02932175456294728 \
1.62165403355976e-06 0.0283374222946415 1.62165423211788e-06 0.02786401170979088 1.621654605819066e-06 0.02699470773596776 1.621654792632261e-06 0.02657042318767052 \
1.621655138633508e-06 0.02580176906824739 1.621655260576947e-06 0.02553595448027303 1.621655643429963e-06 0.02472011952872977 1.621655803864149e-06 0.02438657631284594 \
1.621656246865303e-06 0.02348572425118655 1.621656417479345e-06 0.02314627247835563 1.621656738055941e-06 0.02251902970747987 1.621656938340868e-06 0.0221336684630111 \
1.621657385278801e-06 0.02128811173678137 1.621657513222917e-06 0.02104854104185888 1.621658001100276e-06 0.02014826272243131 1.621658136077553e-06 0.01990454278080647 \
1.621658618329071e-06 0.0190640092473091 1.621658780655186e-06 0.01879235028057063 1.621659267049527e-06 0.01801148170254873 1.621659430077186e-06 0.01776103207540622 \
1.621660110298877e-06 0.01676849304257711 1.621660249382615e-06 0.01657541006259178 1.621660981877148e-06 0.01560782569993242 1.62166114077078e-06 0.01540693214221847 \
1.621661923851867e-06 0.01445869962397344 1.621662069644422e-06 0.01428952172302696 1.621662920425781e-06 0.01334248985256295 1.621663031529053e-06 0.01322388191882306 \
1.621663964823417e-06 0.0122699293983148 1.621664098661466e-06 0.01213902814618388 1.621665057199482e-06 0.01123495036716388 1.621665178316551e-06 0.01112486091825863 \
1.621666300400349e-06 0.01017270671243764 1.621666405901602e-06 0.01008921053061839 1.621667734976014e-06 0.009112307258623473 1.621667855180288e-06 0.009029744095492466 \
1.621669403542048e-06 0.008036808760534916 1.621669484329818e-06 0.007986285493236449 1.621671055209352e-06 0.007024564730313319 1.621671122625551e-06 0.006986095570813155 \
1.621673043392229e-06 0.006001386377072119 1.621673230194113e-06 0.005914747648762168 1.621675545608061e-06 0.0049318160947762 1.621675945134908e-06 0.004777795182599986 \
1.621678508944408e-06 0.003889929704329555 1.621679007815328e-06 0.003736330440833864 1.621682637539317e-06 0.002784984367379526 1.621683188233292e-06 0.002663729254427667 \
1.621688586673672e-06 0.001711392372544448 1.621688899941243e-06 0.001662511220227468 1.621693892233791e-06 0.0006970413096974805 1.621694076252826e-06 0.0006571176749162138 \
1.62434255539561e-06 -0.0002691198397987355 1.624342711454572e-06 -0.0004551674219448388 1.624343259438427e-06 -0.001322174727784445 1.62434337237642e-06 -0.001539785040943742 \
1.62434380163135e-06 -0.002474302920374066 1.624343907888515e-06 -0.002730173903076456 1.624344190690667e-06 -0.003454402452283872 1.62434430428521e-06 -0.003760966378165151 \
1.624344642839789e-06 -0.004705104513819927 1.62434475526375e-06 -0.005021586953003071 1.624345083541651e-06 -0.005887841248467669 1.624345191080172e-06 -0.006130875888161453 \
1.624346071006203e-06 -0.005789627805322099 1.62434624621225e-06 -0.004910736584223327 1.624346363043013e-06 -0.004127745010746014 1.624346489910138e-06 -0.00309221842859156 \
1.624346591442863e-06 -0.002125750314016509 1.624346712864133e-06 -0.0008095618968406578 1.624346803029046e-06 0.0002767910803854594 1.624346900212696e-06 0.001550247908954045 \
1.62434699828696e-06 0.002938803805678211 1.624347165508045e-06 0.005530627736217106 1.624347387813323e-06 0.009378371294171852 1.624347573551714e-06 0.01290572951649239 \
1.624347797633049e-06 0.01747895571448658 1.624347957277782e-06 0.02091945933227325 1.624348121767111e-06 0.02459614091902196 1.624348271591569e-06 0.0280452875125503 \
1.624348420991461e-06 0.03156498790849799 1.624348570522767e-06 0.03515592969144176 1.624348724602661e-06 0.03891669635189081 1.624348886786809e-06 0.0429309674228065 \
1.624349053210035e-06 0.0470989728378523 1.624349229143508e-06 0.05154884981278444 1.624349410271779e-06 0.05616867911875007 1.624349602402705e-06 0.06110225049351239 \
1.624349810098117e-06 0.0664648391313285 1.624350032018198e-06 0.07222051812179281 1.624350267219681e-06 0.07834079218654426 1.624350519405989e-06 0.08491829088081257 \
1.624350795545224e-06 0.09213111703448683 1.624351096666701e-06 0.1000001933597138 1.624351428586562e-06 0.1086702418150647 1.62435180590533e-06 0.1185147411083515 \
1.624352204195387e-06 0.1288888856248832 1.624352673503707e-06 0.1410822143415975 1.624353219529231e-06 0.1552200475789812 1.624353854489538e-06 0.1715918832733369 \
1.624354553890129e-06 0.1895291194622146 1.624355372129055e-06 0.2103807608661494 1.624356277823022e-06 0.2332840710921665 1.624357067334088e-06 0.253091928008631 \
1.624357771092906e-06 0.2706124241987875 1.62435838894372e-06 0.2858796548825839 1.624358954567131e-06 0.2997575097153312 1.624359476302405e-06 0.3124620269501652 \
1.624359974086121e-06 0.3244932238414255 1.624360457724081e-06 0.3360954048923613 1.624360914598215e-06 0.3469667650518959 1.62436138743911e-06 0.3581213589834248 \
1.624361827052466e-06 0.3684065070151987 1.624362314929562e-06 0.379719432411247 1.624362845729985e-06 0.3919028193132517 1.62436334362536e-06 0.4032143644097119 \
1.624363775002613e-06 0.41292177789323 1.624364261889801e-06 0.4237731225600331 1.624364761989243e-06 0.4348012155672935 1.624365106609934e-06 0.4423321287141763 \
1.624365460003778e-06 0.4500000647748709 1.624365887773617e-06 0.4592134948422093 1.624366279634688e-06 0.4675816212925634 1.624366579929044e-06 0.4739471552041949 \
1.624366921860125e-06 0.4811428413521782 1.62436726519457e-06 0.4883132334011818 1.624367525955058e-06 0.4937215836208605 1.624367768011588e-06 0.4987106167174703 \
1.624368034010056e-06 0.5041617362307154 1.62436829349824e-06 0.5094435946950286 1.62436848341454e-06 0.5132872703533161 1.624368698649141e-06 0.5176241792560061 \
1.6243688371999e-06 0.5204025546691405 1.624368982080679e-06 0.5232962183003332 1.624369195494746e-06 0.5275364624051522 1.62436939751936e-06 0.5315382148201082 \
1.624369590248024e-06 0.5353370730264509 1.624369775503404e-06 0.5389735557287745 1.624369952500928e-06 0.5424323215059959 1.624370261764263e-06 0.5484573594957171 \
1.624370522912311e-06 0.5535233414883098 1.624370824731481e-06 0.5593562770234363 1.624371080160122e-06 0.5642781701956761 1.624371372515619e-06 0.5698968483756405 \
1.624371631969813e-06 0.5748654731717864 1.62437190208979e-06 0.5800301911327002 1.624372144100348e-06 0.5846380733684551 1.624372401610146e-06 0.5895273573494454 \
1.624372628054483e-06 0.5938057549890672 1.624372864942966e-06 0.5982619499065401 1.624373074987873e-06 0.6021962733001386 1.624373287918585e-06 0.6061670177072124 \
1.624373541397282e-06 0.6108668889270118 1.624373744692931e-06 0.6146150465592417 1.624373936381114e-06 0.6181346807088086 1.624374125007479e-06 0.6215812235468744 \
1.624374312325417e-06 0.6249823889551316 1.624374517937406e-06 0.6286953279350977 1.624374767760625e-06 0.6331759959753138 1.624374971572403e-06 0.6368063379741715 \
1.624375179211121e-06 0.6404826298163093 1.624375371862737e-06 0.6438748386876914 1.624375616474811e-06 0.6481531432733096 1.624375864373314e-06 0.6524620620600715 \
1.624376044208219e-06 0.6555644139995785 1.624376234982255e-06 0.6588391718544121 1.624376388158437e-06 0.6614554104590837 1.624376559827147e-06 0.6643705886591137 \
1.624376710293968e-06 0.6669108747194671 1.624376846897972e-06 0.6692010654183506 1.624376996338373e-06 0.6716954191563786 1.624377124072523e-06 0.6738189269502312 \
1.62437726394477e-06 0.6761323074508511 1.624377388021905e-06 0.6781756764962316 1.62437751938327e-06 0.6803315871556701 1.624377643554731e-06 0.6823627547057004 \
1.624377781331592e-06 0.6846081866267727 1.624377901575812e-06 0.6865586181592046 1.624378043628417e-06 0.6888545186016138 1.624378143856123e-06 0.6904668682779994 \
1.624378265160113e-06 0.6924123325129877 1.624378356135388e-06 0.6938641504265992 1.624378453518671e-06 0.695411869780077 1.624378550601538e-06 0.6969507228893711 \
1.624378639884158e-06 0.6983595753378042 1.624378737855943e-06 0.699898781449533 1.62437886813103e-06 0.7019319515314388 1.624379021543255e-06 0.7043083163565919 \
1.624379157109067e-06 0.7063909659299702 1.624379301449562e-06 0.708591461371511 1.624379427320445e-06 0.710496752775434 1.624379552347831e-06 0.712376488910674 \
1.624379666630191e-06 0.7140841686551523 1.624379777613336e-06 0.7157331888171029 1.624379877308405e-06 0.7172065512867005 1.624380014352623e-06 0.7192196995505324 \
1.624380133379835e-06 0.7209572005600779 1.624380253677943e-06 0.7227029412191364 1.624380380176863e-06 0.7245276185835638 1.624380504108467e-06 0.7263044524160376 \
1.6243806283948e-06 0.7280754330070212 1.624380754759953e-06 0.7298652243312684 1.624380884571695e-06 0.7316925631262517 1.624381008410214e-06 0.7334254795816325 \
1.624381141191101e-06 0.735272086289578 1.624381242042306e-06 0.7366670415914529 1.624381355233976e-06 0.738224777043618 1.624381442019956e-06 0.7394137384482823 \
1.624381558645253e-06 0.7410021813026957 1.624381647934511e-06 0.7422110784210975 1.624381759111394e-06 0.7437075443329063 1.624381888370158e-06 0.7454347509364776 \
1.624382002229194e-06 0.7469455276109591 1.624382106633406e-06 0.74832188588007 1.624382231000437e-06 0.7499498655229884 1.624382378240616e-06 0.7518616907275563 \
1.624382498520907e-06 0.753411006437983 1.624382614425446e-06 0.7548933175676444 1.62438275450129e-06 0.7566706674475765 1.62438289711296e-06 0.7584645678799224 \
1.624383015067203e-06 0.7599365027959469 1.624383141883712e-06 0.7615071445339606 1.624383282766856e-06 0.7632375905494565 1.624383402560354e-06 0.7646969139886852 \
1.624383547519211e-06 0.7664484133613445 1.624383669077996e-06 0.7679052725436226 1.62438378811749e-06 0.7693214142140735 1.624383909748853e-06 0.7707575700077021 \
1.624384037717832e-06 0.772256936813787 1.624384146933014e-06 0.7735272422640712 1.624384271823892e-06 0.774969549136603 1.624384378939953e-06 0.7761978171588899 \
1.624384512193147e-06 0.7777146071439789 1.624384639296593e-06 0.7791497354387434 1.624384761047568e-06 0.7805132846941326 1.624384877632151e-06 0.7818078758210534 \
1.624384983459753e-06 0.7829735233300771 1.624385122825895e-06 0.7844949153190801 1.624385271897695e-06 0.786105286864636 1.624385419626362e-06 0.7876841235632186 \
1.62438553893224e-06 0.7889471147195867 1.624385672939052e-06 0.7903527806482344 1.624385793365227e-06 0.791604423795974 1.624385934910404e-06 0.7930616786923709 \
1.624386082336417e-06 0.7945638089648995 1.624386206810925e-06 0.7958198087139573 1.624386325854918e-06 0.7970105506108808 1.624386437445202e-06 0.7981174590942314 \
1.624386542674491e-06 0.7991530841216606 1.624386638185594e-06 0.8000862307887144 1.624386774247548e-06 0.8014036057482816 1.624386891123682e-06 0.8025237700417888 \
1.624387010277354e-06 0.8036549841722296 1.624387132589548e-06 0.8048050501807249 1.624387255861622e-06 0.8059526272620129 1.624387382358399e-06 0.8071184350969989 \
1.624387507861062e-06 0.8082633544790385 1.624387638586967e-06 0.8094437311890262 1.624387764154939e-06 0.8105658358439867 1.624387893209804e-06 0.8117072367686948 \
1.624387999065961e-06 0.8126345588578442 1.624388100234837e-06 0.8135133322873783 1.624388194854657e-06 0.8143286754242188 1.62438831913574e-06 0.8153900871385379 \
1.624388408847426e-06 0.816149614585347 1.62438850788495e-06 0.8169816577628611 1.624388645662827e-06 0.8181280288377792 1.624388780198677e-06 0.81923501721715 \
1.624388888604944e-06 0.8201180631035904 1.624389038518447e-06 0.8213254631869725 1.624389189097026e-06 0.8225223201378843 1.62438931459218e-06 0.8235077122548546 \
1.624389458438707e-06 0.8246238332260477 1.624389583021971e-06 0.8255790649890803 1.624389731875191e-06 0.8267066458678887 1.624389868023775e-06 0.827725029289517 \
1.624389993047602e-06 0.8286494160599757 1.624390110754582e-06 0.8295103773055483 1.624390256393581e-06 0.8305630309532103 1.624390422774875e-06 0.8317484146982921 \
1.624390553358565e-06 0.8326660250626342 1.624390726880675e-06 0.8338683097812621 1.624390895002578e-06 0.8350147136930499 1.62439106486518e-06 0.8361549927788252 \
1.624391245766883e-06 0.8373497079260466 1.624391388876165e-06 0.8382806519784776 1.624391502965127e-06 0.839013953006387 1.624391633127604e-06 0.8398410866028793 \
1.624391734972734e-06 0.8404811280669765 1.62439185179894e-06 0.8412075886390841 1.62439198869038e-06 0.8420483852080155 1.624392186497604e-06 0.843243620449199 \
1.624392378122751e-06 0.8443797466267589 1.624392587554618e-06 0.8455974227529048 1.6243927695013e-06 0.8466352798309468 1.624392966630154e-06 0.8477391449715804 \
1.624393139971014e-06 0.8486924050423899 1.624393322979321e-06 0.8496814535024207 1.624393494142356e-06 0.8505903669473519 1.624393668779451e-06 0.851501688465695 \
1.624393844039281e-06 0.8524001683007644 1.62439402018973e-06 0.8532872510191711 1.62439421047003e-06 0.8542278331088334 1.62439440106916e-06 0.8551519386507073 \
1.624394601692395e-06 0.8561055033533737 1.62439479430095e-06 0.8570028516027762 1.624395004981641e-06 0.8579644845832216 1.624395233083109e-06 0.8589827023971403 \
1.624395498871092e-06 0.860139640227508 1.624395797483852e-06 0.8614018215255795 1.624396073772491e-06 0.8625348754565382 1.62439635800901e-06 0.8636666213345715 \
1.62439663221378e-06 0.8647267940813509 1.624396904448638e-06 0.8657495569722869 1.62439717465278e-06 0.8667361702337206 1.624397431808391e-06 0.867649441901348 \
1.624397704388604e-06 0.8685908808535525 1.62439798037489e-06 0.8695169452638583 1.624398250477721e-06 0.870397355937691 1.624398550334798e-06 0.8713451925332844 \
1.624398921362456e-06 0.8724761722512941 1.624399216299767e-06 0.8733433185969293 1.624399470589207e-06 0.8740690226522811 1.624399768845991e-06 0.874895168896023 \
1.624400042455427e-06 0.8756299040683481 1.624400278583914e-06 0.8762466977562872 1.624400518929827e-06 0.8768585021646264 1.624400741263492e-06 0.8774104263690854 \
1.624400935269169e-06 0.8778812671168952 1.624401264991886e-06 0.8786590883967833 1.624401420165319e-06 0.8790156160651978 1.624401737941389e-06 0.8797272612331356 \
1.624401916803032e-06 0.8801171459162566 1.624402259264861e-06 0.8808425821290963 1.624402443393021e-06 0.881221400612852 1.624402918270754e-06 0.8821634994206867 \
1.624403085666965e-06 0.8824839765989225 1.624403551508906e-06 0.8833452998114757 1.624403732330958e-06 0.8836679564577563 1.624404226369383e-06 0.8845176198113115 \
1.624404367718007e-06 0.8847523712107549 1.624404974052073e-06 0.8857188576377059 1.624405126121396e-06 0.8859512996759633 1.624405772809559e-06 0.8868983431897121 \
1.62440590110417e-06 0.8870786909355212 1.624406549221232e-06 0.8879538337624689 1.624406679020295e-06 0.8881220828502663 1.624407457223772e-06 0.8890807033877333 \
1.624407572278734e-06 0.8892148977954012 1.624408427940207e-06 0.8901543051721961 1.624408573301076e-06 0.8903040038307473 1.624409559057127e-06 0.8912446482480114 \
1.624409780162496e-06 0.8914382978987679 1.624410925289424e-06 0.8923659558950503 1.624411056506439e-06 0.8924678262926897 1.624412397715013e-06 0.8934599079028542 \
1.624412549114272e-06 0.8935646301988298 1.624414030551995e-06 0.8944937559627255 1.624414269431373e-06 0.8946275407274444 1.624416038746979e-06 0.8955013787854181 \
1.624416427898191e-06 0.8956696032899972 1.624418821561142e-06 0.8965547188539188 1.62441929727014e-06 0.8967039926079825 1.62442336043021e-06 0.8977020505850396 \
1.624423851854269e-06 0.8977948037134476 1.624432168453822e-06 0.898787348739254 1.62443308835295e-06 0.8988506593152591 1.62457657358348e-06 0.8998476076348748 \
1.624577692016456e-06 0.8998537475785264 1.624782783635956e-06 0.898985773748599 1.624783010725457e-06 0.8988224379910277 1.624784620332255e-06 0.8978282360369357 \
1.624784797740799e-06 0.8977338482811539 1.6248017048891e-06 0.8987315468430059 1.624801814328198e-06 0.8987460089186867 1.624817595049444e-06 0.8997418097871094 \
1.624817891375339e-06 0.8997476966799167 1.625301325027745e-06 0.9007060148833608 1.625301454078085e-06 0.9008313386292994 1.625302104227931e-06 0.9016292186224167 \
1.625302293723661e-06 0.9019133038041363 1.62530279694564e-06 0.9027675859898705 1.6253029324183e-06 0.9030208676018907 1.625303332877016e-06 0.9038195223753869 \
1.625303464814953e-06 0.9040958310886574 1.625303866030017e-06 0.9049509627747726 1.625303964290194e-06 0.9051582028152527 1.625304430164004e-06 0.9060587574877488 \
1.625304591662727e-06 0.9063060456044927 1.625305735675251e-06 0.9055153668657776 1.625305880654596e-06 0.9049059606760256 1.625306059207354e-06 0.9039396653125833 \
1.625306239402631e-06 0.9027054491383806 1.625306382093561e-06 0.9015369228101149 1.625306499253165e-06 0.9004524619440171 1.625306588234526e-06 0.8995505656965809 \
1.625306679878178e-06 0.8985529714258781 1.62530681299011e-06 0.8969831049011855 1.625306906711193e-06 0.8957895978311226 1.625306997850002e-06 0.8945634483845346 \
1.625307111142313e-06 0.8929516940777753 1.625307214251226e-06 0.8913998138690341 1.625307310518406e-06 0.8898830246517148 1.625307429655523e-06 0.8879200664089764 \
1.625307598240772e-06 0.8849885378698126 1.625307760012273e-06 0.8820195265790133 1.625307953231332e-06 0.8782956415026882 1.625308138794443e-06 0.8745571577041361 \
1.625308349060748e-06 0.8701566079887386 1.625308531309789e-06 0.8662213066841463 1.625308716173183e-06 0.8621339172744639 1.62530888885833e-06 0.8582419637438897 \
1.625309074966403e-06 0.8539816046497358 1.625309252782491e-06 0.849858603441091 1.625309433499072e-06 0.8456251963850057 1.625309598637331e-06 0.8417258760277182 \
1.625309763911433e-06 0.837798995916667 1.625309927159096e-06 0.8339004324287677 1.62531008574937e-06 0.8300982805770993 1.625310262673771e-06 0.8258418712800655 \
1.625310459187584e-06 0.8211009660847696 1.625310626744125e-06 0.8170498602679914 1.625310793484544e-06 0.8130123908857781 1.625310967908062e-06 0.8087844286215062 \
1.625311137277684e-06 0.8046757316210446 1.625311305476779e-06 0.8005936994537799 1.625311494325046e-06 0.7960093488074458 1.625311685140882e-06 0.7913773844868103 \
1.625311893523092e-06 0.7863203192056716 1.625312119942597e-06 0.7808277108969495 1.625312309142794e-06 0.7762391340290878 1.625312519289483e-06 0.7711455503222944 \
1.625312668057988e-06 0.7675418410361046 1.625312799050976e-06 0.7643705172588006 1.625312936616212e-06 0.7610417440783073 1.625313042367441e-06 0.7584842184275663 \
1.625313177141075e-06 0.7552262509102785 1.625313288973801e-06 0.7525244432456109 1.625313418408965e-06 0.7493992292091655 1.625313573597688e-06 0.7456545577979357 \
1.625313685233441e-06 0.7429626190147979 1.625313844808055e-06 0.7391166470929011 1.625314020129688e-06 0.7348935218456193 1.625314232505151e-06 0.7297828120356423 \
1.625314425387679e-06 0.7251458607116523 1.625314582088971e-06 0.7213823872711312 1.625314768763662e-06 0.716903961299824 1.625314957650011e-06 0.7123775767926828 \
1.625315148534203e-06 0.70780884692282 1.625315335282138e-06 0.7033444557767304 1.625315518366954e-06 0.698972331957095 1.625315655685935e-06 0.6956951921588121 \
1.625315808928892e-06 0.6920418367118417 1.625316004057543e-06 0.6873949992893974 1.625316161351872e-06 0.6836535194673684 1.625316320746467e-06 0.6798660670227984 \
1.62531651649026e-06 0.6752219404489795 1.625316708689394e-06 0.6706682621108646 1.625316943641022e-06 0.6651105611269369 1.62531713111727e-06 0.6606839627962382 \
1.625317368354404e-06 0.6550894036851447 1.625317557534366e-06 0.6506361170423679 1.625317738150179e-06 0.6463915264929231 1.625317901844741e-06 0.6425504277539856 \
1.62531804639615e-06 0.6391628119244788 1.62531818686792e-06 0.6358764726647652 1.625318313968708e-06 0.6329064225879303 1.625318446276184e-06 0.6298198307262635 \
1.62531857286323e-06 0.626870110582017 1.625318703443498e-06 0.62383130535404 1.625318832712897e-06 0.6208285625908692 1.625318971819793e-06 0.6176004736356133 \
1.625319120330103e-06 0.6141606483517721 1.625319309878658e-06 0.6097777958748198 1.625319455581914e-06 0.6064170107178907 1.625319690632478e-06 0.601007464699683 \
1.625319873631749e-06 0.5968099615921 1.625320097973423e-06 0.5916778694808832 1.625320269146672e-06 0.5877753019413697 1.625320401480491e-06 0.5847634284691802 \
1.62532053327703e-06 0.5817721407249107 1.625320639820933e-06 0.5793579518205488 1.625320735711292e-06 0.5771868999037388 1.625320828211542e-06 0.5750974572268882 \
1.625320920638905e-06 0.5730134868920421 1.625320993067212e-06 0.5713818265150021 1.625321048796317e-06 0.5701269325864891 1.625321109905405e-06 0.5687522410723198 \
1.62532120667008e-06 0.5665806864277688 1.625321268161595e-06 0.5652027770813386 1.625321327214216e-06 0.5638802801505602 1.625321402840882e-06 0.5621878686488651 \
1.62532146986366e-06 0.5606896577364279 1.62532154346077e-06 0.5590483558003441 1.625321611066773e-06 0.5575429304381756 1.625321727135829e-06 0.5549610936632026 \
1.625321827342235e-06 0.5527359403974305 1.625321939349424e-06 0.5502565947066531 1.625322033841475e-06 0.5481686943853854 1.625322154996173e-06 0.5454955387196141 \
1.625322255183939e-06 0.5432910220514219 1.625322371174451e-06 0.5407443765731218 1.625322478878289e-06 0.5383833065966291 1.625322588456977e-06 0.5359861028148916 \
1.625322700578421e-06 0.5335400310751951 1.625322827515605e-06 0.5307765704644959 1.625322949665123e-06 0.5281221248815906 1.625323089426038e-06 0.525095489155881 \
1.625323226564154e-06 0.522132778766487 1.625323376529244e-06 0.5189020692106626 1.625323535302247e-06 0.5154923220538846 1.625323709327905e-06 0.511765695450105 \
1.625323896158028e-06 0.5077823379664483 1.625324101125994e-06 0.5034264211640872 1.625324323834942e-06 0.4987133299464507 1.625324576739139e-06 0.4933874474923696 \
1.625324811693046e-06 0.4884604410272814 1.625325107961308e-06 0.4822828691822955 1.625325397751266e-06 0.4762763831984252 1.625325704087085e-06 0.4699660956099861 \
1.625326016405612e-06 0.4635767846525711 1.625326354971068e-06 0.4566963260653934 1.625326678082485e-06 0.4501741115777416 1.625327016477788e-06 0.4433881855507311 \
1.625327340309054e-06 0.4369378830387565 1.625327664703474e-06 0.4305204627449936 1.62532800763776e-06 0.4237851826852676 1.625328346918578e-06 0.4171698123421442 \
1.625328686393212e-06 0.4105997181257849 1.625329129505058e-06 0.4020958655332711 1.625329491573227e-06 0.3952155038183801 1.625329812124965e-06 0.3891775711374149 \
1.625330199059534e-06 0.3819561902961204 1.625330526929795e-06 0.3758957719299574 1.625330812088852e-06 0.3706704968427373 1.625331130457646e-06 0.3648820026298218 \
1.625331413288573e-06 0.3597820188690578 1.625331641977337e-06 0.3556924369094372 1.625331859870142e-06 0.3518226517641353 1.625332055119486e-06 0.3483769517668343 \
1.625332262027586e-06 0.344751588202948 1.625332476824342e-06 0.3410137651016431 1.625332729050892e-06 0.3366564674340092 1.625332971046205e-06 0.3325077909124976 \
1.625333201898484e-06 0.3285822460490526 1.625333416746675e-06 0.3249550452085373 1.625333637103364e-06 0.3212604562488142 1.625333838674264e-06 0.3179050685021769 \
1.625334041758211e-06 0.3145531374773136 1.625334239655597e-06 0.3113121771742085 1.625334426754836e-06 0.3082694484595072 1.625334620655179e-06 0.3051385396431291 \
1.625334825703514e-06 0.3018527636900292 1.625335005938266e-06 0.2989872106339772 1.625335241836277e-06 0.2952669081535775 1.625335443123828e-06 0.2921198200609627 \
1.625335644514631e-06 0.2889965001417216 1.625335869163794e-06 0.2855437159941698 1.625336034543768e-06 0.2830223598911593 1.625336212348106e-06 0.280330186126118 \
1.625336396004319e-06 0.277570343839212 1.625336581246076e-06 0.2748090658167894 1.625336759391454e-06 0.2721781298892599 1.625336932983517e-06 0.2696316866093095 \
1.62533709334837e-06 0.267306655456324 1.625337214459553e-06 0.2655585721882695 1.625337367654341e-06 0.2633570345323199 1.625337494985789e-06 0.2615475749425888 \
1.625337598313628e-06 0.2600830587034867 1.625337715638424e-06 0.2584225376281647 1.625337833445381e-06 0.2567591557214636 1.625337957409147e-06 0.2550199666844239 \
1.625338074393314e-06 0.2533821414201824 1.625338205189442e-06 0.2515535495016885 1.625338322399552e-06 0.2499173892700276 1.625338475652677e-06 0.2477853623028658 \
1.625338611183197e-06 0.2459029165157107 1.625338742864406e-06 0.244074199323236 1.625338899457317e-06 0.2419017673596028 1.625339024653875e-06 0.2401755227310949 \
1.625339160371502e-06 0.2383060149301216 1.625339292798663e-06 0.2364844144139329 1.625339412772324e-06 0.2348355337769661 1.625339575820161e-06 0.232606585912384 \
1.625339714627252e-06 0.230713852557009 1.625339853100972e-06 0.2288300961780371 1.625339958645721e-06 0.2273962817971701 1.625340087007401e-06 0.2256537837490921 \
1.625340191135024e-06 0.2242444877898851 1.625340291651026e-06 0.222886569499566 1.625340366695402e-06 0.2218745444235658 1.625340444028458e-06 0.2208349692306942 \
1.625340518791637e-06 0.2198305887827458 1.625340596755314e-06 0.218785487158918 1.625340651621824e-06 0.2180503923904892 1.6253407081186e-06 0.2172938400168352 \
1.625340751572119e-06 0.2167123195211523 1.625340791613165e-06 0.2161767335077376 1.625340830852113e-06 0.2156521099473339 1.62534087172635e-06 0.2151058606261434 \
1.62534092587884e-06 0.2143825797409383 1.625340964295972e-06 0.2138698309421548 1.625341003584678e-06 0.2133480458229882 1.625341065121387e-06 0.2125332203444249 \
1.625341127098916e-06 0.2117131287842428 1.625341183575664e-06 0.2109664019951111 1.625341248207255e-06 0.2101124842966758 1.625341343715876e-06 0.2088522205996687 \
1.625341431031607e-06 0.207701294711168 1.625341527641208e-06 0.2064291756790013 1.625341624870762e-06 0.2051510266126755 1.625341725717823e-06 0.2038307158897115 \
1.625341826317594e-06 0.2025192706911573 1.625341922808891e-06 0.2012627769767186 1.625342024991065e-06 0.1999338657614989 1.625342128630722e-06 0.1985898465970496 \
1.625342238404734e-06 0.1971698847140261 1.62534234757976e-06 0.1957617939809042 1.625342467677852e-06 0.1942174441246506 1.625342577697376e-06 0.1928086337505992 \
1.625342685809285e-06 0.1914295694688549 1.625342808837984e-06 0.1898652723262108 1.625342898948554e-06 0.1887234630454603 1.625343006314045e-06 0.1873671680421656 \
1.625343083125353e-06 0.1864004060894758 1.625343166570621e-06 0.1853535952511875 1.625343256102432e-06 0.1842338297700716 1.625343340667899e-06 0.1831790839553313 \
1.625343420384039e-06 0.1821880912968773 1.625343521709242e-06 0.1809331989518758 1.625343630056471e-06 0.1795959386230563 1.62534372653217e-06 0.1784102562612937 \
1.625343851909986e-06 0.1768766438339704 1.625343984693456e-06 0.1752616821119887 1.62534410246428e-06 0.1738362801839788 1.625344248115856e-06 0.1720835746408261 \
1.625344358713008e-06 0.1707596463148658 1.625344500843447e-06 0.1690680578777541 1.62534461655307e-06 0.1676985735146403 1.625344722027083e-06 0.166456424915798 \
1.625344816543742e-06 0.1653485352650968 1.625344912181115e-06 0.1642320043563913 1.625345009252959e-06 0.1631032360400927 1.625345108304212e-06 0.161956192050434 \
1.625345202227769e-06 0.1608730077890209 1.625345287503444e-06 0.1598934595213354 1.625345387883236e-06 0.1587475631033795 1.625345472186073e-06 0.1577906478848196 \
1.625345574585582e-06 0.1566342854655733 1.625345651979844e-06 0.1557646215197878 1.625345744324758e-06 0.154731814591042 1.62534581457623e-06 0.1539498814072817 \
1.625345910750659e-06 0.1528844393027091 1.625345987575323e-06 0.152038051282755 1.625346066345474e-06 0.1511758489440315 1.625346140238395e-06 0.150370438825067 \
1.625346207936138e-06 0.1496353997608715 1.625346304000026e-06 0.1485973848112393 1.625346373572453e-06 0.1478489919002561 1.625346457461626e-06 0.1469503328160803 \
1.625346518593461e-06 0.146298213254472 1.625346590861543e-06 0.1455309799806117 1.625346663300106e-06 0.1447677488542132 1.625346744281147e-06 0.1439178685120187 \
1.625346810355616e-06 0.1432275520600639 1.625346887756114e-06 0.1424219220725307 1.625346977131571e-06 0.1414956876531561 1.625347047992216e-06 0.1407644282175171 \
1.625347146879283e-06 0.1397487730030469 1.625347224198192e-06 0.1389620820751095 1.625347306243418e-06 0.1381330876879582 1.62534739435453e-06 0.1372467208126059 \
1.625347461981677e-06 0.1365690714953818 1.625347542278859e-06 0.1357674830239305 1.625347617062888e-06 0.1350239185327315 1.625347685064065e-06 0.1343502586094245 \
1.625347731746974e-06 0.1338891847862563 1.625347820998568e-06 0.1330118383700247 1.625347859221617e-06 0.1326395291833771 1.625347928213527e-06 0.1319690872918072 \
1.625347980961596e-06 0.1314578750898332 1.625348063954378e-06 0.1306559489775353 1.625348104132829e-06 0.1302688434457458 1.625348196650203e-06 0.1293805059784019 \
1.62534823536857e-06 0.1290098403727171 1.625348309129285e-06 0.1283055160094505 1.625348370757287e-06 0.1277188748199021 1.625348442784976e-06 0.1270353589407805 \
1.625348510952008e-06 0.1263909833196726 1.625348585574169e-06 0.1256908956540175 1.625348667426635e-06 0.1249253613889138 1.625348750880797e-06 0.124147338931438 \
1.625348823832511e-06 0.1234692772477456 1.625348896559441e-06 0.122795332839617 1.625348956549436e-06 0.1222410931008323 1.625349042917447e-06 0.121445549533078 \
1.625349103886165e-06 0.1208856452315438 1.625349162271956e-06 0.1203507897957366 1.62534922790662e-06 0.119751336354628 1.625349287260861e-06 0.1192111367930785 \
1.625349355292642e-06 0.1185941868697126 1.625349452587012e-06 0.11771710490035 1.625349531078992e-06 0.1170124163111649 1.625349621315123e-06 0.1162055395685231 \
1.625349717161808e-06 0.1153523005684616 1.625349792119505e-06 0.1146878351828532 1.625349896478921e-06 0.1137670532163148 1.625349983267518e-06 0.1130053589403202 \
1.625350092924934e-06 0.1120476726212376 1.625350174478997e-06 0.1113387926087848 1.625350270092629e-06 0.1105114393564785 1.625350346804823e-06 0.10985058581598 \
1.625350441723287e-06 0.1090364400125625 1.625350517546392e-06 0.1083889268999046 1.625350595246049e-06 0.1077282965354292 1.6253506775775e-06 0.1070311517075373 \
1.625350737142764e-06 0.1065286079538068 1.625350800900501e-06 0.1059924133642201 1.625350861995109e-06 0.1054803128126646 1.625350957858847e-06 0.1046801683739134 \
1.625351002721942e-06 0.1043071445723913 1.625351085962687e-06 0.1036173314376927 1.625351135082509e-06 0.1032117000904133 1.625351244131271e-06 0.1023149933518279 \
1.625351288967354e-06 0.1019479364619093 1.625351379228585e-06 0.1012117400678687 1.625351420105203e-06 0.1008795969612472 1.625351490563617e-06 0.1003088525914566 \
1.625351576851038e-06 0.09961307626065434 1.625351668628597e-06 0.09887705578174606 1.62535173815669e-06 0.09832225024344161 1.625351816683849e-06 0.09769854072774181 \
1.625351907412525e-06 0.09698178745350861 1.625351983228664e-06 0.09638605854785212 1.625352065241407e-06 0.09574500473888557 1.625352146994444e-06 0.09510943278387665 \
1.625352237502267e-06 0.09440967388330095 1.625352327061565e-06 0.09372126988887708 1.625352412671398e-06 0.09306698857649189 1.625352505450897e-06 0.09236212353634379 \
1.625352586338857e-06 0.0917510971760913 1.625352687467827e-06 0.09099177263830999 1.625352767961353e-06 0.09039108594384238 1.625352852204218e-06 0.08976589684797046 \
1.625352926049265e-06 0.08922077348043934 1.625353002898743e-06 0.08865632925481931 1.625353091039113e-06 0.08801255002475737 1.625353171103482e-06 0.08743108261130086 \
1.625353264139672e-06 0.08675939571108145 1.625353382140385e-06 0.08591369538214398 1.625353524513613e-06 0.08490278100234279 1.625353668761962e-06 0.08388867104764453 \
1.625353811089671e-06 0.08289807427203813 1.625353960667415e-06 0.08186746790234835 1.625354096981161e-06 0.08093761126893445 1.625354239101592e-06 0.0799778356000513 \
1.62535437365502e-06 0.07907840240745091 1.62535451400773e-06 0.07814980287393705 1.625354661689802e-06 0.0771833418413561 1.625354811805299e-06 0.07621180464723754 \
1.625354976525777e-06 0.07515824360926991 1.625355140155128e-06 0.07412455432658185 1.625355314933688e-06 0.07303438636984133 1.625355502186304e-06 0.07188220095900363 \
1.625355712231308e-06 0.07060976590783831 1.625355930441531e-06 0.06930979572898451 1.62535616389862e-06 0.06794333957253913 1.625356418744638e-06 0.06648001693367038 \
1.625356711839195e-06 0.06483321328442151 1.625357014178957e-06 0.06317411115207273 1.625357328765833e-06 0.06148945259513613 1.625357725026527e-06 0.05942677493938087 \
1.625358058743672e-06 0.05774249301432461 1.625358466054501e-06 0.05574994498853819 1.62535879393926e-06 0.05419380357502902 1.625359150629899e-06 0.05254809000207299 \
1.62535946386806e-06 0.05114243792209583 1.625359766835193e-06 0.04981740498512215 1.625360064375719e-06 0.04854875663330436 1.625360343155274e-06 0.04739109061078805 \
1.625360626155169e-06 0.04624570307560639 1.625360887895477e-06 0.04521055793698023 1.62536116713437e-06 0.04413130357485813 1.62536143924029e-06 0.0431040186124033 \
1.625361746607047e-06 0.04197194005652995 1.625361968409948e-06 0.04117329707315532 1.625362274870428e-06 0.04009446155587663 1.625362501059881e-06 0.03931650950691581 \
1.625362739977206e-06 0.03851359500741255 1.625362964401039e-06 0.03777663690506906 1.625363166663321e-06 0.03712468825868943 1.625363367705949e-06 0.03648814235703791 \
1.625363719479983e-06 0.03540095449820539 1.625363969725821e-06 0.03464776841732944 1.625364216044101e-06 0.03392252499723709 1.625364497376965e-06 0.03311308780599518 \
1.62536474046795e-06 0.03242954897046491 1.625364975941701e-06 0.03178112583711486 1.625365217601206e-06 0.03113119522156456 1.625365454483484e-06 0.03050988948014832 \
1.625365685016041e-06 0.02991733361391674 1.625365898984569e-06 0.02937801894285819 1.625366104927116e-06 0.02886851641492237 1.625366497651603e-06 0.02792196059063811 \
1.625366685729283e-06 0.02747992420741849 1.625367061168249e-06 0.02661861215736662 1.625367236042478e-06 0.02622659266649364 1.625367659365492e-06 0.02530049759795254 \
1.625367780614876e-06 0.02504150687334681 1.625368221176528e-06 0.02412433837770948 1.625368363674648e-06 0.02383402682615681 1.625368695728158e-06 0.02316883068419595 \
1.625368878693682e-06 0.02280879143785283 1.625369267997886e-06 0.02205689891561978 1.625369436343594e-06 0.02173705378531499 1.625369908457993e-06 0.02085107653961301 \
1.625370048202727e-06 0.0205916297664938 1.625370543782805e-06 0.01969297428531048 1.625370671008238e-06 0.01946923320191776 1.625371238917342e-06 0.01851512288677271 \
1.62537140317129e-06 0.0182513999453204 1.625372013043029e-06 0.0173209960017622 1.625372172728257e-06 0.01708922829277545 1.625372699639798e-06 0.01635462467776483 \
1.625372904157091e-06 0.01608193551804103 1.625373627634478e-06 0.01515939662837778 1.62537379307661e-06 0.01495683325581705 1.625374539636356e-06 0.01408081084911163 \
1.625374672939569e-06 0.01393008075245666 1.625375533124155e-06 0.01299799962960837 1.62537566920557e-06 0.01285670227674402 1.625376609799459e-06 0.01192267652923807 \
1.625376773572533e-06 0.01176632439256516 1.625377774751465e-06 0.01084959205883911 1.625377912229187e-06 0.01072929995296418 1.625379082926799e-06 0.009787962024485789 \
1.625379175323166e-06 0.009718668544398181 1.625380593399014e-06 0.008725931027897449 1.625380680375162e-06 0.00866912727384293 1.625382221370793e-06 0.00770199130002063 \
1.625382330686807e-06 0.007633428668288294 1.625383973934629e-06 0.006673746291950173 1.625384106791908e-06 0.006603544020797993 1.625386201172206e-06 0.005605323336654431 \
1.625386409576941e-06 0.00551468736035817 1.625388763913366e-06 0.004577307911602986 1.625389237472123e-06 0.004407121484391641 1.62539212290898e-06 0.003492041675788492 \
1.625392652573326e-06 0.00334538389506189 1.625396860800552e-06 0.00237996320858989 1.625397374234803e-06 0.002283557532494709 1.625403133485496e-06 0.001325291758975802 \
1.625403368066713e-06 0.001279502680325907 1.625418035894088e-06 0.0002809017338477542 1.62541814896418e-06 0.0002788534805396912 1.62805516904393e-06 -0.0006849217749926401 \
1.628055335205606e-06 -0.0009443270389602415 1.628055814074993e-06 -0.001850320037528519 1.62805590679462e-06 -0.002050462221988249 1.628056272019697e-06 -0.002913187630468476 \
1.628056363676814e-06 -0.00314709230904735 1.628056729783165e-06 -0.004133001189868674 1.628056839930291e-06 -0.004442309109773816 1.628057150668543e-06 -0.005311341427314526 \
1.628057252407188e-06 -0.005583925258601597 1.628057616111313e-06 -0.00638370916272213 1.628057780957636e-06 -0.006585924750287024 1.628058360754957e-06 -0.005792290386912202 \
1.628058535589415e-06 -0.004916934050781314 1.628058652279015e-06 -0.00413641027497409 1.628058778708708e-06 -0.00310656561120747 1.628058880730911e-06 -0.002137079422087956 \
1.628059000577393e-06 -0.0008406209844352954 1.628059091214629e-06 0.0002489246187367611 1.628059189634679e-06 0.001536790859923857 1.628059289358324e-06 0.002948496343048522 \
1.628059456842333e-06 0.005545701385567424 1.628059675420934e-06 0.009327395936412004 1.628059861491256e-06 0.0128572688386996 1.628060082873864e-06 0.01737012273305725 \
1.628060243533998e-06 0.02082840415615294 1.628060406999647e-06 0.02447866954313523 1.628060557635164e-06 0.02794359528291388 1.628060706690917e-06 0.03145289236167962 \
1.628060856153671e-06 0.03504014479003619 1.628061010184684e-06 0.03879791952579481 1.628061172300943e-06 0.04280891157365373 1.628061338330408e-06 0.04696567134311741 \
1.628061514283228e-06 0.05141478668696391 1.628061694953866e-06 0.05602187592747932 1.628061886774812e-06 0.06094655248807559 1.628062093880316e-06 0.06629309753158302 \
1.628062315452046e-06 0.07203901748582854 1.628062550186216e-06 0.07814662931008168 1.628062801725783e-06 0.08470684589377442 1.628063077167849e-06 0.09190125212984442 \
1.628063377363668e-06 0.09974607960254324 1.628063708295878e-06 0.108390578238945 1.628064083962612e-06 0.1181923833971668 1.62806448154548e-06 0.1285487285136021 \
1.628064948370082e-06 0.1406786766767902 1.628065491362617e-06 0.1547396794802719 1.62806612478764e-06 0.1710742296429572 1.628066820727691e-06 0.1889259607126788 \
1.6280676362848e-06 0.2097135943149445 1.628068546312904e-06 0.2327316641523666 1.628069339569124e-06 0.2526372689279454 1.6280700450442e-06 0.2702038474981599 \
1.628070663988468e-06 0.2855008995781749 1.628071231094408e-06 0.2994177966724069 1.628071754174414e-06 0.3121574438576628 1.628072253153207e-06 0.3242197130846058 \
1.628072737193214e-06 0.3358335658028451 1.628073192420047e-06 0.3466679577370423 1.628073666932009e-06 0.3578644504627745 1.628074106840717e-06 0.368158604789619 \
1.628074592685345e-06 0.3794271463718566 1.628075124288119e-06 0.3916316501999784 1.628075626951417e-06 0.4030538969706937 1.62807605602367e-06 0.4127111343288326 \
1.628076547040338e-06 0.4236561147984291 1.628077048470419e-06 0.434714731975362 1.628077395015009e-06 0.442288187401736 1.628077750424386e-06 0.4500000616404133 \
1.628078177652114e-06 0.4592019891792938 1.628078569851637e-06 0.4675774400278049 1.628078870233395e-06 0.4739448723400065 1.628079212045155e-06 0.4811381049525967 \
1.628079555484969e-06 0.4883107756756314 1.628079816220096e-06 0.4937186470393492 1.628080058250049e-06 0.4987071765458648 1.628080324195292e-06 0.5041573145298286 \
1.628080581464587e-06 0.509394255416739 1.628080771583691e-06 0.5132422368582924 1.628080985109851e-06 0.5175451019736222 1.628081124800157e-06 0.5203466115392713 \
1.628081271000449e-06 0.5232668091041763 1.62808148498835e-06 0.5275186200231483 1.62808169300461e-06 0.5316389396023125 1.628081885465879e-06 0.5354321131715788 \
1.628082070582111e-06 0.5390651926504321 1.628082244955557e-06 0.5424725330931349 1.628082549497633e-06 0.5484058192982523 1.628082810056515e-06 0.5534602958276967 \
1.628083111487545e-06 0.5592859190791987 1.628083365805138e-06 0.5641865993769294 1.628083658661328e-06 0.5698153316805189 1.62808391787448e-06 0.5747800306938655 \
1.628084188950812e-06 0.579963273174682 1.628084430794572e-06 0.5845680738798381 1.628084688299729e-06 0.5894577538325241 1.628084915043605e-06 0.5937419314630586 \
1.628085152044424e-06 0.5982006324572362 1.628085362230986e-06 0.6021379329905048 1.62808557499152e-06 0.6061060319396779 1.628085827870286e-06 0.6107954169450593 \
1.628086031533554e-06 0.6145509252949414 1.628086222250936e-06 0.6180531102377972 1.628086409587374e-06 0.6214768531423983 1.628086598465652e-06 0.6249070011644339 \
1.628086806665447e-06 0.6286671070650327 1.628087050997562e-06 0.6330499453121026 1.628087250564095e-06 0.6366057789565548 1.628087454709836e-06 0.6402215701419991 \
1.62808763934909e-06 0.643474671963314 1.628087908884781e-06 0.6481901084955864 1.628088136591637e-06 0.652149230294136 1.628088324263375e-06 0.6553888277830079 \
1.62808850516352e-06 0.6584949378977958 1.628088664704602e-06 0.661221510907812 1.628088835167002e-06 0.6641177016088209 1.628088986918443e-06 0.6666817235716488 \
1.628089124561455e-06 0.6689905419339194 1.628089273556319e-06 0.6714784915997724 1.628089401298182e-06 0.6736028790357499 1.628089544284695e-06 0.675968899142866 \
1.628089666067751e-06 0.6779749688503388 1.628089802351161e-06 0.6802121872853304 1.628089922180063e-06 0.682172759947357 1.628090068775624e-06 0.6845626218370968 \
1.628090187248565e-06 0.6864845934661837 1.628090283181927e-06 0.6880368302455475 1.628090375701511e-06 0.6895284278106264 1.628090480762023e-06 0.6912169000724893 \
1.628090578843908e-06 0.6927871490736753 1.628090715959225e-06 0.6949707622226827 1.628090835157868e-06 0.6968607547931925 1.628090945097838e-06 0.6985951241089645 \
1.628091082597082e-06 0.7007503743809057 1.628091214026983e-06 0.7027960765825516 1.628091346256499e-06 0.7048392108129343 1.628091459433897e-06 0.7065756917706891 \
1.628091613866752e-06 0.708927873976708 1.628091744646745e-06 0.7109048231498766 1.628091867315455e-06 0.7127465601965561 1.628091973583711e-06 0.7143329262278221 \
1.628092095963735e-06 0.7161490373358268 1.628092197817232e-06 0.7176517022913665 1.628092331955131e-06 0.7196190116794019 1.628092452648172e-06 0.7213783352064487 \
1.62809257178997e-06 0.7231049829175343 1.628092696807985e-06 0.7249059312823601 1.628092826647791e-06 0.7267645120560844 1.628092946459962e-06 0.7284691779696002 \
1.628093075453213e-06 0.730293808329565 1.628093207560278e-06 0.7321507998840678 1.628093325866095e-06 0.7338038328985433 1.628093469126786e-06 0.7357927618453034 \
1.628093571581473e-06 0.7372070005703254 1.628093667788359e-06 0.7385290937783453 1.62809377280598e-06 0.7399656334130889 1.628093883577511e-06 0.7414708009413548 \
1.628093985256052e-06 0.7428439364018735 1.628094088217507e-06 0.7442258341871242 1.628094205143661e-06 0.7457850038572696 1.628094333903936e-06 0.747489965072781 \
1.628094435062908e-06 0.7488201182152049 1.628094583931952e-06 0.7507626302114226 1.628094731611489e-06 0.75267249971878 1.628094850976855e-06 0.7542038164026367 \
1.6280949974607e-06 0.7560679527984652 1.62809512063619e-06 0.7576223900169708 1.628095261439865e-06 0.7593848990234215 1.628095398032531e-06 0.7610800595258669 \
1.628095520190381e-06 0.7625841275516777 1.628095632846779e-06 0.7639610711610054 1.62809577457292e-06 0.7656796138775311 1.62809590073942e-06 0.767196844592689 \
1.628096016156724e-06 0.768574452686535 1.628096146464904e-06 0.7701179991486644 1.628096262177572e-06 0.7714782821591826 1.62809638500186e-06 0.7729116492687436 \
1.628096502846128e-06 0.7742769236963016 1.628096608476119e-06 0.7754922619072108 1.628096723849554e-06 0.7768108638983861 1.628096829112716e-06 0.7780056027231214 \
1.628096940062529e-06 0.7792565499870431 1.628097026467031e-06 0.7802246528436213 1.628097130500851e-06 0.7813823422463088 1.628097244396594e-06 0.7826398494046257 \
1.628097347430014e-06 0.7837684443710583 1.628097455512714e-06 0.7849432998269023 1.62809756376437e-06 0.7861107422109641 1.628097699181617e-06 0.7875582910536544 \
1.628097811855724e-06 0.7887521292973186 1.628097936279784e-06 0.7900592323105087 1.628098054252648e-06 0.7912877959129118 1.628098198720603e-06 0.7927781272271259 \
1.628098316389742e-06 0.7939806363584788 1.628098452269582e-06 0.7953567374150946 1.628098587013954e-06 0.7967081403609936 1.628098698084933e-06 0.7978123285366109 \
1.628098797974273e-06 0.7987978371087655 1.628098899654231e-06 0.7997937268659365 1.628099032867897e-06 0.8010867894381996 1.628099151240716e-06 0.8022243628210853 \
1.62809927278179e-06 0.8033812848148773 1.628099392145442e-06 0.8045065422543012 1.628099513276819e-06 0.80563739819571 1.628099644976236e-06 0.8068544426691319 \
1.628099767984513e-06 0.8079795872959963 1.62809989582812e-06 0.8091371804586788 1.62810002673464e-06 0.8103101881504271 1.628100150327798e-06 0.8114062915203997 \
1.628100257500303e-06 0.8123479140825919 1.628100364929502e-06 0.8132835730547656 1.628100447598621e-06 0.8139979974227743 1.628100565310381e-06 0.8150069815425507 \
1.628100655915986e-06 0.8157770472204025 1.628100786569431e-06 0.8168774959419571 1.628100930959301e-06 0.8180800468042847 1.628101064133715e-06 0.8191766687328477 \
1.628101174025106e-06 0.8200725423139092 1.628101317623992e-06 0.8212302325252553 1.628101471014683e-06 0.8224508494407716 1.628101599092908e-06 0.8234574467428303 \
1.628101738880276e-06 0.8245431382086058 1.628101865129839e-06 0.8255122018650548 1.628102019728392e-06 0.8266841987320058 1.628102151939368e-06 0.8276738265999063 \
1.628102278166151e-06 0.8286078934539939 1.628102395913874e-06 0.8294698388787296 1.628102544986668e-06 0.8305480062617677 1.628102712318221e-06 0.8317406852496945 \
1.628102845539497e-06 0.8326770812274722 1.62810301832082e-06 0.8338744310092966 1.628103186826193e-06 0.8350236380668206 1.628103356205492e-06 0.8361608866600232 \
1.628103537840761e-06 0.8373606451951652 1.628103680174083e-06 0.8382866867625347 1.628103794011069e-06 0.8390185116470331 1.628103925192579e-06 0.8398522525089582 \
1.628104026724794e-06 0.8404903982372576 1.628104143009054e-06 0.8412135669902132 1.628104277643808e-06 0.8420406924792603 1.628104474666644e-06 0.8432316292878405 \
1.628104664772186e-06 0.8443592803112207 1.628104874895499e-06 0.8455816023960827 1.628105055213604e-06 0.8466107566581813 1.628105252676705e-06 0.8477171937062282 \
1.62810542674582e-06 0.8486750118570332 1.62810560906524e-06 0.8496608982186138 1.628105780480376e-06 0.8505716849290491 1.628105954593653e-06 0.8514808063694008 \
1.628106130324621e-06 0.8523822271368225 1.628106306436321e-06 0.8532696099472232 1.628106496054173e-06 0.8542074684498208 1.62810668683567e-06 0.8551330189126392 \
1.628106888431747e-06 0.8560917259710515 1.628107081166005e-06 0.856990088884472 1.628107290037826e-06 0.8579439907476532 1.628107520740263e-06 0.8589743400177088 \
1.628107785183227e-06 0.8601259267840322 1.628108084005915e-06 0.8613896125360476 1.628108363960216e-06 0.8625380186322354 1.628108648086082e-06 0.8636694076724545 \
1.628108922855057e-06 0.8647317823994775 1.628109194712217e-06 0.8657531067718063 1.628109465089334e-06 0.8667403371654003 1.628109722167856e-06 0.8676533221001362 \
1.628109994792687e-06 0.868594905839151 1.628110270759836e-06 0.8695208838709013 1.628110540864093e-06 0.8704012674911344 1.628110840740104e-06 0.8713491368600049 \
1.628111211801163e-06 0.8724801680184872 1.62811150674079e-06 0.8733472453740196 1.628111761036548e-06 0.8740729094291386 1.628112059297474e-06 0.8748989982677786 \
1.628112332904015e-06 0.8756336613858092 1.628112569029958e-06 0.876250392688866 1.628112809374056e-06 0.8768621356511911 1.628113031706182e-06 0.8774140071409635 \
1.628113225712247e-06 0.8778848105679672 1.628113555434997e-06 0.8786625669521169 1.628113710608526e-06 0.8790190643519731 1.628114028387606e-06 0.879730644938159 \
1.628114207248865e-06 0.8801204696806418 1.628114549710761e-06 0.8808457867651537 1.628114733837363e-06 0.8812245477320809 1.628115208711942e-06 0.8821665346129511 \
1.628115376108352e-06 0.8824869809105039 1.628115841951854e-06 0.883348261932613 1.628116022773548e-06 0.8836708855253055 1.628116516812651e-06 0.8845204537290557 \
1.628116658162059e-06 0.8847551796839913 1.628117264500122e-06 0.8857215808967022 1.628117416569336e-06 0.8859539944113424 1.628118063256356e-06 0.8869009218298172 \
1.628118191551239e-06 0.8870812460539503 1.628118839667745e-06 0.8879562712787433 1.628118969467641e-06 0.8881245027440973 1.62811974767834e-06 0.8890830197250962 \
1.628119862725472e-06 0.8892171882189283 1.628120718396314e-06 0.8901564861234483 1.628120863744077e-06 0.8903061494816453 1.628121849499649e-06 0.8912466483555094 \
1.628122070607711e-06 0.8914402669210102 1.628123215727715e-06 0.892367747196105 1.628123346939159e-06 0.8924695935232408 1.628124688211624e-06 0.8934615053489913 \
1.6281248396029e-06 0.8935661991834861 1.62812632105512e-06 0.8944951400107031 1.628126559934816e-06 0.8946288932334222 1.628128329356654e-06 0.895502508848118 \
1.628128718477945e-06 0.895670668133377 1.628131112210654e-06 0.8965556062201232 1.628131587750593e-06 0.8967047758494365 1.628135650819818e-06 0.8977025964496719 \
1.628136142295654e-06 0.8977953148389237 1.628144458892796e-06 0.8987880790885289 1.628145378794248e-06 0.8988514070442593 1.628299242370168e-06 0.8998485708192639 \
1.628302885496458e-06 0.8998628537402877 1.628529614276672e-06 0.8989664306490068 1.628529844616583e-06 0.8988008565867064 1.62853145953688e-06 0.897804750401333 \
1.628531637269167e-06 0.8977103535805105 1.628548403669272e-06 0.8986978311584225 1.628548539768403e-06 0.8987160394686986 1.628563710608672e-06 0.8997133888183054 \
1.628563987713508e-06 0.899719468756186 1.629048028906422e-06 0.9005852143835333 1.629048202241039e-06 0.9007408621809421 1.629048862730638e-06 0.9015135064485434 \
1.62904902879582e-06 0.9017527716291757 1.629049555130528e-06 0.9026184054967997 1.629049746244448e-06 0.9029704910143604 1.6290501104655e-06 0.9036902342402512 \
1.629050289664921e-06 0.9040628043424317 1.629050651551594e-06 0.9048333795345931 1.629050846661164e-06 0.9052442844328937 1.629051379059525e-06 0.9062266394381637 \
1.629051561413164e-06 0.9064623886473868 1.629052553393556e-06 0.905594670761786 1.629052714934123e-06 0.9049318860608667 1.629052882926576e-06 0.9040378649110347 \
1.629053042758061e-06 0.9029782421366458 1.629053180254799e-06 0.9018984154159868 1.629053313162111e-06 0.9007052793196499 1.629053439587579e-06 0.8994328447569792 \
1.629053546986819e-06 0.8982475863895881 1.629053651483477e-06 0.8970047013543965 1.629053765533147e-06 0.8955451342423859 1.629053855502734e-06 0.8943225684615312 \
1.629053960321373e-06 0.8928208677113324 1.629054049769612e-06 0.891473284704788 1.629054132145393e-06 0.8901820884368528 1.629054223238393e-06 0.8887006634027688 \
1.629054360574471e-06 0.8863657732814155 1.629054459067403e-06 0.8846195012157601 1.629054571141153e-06 0.8825649218508906 1.629054702024186e-06 0.880080778639088 \
1.629054838495216e-06 0.8774018563482072 1.629054991949379e-06 0.8742910281085086 1.629055151043747e-06 0.8709679977889497 1.629055315327649e-06 0.867445283300377 \
1.629055471995751e-06 0.8640104344288071 1.629055624086531e-06 0.860615744772629 1.629055777800206e-06 0.857132398554192 1.629055937362381e-06 0.853469801378647 \
1.629056092451083e-06 0.8498714074018293 1.629056266130402e-06 0.8458039138600054 1.629056429161269e-06 0.8419559450883216 1.629056590803684e-06 0.8381170660338335 \
1.629056753450421e-06 0.8342344554797501 1.629056914868927e-06 0.8303657475978833 1.629057083463406e-06 0.8263109424305363 1.629057266356504e-06 0.8219002364007665 \
1.629057434185218e-06 0.8178440888239877 1.629057602471033e-06 0.8137703061148112 1.629057773299085e-06 0.8096302849976138 1.629057945473642e-06 0.8054541271740473 \
1.629058113235561e-06 0.8013830614994394 1.629058296865019e-06 0.7969255463994016 1.629058468271496e-06 0.7927646873948894 1.629058653714802e-06 0.7882638003278283 \
1.629058820385454e-06 0.7842196820467244 1.629058989271585e-06 0.7801233737411432 1.629059173427882e-06 0.7756572567105651 1.62905936803791e-06 0.7709405333854473 \
1.629059515293242e-06 0.7673736106648734 1.629059641923832e-06 0.7643079795643375 1.629059783780644e-06 0.7608754495129878 1.629059888184422e-06 0.7583505812556488 \
1.629060020577074e-06 0.7551502542766809 1.629060130161271e-06 0.7525028097975122 1.629060263325923e-06 0.7492875979647342 1.629060419507685e-06 0.7455190770546114 \
1.629060532737112e-06 0.7427887939149777 1.629060695258476e-06 0.7388718945951063 1.629060867439291e-06 0.7347246296492568 1.629061063444044e-06 0.7300078517193382 \
1.629061227834023e-06 0.7260553905833119 1.629061380230704e-06 0.7223944885043934 1.629061543905858e-06 0.718466402706526 1.629061711831558e-06 0.7144406657912139 \
1.629061891671936e-06 0.7101336212543717 1.629062067965886e-06 0.7059164985576465 1.629062239040521e-06 0.7018286413152719 1.629062407358697e-06 0.6978099102718778 \
1.629062560624829e-06 0.6941537154717222 1.629062722508398e-06 0.6902960245155986 1.629062901459938e-06 0.6860364417190952 1.62906303567149e-06 0.6828448068431195 \
1.629063139177788e-06 0.6803854168085423 1.629063238462201e-06 0.6780286039046017 1.629063339916677e-06 0.6756220912380299 1.629063432373276e-06 0.6734303711245889 \
1.629063516962075e-06 0.6714267031582685 1.629063610539411e-06 0.6692114082407524 1.629063727081631e-06 0.6664546942583044 1.629063836559192e-06 0.6638675763958631 \
1.629063949672203e-06 0.6611971533414394 1.62906407279097e-06 0.6582923426231613 1.629064197017283e-06 0.6553636581362478 1.629064367777427e-06 0.6513432847262797 \
1.629064526226015e-06 0.6476181700514572 1.629064698513837e-06 0.6435738126612673 1.629064844491904e-06 0.6401512360303271 1.62906498628512e-06 0.6368325564797357 \
1.629065117883574e-06 0.6337564355289309 1.629065248046859e-06 0.630718219665797 1.6290653735718e-06 0.6277924818644975 1.629065505354707e-06 0.6247239543970449 \
1.629065635278203e-06 0.6217046839485236 1.629065771586778e-06 0.6185408917806742 1.629065916200345e-06 0.615188962872713 1.629066075692536e-06 0.611499189008522 \
1.629066249152652e-06 0.6074939486938447 1.629066420159954e-06 0.6035554342946753 1.629066651528523e-06 0.5982402936372396 1.629066894990528e-06 0.5926661367297537 \
1.629067069111016e-06 0.5886942528256315 1.629067215383093e-06 0.5853638081576373 1.629067349755312e-06 0.58231230528805 1.629067466850207e-06 0.5796585826255305 \
1.629067562614553e-06 0.5774900935424465 1.629067661461096e-06 0.5752566196463251 1.629067745438414e-06 0.5733628024369305 1.629067823052464e-06 0.571614165956722 \
1.629067884377937e-06 0.5702331258704825 1.629067949058576e-06 0.5687779664863769 1.629068030366712e-06 0.5669528575016536 1.629068080436707e-06 0.5658306078972934 \
1.629068129757269e-06 0.5647256890740617 1.629068191677069e-06 0.5633393552914843 1.629068239508894e-06 0.5622690492396486 1.62906829001368e-06 0.5611395143522533 \
1.629068350075717e-06 0.559799205480933 1.629068409358512e-06 0.5584782058326896 1.629068484415226e-06 0.5568072508052372 1.629068554097883e-06 0.5552574373576753 \
1.629068639686449e-06 0.5533559356568912 1.629068726753821e-06 0.5514265885063823 1.629068810416341e-06 0.5495763264044081 1.629068896561366e-06 0.5476734676082877 \
1.629068992265987e-06 0.5455621222678217 1.629069096550939e-06 0.5432673229847179 1.629069211218113e-06 0.5407497407899529 1.629069319936574e-06 0.5383664115638558 \
1.629069429508814e-06 0.5359693749054023 1.629069541813574e-06 0.5335193270114367 1.629069668589196e-06 0.530759392645703 1.629069790866427e-06 0.5281021910076299 \
1.629069930952405e-06 0.5250685463469849 1.629070067969763e-06 0.5221084647952599 1.629070218271135e-06 0.5188705764247719 1.629070377166376e-06 0.5154582091324615 \
1.629070551500259e-06 0.5117250894133971 1.629070738517481e-06 0.5077378180012799 1.629070943835486e-06 0.5033745272871338 1.629071155677679e-06 0.498891131759938 \
1.629071408479721e-06 0.4935662239713107 1.62907161056737e-06 0.4893264048484654 1.629071845160675e-06 0.4844277613141263 1.629072081275272e-06 0.4795194943790256 \
1.629072334451769e-06 0.474283574581623 1.629072644981732e-06 0.4679020429045382 1.62907286303971e-06 0.4634451779596257 1.629073036485344e-06 0.4599153839204358 \
1.629073212977781e-06 0.4563351808422506 1.629073492459578e-06 0.4506930409909046 1.629073724703484e-06 0.4460279192631412 1.629074011797073e-06 0.44029020239849 \
1.629074229643181e-06 0.435960758243863 1.629074439695769e-06 0.4318042429497612 1.629074640893605e-06 0.4278406951573778 1.629074823313766e-06 0.4242617300271556 \
1.629074997208751e-06 0.4208637793449936 1.629075162072867e-06 0.4176529694331993 1.62907532082684e-06 0.4145718140694327 1.629075487073787e-06 0.4113577680628809 \
1.629075635718993e-06 0.4084923702366076 1.629075788087249e-06 0.4055658186126443 1.629075930150432e-06 0.4028468403491589 1.62907609952631e-06 0.3996150665462138 \
1.62907621990823e-06 0.3973276483660343 1.629076329881494e-06 0.3952449223617059 1.629076444806895e-06 0.3930732253581283 1.629076597048475e-06 0.3902080468194818 \
1.62907670926954e-06 0.3881039677199808 1.629076816462041e-06 0.386098874836553 1.62907696899029e-06 0.383254723448244 1.629077097137419e-06 0.380874963946598 \
1.629077219985412e-06 0.3786015923730871 1.629077399083788e-06 0.375299968600122 1.62907754816842e-06 0.3725653942578417 1.629077715875808e-06 0.3695018296724824 \
1.629077871273443e-06 0.3666748141177644 1.629077995440288e-06 0.3644243980538668 1.629078109332156e-06 0.3623666676050148 1.629078230775526e-06 0.3601804966264144 \
1.629078410927293e-06 0.3569532670533712 1.629078577415114e-06 0.3539878629329621 1.629078767834223e-06 0.3506138544217919 1.629078959590819e-06 0.3472380408565978 \
1.629079142640212e-06 0.344035729794033 1.629079291612277e-06 0.3414435189591631 1.629079411552182e-06 0.3393660536257183 1.629079534213665e-06 0.3372483242714233 \
1.629079657244152e-06 0.3351324902755385 1.629079802148562e-06 0.3326515017845288 1.629079905461337e-06 0.3308907757076019 1.629079999190846e-06 0.3292979229163631 \
1.629080089851149e-06 0.3277620998585528 1.629080200972602e-06 0.3258853746017661 1.629080308145579e-06 0.3240820510456246 1.62908040642023e-06 0.3224338250618513 \
1.629080518824776e-06 0.3205545940512134 1.629080682764676e-06 0.3178277446588927 1.629080844402555e-06 0.3151576097143818 1.629080992189301e-06 0.3127316247504084 \
1.629081154434516e-06 0.3100832165115083 1.629081314465073e-06 0.3074868334344322 1.629081466728372e-06 0.3050304870660137 1.629081620100242e-06 0.3025703731928215 \
1.629081778808771e-06 0.3000411640344692 1.6290819432579e-06 0.297437246442505 1.629082110484976e-06 0.2948063590562646 1.629082263596514e-06 0.292412731930112 \
1.629082446694441e-06 0.2895700146919417 1.629082637002178e-06 0.2866380344427262 1.629082785905237e-06 0.2843603072871506 1.629082959842542e-06 0.2817165165722222 \
1.62908313671993e-06 0.2790484233348025 1.629083284317149e-06 0.2768363681311815 1.629083473948849e-06 0.2740172295061162 1.629083623950768e-06 0.2718052906662373 \
1.629083761060958e-06 0.2697943906627059 1.629083902591401e-06 0.2677397479842996 1.62908401605027e-06 0.2661005451260196 1.629084152340597e-06 0.2641384584581135 \
1.629084282417217e-06 0.2622807416655737 1.62908440067147e-06 0.2606037730704709 1.629084518527066e-06 0.2589348966568543 1.629084649420877e-06 0.2570853888657079 \
1.629084789659635e-06 0.2551145527343576 1.629084905154221e-06 0.2534976852533538 1.629085034005598e-06 0.2516957519945816 1.62908514915158e-06 0.2500885525459272 \
1.629085302462547e-06 0.2479513765689386 1.629085440316308e-06 0.2460367343642474 1.62908557977796e-06 0.2441002375748529 1.629085735245815e-06 0.2419427021952501 \
1.62908586002843e-06 0.2402176526454788 1.629085999893338e-06 0.2382916534360561 1.629086128595514e-06 0.2365220787132559 1.629086249554366e-06 0.234860341242685 \
1.629086366599666e-06 0.2332541163798121 1.62908649260073e-06 0.2315368940272461 1.629086589320323e-06 0.2302195772445239 1.629086681409196e-06 0.2289683907689286 \
1.629086795826667e-06 0.2274152998827935 1.629086894197314e-06 0.2260807986508055 1.629087011344108e-06 0.2244933520241092 1.629087114435226e-06 0.2231010305483718 \
1.629087219949952e-06 0.2216798666278746 1.629087300868012e-06 0.2205933880575098 1.629087374539197e-06 0.2196046443759679 1.629087417268434e-06 0.2190314036349237 \
1.629087460398579e-06 0.2184540235451489 1.629087511196061e-06 0.217774515685755 1.629087548370939e-06 0.217277430841393 1.629087589041954e-06 0.2167338127731004 \
1.629087631833756e-06 0.2161620985357572 1.629087668244897e-06 0.2156758299561118 1.629087710169888e-06 0.2151161507306283 1.629087764712099e-06 0.2143884526296278 \
1.629087803170857e-06 0.2138756926875936 1.629087842797626e-06 0.2133496230586122 1.629087904630128e-06 0.212531488259555 1.629087966356579e-06 0.2117156525305126 \
1.629088022493854e-06 0.210974237875411 1.629088086149084e-06 0.210134110843225 1.629088180240117e-06 0.2088936328424611 1.629088267048376e-06 0.2077505933124353 \
1.62908836100502e-06 0.2065146061917991 1.629088459047254e-06 0.2052266823513323 1.62908856063462e-06 0.2038976009052371 1.629088661543568e-06 0.2025832113009377 \
1.629088758279377e-06 0.2013244528083448 1.629088860404348e-06 0.1999972806373927 1.629088963735905e-06 0.1986583046056677 1.629089073618507e-06 0.1972379690671278 \
1.629089182560765e-06 0.1958337611883887 1.629089302395885e-06 0.1942937175364915 1.629089412679751e-06 0.1928822800638286 1.629089520558496e-06 0.191507108810815 \
1.629089646621254e-06 0.1899051957406391 1.629089736488961e-06 0.1887671190866151 1.6290898469673e-06 0.1873723090993208 1.629089924500249e-06 0.1863971337376019 \
1.629090008823992e-06 0.1853400660204312 1.62909009641205e-06 0.1842452710069853 1.629090184204644e-06 0.18315095174413 1.629090265924516e-06 0.1821357652581398 \
1.629090363486193e-06 0.1809282658474054 1.629090470197344e-06 0.1796118512064394 1.629090570679026e-06 0.178377576484793 1.629090694850238e-06 0.1768595317522179 \
1.629090828741761e-06 0.1752320886156309 1.629090947653953e-06 0.1737937102924047 1.629091098054147e-06 0.1719851742607024 1.62909120888924e-06 0.1706594030660365 \
1.629091348655982e-06 0.168997130456427 1.62909146718129e-06 0.1675953052211382 1.629091572608521e-06 0.1663548750207849 1.62909166731838e-06 0.1652455210322802 \
1.629091760628155e-06 0.1641568522804657 1.62909186153427e-06 0.1629842804551663 1.629091956952102e-06 0.1618800504313296 1.629092054143026e-06 0.1607598891027116 \
1.629092135704507e-06 0.1598237474547246 1.629092241020952e-06 0.1586229753023833 1.629092324500659e-06 0.1576763029943549 1.629092426029949e-06 0.1565306813704828 \
1.629092503260486e-06 0.1556635090415242 1.629092594132523e-06 0.154647919213242 1.629092663483833e-06 0.1538765336840219 1.629092748067885e-06 0.1529397840535594 \
1.629092822461091e-06 0.1521208717489242 1.629092901831293e-06 0.151251902275755 1.629092976418964e-06 0.1504388356812226 1.629093045640521e-06 0.1496871728711989 \
1.629093140321328e-06 0.1486640077242138 1.629093210087093e-06 0.1479134441579097 1.629093294531656e-06 0.147008717574758 1.629093356097002e-06 0.1463518850554192 \
1.629093430139493e-06 0.1455673550676988 1.629093503525017e-06 0.1447940960774066 1.629093584960259e-06 0.1439395015691976 1.629093654409405e-06 0.1432139999234875 \
1.629093729511102e-06 0.1424323701137583 1.629093819423174e-06 0.1415006120834361 1.629093896506793e-06 0.1407052977810757 1.629093995617377e-06 0.1396885207473417 \
1.62909406515744e-06 0.138983077430453 1.629094146475916e-06 0.1381612812129989 1.629094216644325e-06 0.1374549162714094 1.629094295612438e-06 0.1366629455350578 \
1.62909437459072e-06 0.1358740351737466 1.62909444691251e-06 0.1351544405911459 1.629094516277969e-06 0.1344667589602006 1.629094564981977e-06 0.1339854049281765 \
1.629094655744348e-06 0.1330945614011112 1.629094687765876e-06 0.1327823711724506 1.629094775869844e-06 0.131925672678654 1.629094808363886e-06 0.1316105445757083 \
1.629094907031544e-06 0.1306564447580443 1.629094950687519e-06 0.130235859061297 1.629095028669336e-06 0.1294866595045693 1.629095066000294e-06 0.1291289430202982 \
1.629095168151694e-06 0.128153223240932 1.629095235595654e-06 0.1275115375392494 1.629095300748612e-06 0.1268935577290946 1.629095366654626e-06 0.1262729746041904 \
1.629095437806609e-06 0.1256052797936485 1.62909552074397e-06 0.1248293808775363 1.629095606139451e-06 0.1240331657139879 1.629095682226845e-06 0.1233259817834828 \
1.629095762687521e-06 0.1225806238777534 1.629095820771462e-06 0.1220441728027253 1.629095892104936e-06 0.1213870835332726 1.629095976893369e-06 0.1206085709991845 \
1.629096038048402e-06 0.1200487744399507 1.629096108134853e-06 0.1194096117168642 1.629096170640142e-06 0.1188419501154776 1.62909623664509e-06 0.1182453094891599 \
1.629096305417857e-06 0.1176255789053269 1.629096374874481e-06 0.1170017375875525 1.629096458038731e-06 0.1162574953874909 1.629096531156255e-06 0.1156056107435251 \
1.629096601870241e-06 0.1149774116339468 1.629096661221924e-06 0.1144518657417393 1.629096766519136e-06 0.1135239342411639 1.62909681238663e-06 0.1131212254602471 \
1.629096899340684e-06 0.1123603821649216 1.629096942354464e-06 0.1119852310621949 1.629096987221211e-06 0.1115947726395539 1.629097076954706e-06 0.1108164664143028 \
1.629097147839057e-06 0.110204256460374 1.629097226692571e-06 0.109525796983828 1.629097289470346e-06 0.1089876103666232 1.629097349464702e-06 0.1084750215669379 \
1.629097460462474e-06 0.1075310013968523 1.62909754121676e-06 0.1068475792877216 1.629097653680086e-06 0.1059005796323111 1.629097704824629e-06 0.1054717782906781 \
1.629097787809798e-06 0.1047785948356612 1.629097845974503e-06 0.1042945647727652 1.629097960212503e-06 0.1033482075721767 1.62909801011597e-06 0.1029366076865433 \
1.629098095857569e-06 0.1022320954501846 1.62909814488902e-06 0.1018307629303728 1.629098227455441e-06 0.101157455862875 1.629098298387777e-06 0.1005815064560546 \
1.629098366538127e-06 0.1000302812267231 1.629098444148443e-06 0.0994053199805509 1.629098516491814e-06 0.09882546240595018 1.629098594067778e-06 0.09820656846618626 \
1.629098682738439e-06 0.09750287271560702 1.629098756553227e-06 0.09692010793638871 1.629098838144235e-06 0.09627924899616347 1.629098916282703e-06 0.09566870926115327 \
1.629099002032494e-06 0.09500229249765579 1.629099089729402e-06 0.09432453920671229 1.629099183638967e-06 0.09360304191323381 1.629099280098285e-06 0.09286661217778783 \
1.629099358728946e-06 0.09226977907248698 1.629099461452546e-06 0.09149473120661993 1.629099545280196e-06 0.09086620530027881 1.629099666032378e-06 0.08996702094116031 \
1.629099795302029e-06 0.08901247130467421 1.629099951190493e-06 0.08787237469953549 1.629100106290076e-06 0.08675000010972149 1.629100263305882e-06 0.08562614142917294 \
1.629100443326735e-06 0.08435280068725284 1.629100593847601e-06 0.08330035525696428 1.629100742221624e-06 0.08227363395463329 1.629100879838855e-06 0.08133079092382095 \
1.629101019758505e-06 0.08038162993974078 1.629101156365493e-06 0.07946425488810546 1.629101295092791e-06 0.07854214404995859 1.629101440403653e-06 0.07758663187171365 \
1.629101588151466e-06 0.07662571164688473 1.629101746748333e-06 0.07560598447141591 1.629101911000851e-06 0.07456266320243836 1.629102080017927e-06 0.07350246718885647 \
1.629102261906921e-06 0.07237646636762114 1.62910246252902e-06 0.07115268999588262 1.629102676406562e-06 0.0698691158856425 1.629102904040694e-06 0.0685263410462881 \
1.629103145626235e-06 0.06712722147996912 1.629103427215414e-06 0.06552977831071743 1.629103724369535e-06 0.06388229915275011 1.629104047802612e-06 0.06213267023812474 \
1.629104438962031e-06 0.0600758559534558 1.629104840456333e-06 0.05803293250078725 1.62910521739706e-06 0.05617754872181892 1.629105584510791e-06 0.05442503025024555 \
1.629105934627471e-06 0.05280240270907886 1.629106253933125e-06 0.05136309724710254 1.629106558257407e-06 0.05002640192327024 1.629106855163313e-06 0.04875503464657577 \
1.629107137163639e-06 0.04757867888787161 1.629107417596943e-06 0.04643900623749339 1.629107682320567e-06 0.04538777697325767 1.629107958218279e-06 0.04431704973151576 \
1.629108232683143e-06 0.04327654260273706 1.629108531102424e-06 0.04217254828989973 1.62910875761848e-06 0.04135316230013186 1.629109069531318e-06 0.04025053053625379 \
1.629109289786109e-06 0.03948972371590862 1.629109507050864e-06 0.03875470657060948 1.629109716773513e-06 0.03806113111453101 1.6291100269559e-06 0.03705828856757609 \
1.629110249553778e-06 0.03635538859683734 1.629110496919279e-06 0.03559019656168042 1.629110769325656e-06 0.03476651972027592 1.629110989958209e-06 0.03411384091885184 \
1.62911127423846e-06 0.03329124852897781 1.629111512151753e-06 0.0326183788879464 1.629111750241164e-06 0.03195887699386461 1.629111985496492e-06 0.03132132139405813 \
1.629112214275199e-06 0.03071728735992773 1.629112447005948e-06 0.03011490821398154 1.629112666308989e-06 0.02955843195412813 1.62911287025206e-06 0.02905055018162466 \
1.629113269161796e-06 0.02808303002558106 1.629113456316051e-06 0.02764052191221165 1.629113828521772e-06 0.0267814187683372 1.629114015473295e-06 0.02635997027055515 \
1.629114384827242e-06 0.02554620807076183 1.62911453848041e-06 0.02521471147941385 1.629114954694565e-06 0.02434161493068329 1.629115160182381e-06 0.02392065165079968 \
1.629115499190341e-06 0.02323955384462723 1.629115681885069e-06 0.02287916718068597 1.629116138978978e-06 0.02199597290476789 1.629116268719715e-06 0.02174967209293581 \
1.629116722140138e-06 0.02089828923199067 1.62911686451243e-06 0.0206336680476187 1.629117394079191e-06 0.01967289368906444 1.629117520286197e-06 0.01945139161001456 \
1.629118082520636e-06 0.01850749734048266 1.629118245259022e-06 0.01824627541187189 1.629118809439087e-06 0.01738327200207762 1.629118961183154e-06 0.01716165742474803 \
1.629119662862638e-06 0.01618760396393164 1.629119832951728e-06 0.01596324388168 1.629120488009604e-06 0.01513221026437959 1.629120654523917e-06 0.01492874613340729 \
1.629121387637676e-06 0.01406966818047924 1.629121520900854e-06 0.01391906482409888 1.629122372558029e-06 0.01299647369571925 1.629122510500478e-06 0.01285324185793544 \
1.629123450559967e-06 0.0119198170026788 1.629123614321604e-06 0.01176347583728811 1.629124601555039e-06 0.01085909507266535 1.629124736144115e-06 0.0107410715025141 \
1.629125877583545e-06 0.009819907073012045 1.629125985822443e-06 0.009738548299709823 1.629127309069827e-06 0.00880579379490502 1.629127441815525e-06 0.008718202093769473 \
1.62912896431665e-06 0.007760835273143199 1.629129076858719e-06 0.007690148685505111 1.629130769150306e-06 0.00669558715138598 1.629130909416892e-06 0.00662113250846694 \
1.629132982426194e-06 0.005629132576249021 1.629133174987711e-06 0.005545002188831318 1.629135385197559e-06 0.004656096148610405 1.629135791984232e-06 0.004507219767123045 \
1.629138613724209e-06 0.003590578528330178 1.629139135019959e-06 0.00344214578404881 1.629143347121009e-06 0.002447529662748036 1.629143899683877e-06 0.002340875287107731 \
1.629149782973417e-06 0.001359168649576994 1.629150032246415e-06 0.001311490127959886 1.629163182367465e-06 0.0003136950974005476 1.629163299150435e-06 0.0003112730584132499 \
1.658990000000011e-06 3.042397160644726e-06 1.702746667027013e-06 -0.0009024818035526668 1.702746739442629e-06 -0.001022682652537627 1.702747175467347e-06 -0.001858525046639076 \
1.70274726236173e-06 -0.002046124893065343 1.702747617065043e-06 -0.00288168582347465 1.702747716611644e-06 -0.003135075204051477 1.702747976881349e-06 -0.003828199033013717 \
1.70274811720375e-06 -0.004216406518003108 1.702748344689832e-06 -0.004856871791621592 1.702748481897271e-06 -0.005239031028659006 1.70274886679612e-06 -0.006187559915121 \
1.702748998893307e-06 -0.006423332025500122 1.702749687336335e-06 -0.005917035979538006 1.702749844265069e-06 -0.005202654566481615 1.702749971914231e-06 -0.004414133290428114 \
1.702750099456021e-06 -0.003433350487145549 1.702750217130233e-06 -0.002355902309038119 1.70275031626992e-06 -0.001320627313728655 1.70275042165263e-06 -9.507383675133965e-05 \
1.702750535559933e-06 0.001369964538583592 1.702750666615329e-06 0.003229572948258866 1.702750791978547e-06 0.005172303930030842 1.702750983820411e-06 0.008432154569684791 \
1.702751127490204e-06 0.01107975669588844 1.702751285472017e-06 0.01417105828876112 1.702751434071664e-06 0.01723098336859398 1.702751587122593e-06 0.02051714008521248 \
1.702751746187569e-06 0.02405720796424875 1.702751899257778e-06 0.02756764950178633 1.702752047604842e-06 0.03105219347129199 1.702752196711284e-06 0.03462388853332505 \
1.702752351275713e-06 0.03838854885099419 1.702752511961677e-06 0.04235886888523473 1.702752676640863e-06 0.04647718198980624 1.702752853163806e-06 0.05093664320808645 \
1.702753032175606e-06 0.05549818742091989 1.702753222948448e-06 0.0603932190016783 1.7027534277958e-06 0.06567927942044927 1.702753648293053e-06 0.07139554989571946 \
1.702753881211021e-06 0.07745499876455469 1.702754130458799e-06 0.08395499695136356 1.702754403380327e-06 0.09108394918256098 1.702754700173383e-06 0.09884095133633181 \
1.702755027609896e-06 0.1073964775374675 1.702755397423694e-06 0.1170487607486894 1.702755792369975e-06 0.1273407304921971 1.702756250458528e-06 0.1392499850125259 \
1.702756782558388e-06 0.1530377249371455 1.702757408110397e-06 0.169180864038255 1.702758094102463e-06 0.1867931863309214 1.702758896945878e-06 0.2072766958045763 \
1.70275979625821e-06 0.2300508264895909 1.702760696698323e-06 0.2526618731709107 1.702761498589855e-06 0.2726215666318766 1.702762194096996e-06 0.2897857674353052 \
1.702762826931282e-06 0.3052728323588638 1.702763422339773e-06 0.3197161646377594 1.702763969382815e-06 0.3328722959176427 1.702764503143162e-06 0.3455929446372428 \
1.702765022382586e-06 0.3578476146335662 1.702765529774049e-06 0.3697097539883151 1.702766033395218e-06 0.3813674725871593 1.702766545138114e-06 0.3930934709428262 \
1.702767052299123e-06 0.404595334768291 1.702767582595137e-06 0.4164962117964878 1.702768068708626e-06 0.4272847049163567 1.702768546816947e-06 0.437781779057129 \
1.702768986249071e-06 0.4473362978389137 1.702769109408535e-06 0.4500002106608159 1.702769355727463e-06 0.4553046876287923 1.702769698999458e-06 0.4626558934952216 \
1.702770010436459e-06 0.4692815017887791 1.702770261147724e-06 0.4745855323881177 1.702770531976868e-06 0.480281321066213 1.702770868458777e-06 0.4873122872019196 \
1.702771224467388e-06 0.4946959640027882 1.702771541737556e-06 0.5012322602315481 1.702771780618105e-06 0.506122906570856 1.702772021646287e-06 0.5110269393752048 \
1.702772273577991e-06 0.5161276795544476 1.702772513731835e-06 0.5209621749612534 1.702772736483296e-06 0.5254248476203834 1.702772925040943e-06 0.5291850880529715 \
1.702773139790987e-06 0.5334523706207774 1.702773354339378e-06 0.5376948565446859 1.70277361310367e-06 0.5427871977552768 1.702773863931242e-06 0.5477009885064807 \
1.702774119350104e-06 0.5526782776843104 1.702774470392629e-06 0.5594898819265107 1.702774735000954e-06 0.5645984056527484 1.70277500141751e-06 0.569709962982798 \
1.70277526193182e-06 0.5746801970751495 1.702775529021882e-06 0.5797469183389945 1.702775772159962e-06 0.5843213438768613 1.702776027852189e-06 0.5890994944692448 \
1.702776255671159e-06 0.5933243819692556 1.702776493215979e-06 0.5976999800355528 1.702776704606465e-06 0.6015679915939678 1.702776916747224e-06 0.6054277082074113 \
1.702777105936602e-06 0.6088479815213901 1.70277723709492e-06 0.6112112531841202 1.702777369391478e-06 0.6135871094428261 1.702777554614204e-06 0.6169015645304802 \
1.702777716636591e-06 0.6197943209800671 1.702777875055755e-06 0.6226100751126036 1.702778009167621e-06 0.6249846001944386 1.702778181488729e-06 0.6280247049765127 \
1.702778310427531e-06 0.6302937061188456 1.702778430805044e-06 0.6324061607157294 1.702778571333915e-06 0.634864734791624 1.702778764419407e-06 0.6382321981637986 \
1.702778914230185e-06 0.6408363654380513 1.70277908153778e-06 0.6437327988167145 1.702779262592003e-06 0.6468572757970242 1.702779465918433e-06 0.6503523798695617 \
1.702779648771588e-06 0.6534819287355287 1.702779819395834e-06 0.6563879501053153 1.702779996860074e-06 0.6594029650344411 1.702780162839025e-06 0.6622113135173925 \
1.702780320075814e-06 0.6648594636266301 1.702780460561866e-06 0.6672075432495704 1.702780604291994e-06 0.6695987751186935 1.702780737338985e-06 0.6718055529208897 \
1.702780879311128e-06 0.6741523780906628 1.702780999371661e-06 0.6761293215200647 1.702781144309748e-06 0.6785098354674278 1.702781260306798e-06 0.6804095298668216 \
1.702781379886685e-06 0.6823647593763783 1.70278147884666e-06 0.68397755359623 1.702781597355078e-06 0.6859039329668146 1.70278168439936e-06 0.6873150904607619 \
1.702781806410179e-06 0.6892866586554622 1.702781905332791e-06 0.6908817703737582 1.702781997228166e-06 0.6923536807698466 1.702782097196705e-06 0.6939486118486815 \
1.702782195442366e-06 0.6955126686751646 1.702782287156128e-06 0.6969676095571918 1.70278239128907e-06 0.698613189139943 1.702782527015812e-06 0.7007470979739818 \
1.702782681624274e-06 0.7031613517373301 1.702782816731986e-06 0.7052558942641604 1.702782963068532e-06 0.7075085519458914 1.702783091536073e-06 0.7094732734147607 \
1.702783215720207e-06 0.7113609898537658 1.702783325624507e-06 0.7130225953369277 1.702783442207576e-06 0.7147759898693785 1.702783542385407e-06 0.7162749667021007 \
1.702783679474215e-06 0.7183149847558421 1.702783799463242e-06 0.7200901405411056 1.70278391857669e-06 0.7218426783097279 1.702784045072077e-06 0.723693513465353 \
1.702784170939449e-06 0.7255245570057045 1.702784293560467e-06 0.7272980597885179 1.702784421177991e-06 0.7291334326655684 1.702784551426783e-06 0.7309957624152177 \
1.702784673019733e-06 0.73272442801297 1.702784811788425e-06 0.7346853525547948 1.702784912196869e-06 0.7360963845229137 1.702785015584257e-06 0.7375412410987998 \
1.7027851092447e-06 0.7388443755773992 1.702785220866297e-06 0.7403895158541485 1.702785307334899e-06 0.7415798421827293 1.70278540819801e-06 0.7429609798983192 \
1.702785540294732e-06 0.7447573558536402 1.702785649496034e-06 0.7462323422761349 1.702785754027664e-06 0.747635567415085 1.702785877674145e-06 0.7492836897664436 \
1.70278602637058e-06 0.7512497161812216 1.702786148251239e-06 0.7528480713857697 1.702786261855803e-06 0.7543274008692354 1.702786402375488e-06 0.7561429069656862 \
1.70278654356493e-06 0.7579511824827749 1.702786661311106e-06 0.7594470562859095 1.702786790000766e-06 0.7610693809796742 1.702786932555413e-06 0.7628512182523866 \
1.702787048411964e-06 0.7642872416835913 1.70278719417523e-06 0.7660789429779771 1.702787316007677e-06 0.7675637574673733 1.702787434476374e-06 0.7689965471136999 \
1.702787557264006e-06 0.7704700089613156 1.702787683416889e-06 0.7719718272910862 1.702787793785939e-06 0.7732757954107932 1.702787919217035e-06 0.7747465774777432 \
1.702788024698746e-06 0.775974259539018 1.702788157865176e-06 0.7775122819577122 1.702788280546631e-06 0.7789173428708996 1.702788415309674e-06 0.7804473432620218 \
1.702788525980962e-06 0.7816923373676121 1.702788635302591e-06 0.7829118427552927 1.702788770435025e-06 0.7844048889494442 1.70278892121405e-06 0.7860523747618094 \
1.702789061582958e-06 0.7875692293014268 1.702789181294483e-06 0.7888502570533434 1.702789319548823e-06 0.7903153082715967 1.702789442919159e-06 0.7916096503654788 \
1.702789588017784e-06 0.7931164937536124 1.702789727758043e-06 0.7945521172774316 1.702789854939467e-06 0.7958455533278409 1.70278997397922e-06 0.7970449251022731 \
1.702790086337411e-06 0.7981670522831598 1.702790190566191e-06 0.79919939674296 1.702790285905002e-06 0.8001364844871954 1.702790422193112e-06 0.8014634245741865 \
1.702790539085656e-06 0.8025894467082511 1.702790658725145e-06 0.8037305025474466 1.702790780606717e-06 0.8048811831579785 1.702790902985054e-06 0.8060245537852575 \
1.702791031013733e-06 0.8072081965553952 1.702791155658532e-06 0.8083483262222385 1.702791286157279e-06 0.8095291977395493 1.702791412617707e-06 0.8106611567088965 \
1.702791539743675e-06 0.8117869190804841 1.702791644861151e-06 0.8127087429624065 1.70279175011134e-06 0.8136235164943317 1.702791841251591e-06 0.8144090748259969 \
1.702791964669625e-06 0.8154632009865571 1.702792051748274e-06 0.8162003374872545 1.702792151070959e-06 0.8170344894488412 1.702792295992703e-06 0.8182390501293432 \
1.702792432261206e-06 0.8193582434421302 1.702792541723485e-06 0.8202477434185359 1.702792687843586e-06 0.8214214001843773 1.702792839202198e-06 0.8226208465286928 \
1.70279296500612e-06 0.8236052915965452 1.702793109416779e-06 0.824721541823094 1.70279323401773e-06 0.8256729463037898 1.702793384729791e-06 0.8268094083523665 \
1.70279352010105e-06 0.8278169867326588 1.702793645303979e-06 0.8287379047458127 1.702793762973362e-06 0.829593908450195 1.702793908801339e-06 0.8306418458276996 \
1.70279407529732e-06 0.8318207857986918 1.702794206154408e-06 0.8327345044534114 1.702794379603848e-06 0.833928356718921 1.702794547722322e-06 0.8350667646575466 \
1.702794717596124e-06 0.8361988603660855 1.702794898450754e-06 0.8373843006762304 1.702795041633135e-06 0.8383085120571983 1.702795155746479e-06 0.8390361588138326 \
1.70279528581247e-06 0.8398559950134801 1.702795387687706e-06 0.8404909448220066 1.702795504566998e-06 0.8412116130393378 1.702795641678929e-06 0.8420465258793415 \
1.702795839559572e-06 0.843231707656198 1.702796031345765e-06 0.8443585547012582 1.702796240708828e-06 0.8455646258450146 1.702796422822406e-06 0.846593677725298 \
1.702796619917178e-06 0.8476867969181797 1.702796793185875e-06 0.8486305714188691 1.702796976264561e-06 0.8496104335327738 1.702797147401587e-06 0.8505103231661706 \
1.702797322080438e-06 0.8514128411730317 1.702797497318728e-06 0.8523022053693007 1.702797673458367e-06 0.8531802340241421 1.702797863809624e-06 0.8541115036082744 \
1.70279805438677e-06 0.855025905954957 1.702798254818193e-06 0.8559685891497206 1.702798447410669e-06 0.8568563992305701 1.702798658273806e-06 0.8578086227668252 \
1.702798886187182e-06 0.8588150784816577 1.702799152217719e-06 0.8599606428795262 1.702799450738801e-06 0.8612090806949765 1.702799726692482e-06 0.8623286542354505 \
1.702800010954596e-06 0.8634483918036945 1.702800285103046e-06 0.8644969441068078 1.702800557392313e-06 0.8655088801415273 1.702800827558089e-06 0.8664846790737442 \
1.702801084736186e-06 0.8673881555543895 1.702801357299353e-06 0.868319368003445 1.702801633304697e-06 0.8692355072818493 1.702801903418629e-06 0.870106770567397 \
1.702802203245002e-06 0.8710447971670072 1.702802574222291e-06 0.8721640818024149 1.702802869154012e-06 0.8730224021943973 1.702803123432376e-06 0.873740732376842 \
1.702803421677207e-06 0.8745584461000401 1.702803695285219e-06 0.8752856917963749 1.702803931415444e-06 0.8758961959341748 1.702804171760979e-06 0.8765017794770257 \
1.702804394097168e-06 0.8770481951318053 1.70280458810245e-06 0.8775144010549708 1.702804917823794e-06 0.8782846129827527 1.70280507299682e-06 0.8786376896881318 \
1.702805390752408e-06 0.8793424631377607 1.702805569616983e-06 0.8797286397841958 1.702805912078462e-06 0.8804474051285093 1.702806096217817e-06 0.880822800830328 \
1.702806571118475e-06 0.881756283451624 1.702806738513154e-06 0.8820737784441692 1.7028072043462e-06 0.8829272622221894 1.702807385170493e-06 0.8832470363605239 \
1.702807879204793e-06 0.8840891816604841 1.702808020548669e-06 0.8843218944112644 1.702808626940586e-06 0.8852805359894154 1.702808779011766e-06 0.8855111592597558 \
1.702809425691436e-06 0.8864506941541785 1.702809553987642e-06 0.8866295550025313 1.702810202164815e-06 0.8874976172723908 1.702810331923675e-06 0.8876644392549727 \
1.702811100144497e-06 0.8886037370453904 1.702811229881009e-06 0.8887539063021698 1.702812083306654e-06 0.8896836309705964 1.702812226565088e-06 0.8898301468060963 \
1.702813212785821e-06 0.890764641901611 1.702813434267227e-06 0.8909571971396437 1.702814577308628e-06 0.8918770673440963 1.702814707298117e-06 0.8919774876506176 \
1.702816058923389e-06 0.8929731820841386 1.70281620928357e-06 0.89307657739048 1.702817689916169e-06 0.8939986636922405 1.702817928817934e-06 0.8941315911431026 \
1.702819693311633e-06 0.894999985510941 1.702820000994978e-06 0.8951330875684044 1.702822522266181e-06 0.8960612226716312 1.702822959317422e-06 0.8961978289811912 \
1.702826862729643e-06 0.8971619289239613 1.70282710951145e-06 0.8972094058147089 1.702834686001284e-06 0.8981998139535015 1.702834801913031e-06 0.8982099955090975 \
1.702853900445735e-06 0.8992062631372056 1.702854297888509e-06 0.8992194728667773 1.70300471332359e-06 0.9002121614362558 1.703004979381947e-06 0.9002436812458944 \
1.703010247532015e-06 0.8993470931706574 1.703010453902932e-06 0.899191170936528 1.703011932015742e-06 0.8982046351054961 1.703012112466399e-06 0.8981003355419954 \
1.703014334948061e-06 0.8971299612768925 1.703014541040576e-06 0.897079983173831 1.703024949306681e-06 0.8980580240048047 1.703025087164257e-06 0.8980839755683444 \
1.703031884513298e-06 0.8990685088718567 1.703032070084766e-06 0.8990874390200084 1.703528299258968e-06 0.9000706848616691 1.703528359054814e-06 0.9000975977971888 \
1.703529612605432e-06 0.9010828413531861 1.703529718298035e-06 0.9012097231395001 1.703530376428752e-06 0.9021613947651476 1.703530513611021e-06 0.9023918767045529 \
1.703531036637641e-06 0.9033649777562528 1.703531099501233e-06 0.9034908765919824 1.703531572096782e-06 0.904476514442582 1.703531623410595e-06 0.9045863669199017 \
1.703532089373931e-06 0.9055619780118375 1.703532121578392e-06 0.9056252631670594 1.703532838677129e-06 0.9066212416280413 1.703532923113402e-06 0.9066528951765993 \
1.703533523179781e-06 0.9059679814895146 1.703533643037393e-06 0.9055903401525059 1.703533774200172e-06 0.9050640446667092 1.703533909019925e-06 0.9043926011431642 \
1.703534057154984e-06 0.9034897747335404 1.703534194714335e-06 0.902493211317788 1.703534334926095e-06 0.9013135799985507 1.703534433588205e-06 0.9003872218501816 \
1.703534519272014e-06 0.8995148096066522 1.703534601836213e-06 0.8986166894493001 1.703534716618842e-06 0.8972773101170661 1.703534797717086e-06 0.8962642459447687 \
1.703534877134364e-06 0.8952218112132616 1.703534982588892e-06 0.8937633947192651 1.703535105230195e-06 0.8919606744930825 1.703535204954274e-06 0.890414036797163 \
1.703535375148685e-06 0.8876203405523397 1.703535521333777e-06 0.8850727273800474 1.703535689551925e-06 0.8819879035815887 1.703535861713021e-06 0.8786780617039783 \
1.703536046099114e-06 0.8749807502679057 1.703536230665458e-06 0.8711418063496947 1.703536414912944e-06 0.8671917613865908 1.703536600248607e-06 0.8631174608718694 \
1.703536774636335e-06 0.8592060069639053 1.703536957340272e-06 0.8550405244181323 1.703537132687366e-06 0.8509893565349284 1.703537315016877e-06 0.8467313026054767 \
1.703537505330306e-06 0.8422468264612591 1.703537675660435e-06 0.838204894125699 1.703537842184074e-06 0.8342320488410089 1.703538004754937e-06 0.830337741667393 \
1.70353815461616e-06 0.8267359097041467 1.703538305792179e-06 0.8230937075736249 1.703538494937653e-06 0.8185270080344306 1.703538640655707e-06 0.8150026134285653 \
1.703538815646674e-06 0.8107652770601156 1.703538964118217e-06 0.807166938184282 1.703539136005683e-06 0.8029987283123258 1.703539305073922e-06 0.7988973224349885 \
1.703539469252632e-06 0.7949140139776875 1.703539628580169e-06 0.7910485911592836 1.703539789029776e-06 0.7871568543472617 1.703539990849157e-06 0.7822630953020117 \
1.703540139296892e-06 0.7786646206504594 1.703540293464276e-06 0.77492821376164 1.703540430547636e-06 0.7716074476660475 1.703540539933082e-06 0.7689587163513494 \
1.703540645866538e-06 0.7663946531324515 1.703540772880885e-06 0.7633217481666642 1.703540887243854e-06 0.7605561828888391 1.703540990091676e-06 0.7580702160470256 \
1.703541111681992e-06 0.7551325442760125 1.703541222459267e-06 0.7524575925939972 1.703541339308092e-06 0.7496376180588871 1.703541450092818e-06 0.7469652567786068 \
1.703541568458919e-06 0.7441116745915923 1.703541693286014e-06 0.7411038668912771 1.70354184584781e-06 0.7374292753756717 1.703541979744798e-06 0.7342062928952946 \
1.703542100776237e-06 0.7312947572377408 1.703542264973752e-06 0.7273475399259534 1.703542442334699e-06 0.7230877912371642 1.703542624545108e-06 0.7187161681757385 \
1.703542805542373e-06 0.7143786395952922 1.703542986206316e-06 0.7100537072471783 1.703543176357883e-06 0.7055071781827296 1.703543364117777e-06 0.7010230964996226 \
1.703543564650881e-06 0.696237807975249 1.703543773336343e-06 0.6912646166759551 1.703543980979908e-06 0.6863227581165517 1.703544208547776e-06 0.6809140411171237 \
1.70354440082261e-06 0.6763521085712711 1.703544638087858e-06 0.6707310800019505 1.703544831366122e-06 0.6661595641347996 1.703545064098869e-06 0.6606646229758047 \
1.703545269656336e-06 0.6558174602470968 1.703545502009757e-06 0.6503484594495911 1.703545697011728e-06 0.6457674053103037 1.703545900240336e-06 0.6410004262200759 \
1.703546080092881e-06 0.6367906205544323 1.703546259199312e-06 0.6326052789263827 1.703546422576526e-06 0.628795088826817 1.70354659462593e-06 0.6247880828503264 \
1.703546758118769e-06 0.6209892715878097 1.703546933908587e-06 0.6169100951581823 1.703547115847573e-06 0.6126978430086294 1.703547304331305e-06 0.6083422542008314 \
1.703547510763727e-06 0.6035858951323969 1.70354769007839e-06 0.5994633272559844 1.703547887257256e-06 0.5949432360761027 1.703548096345397e-06 0.5901646611556908 \
1.70354830209466e-06 0.5854760387944159 1.703548542605348e-06 0.5800160304866983 1.70354871573345e-06 0.5760958285528379 1.703548880627452e-06 0.5723746772837877 \
1.703549061488027e-06 0.5683014035092815 1.703549218774123e-06 0.5647722902613652 1.703549387756918e-06 0.5609879409349005 1.703549567863379e-06 0.5569709657351898 \
1.703549720846506e-06 0.5535669615732179 1.703549852560951e-06 0.5506462283231492 1.703549999948651e-06 0.5473865746199473 1.703550087374242e-06 0.5454560063082221 \
1.703550172245482e-06 0.5435860258811447 1.703550270874694e-06 0.5414171943998213 1.703550342966855e-06 0.5398340751058975 1.703550440057874e-06 0.5377039800781129 \
1.703550525648258e-06 0.5358302678688993 1.703550590729134e-06 0.5344081412607664 1.703550714329502e-06 0.5317121235594142 1.703550808753772e-06 0.52965475734789 \
1.703550906276994e-06 0.5275349985745696 1.703551079137645e-06 0.5237893654184622 1.703551214133166e-06 0.5208709659121862 1.703551368316628e-06 0.5175498113398643 \
1.703551542781984e-06 0.5138002600288881 1.70355169458797e-06 0.510550000123414 1.703551840818953e-06 0.5074290310664136 1.703551984717826e-06 0.5043644611166801 \
1.703552127739669e-06 0.5013276181140283 1.703552223349517e-06 0.499301733014788 1.703552317793473e-06 0.4973032961550828 1.703552438849414e-06 0.4947494705229025 \
1.70355253372771e-06 0.4927525559781179 1.703552649558553e-06 0.4903172469328811 1.703552736822402e-06 0.4884854516151125 1.703552819252848e-06 0.4867593351188191 \
1.703552914660801e-06 0.484765406725184 1.703553015371081e-06 0.4826639978995959 1.703553112231473e-06 0.4806459052877932 1.703553250961225e-06 0.4777646955734051 \
1.703553386666086e-06 0.4749532752442271 1.703553587150809e-06 0.4708139964547478 1.703553802464962e-06 0.4663911383470885 1.703553984040267e-06 0.462674698484628 \
1.703554183012236e-06 0.4586189944293299 1.703554353577757e-06 0.455154096457448 1.703554527931445e-06 0.4516251957269069 1.703554696864699e-06 0.4482170126441485 \
1.70355486946186e-06 0.4447467276163349 1.70355505206819e-06 0.4410867902598327 1.703555240617055e-06 0.4373240875354826 1.703555434084593e-06 0.4334777823509549 \
1.703555642405232e-06 0.4293535036700135 1.703555856750462e-06 0.4251286740881063 1.703556082455792e-06 0.4207018662297695 1.70355630899916e-06 0.4162771402745992 \
1.703556571175911e-06 0.4111844468197049 1.703556820209735e-06 0.4063709766754009 1.703557121308433e-06 0.4005865607947761 1.70355741072925e-06 0.3950673729298416 \
1.703557718243529e-06 0.3892455819062323 1.703558040439924e-06 0.3831936848847286 1.703558368170407e-06 0.3770882112794804 1.703558700600163e-06 0.3709500980558715 \
1.70355903032917e-06 0.3649083177186754 1.703559351558758e-06 0.3590729273462687 1.703559682375082e-06 0.3531219177045733 1.703560024730645e-06 0.3470224718704957 \
1.703560324371677e-06 0.3417374346434491 1.703560654159242e-06 0.3359723367088904 1.703560981053185e-06 0.3303128110141857 1.703561319032532e-06 0.3245206193888226 \
1.703561628003696e-06 0.3192755432624759 1.703561952801669e-06 0.31382336954194 1.703562268431866e-06 0.3085864885517507 1.703562573419032e-06 0.3035810258414895 \
1.703562828757677e-06 0.2994330834535801 1.703563093620834e-06 0.295170851203172 1.703563380703519e-06 0.2905978071194348 1.703563603673297e-06 0.2870801635277143 \
1.703563803212566e-06 0.2839591363066187 1.70356401286858e-06 0.2807045410859125 1.703564193125121e-06 0.2779290029372279 1.703564355469842e-06 0.2754463208250681 \
1.703564505904816e-06 0.2731629026725527 1.703564656910124e-06 0.2708866524077067 1.703564853800715e-06 0.2679392949564011 1.703564984945479e-06 0.2659970646012914 \
1.703565109682017e-06 0.2641561221543183 1.70356526127406e-06 0.2619266655689588 1.703565357242231e-06 0.2605306204207966 1.7035654537936e-06 0.2591282589302421 \
1.703565578413389e-06 0.2573209601776467 1.703565720989923e-06 0.255257422470362 1.703565879923458e-06 0.25296979123958 1.703566012589525e-06 0.251062957019046 \
1.703566196158294e-06 0.2484301322588876 1.70356637739346e-06 0.2458327969660818 1.703566588907564e-06 0.2428051031600066 1.703566791497399e-06 0.2399069804317323 \
1.703566958053847e-06 0.2375282895552967 1.703567168273059e-06 0.2345337828133105 1.703567341690945e-06 0.2320692345528927 1.703567570533673e-06 0.2288260787734411 \
1.703567791168424e-06 0.2257162440502939 1.703567966830138e-06 0.2232503232699662 1.703568147290643e-06 0.2207258962977968 1.703568318047021e-06 0.2183528725291195 \
1.703568498243287e-06 0.2158619697278009 1.703568664973905e-06 0.2135675266585953 1.703568814095326e-06 0.2115251542210239 1.703568969905344e-06 0.2094125291275523 \
1.703569105085769e-06 0.2075875692769576 1.703569255167197e-06 0.2055694209972212 1.703569387612823e-06 0.2037957203154137 1.703569528157359e-06 0.2019220745191926 \
1.703569645226124e-06 0.2003748851744883 1.70356977493373e-06 0.1986681706274326 1.703569896991199e-06 0.1970700654731777 1.703570019534635e-06 0.1954731161836187 \
1.703570137553958e-06 0.1939418157697267 1.703570272576731e-06 0.1921981789937757 1.703570417201182e-06 0.1903420634523806 1.703570545551681e-06 0.1887049708672087 \
1.703570669186156e-06 0.1871351133418249 1.703570766736279e-06 0.1859021016257166 1.703570881809208e-06 0.1844539912642748 1.703570975507888e-06 0.1832809848801438 \
1.703571074292012e-06 0.1820493959460708 1.703571197226553e-06 0.1805230483556907 1.703571292980556e-06 0.1793400249325384 1.703571422068107e-06 0.177753298391591 \
1.703571524533477e-06 0.1764993061988986 1.703571622786974e-06 0.1753029542432101 1.703571742874187e-06 0.1738483570896001 1.703571845423405e-06 0.1726127298531683 \
1.703571955881064e-06 0.1712877101305652 1.703572084370928e-06 0.1697552709290656 1.703572175855769e-06 0.1686698090598139 1.703572280340358e-06 0.1674358120019214 \
1.703572355277094e-06 0.1665544493622226 1.703572444845591e-06 0.1655049734124585 1.7035724954106e-06 0.164914347906921 1.703572545388976e-06 0.1643318187475747 \
1.703572610358061e-06 0.163576534137217 1.703572645872029e-06 0.1631646263336159 1.703572718071202e-06 0.162329174921529 1.703572785200297e-06 0.1615546732967998 \
1.703572844430032e-06 0.160873195114598 1.70357288817563e-06 0.1603710314414745 1.703572935822458e-06 0.1598254649913795 1.703573006202993e-06 0.1590230739426561 \
1.703573088541159e-06 0.1580883269013631 1.703573166712759e-06 0.1572048664554128 1.703573248765708e-06 0.1562816770844126 1.703573341469331e-06 0.1552436243401225 \
1.703573464249495e-06 0.153877370231325 1.703573563395588e-06 0.1527810927807017 1.703573664895935e-06 0.1516651170047695 1.703573766171126e-06 0.1505582666538253 \
1.703573862662911e-06 0.1495093242781697 1.703573962080946e-06 0.1484346886615803 1.703574046381569e-06 0.1475281828465028 1.703574139320259e-06 0.1465342051547719 \
1.7035742219212e-06 0.1456551508734999 1.703574330687285e-06 0.1445034822456445 1.703574436330265e-06 0.1433917535370727 1.703574517989854e-06 0.1425365900703354 \
1.703574611735024e-06 0.1415598856352903 1.703574705302971e-06 0.1405903867550886 1.703574788187462e-06 0.139735765814107 1.703574876346636e-06 0.1388313836440244 \
1.703574956132722e-06 0.1380170907865772 1.703575049728122e-06 0.1370669869522621 1.703575139660646e-06 0.1361590166429519 1.703575210211042e-06 0.1354501541392388 \
1.703575279971219e-06 0.1347521119166949 1.703575394120126e-06 0.1336164586193709 1.70357547609874e-06 0.1328058651355588 1.703575563704042e-06 0.1319440719770354 \
1.703575663205238e-06 0.1309710196939938 1.703575772385241e-06 0.1299110174488692 1.703575874550573e-06 0.1289256009328031 1.703575982010779e-06 0.1278959836800649 \
1.703576102045057e-06 0.1267549558890445 1.703576196253091e-06 0.1258657925752028 1.703576327232195e-06 0.1246390638240933 1.703576426659896e-06 0.1237164070883829 \
1.703576535781582e-06 0.1227104370444639 1.70357664463475e-06 0.1217138859540913 1.703576736944154e-06 0.120874257454373 1.703576849784484e-06 0.1198547128626846 \
1.703576946796524e-06 0.118986084968971 1.703577051062872e-06 0.1180628196869088 1.703577160029802e-06 0.1171053395831002 1.703577259569368e-06 0.1162371554254778 \
1.703577376562078e-06 0.1152245300989246 1.703577463662868e-06 0.1144761644999183 1.70357757295452e-06 0.1135478691973115 1.703577654479583e-06 0.1128618460838699 \
1.703577754254576e-06 0.1120273350449922 1.703577871679726e-06 0.1110526766231405 1.703577973464844e-06 0.1102143708571793 1.703578061203792e-06 0.1094962336869811 \
1.7035781420033e-06 0.1088432886892514 1.703578228954319e-06 0.1081456845520918 1.703578309740945e-06 0.1075007757815706 1.703578399947511e-06 0.1067842832273628 \
1.703578490898266e-06 0.1060655611559195 1.70357857956879e-06 0.1053685613006139 1.703578678583611e-06 0.1045946508745568 1.703578772289787e-06 0.1038723470842792 \
1.703578866149063e-06 0.1031520741219857 1.703578966976511e-06 0.1023817709659086 1.703579071607409e-06 0.1015861061604995 1.703579195570165e-06 0.1006484085638475 \
1.703579292969478e-06 0.09991551135558702 1.703579413227425e-06 0.09901872452754552 1.7035795240953e-06 0.09819831936474602 1.703579628568336e-06 0.09742874659471555 \
1.703579745805045e-06 0.09656937225591002 1.703579847599366e-06 0.09582695326576983 1.703579945574917e-06 0.09511577589263259 1.703580086079406e-06 0.09410164141823299 \
1.703580191157202e-06 0.09334832721827611 1.703580289770019e-06 0.09264549593674179 1.703580382484827e-06 0.09198739948435641 1.703580468683212e-06 0.09137785861853052 \
1.703580562596188e-06 0.09071637432184691 1.703580659696934e-06 0.09003559055802626 1.703580769117988e-06 0.08927317549644689 1.703580870101537e-06 0.08857281843916648 \
1.703580963759483e-06 0.08792605868920525 1.703581037934155e-06 0.08741581771673042 1.703581175834007e-06 0.08647193599618339 1.703581248191011e-06 0.08597917321277694 \
1.703581383512214e-06 0.08506274029062395 1.703581469423819e-06 0.08448410751389913 1.703581614152054e-06 0.08351486081643937 1.703581710382619e-06 0.0828744112740944 \
1.703581798218398e-06 0.08229260392026354 1.703581914017306e-06 0.08152964121883956 1.703582029145757e-06 0.08077575264951149 1.70358214291219e-06 0.08003553900012179 \
1.703582283169683e-06 0.0791300282244784 1.703582424545716e-06 0.07822490276368012 1.703582574181758e-06 0.07727536491519127 1.703582718670613e-06 0.07636690312463701 \
1.703582869844724e-06 0.07542565384097814 1.703583019215544e-06 0.07450459906593411 1.703583168562251e-06 0.0735926433331697 1.703583328517767e-06 0.07262574717347114 \
1.703583484664678e-06 0.07169171823582712 1.703583659153112e-06 0.07065947636250877 1.703583828862219e-06 0.0696671357044583 1.703584014041303e-06 0.0685979885997255 \
1.70358421076238e-06 0.06747763456279594 1.7035844212802e-06 0.06629631776014881 1.703584643312255e-06 0.06507007089066431 1.703584873524276e-06 0.0638195278444372 \
1.703585116035382e-06 0.06252626147401 1.703585376689467e-06 0.06116236403900636 1.703585656588531e-06 0.05972739422233359 1.703585950172255e-06 0.05825544847408989 \
1.703586265108239e-06 0.05671370145268265 1.703586607914164e-06 0.05507846134953124 1.703586957380758e-06 0.0534565727116736 1.703587366284915e-06 0.05161746230842366 \
1.703587712949942e-06 0.05010669351290297 1.703588100364996e-06 0.04846839895323611 1.703588444582788e-06 0.04705645202362623 1.703588768009047e-06 0.04576625679949029 \
1.703589073054809e-06 0.04458093278443617 1.703589365916806e-06 0.04347099288378908 1.703589650057723e-06 0.04242242262004604 1.703589926078015e-06 0.04142902112907627 \
1.703590192930566e-06 0.04049015932812138 1.703590461822789e-06 0.03956531631184226 1.703590737883211e-06 0.03863769040165695 1.703591025478782e-06 0.03769451689421055 \
1.703591265044408e-06 0.03692662498323904 1.703591554211835e-06 0.03602084344675294 1.703591770003438e-06 0.03535960341037672 1.703591957720476e-06 0.03479599077274986 \
1.703592155849582e-06 0.03421285035004928 1.703592518724446e-06 0.03317032497347058 1.703592776866276e-06 0.03244834222605905 1.70359308657919e-06 0.0316030971185694 \
1.703593352049329e-06 0.03089664771451467 1.703593620168408e-06 0.03019941363307669 1.703593899042439e-06 0.02949128999862272 1.703594145228875e-06 0.02888043298519722 \
1.703594375860285e-06 0.02832033800396738 1.703594614150204e-06 0.02775711540944564 1.703594849157568e-06 0.02721270742060762 1.703595076940031e-06 0.02669509678424227 \
1.703595485552303e-06 0.02579039168486155 1.703595661854632e-06 0.02540904040268441 1.703596016332316e-06 0.02465798827491217 1.703596200203288e-06 0.02427641469830137 \
1.70359653515201e-06 0.02359448510613503 1.703596699060727e-06 0.02326678168937357 1.703597091331304e-06 0.02249905491676728 1.703597247322069e-06 0.02220010404946675 \
1.703597678925426e-06 0.02138321689778962 1.703597816314806e-06 0.0211255367654138 1.703598333123589e-06 0.02017559010600388 1.703598458659483e-06 0.01995091418019728 \
1.703598915901007e-06 0.01915998482559782 1.703599075046989e-06 0.01889493739859509 1.703599682285467e-06 0.01793263500095189 1.703599816822955e-06 0.01772934138481063 \
1.703600480086948e-06 0.01678091027541291 1.703600673410379e-06 0.01651856846389665 1.703601341067039e-06 0.01565087920017967 1.703601502655887e-06 0.01544858341705342 \
1.70360225789114e-06 0.01454101846553843 1.703602407452107e-06 0.01436800730673201 1.703603297789931e-06 0.01338293844200974 1.703603396447817e-06 0.01327873262558703 \
1.703604353121314e-06 0.01230993787860994 1.703604474231021e-06 0.01219243157195396 1.70360546572373e-06 0.01126376273051215 1.70360562925246e-06 0.01111855113153209 \
1.703606759174536e-06 0.01018247077230436 1.703606871621774e-06 0.01009565848301377 1.703608249445262e-06 0.009103273453806031 1.703608388390533e-06 0.009009747578659758 \
1.703609942788868e-06 0.008018073335410726 1.70361005485534e-06 0.00794673960805117 1.70361169983817e-06 0.006958154532207958 1.703611807090665e-06 0.006899512253112593 \
1.703613751584152e-06 0.005937533026687714 1.70361395848211e-06 0.005843834961138424 1.703616297369853e-06 0.00487227039639981 1.703616721356264e-06 0.004712306502041247 \
1.70361949358946e-06 0.003780857497341114 1.703619941898552e-06 0.003647790772321777 1.703623582397237e-06 0.00272553831825111 1.703624079053072e-06 0.002619503085887757 \
1.703629830173496e-06 0.001650572925599863 1.703630116955383e-06 0.001609446887446839 1.703635471944067e-06 0.0006353228983793809 1.703635677300692e-06 0.0005920420449145349 \
1.706282712074507e-06 -0.0002718533828215428 1.706282867950111e-06 -0.0004579010352009555 1.706283416265203e-06 -0.001326296959495401 1.706283529048879e-06 -0.001543805653187533 \
1.706283963541018e-06 -0.002491429791030493 1.706284039366175e-06 -0.002673591589873599 1.706284396016773e-06 -0.003590195133438418 1.706284523065853e-06 -0.003936807634339821 \
1.706284801566247e-06 -0.004716444651655622 1.70628490965073e-06 -0.005020876868076652 1.706285253249855e-06 -0.00592430224391268 1.70628536024372e-06 -0.006162325733041658 \
1.706286259614116e-06 -0.005653094509861465 1.706286438047545e-06 -0.004687598829536962 1.70628654377096e-06 -0.003940993102967527 1.706286668833738e-06 -0.002883597584075996 \
1.706286762417834e-06 -0.001971418478057775 1.706286840257396e-06 -0.001132968824455395 1.706286920329394e-06 -0.0001977429743171 1.706287042702205e-06 0.001370578777960296 \
1.706287160958077e-06 0.003041212838230153 1.706287279607187e-06 0.004860750887681821 1.706287393089626e-06 0.006730904986417607 1.706287496532764e-06 0.008536402178002854 \
1.706287611192018e-06 0.01064190690353853 1.706287801775811e-06 0.0143607330143792 1.706287935565949e-06 0.01711819191720031 1.706288085819515e-06 0.02033933849841947 \
1.706288240988763e-06 0.02378599874269359 1.706288396380811e-06 0.0273434151175349 1.706288544088043e-06 0.03080849965087477 1.706288693077668e-06 0.03437359286003162 \
1.706288848068751e-06 0.03814545786868043 1.706289007439365e-06 0.04208062121327779 1.706289172372776e-06 0.04620305710844342 1.706289347319104e-06 0.0506208066052034 \
1.706289526449176e-06 0.05518387280380205 1.706289716238432e-06 0.06005265756871143 1.7062899199354e-06 0.06530840376289772 1.706290139745932e-06 0.07100650943730057 \
1.706290371497376e-06 0.07703584544314998 1.706290619322673e-06 0.08349927754587044 1.706290890643603e-06 0.09058756662233436 1.706291185356381e-06 0.09829181712822582 \
1.706291510614029e-06 0.106792896697727 1.706291876859735e-06 0.1163551101154179 1.706292270156448e-06 0.1266079356677421 1.706292722809344e-06 0.1383809089651769 \
1.706293248524511e-06 0.1520098384503803 1.706293867738049e-06 0.1679979965193872 1.706294548482366e-06 0.1854865650013753 1.70629534215732e-06 0.2057488551561759 \
1.706296230922953e-06 0.2282732214494322 1.706297044312215e-06 0.2487218262351868 1.706297766061792e-06 0.2667261628598245 1.7062984017258e-06 0.282460740414376 \
1.706298973442562e-06 0.2965101025186013 1.706299508996846e-06 0.3095696210007924 1.706300012355259e-06 0.3217495654069301 1.706300488682702e-06 0.3331878525640654 \
1.706300962606306e-06 0.3444754071334732 1.706301420078024e-06 0.3552759747331513 1.706301886058294e-06 0.3661792384270033 1.706302335046104e-06 0.376592601923634 \
1.706302831152646e-06 0.3879857357798637 1.706303350914508e-06 0.3998002499051578 1.706303730319152e-06 0.4083447473225827 1.706304170327876e-06 0.4181679450526055 \
1.706304640096814e-06 0.4285466970600206 1.706305125617752e-06 0.4391589006481625 1.706305565065858e-06 0.4486701556983262 1.706305626818807e-06 0.4500002248264944 \
1.706305750324704e-06 0.4526540461147197 1.706305997336498e-06 0.4579447795386873 1.706306249931409e-06 0.463325462421476 1.706306447502524e-06 0.467511453725808 \
1.706306673074271e-06 0.4722681264242033 1.706306994642268e-06 0.4790073975813253 1.706307263421497e-06 0.4846013351959894 1.70630748207297e-06 0.4891262574467725 \
1.706307692176936e-06 0.4934547887280634 1.706307918582462e-06 0.4980921872304203 1.706308127687652e-06 0.5023516957637455 1.706308317089911e-06 0.5061927337048852 \
1.706308441251129e-06 0.5086969563931187 1.706308568006226e-06 0.5112441466129884 1.706308728004704e-06 0.5144514110933732 1.706308975647656e-06 0.5193914248715521 \
1.706309154234115e-06 0.5229351592435862 1.706309325187692e-06 0.5263079149198099 1.706309586537288e-06 0.5314455197962068 1.70630981260887e-06 0.5358634945234868 \
1.706310015740537e-06 0.5398188128751134 1.706310180971267e-06 0.5430252218652345 1.706310337758288e-06 0.5460612552756139 1.706310526914905e-06 0.5497137532216215 \
1.706310728782658e-06 0.5535976061995346 1.706310952933981e-06 0.5578986282275192 1.706311191316346e-06 0.5624617013850463 1.706311426077985e-06 0.566941985223824 \
1.70631165634869e-06 0.5713275351537204 1.706311862141324e-06 0.5752375533958141 1.706312067125538e-06 0.5791255875933676 1.70631230994078e-06 0.5837094709690289 \
1.706312564698362e-06 0.588493349632063 1.706312792926793e-06 0.5927514274590796 1.706313030765665e-06 0.5971656109489694 1.706313243043101e-06 0.6010807441713891 \
1.706313454836505e-06 0.6049674646600495 1.706313708720774e-06 0.6095919957414236 1.706313913314301e-06 0.6132953190650409 1.706314165037654e-06 0.6178178328453598 \
1.706314352827174e-06 0.6211736970442716 1.706314605700251e-06 0.6256587164710262 1.706314804109613e-06 0.6291560967673944 1.706314983842284e-06 0.6323071487074056 \
1.706315254113091e-06 0.6370161336915187 1.706315471396857e-06 0.6407803561788556 1.706315651923236e-06 0.6438916924996977 1.706315853084131e-06 0.6473460740030906 \
1.706316021667512e-06 0.650231451944099 1.70631622602572e-06 0.6537144072723954 1.706316371688778e-06 0.6561873372238678 1.706316536247377e-06 0.6589728476742622 \
1.706316705716593e-06 0.6618316558839334 1.706316859256675e-06 0.664412775690417 1.706317000490202e-06 0.6667750288922751 1.706317144066014e-06 0.6691685747430841 \
1.706317277296139e-06 0.6713840140331436 1.706317419196459e-06 0.6737368819239464 1.706317539430086e-06 0.6757233098298149 1.706317684081138e-06 0.6781085120392751 \
1.706317800299844e-06 0.6800197521569988 1.706317919382163e-06 0.6819757159594566 1.706318017960477e-06 0.6835903813535821 1.706318135558183e-06 0.6855122399681081 \
1.706318222994146e-06 0.6869376986921233 1.706318347740232e-06 0.6889650632873403 1.706318447547296e-06 0.6905825000046129 1.706318540037093e-06 0.6920753042469043 \
1.706318641321177e-06 0.6937043390836264 1.706318739114283e-06 0.695273833970533 1.706318830385075e-06 0.6967333967490603 1.706318932842905e-06 0.6983656370917724 \
1.706319065752135e-06 0.7004728611232253 1.706319220767541e-06 0.7029137789397926 1.706319355649227e-06 0.7050222373350452 1.706319501145018e-06 0.7072806469370021 \
1.706319628999685e-06 0.709252249158637 1.706319753457981e-06 0.7111597484283609 1.706319864783685e-06 0.7128563623504806 1.706319978813713e-06 0.7145852226468989 \
1.70632007932493e-06 0.7161013069709498 1.706320216526077e-06 0.7181590832501857 1.706320336471979e-06 0.7199473375636642 1.706320455641778e-06 0.7217141075019444 \
1.706320582586792e-06 0.7235855504531626 1.706320707354209e-06 0.7254141264975077 1.706320830849597e-06 0.7272133847865295 1.70632095763087e-06 0.7290498056238117 \
1.706321088220355e-06 0.730930225429108 1.706321210432258e-06 0.7326797786847141 1.706321347490271e-06 0.7346298644824388 1.706321448705626e-06 0.7360619656663578 \
1.706321553674562e-06 0.7375401619041119 1.706321645165995e-06 0.7388229997694907 1.706321758241356e-06 0.7404001534680551 1.70632184554224e-06 0.7416107338190071 \
1.706321950005571e-06 0.7430512000342341 1.706322080768703e-06 0.7448411286358657 1.7063221906822e-06 0.7463352048609909 1.706322295341958e-06 0.7477488743938407 \
1.70632241917362e-06 0.7494094725133206 1.706322567926971e-06 0.751387874302702 1.706322689842132e-06 0.7529958494242643 1.706322803696392e-06 0.7544867042370438 \
1.70632294419585e-06 0.7563117925204224 1.706323085519364e-06 0.7581313010100689 1.706323203298972e-06 0.7596352654099263 1.706323331697459e-06 0.7612620174900669 \
1.706323474021161e-06 0.7630496612437514 1.706323590410316e-06 0.7644991888858087 1.706323736133978e-06 0.7662987831554334 1.706323857913867e-06 0.7677897310961733 \
1.706323976478797e-06 0.7692300520321635 1.706324099092246e-06 0.7707078417740018 1.706324225543629e-06 0.77221964326554 1.706324335666584e-06 0.7735261258099556 \
1.706324461188726e-06 0.7750039859681491 1.706324566849672e-06 0.7762386743660952 1.706324702026829e-06 0.7778058706872942 1.706324825637346e-06 0.7792267957652825 \
1.706324955634725e-06 0.7807078764205345 1.706325068606223e-06 0.7819831642610904 1.706325176500111e-06 0.7831908181350914 1.706325313030793e-06 0.7847046126527283 \
1.706325463151702e-06 0.7863508260127218 1.706325605416006e-06 0.7878933964149381 1.706325724997519e-06 0.7891771019825847 1.706325861808649e-06 0.7906313890246753 \
1.706325984312413e-06 0.7919206245676671 1.706326128984341e-06 0.7934276941869095 1.706326269769414e-06 0.794878360380241 1.706326396585209e-06 0.796171745508174 \
1.706326515632602e-06 0.7973744708066829 1.706326627895563e-06 0.7984986270115709 1.706326732283333e-06 0.7995352562746869 1.706326827560395e-06 0.8004739840425704 \
1.706326963902891e-06 0.8018044219089175 1.70632708076796e-06 0.8029326473252685 1.706327200364489e-06 0.8040757482679398 1.706327322250299e-06 0.8052288531124292 \
1.706327444838559e-06 0.8063765489401953 1.706327572579618e-06 0.8075599074701925 1.706327697362526e-06 0.8087035441861687 1.706327827862901e-06 0.8098867241643505 \
1.706327954229597e-06 0.8110199871086299 1.706328081578389e-06 0.8121498004723215 1.706328186791179e-06 0.8130740322933268 1.706328291495184e-06 0.8139855427426806 \
1.70632838302539e-06 0.8147757515715357 1.70632850639836e-06 0.8158311616195392 1.706328593352408e-06 0.8165684017534872 1.706328692208245e-06 0.8173999442793862 \
1.706328836710884e-06 0.8186029267949408 1.706328973036573e-06 0.8197243345631372 1.706329082445008e-06 0.8206145128367788 1.706329228461948e-06 0.821788834531623 \
1.706329380203007e-06 0.8229927727264784 1.706329506119585e-06 0.8239792970156907 1.706329650568649e-06 0.8250971468990039 1.706329775264817e-06 0.8260503472050121 \
1.706329925878834e-06 0.8271873005969326 1.706330061249302e-06 0.8281959289694237 1.706330186472937e-06 0.8291179217777711 1.706330304128897e-06 0.8299746468143927 \
1.70633044991051e-06 0.8310230722388168 1.70633061639426e-06 0.8322027532553667 1.706330747215023e-06 0.8331167337813133 1.706330920675045e-06 0.834311196379941 \
1.706331088787841e-06 0.8354501125721271 1.706331258668969e-06 0.8365827385393307 1.706331439512628e-06 0.8377685497174457 1.706331582704692e-06 0.8386931238161603 \
1.706331696822189e-06 0.8394210074154138 1.7063318268738e-06 0.8402408682651782 1.706331928753516e-06 0.8408758513273116 1.706332045641139e-06 0.841596551294542 \
1.706332182786859e-06 0.8424315815669623 1.706332380696072e-06 0.8436167827761205 1.706332572515411e-06 0.8447436440637145 1.706332781866158e-06 0.8459494874145237 \
1.706332964017768e-06 0.8469786287449077 1.70633316110399e-06 0.8480715276019779 1.706333334356719e-06 0.8490148531186206 1.706333517450963e-06 0.8499943787178993 \
1.70633368858243e-06 0.8508936588199895 1.706333863270272e-06 0.8517955326875627 1.706334038504287e-06 0.8526841769874772 1.706334214641154e-06 0.8535614892404448 \
1.706334405008494e-06 0.8544920815553035 1.706334595580845e-06 0.8554057038167108 1.706334795976838e-06 0.8563474066245403 1.706334988566463e-06 0.8572344253714166 \
1.706335199466375e-06 0.858185963363946 1.706335427341862e-06 0.8591913103610016 1.706335693424718e-06 0.8603357477151101 1.706335991926854e-06 0.8615822374427254 \
1.706336267816323e-06 0.8627000332972231 1.706336552083493e-06 0.8638181192989086 1.706336826221443e-06 0.8648650323418529 1.706337098522366e-06 0.8658754039994767 \
1.706337368678562e-06 0.8668495780678541 1.706337625862699e-06 0.8677515347235455 1.706337898421613e-06 0.8686810999091764 1.706338174469331e-06 0.8695957110915412 \
1.706338444589598e-06 0.8704649939918846 1.706338744449489e-06 0.8714007440816277 1.706339115430114e-06 0.8725171209518352 1.706339410352536e-06 0.8733732402027278 \
1.706339664628271e-06 0.8740897163373675 1.706339962841735e-06 0.8749052413925265 1.706340236411346e-06 0.8756305047096297 1.706340472534749e-06 0.8762394088953867 \
1.706340712859886e-06 0.8768433401198644 1.706340935193821e-06 0.8773882060838187 1.706341129200254e-06 0.8778530214284207 1.706341458909681e-06 0.8786208714695904 \
1.70634161408109e-06 0.87897283049042 1.706341931723491e-06 0.8796750328643211 1.706342110604035e-06 0.8800599154915705 1.706342453064798e-06 0.8807759898408113 \
1.70634263726721e-06 0.8811501695110489 1.706343112296513e-06 0.8820806183873429 1.706343279683462e-06 0.8823969901232691 1.706343745459843e-06 0.8832471741583867 \
1.706343926299187e-06 0.8835657112976044 1.706344420308805e-06 0.8844044135654346 1.706344561623711e-06 0.8846360992458032 1.706345167867327e-06 0.8855901496945974 \
1.706345319942526e-06 0.8858196526512701 1.706345966662599e-06 0.8867549368993356 1.706346094949266e-06 0.8869330782847171 1.706346743158686e-06 0.8877977435561634 \
1.706346872882985e-06 0.8879638504720397 1.706347641302053e-06 0.8888993076310558 1.706347771073903e-06 0.8890488273083775 1.706348624736509e-06 0.8899738047157748 \
1.706348767761561e-06 0.8901192131187072 1.706349754067048e-06 0.8910487927319016 1.7063499755536e-06 0.8912403904783051 1.706351118378138e-06 0.8921548233216382 \
1.706351248258076e-06 0.8922544308366913 1.706352600758498e-06 0.8932425879319322 1.706352751041431e-06 0.8933452769452155 1.706354231575698e-06 0.8942627870546499 \
1.706354470485492e-06 0.8943950258099049 1.706356252518433e-06 0.8952625983306248 1.70635663826586e-06 0.895426813549116 1.706359040424079e-06 0.8963023915260389 \
1.706359515360049e-06 0.8964490046842035 1.706363433287165e-06 0.8974035634625627 1.706363903247409e-06 0.8974927205890085 1.706372272035387e-06 0.8984807567386782 \
1.706372492545714e-06 0.8984960697096243 1.706417072074293e-06 0.8994905034760702 1.706418273460192e-06 0.8995076493514624 1.706554083268694e-06 0.9004821828323031 \
1.706554262245419e-06 0.9005421539807538 1.706557707120337e-06 0.8996085030263692 1.706557879904192e-06 0.8994755022453073 1.7065592062239e-06 0.8985168769831137 \
1.706559392989208e-06 0.8983970610744239 1.706561177194233e-06 0.8974304740967198 1.706561389324515e-06 0.8973403978332656 1.706574730020299e-06 0.8983331062395279 \
1.706574843308144e-06 0.8983517458922662 1.706583546661241e-06 0.8993273409280406 1.70658409447182e-06 0.8993637478389299 1.707076621843715e-06 0.9003542216796759 \
1.707076717582566e-06 0.9004233209197793 1.707077660131942e-06 0.9014023545001312 1.707077822585254e-06 0.9016297223302431 1.7070783892915e-06 0.9025464066367429 \
1.707078496462212e-06 0.9027401250447874 1.707078889770564e-06 0.9035002370985188 1.707079022567928e-06 0.9037710185404622 1.707079402169034e-06 0.9045728679206633 \
1.70707953238378e-06 0.9048512534150681 1.707079993790073e-06 0.9057878278182891 1.707080113037131e-06 0.9060008176934132 1.707081542646165e-06 0.9050557440230738 \
1.707081626316292e-06 0.9046580283931719 1.707081751622122e-06 0.9039622140338933 1.70708185943629e-06 0.9032622438705011 1.707081978430637e-06 0.9023800387125585 \
1.707082093802854e-06 0.9014106868475621 1.707082183899751e-06 0.900578017289966 1.707082295347455e-06 0.8994526603282017 1.707082381426603e-06 0.8985125975436928 \
1.707082487392251e-06 0.8972736935213672 1.707082587160618e-06 0.8960214106762436 1.707082668156228e-06 0.8949470092681954 1.707082777804195e-06 0.8934133399212493 \
1.707082863391606e-06 0.8921520042367302 1.707082955514215e-06 0.8907345325087322 1.707083043733598e-06 0.8893220116766375 1.707083152508351e-06 0.8875100775672261 \
1.707083235401386e-06 0.8860780350921965 1.707083343975057e-06 0.8841400608632336 1.707083436201252e-06 0.8824412727986957 1.70708352082175e-06 0.8808423775446282 \
1.70708360666218e-06 0.8791839877465467 1.70708368587706e-06 0.8776224824828824 1.70708376196503e-06 0.8760960492665846 1.707083854301399e-06 0.874210837196514 \
1.707083914177735e-06 0.8729702140710593 1.707083971566019e-06 0.8717685933706794 1.707084033561192e-06 0.8704574090763495 1.707084096840043e-06 0.8691057216070059 \
1.707084146911381e-06 0.8680269866686803 1.707084196353533e-06 0.8669542389500936 1.70708426002324e-06 0.8655623656543436 1.707084335970659e-06 0.8638877358586781 \
1.707084384801671e-06 0.8628032002737418 1.707084433325624e-06 0.8617197496806845 1.707084509037347e-06 0.8600184098866027 1.707084576246125e-06 0.8584975010852487 \
1.707084618952631e-06 0.8575263577286506 1.707084662855204e-06 0.8565244243916033 1.707084750660351e-06 0.8545103166059256 1.707084813513519e-06 0.8530605771626394 \
1.707084872183177e-06 0.8517018597088126 1.707084908361778e-06 0.8508614974547222 1.707084943180258e-06 0.8500510151036469 1.707084978206243e-06 0.8492340038666518 \
1.707085048258213e-06 0.8475953578585981 1.707085096728698e-06 0.8464581214772323 1.707085140673499e-06 0.8454248116355969 1.707085186191255e-06 0.8443523575543517 \
1.707085250092166e-06 0.8428433081697474 1.70708531621854e-06 0.8412777165526386 1.707085421348608e-06 0.8387809254526315 1.707085509283283e-06 0.8366857089760468 \
1.707085588228565e-06 0.834800137446173 1.707085676393602e-06 0.8326899670047023 1.707085763209599e-06 0.8306078985741704 1.707085851101283e-06 0.8284959280419055 \
1.707085942350373e-06 0.8262996967350639 1.707086045112241e-06 0.8238226494465998 1.707086143615716e-06 0.8214450402687625 1.707086255948632e-06 0.8187302447322098 \
1.707086368922768e-06 0.8159967029774419 1.707086490210663e-06 0.8130591602364435 1.707086620717817e-06 0.8098958628758253 1.707086749763719e-06 0.8067658935936169 \
1.70708690323932e-06 0.8030416153605923 1.707087068523541e-06 0.799029304640783 1.707087236264745e-06 0.7949567682299736 1.707087432788334e-06 0.7901857478752816 \
1.707087637550659e-06 0.7852160332972318 1.707087850227715e-06 0.7800563994093253 1.707088050847662e-06 0.7751902022758907 1.707088251706389e-06 0.7703212856706637 \
1.707088401728407e-06 0.766686939713112 1.707088532263574e-06 0.7635264252913375 1.707088666681014e-06 0.7602735436595947 1.707088772876544e-06 0.7577048602246427 \
1.707088906182877e-06 0.754482067181252 1.707089013215803e-06 0.7518959494812111 1.707089156291704e-06 0.7484409822837247 1.707089320797846e-06 0.7444713482725677 \
1.707089441615093e-06 0.74155777711076 1.707089612721757e-06 0.7374334100931738 1.707089773612309e-06 0.733558046396253 1.70708999020493e-06 0.7283457217000903 \
1.707090183460631e-06 0.7236999380850822 1.707090362395765e-06 0.7194029726762079 1.707090529212387e-06 0.7154015770462002 1.707090715418352e-06 0.7109395231330657 \
1.707090903351593e-06 0.7064416825495208 1.707091069273699e-06 0.7024749886985119 1.707091261631787e-06 0.6978803202016938 1.707091402988682e-06 0.6945068232011449 \
1.707091559996444e-06 0.6907636199298515 1.707091755976089e-06 0.6860965106368763 1.707091918410194e-06 0.6822325558671515 1.707092079586376e-06 0.6784034260021697 \
1.707092271894574e-06 0.6738409413562468 1.707092489556454e-06 0.6686845685784016 1.707092737577756e-06 0.6628199086538362 1.707092915635219e-06 0.6586162961343578 \
1.707093164179028e-06 0.6527567611811057 1.707093366786271e-06 0.6479896840619462 1.707093536596938e-06 0.6440011601507294 1.707093695213124e-06 0.6402799599229552 \
1.707093833743559e-06 0.637035894415233 1.707093969951322e-06 0.6338503464729111 1.707094096262698e-06 0.6309003762865483 1.707094225721933e-06 0.6278810604265532 \
1.707094354053672e-06 0.6248911458464299 1.707094485383603e-06 0.6218374290191309 1.707094617410215e-06 0.6187713222160208 1.707094761570095e-06 0.6154276788919771 \
1.707094905778687e-06 0.6120888358645944 1.707095053433791e-06 0.6086753592300279 1.707095200490149e-06 0.6052842859263143 1.707095358304176e-06 0.6016504852589418 \
1.707095490909828e-06 0.5986039825107707 1.707095622374795e-06 0.5955897059985247 1.707095741804593e-06 0.5928552647156846 1.707095877873286e-06 0.5897484304797134 \
1.707095992801548e-06 0.5871283594046445 1.707096143912269e-06 0.5836892419704927 1.707096258561337e-06 0.5810871834776226 1.707096376499006e-06 0.5784138884735546 \
1.707096466280294e-06 0.576381560286313 1.707096556599689e-06 0.5743415774978985 1.707096623290559e-06 0.5728373329037385 1.707096688852372e-06 0.5713590910263378 \
1.707096739894496e-06 0.5702089751121119 1.707096801596215e-06 0.5688198806440578 1.707096864686071e-06 0.5674025889664359 1.707096929044424e-06 0.5659586381304559 \
1.707096982438223e-06 0.5647616504486359 1.707097075080806e-06 0.5626864159088959 1.707097151688078e-06 0.5609719030357503 1.70709720751314e-06 0.5597256439368602 \
1.707097276567267e-06 0.5581857825097393 1.707097383455393e-06 0.5558054549196561 1.707097461199018e-06 0.5540764009223496 1.707097562049117e-06 0.5518382286767042 \
1.707097687729972e-06 0.5490568313009737 1.707097787971657e-06 0.5468419758621708 1.70709789988934e-06 0.5443739014182352 1.707098003155247e-06 0.5421024366463116 \
1.707098122904589e-06 0.5394737463112931 1.707098224637469e-06 0.5372436950013484 1.707098340157213e-06 0.5347185748314579 1.707098455192299e-06 0.5322102907975605 \
1.707098581673211e-06 0.529456475824718 1.707098707047008e-06 0.5267350629320526 1.707098853862932e-06 0.5235577714138258 1.707098989426381e-06 0.5206304261698983 \
1.707099147124634e-06 0.5172373565578411 1.707099309443689e-06 0.5137528589513558 1.707099490267585e-06 0.5098871206809381 1.707099682715905e-06 0.5057874350093188 \
1.707099895621209e-06 0.5012700264709963 1.707100127802608e-06 0.4963634062180514 1.707100385093187e-06 0.4909555076455908 1.70710062471901e-06 0.4859407514401474 \
1.707100926434446e-06 0.479662588092526 1.7071012143538e-06 0.4737079198104491 1.707101527242619e-06 0.4672821326282255 1.707101846980824e-06 0.4607585360408045 \
1.707102186575985e-06 0.4538766993710576 1.707102513478483e-06 0.4472977926730654 1.707102849036864e-06 0.4405887635920606 1.707103166132787e-06 0.4342949501181722 \
1.707103500370541e-06 0.4277061431972559 1.707103851801663e-06 0.4208322784122511 1.707104166327818e-06 0.4147233751108969 1.707104489505308e-06 0.4084912998479469 \
1.707104930620066e-06 0.400057814108821 1.707105272736103e-06 0.3935812134363078 1.707105572680633e-06 0.3879522399691127 1.707105947811638e-06 0.3809760137481454 \
1.707106277555878e-06 0.3749002425561211 1.707106560798804e-06 0.3697269896098562 1.707106860945059e-06 0.3642865787664632 1.707107140547253e-06 0.3592589179584539 \
1.707107364323365e-06 0.3552676761685443 1.707107576103695e-06 0.3515151294490645 1.707107778537159e-06 0.3479514629380864 1.707107979628427e-06 0.3444362246481504 \
1.707108185342845e-06 0.3408632458568372 1.707108452965717e-06 0.3362478643926977 1.707108691897011e-06 0.3321601360780691 1.707108925403074e-06 0.3281974319442653 \
1.707109138868474e-06 0.3246000376975314 1.707109360246046e-06 0.3208952602338652 1.707109560209693e-06 0.3175728982722026 1.707109764482006e-06 0.3142073831356898 \
1.707109961828878e-06 0.3109812293225088 1.707110147201405e-06 0.3079732989686547 1.707110343307796e-06 0.3048147723336881 1.707110545584936e-06 0.3015820927993307 \
1.707110721243233e-06 0.2988007390096292 1.70711090711339e-06 0.295878328903569 1.707111114092783e-06 0.2926488196724605 1.707111299414374e-06 0.2897857719971084 \
1.707111494641182e-06 0.2867989994419413 1.707111650415531e-06 0.28443329608414 1.707111829172313e-06 0.2817356906084737 1.707112010203233e-06 0.2790344478478936 \
1.707112160100347e-06 0.2768142575519123 1.707112361143774e-06 0.273859574769726 1.707112510258904e-06 0.2716833853889438 1.707112648798333e-06 0.2696726034832688 \
1.707112800673409e-06 0.2674956304896134 1.707112915147538e-06 0.2658586287383957 1.707113046677468e-06 0.2639823142040156 1.707113172435956e-06 0.2622048582339201 \
1.707113276776362e-06 0.2607341604582348 1.707113389755722e-06 0.2591418073851619 1.707113506084246e-06 0.2575033437579446 1.707113649011667e-06 0.2554974228347739 \
1.707113762273172e-06 0.2539102348881249 1.707113896429905e-06 0.2520298733123076 1.70711400690271e-06 0.2504818583075984 1.707114162335285e-06 0.2483006006477398 \
1.707114303220383e-06 0.2463217957442577 1.707114454612954e-06 0.2441928603691365 1.707114609775035e-06 0.2420086586735095 1.707114739184283e-06 0.2401849910837116 \
1.707114873896376e-06 0.2382868210192302 1.707115011594202e-06 0.2363478190565156 1.707115129346217e-06 0.2346905900295477 1.70711528867041e-06 0.2324499447852502 \
1.707115425932636e-06 0.2305210708572645 1.707115566678993e-06 0.2285488733964877 1.707115672470167e-06 0.2270688194984586 1.707115802411564e-06 0.2252532503786337 \
1.707115902948028e-06 0.2238506847401111 1.707116005281736e-06 0.2224250970611539 1.707116079010317e-06 0.2214012665004395 1.70711615824426e-06 0.2203047212273054 \
1.707116229215507e-06 0.2193236206014474 1.707116280678535e-06 0.218612902325451 1.707116333626988e-06 0.2178825126218075 1.707116412781991e-06 0.2167921001391954 \
1.707116455054626e-06 0.2162104926182252 1.707116494899171e-06 0.2156628374086678 1.70711653812282e-06 0.2150692779925967 1.707116579029822e-06 0.2145080585354088 \
1.707116649152284e-06 0.2135474129702876 1.707116682837256e-06 0.2130867492099046 1.707116727666638e-06 0.212477723463 1.7071167865238e-06 0.2116792343136102 \
1.70711685130926e-06 0.2108017053965978 1.707116908790025e-06 0.2100241135398916 1.707116969219033e-06 0.209207737948094 1.707117066255463e-06 0.2078991976528634 \
1.707117150945123e-06 0.2067595417901527 1.707117259855885e-06 0.2052972881712416 1.707117356256692e-06 0.2040065614180294 1.707117451273329e-06 0.2027428333585779 \
1.707117554705127e-06 0.2013717100485363 1.707117649634473e-06 0.2001158751783069 1.707117752654899e-06 0.198757993281026 1.707117857737332e-06 0.1973779917312911 \
1.707117967046146e-06 0.1959482000350934 1.707118077489628e-06 0.1945091075764383 1.707118193779903e-06 0.1929996650696684 1.707118303709896e-06 0.1915811184357085 \
1.70711841337232e-06 0.1901717999899754 1.707118515088965e-06 0.1888694322720079 1.707118608043679e-06 0.1876837490531375 1.707118700772569e-06 0.1865049219968967 \
1.707118774458125e-06 0.1855719169757668 1.70711885729934e-06 0.1845269810791141 1.707118931885337e-06 0.1835895008849975 1.707119001608678e-06 0.1827150226754214 \
1.707119068327085e-06 0.1818808699270075 1.707119164170411e-06 0.1806871657728035 1.707119246877184e-06 0.1796611249561687 1.707119340441007e-06 0.1785035608809835 \
1.707119435337095e-06 0.1773351434884491 1.707119546707405e-06 0.1759704596301353 1.707119688349759e-06 0.1742450478777388 1.707119803596612e-06 0.1728486436789435 \
1.707119948144251e-06 0.1711076225712051 1.707120059739928e-06 0.1697708811114609 1.707120200958902e-06 0.1680898955975501 1.707120316696175e-06 0.1667201145354908 \
1.707120422656861e-06 0.1654722325850081 1.707120521416477e-06 0.164314417410061 1.70712061775965e-06 0.1631901152369615 1.707120706417402e-06 0.1621596955203892 \
1.707120831751673e-06 0.1607099933926625 1.707120926277088e-06 0.1596224416957933 1.70712102401604e-06 0.1585042187118262 1.707121132110917e-06 0.1572745454417887 \
1.707121226778605e-06 0.1562036643369483 1.707121334226451e-06 0.1549951394274829 1.707121425315495e-06 0.1539767092330788 1.707121532087207e-06 0.1527896463435911 \
1.707121635480473e-06 0.1516469620792683 1.707121746560958e-06 0.1504267727114754 1.707121835786939e-06 0.1494522115900035 1.707121921266868e-06 0.1485231035185812 \
1.707122005192055e-06 0.1476157397758405 1.707122074898619e-06 0.1468658175993407 1.707122153536697e-06 0.1460232248551682 1.707122231847954e-06 0.1451880611912267 \
1.707122302483827e-06 0.1444378248611795 1.707122387974695e-06 0.1435337156153706 1.707122475363672e-06 0.1426139614481139 1.707122556951186e-06 0.1417594571206545 \
1.707122654270137e-06 0.1407454482154784 1.70712273495966e-06 0.139910090776864 1.70712282574469e-06 0.1389752404035735 1.707122947088963e-06 0.1377336220260025 \
1.707123036138604e-06 0.13682812281983 1.707123134655454e-06 0.1358318692385875 1.707123221741723e-06 0.1349560640726983 1.707123332152611e-06 0.1338550874529322 \
1.707123420611433e-06 0.1329791517134813 1.707123521340027e-06 0.1319874611681985 1.70712362612958e-06 0.1309622419763913 1.707123720519813e-06 0.1300442429014473 \
1.707123817024605e-06 0.1291112112475518 1.707123916511258e-06 0.1281591654439075 1.707124002912429e-06 0.1273384721630967 1.70712409789256e-06 0.1264411177628728 \
1.707124202081388e-06 0.1254629331099751 1.707124311200139e-06 0.124445178694 1.707124405550594e-06 0.1235704029653004 1.707124517846343e-06 0.1225411084520107 \
1.707124613309697e-06 0.1216733466577494 1.707124717520587e-06 0.1207311846737792 1.707124806865944e-06 0.1199276649878674 1.707124877253217e-06 0.1192980345746366 \
1.707124952639251e-06 0.1186268760051257 1.707125028771421e-06 0.1179522201461119 1.707125097748918e-06 0.1173458504859956 1.707125180268091e-06 0.1166263596898966 \
1.707125252211578e-06 0.1160015972854393 1.707125334290304e-06 0.1152916772467617 1.70712541862478e-06 0.1145654108773922 1.707125496418619e-06 0.113898375935255 \
1.707125589183521e-06 0.1131065723182637 1.707125704787342e-06 0.1121254933399327 1.707125810692911e-06 0.1112341778178403 1.707125888349831e-06 0.1105854195321705 \
1.707125976646302e-06 0.1098504899494786 1.707126056703354e-06 0.1091866403929743 1.707126153629479e-06 0.1083861389179563 1.707126248864964e-06 0.1076031391441806 \
1.707126337436159e-06 0.1068780200140514 1.70712643874426e-06 0.1060523297458165 1.707126544289947e-06 0.1051963702337609 1.707126653484312e-06 0.1043160928234657 \
1.707126761601933e-06 0.1034503663302994 1.707126881519694e-06 0.1024949450012773 1.707126982881521e-06 0.1016914181115986 1.707127088891151e-06 0.100855068690839 \
1.70712721468278e-06 0.09986840123414902 1.707127344240086e-06 0.09885896724496235 1.70712747991544e-06 0.09780904711780367 1.707127655987304e-06 0.09645781830037269 \
1.707127819787824e-06 0.09521257997344186 1.707127982612565e-06 0.09398642071914091 1.7071280677512e-06 0.09334985726464029 1.707128137589223e-06 0.09282999162688726 \
1.707128207084828e-06 0.09231474740697931 1.707128281043488e-06 0.09176875214326782 1.707128377198375e-06 0.09106241641841166 1.707128451613741e-06 0.09051841344162129 \
1.70712852960331e-06 0.08995079828656057 1.707128606052139e-06 0.08939693755534793 1.707128693546224e-06 0.08876614459792892 1.707128795722934e-06 0.08803382885421264 \
1.707128884287322e-06 0.08740269463919083 1.70712899395281e-06 0.08662585268124241 1.707129110009217e-06 0.08580942306245626 1.707129251558034e-06 0.0848216759818637 \
1.707129384427017e-06 0.08390253510334872 1.707129525187328e-06 0.08293727564630923 1.707129674896948e-06 0.08192024575105315 1.707129810608835e-06 0.08100683753927941 \
1.707129952125717e-06 0.08006309454860433 1.707130087247591e-06 0.07917070961097784 1.707130228520028e-06 0.07824718349428782 1.70713037561292e-06 0.07729532867436953 \
1.707130527122786e-06 0.07632524417621221 1.7071306924985e-06 0.07527819040792309 1.70713085625969e-06 0.07425356708383206 1.707131032389632e-06 0.07316505371836476 \
1.70713122152861e-06 0.07201151367936541 1.707131432202234e-06 0.07074528708793332 1.707131651768855e-06 0.06944624562626683 1.707131886535262e-06 0.06808094281860989 \
1.7071321449277e-06 0.06660616301228137 1.70713243959236e-06 0.06496103773121734 1.707132743671683e-06 0.06330286177969326 1.707133104582163e-06 0.06138472526627536 \
1.707133440499035e-06 0.05964719353945821 1.707133880676406e-06 0.05743991201668189 1.707134259043809e-06 0.05560437501227136 1.707134701502772e-06 0.05352996728430704 \
1.707135055522916e-06 0.05192508193542229 1.707135442039672e-06 0.05022502935509546 1.707135786643729e-06 0.04875485597254389 1.707136108618665e-06 0.04741934964807833 \
1.707136412152492e-06 0.04619304551845941 1.707136707073488e-06 0.04503122626702559 1.707136989555767e-06 0.04394770877170886 1.707137266636177e-06 0.04291147062934708 \
1.707137532363668e-06 0.04194013461971725 1.707137803594355e-06 0.0409708748276704 1.707138079853372e-06 0.04000619535229137 1.707138369752594e-06 0.03901828782233653 \
1.707138598128987e-06 0.03825741181922668 1.707138903013054e-06 0.03726495139513845 1.70713911968491e-06 0.03657573971894532 1.707139311041637e-06 0.03597943984071691 \
1.707139509636156e-06 0.03537298232318693 1.707139839551497e-06 0.03438820140908775 1.70714008149717e-06 0.03368375433354889 1.707140396809222e-06 0.03278771666975258 \
1.707140666929207e-06 0.03203957074185158 1.707140923300881e-06 0.03134567005659093 1.707141203312881e-06 0.03060515313352298 1.707141448968657e-06 0.02997014710356035 \
1.707141681704302e-06 0.02938120249260199 1.707141924434299e-06 0.02878348292867495 1.707142161161563e-06 0.02821317433052753 1.707142389807974e-06 0.0276732289298247 \
1.707142807093635e-06 0.02671456010533928 1.707143002274328e-06 0.02627749693639509 1.707143383441411e-06 0.02544369227895442 1.707143560694233e-06 0.02506446942885681 \
1.707143903145688e-06 0.02434654114125227 1.70714405641412e-06 0.02403127656358269 1.707144431432584e-06 0.02327616399748992 1.707144569066725e-06 0.02300530455388665 \
1.707145053333359e-06 0.02207084195640928 1.70714517295276e-06 0.02184403312078184 1.707145589991563e-06 0.02106026682208277 1.707145733393791e-06 0.02079332360769017 \
1.707146254605172e-06 0.01984598817089831 1.707146382379043e-06 0.0196205814374062 1.707146966791417e-06 0.01863359713481367 1.707147139226823e-06 0.01835589372257288 \
1.707147743323573e-06 0.01743644241612937 1.707147904755214e-06 0.01720262545858322 1.707148544701434e-06 0.01631831686205014 1.7071487230176e-06 0.016083210242981 \
1.707149371001649e-06 0.01526127675881721 1.70714953625524e-06 0.01505930898173208 1.707150272557175e-06 0.01419381259610907 1.707150406833225e-06 0.01404154276213586 \
1.707151203932743e-06 0.01317592498067951 1.707151344530354e-06 0.01302934089458718 1.707152309873577e-06 0.0120661300044765 1.707152474212383e-06 0.01190857475316222 \
1.707153474943512e-06 0.01099048917119646 1.707153612213369e-06 0.01087009009405628 1.707154750907886e-06 0.009949273443646761 1.707154865085787e-06 0.009863136028526375 \
1.707156245730622e-06 0.008889755784408603 1.707156400087833e-06 0.00878832203975914 1.707157946582061e-06 0.00781340401000951 1.707158030943764e-06 0.007760176032106158 \
1.707159716371082e-06 0.006770348169342283 1.707159839899572e-06 0.00670487246831437 1.707161889714139e-06 0.005720970231232756 1.707162086114296e-06 0.005634691917282852 \
1.707164404793654e-06 0.004698942116576918 1.707164865407989e-06 0.004530544077955615 1.70716760550353e-06 0.003639937533647344 1.707168123648567e-06 0.00349159181499799 \
1.707172274289875e-06 0.002502201117031859 1.707172812139882e-06 0.002396807933581942 1.70717889437533e-06 0.001421603691354927 1.707179153355741e-06 0.001378272220758726 \
1.70718447611909e-06 0.0003814093765652445 1.707184589276134e-06 0.0003711807182531981 1.70983070639237e-06 -0.0004615907568095335 1.709830868831338e-06 -0.0006852153244161934 \
1.709831369832807e-06 -0.001554404032531494 1.70983145401537e-06 -0.001725199767551738 1.709831855538194e-06 -0.002626792336557519 1.709831944873161e-06 -0.002845673237760077 \
1.70983223146497e-06 -0.0035898660494722 1.709832359033499e-06 -0.003937855927128601 1.709832677745161e-06 -0.004830400105952924 1.709832791946313e-06 -0.00515011308870196 \
1.709833074346638e-06 -0.005887653497963378 1.709833204572857e-06 -0.006177415671381139 1.709834182925754e-06 -0.005220113099403402 1.709834370233287e-06 -0.004004368716724641 \
1.709834501677689e-06 -0.002901539130564616 1.709834607105242e-06 -0.001869327786897239 1.709834692822726e-06 -0.0009323217369615201 1.709834774749213e-06 4.151965372454519e-05 \
1.709834895786036e-06 0.001618129410352471 1.709834994714683e-06 0.003024565667809575 1.709835153111357e-06 0.005482561958548801 1.709835370558587e-06 0.00923691162542661 \
1.70983555178081e-06 0.0126653356758144 1.709835763874906e-06 0.01697021734206094 1.709835926898563e-06 0.02046388365739064 1.709836087520978e-06 0.02403759527126768 \
1.709836241061221e-06 0.02755862871109176 1.709836389117902e-06 0.031036270750196 1.709836538198811e-06 0.03460722192241437 1.709836692728722e-06 0.03837091703902212 \
1.709836853379538e-06 0.04234026030123839 1.709837018034219e-06 0.04645786783841532 1.709837194575117e-06 0.05091770581196236 1.709837373537969e-06 0.05547793877747508 \
1.709837564281134e-06 0.0603721650098247 1.709837769062163e-06 0.06565647483694508 1.709837989534449e-06 0.07137203566208646 1.709838222394174e-06 0.0774299331224613 \
1.70983847158165e-06 0.08392829098722057 1.709838744423777e-06 0.09105513637423955 1.709839041127578e-06 0.09880974921055499 1.709839368453968e-06 0.1073623706929605 \
1.709839738105355e-06 0.11701033799881 1.709840132977169e-06 0.1273002725707723 1.70984059081541e-06 0.1392030195235975 1.70984112262225e-06 0.1529832553757746 \
1.709841747860046e-06 0.1691182447448397 1.709842433607517e-06 0.1867241161332086 1.709843236003391e-06 0.2071957342970069 1.709844134802183e-06 0.2299563735557614 \
1.709844940415632e-06 0.2501946571168963 1.709845654166966e-06 0.2679877251922811 1.709846283728848e-06 0.2835633151515627 1.709846854092298e-06 0.2975737963344939 \
1.70984738504768e-06 0.3105173405876944 1.70984788683513e-06 0.3226580892822354 1.709848366129684e-06 0.3341673054699896 1.709848831685103e-06 0.3452566901045974 \
1.709849295481511e-06 0.3562094254686541 1.709849751229541e-06 0.3668794056881832 1.709850211449675e-06 0.3775613305945491 1.709850749733646e-06 0.3899285626759094 \
1.709851250584179e-06 0.4013172511919189 1.709851650806863e-06 0.4103337945930838 1.709852157667644e-06 0.421642452039157 1.709852643633856e-06 0.4323669409017459 \
1.709853043148568e-06 0.4410997362599856 1.709853453760627e-06 0.4500002277813482 1.70985388268706e-06 0.4592207708982954 1.709854284201442e-06 0.4677760623951868 \
1.709854591591889e-06 0.4742753916877908 1.709854941833647e-06 0.4816249679276425 1.709855295073851e-06 0.4889795533930016 1.70985554824443e-06 0.4942125642332652 \
1.70985578118832e-06 0.4989990073547648 1.709856022831611e-06 0.5039392821429431 1.709856247822229e-06 0.5085102868389438 1.709856439858337e-06 0.5123881070394828 \
1.709856624670034e-06 0.5161059569497825 1.70985684696035e-06 0.5205538992744256 1.709857013671757e-06 0.5238726938135662 1.709857230888352e-06 0.5281726418673847 \
1.709857433967244e-06 0.5321820613122353 1.709857611378699e-06 0.5356681922482178 1.709857799451086e-06 0.5393528234657015 1.709858035483266e-06 0.5439555888699217 \
1.709858301365289e-06 0.5491186112539347 1.709858523127178e-06 0.5534070305875756 1.709858803185033e-06 0.5588091140818973 1.709859046184818e-06 0.5634839438879177 \
1.709859321538161e-06 0.5687575845994758 1.709859566533502e-06 0.5734440561015828 1.70985980682772e-06 0.5780305526007354 1.709860047867023e-06 0.5826153106864888 \
1.709860305457841e-06 0.5874946531182738 1.709860540824618e-06 0.5919209497705462 1.709860772126727e-06 0.5962518282209535 1.709860994653448e-06 0.6003950532231523 \
1.709861203013056e-06 0.6042587207462122 1.709861440854871e-06 0.6086392006348278 1.709861651715085e-06 0.612499186772883 1.709861907322267e-06 0.617151767543529 \
1.709862106050033e-06 0.620751700070918 1.709862381682677e-06 0.6257066023742009 1.709862604438798e-06 0.6296824120643636 1.709862897809922e-06 0.6348814180513288 \
1.709863130579923e-06 0.6389753720667986 1.709863350781309e-06 0.6428252659334456 1.709863552051921e-06 0.6463216644290061 1.709863769340793e-06 0.6500784077528632 \
1.709863944056704e-06 0.6530842133917786 1.709864130321333e-06 0.6562672470877895 1.709864309060386e-06 0.6593113758161715 1.709864471764399e-06 0.6620700940033843 \
1.70986463703341e-06 0.6648583661366954 1.709864780301224e-06 0.6672607123132118 1.709864919531648e-06 0.669583864918244 1.709865059332214e-06 0.6719085596965743 \
1.709865194107422e-06 0.6741424479378803 1.709865321601663e-06 0.6762463034350935 1.709865454555775e-06 0.6784344250006583 1.709865576160125e-06 0.680430207161383 \
1.709865704573366e-06 0.6825336955632141 1.709865820340421e-06 0.6844241240890321 1.709865918381594e-06 0.686020684362688 1.7098660190777e-06 0.687656981754083 \
1.709866128831462e-06 0.689434454762776 1.709866245599418e-06 0.6913211166705923 1.709866336826191e-06 0.6927889453402305 1.709866446031605e-06 0.6945396927028351 \
1.709866547140326e-06 0.6961566646470493 1.709866642540618e-06 0.6976767415743361 1.709866752022642e-06 0.6994136821864276 1.709866886474277e-06 0.7015344809028976 \
1.709867035493214e-06 0.7038694457768003 1.709867164423232e-06 0.7058755144243859 1.709867311083691e-06 0.7081418729260142 1.709867437868072e-06 0.7100885084081828 \
1.709867562465961e-06 0.7119899232102255 1.709867674319728e-06 0.7136874821928206 1.709867787275692e-06 0.7153928249203609 1.709867887829089e-06 0.716903336497302 \
1.709868025110592e-06 0.7189542886859326 1.709868144979452e-06 0.7207346491296758 1.709868264162204e-06 0.7224952472954583 1.709868391164314e-06 0.7243608783177121 \
1.709868515712665e-06 0.726179956024653 1.709868639383676e-06 0.7279757435764195 1.709868765971953e-06 0.7298035010246171 1.709868896541188e-06 0.7316777339938921 \
1.709869019056222e-06 0.7334262671520465 1.709869155299713e-06 0.7353588786631546 1.709869256742486e-06 0.7367901064855561 1.709869362765969e-06 0.7382789144707947 \
1.709869453297152e-06 0.7395446819117977 1.709869567123378e-06 0.7411267287627761 1.70986965478496e-06 0.742338113895605 1.709869760680238e-06 0.7437932991468792 \
1.709869891033532e-06 0.7455718205320391 1.70987000160114e-06 0.7470699275523445 1.709870106271611e-06 0.7484790865773925 1.709870230233143e-06 0.7501360792234356 \
1.709870378790597e-06 0.752105598322839 1.709870500473193e-06 0.7537054667443914 1.709870614584882e-06 0.7551949470168074 1.709870755005484e-06 0.7570132059451244 \
1.709870896533544e-06 0.7588296197226846 1.709871014322813e-06 0.7603289862386273 1.709871142522635e-06 0.7619481626911874 1.709871284590468e-06 0.7637269294216019 \
1.709871401465576e-06 0.7651780119234867 1.709871547139362e-06 0.7669714049983392 1.70987166887781e-06 0.7684572223066155 1.709871787518301e-06 0.7698939375992205 \
1.709871909984594e-06 0.7713653733660819 1.709872036701685e-06 0.7728756341192486 1.709872146603679e-06 0.7741754302862822 1.709872272219022e-06 0.7756497674172792 \
1.709872378029431e-06 0.7768823528242577 1.709872514199553e-06 0.7784559787239111 1.709872638546601e-06 0.7798807766277074 1.709872765971877e-06 0.7813271999647126 \
1.709872880527956e-06 0.7826155184370988 1.709872987208226e-06 0.7838050786084815 1.709873125150823e-06 0.785328674235108 1.709873274600319e-06 0.7869612315653352 \
1.709873419452536e-06 0.7885256944569791 1.709873538888287e-06 0.7898026796320731 1.70987367431316e-06 0.7912364721526877 1.709873795807481e-06 0.7925100718437531 \
1.709873939166555e-06 0.7939977458315933 1.709874082600237e-06 0.7954699260458764 1.709874208411247e-06 0.7967479640295563 1.709874327457929e-06 0.7979459892863545 \
1.709874439471573e-06 0.7990632136113104 1.709874544263454e-06 0.8000996927221937 1.709874639456303e-06 0.8010335634530776 1.709874775866829e-06 0.8023587211299719 \
1.709874892679005e-06 0.8034813603122919 1.709875012140248e-06 0.8046180202255495 1.7098751341806e-06 0.8057672874017472 1.709875257080697e-06 0.8069126780167393 \
1.709875384200053e-06 0.8080849010520604 1.709875509341915e-06 0.8092265787736463 1.709875639893142e-06 0.8104047139317369 1.709875765969389e-06 0.811530109085512 \
1.709875893966049e-06 0.8126603425876329 1.709875999427297e-06 0.8135823118114501 1.709876102696598e-06 0.814477091043954 1.709876195349946e-06 0.8152732203909091 \
1.709876319044181e-06 0.8163262937528154 1.709876406664096e-06 0.8170655553659417 1.709876505330151e-06 0.8178914289762149 1.709876648877154e-06 0.819080619224994 \
1.709876784463306e-06 0.8201904093102529 1.709876893653288e-06 0.8210742465492874 1.709877041102747e-06 0.8222539401850584 1.709877191506449e-06 0.8234410273756358 \
1.709877316975412e-06 0.8244188977545531 1.709877461141395e-06 0.8255287290252299 1.70987758542996e-06 0.8264738611628292 1.709877735900256e-06 0.8276038147969816 \
1.709877871506614e-06 0.8286089145501508 1.709877996601616e-06 0.8295251220930787 1.709878114317453e-06 0.8303776282987162 1.709878260203052e-06 0.8314210189912619 \
1.709878426696148e-06 0.8325942517713072 1.709878557562851e-06 0.833503494447128 1.709878731007462e-06 0.8346911703335461 1.709878899140202e-06 0.8358239212093587 \
1.70987906899395e-06 0.8369500705213252 1.709879249886955e-06 0.838129582835239 1.709879393021216e-06 0.8390486258646698 1.709879507119162e-06 0.8397723391454259 \
1.709879637246322e-06 0.8405879656882547 1.709879739102179e-06 0.8412191375388212 1.709879855947599e-06 0.8419354178465567 1.709879992919396e-06 0.84276453896487 \
1.709880190759142e-06 0.843942473808897 1.70988038244463e-06 0.8450620046306492 1.709880591850993e-06 0.8462610422160779 1.709880773861877e-06 0.8472832413425977 \
1.709880970977333e-06 0.8483697584184032 1.709881144290447e-06 0.8493077402131245 1.709881327325656e-06 0.8502809338042043 1.709881498478783e-06 0.8511747489972419 \
1.709881673131736e-06 0.8520708361396651 1.709881848382891e-06 0.8529540285731302 1.709882024530391e-06 0.8538259128238825 1.709882214836779e-06 0.8547503816925358 \
1.709882405427748e-06 0.8556583881771193 1.709882605979791e-06 0.8565949481971697 1.709882798582588e-06 0.8574764650234362 1.709883009331288e-06 0.8584213553684483 \
1.709883237362186e-06 0.8594210644592908 1.709883503241952e-06 0.8605573106989262 1.709883801820094e-06 0.8617960322792503 1.709884077983729e-06 0.8629075153790151 \
1.709884362230229e-06 0.8640180616030438 1.709884636414231e-06 0.8650581816846495 1.70988490866944e-06 0.8660616517296992 1.709885178858914e-06 0.8670295451208139 \
1.709885436023238e-06 0.8679256252637404 1.709885708596972e-06 0.8688492356117473 1.709885984602435e-06 0.8697577927663542 1.709886254710518e-06 0.8706213441784563 \
1.709886554568938e-06 0.8715508809746347 1.709886925582816e-06 0.8726599440782473 1.709887220515529e-06 0.873510245983525 1.709887474800896e-06 0.8742218447789023 \
1.709887773044171e-06 0.8750318897722944 1.709888046640929e-06 0.8757523113099853 1.709888282767907e-06 0.8763571312809064 1.709888523107205e-06 0.876957042728428 \
1.709888745440861e-06 0.8774982514557473 1.709888939446794e-06 0.8779599514934209 1.709889269165228e-06 0.8787226653583874 1.709889424338019e-06 0.8790722725343518 \
1.70988974207141e-06 0.8797700114458387 1.70988992093906e-06 0.880152324917399 1.709890263400534e-06 0.8808637455080008 1.709890447552368e-06 0.8812353200296749 \
1.709890922478418e-06 0.8821594045029107 1.709891089871654e-06 0.8824737723885729 1.709891555692961e-06 0.8833186808430151 1.709891736520447e-06 0.883635209600208 \
1.709892230549786e-06 0.8844687288968743 1.709892371887773e-06 0.8846990198924604 1.709892978249103e-06 0.8856473543416146 1.709893130320955e-06 0.8858754372639542 \
1.709893777008948e-06 0.8868048391838264 1.709893905303109e-06 0.8869818633102416 1.709894553496582e-06 0.8878410756373726 1.709894683245133e-06 0.8880061989117775 \
1.709895451498601e-06 0.8889361126992519 1.709895581240625e-06 0.8890847997417872 1.709896434697557e-06 0.8900046759307325 1.709896577924673e-06 0.8901495209380393 \
1.709897564158077e-06 0.8910738355210844 1.709897785636141e-06 0.8912643084423501 1.709898928653688e-06 0.8921737958641509 1.709899058631989e-06 0.8922730011388891 \
1.709900410338988e-06 0.8932565980587214 1.709900560692342e-06 0.8933589605607284 1.709902041315768e-06 0.8942730372387374 1.70990228021907e-06 0.8944047337041336 \
1.709904061344228e-06 0.8952702388217941 1.709904447325594e-06 0.8954343910560414 1.709906848871634e-06 0.896309305076933 1.70990732380842e-06 0.8964562995603377 \
1.709911141970139e-06 0.8973944547681553 1.709911624459336e-06 0.897487269196476 1.709919510474849e-06 0.898471373493449 1.70992012663754e-06 0.8985180228791175 \
1.710015282612379e-06 0.899508178894561 1.710016773214557e-06 0.8995204306067698 1.710128061288741e-06 0.9005118233983579 1.710128237625743e-06 0.9005706457326812 \
1.710131860757067e-06 0.8996048713171836 1.710132041955094e-06 0.8994654179496379 1.71013335307657e-06 0.8985275682722235 1.710133534953976e-06 0.8984123497545736 \
1.71013535794417e-06 0.8974436520388238 1.710135517857424e-06 0.8973766233009967 1.710148668688723e-06 0.8983720910457982 1.710148779670276e-06 0.8983905835035384 \
1.710157601254383e-06 0.8993863063850064 1.710158148023847e-06 0.8994226481040219 1.71065071997668e-06 0.9003987622903815 1.710650789769166e-06 0.9004496773542636 \
1.710651622421929e-06 0.9012853800543292 1.710651748468094e-06 0.9014513953152168 1.710652328988957e-06 0.9023435091985418 1.710652469953212e-06 0.9025895326188698 \
1.710652869091291e-06 0.9033428289365844 1.710653019240832e-06 0.9036449200440446 1.710653462322153e-06 0.9045762589490434 1.710653619494256e-06 0.9049121924877023 \
1.710654065120987e-06 0.9058152254958243 1.710654163577326e-06 0.9059929146639856 1.71065558025872e-06 0.9052304871087643 1.710655711415865e-06 0.904616184869324 \
1.710655880423041e-06 0.9036290332250884 1.710656045714916e-06 0.9024406226812831 1.710656151980698e-06 0.9015554774641358 1.710656255417528e-06 0.9006052096506509 \
1.710656341184247e-06 0.8997486040545581 1.710656430678233e-06 0.8987887485205278 1.710656554922632e-06 0.8973492764100613 1.71065667300358e-06 0.8958624931586439 \
1.710656760219672e-06 0.8946938835082598 1.710656884526716e-06 0.8929289312882503 1.710656991510644e-06 0.8913158670103165 1.710657091342348e-06 0.8897378501708729 \
1.710657217633174e-06 0.8876466417139378 1.710657385821785e-06 0.884705368138502 1.710657541521538e-06 0.8818365157686672 1.710657738126367e-06 0.8780362649814708 \
1.710657921747617e-06 0.8743271923380105 1.71065813325501e-06 0.8698916163736473 1.71065831406481e-06 0.8659808238081558 1.710658498645858e-06 0.8618945354625286 \
1.710658671649854e-06 0.8579913311618118 1.710658857050504e-06 0.8537436868396935 1.710659036133651e-06 0.8495884889292737 1.710659219722713e-06 0.8452850234109005 \
1.710659386484418e-06 0.8413449312544377 1.710659554574996e-06 0.8373487193315756 1.710659717684167e-06 0.8334514816705533 1.710659872870403e-06 0.829729402178684 \
1.710660045969282e-06 0.8255639501984255 1.710660231959738e-06 0.8210763864673301 1.710660396580221e-06 0.8170961425007568 1.710660561450132e-06 0.8131038678717658 \
1.710660736782164e-06 0.8088537582860886 1.710660901208668e-06 0.8048648186953292 1.710661069844279e-06 0.8007719922541914 1.710661260647645e-06 0.7961398815555145 \
1.710661446171818e-06 0.7916360074082958 1.710661655100628e-06 0.7865651471012967 1.710661879917618e-06 0.7811107659751856 1.710662069732705e-06 0.77650678233121 \
1.710662271590188e-06 0.7716133355283564 1.710662415860827e-06 0.76811790639139 1.710662557504392e-06 0.7646880872338248 1.710662685202102e-06 0.7615975116975136 \
1.710662796247943e-06 0.7589113686396982 1.71066292481058e-06 0.7558028559024855 1.710663057376087e-06 0.7525995467138866 1.710663170697783e-06 0.7498629233610832 \
1.710663307032409e-06 0.7465723252212872 1.710663413431661e-06 0.7440058350410135 1.710663572650447e-06 0.7401674766516904 1.710663745028142e-06 0.7360137588823189 \
1.710663907275386e-06 0.7321074183421575 1.710664079624344e-06 0.7279612819449855 1.710664239010527e-06 0.7241302920521341 1.710664446815714e-06 0.7191408067115369 \
1.710664607355379e-06 0.7152908836069264 1.710664799844715e-06 0.7106793324906435 1.710664985361064e-06 0.7062404417184839 1.710665155237109e-06 0.7021802791355866 \
1.710665347106947e-06 0.6975984806629684 1.710665493330962e-06 0.6941099299715526 1.710665653617309e-06 0.6902897983225644 1.710665856006145e-06 0.6854719661536142 \
1.710666037294609e-06 0.681161582477689 1.710666206116036e-06 0.6771536053116509 1.710666391961911e-06 0.6727470762459599 1.710666597892751e-06 0.6678715161770782 \
1.710666765819558e-06 0.6639016226084196 1.710666926081261e-06 0.6601182542089066 1.710667164933735e-06 0.65448589698252 1.710667332694849e-06 0.6505369020837752 \
1.710667513768288e-06 0.6462813620835641 1.710667674923199e-06 0.642499550819208 1.71066782119046e-06 0.6390715923276049 1.710667959878569e-06 0.6358268652274862 \
1.710668089235615e-06 0.6328040340451749 1.71066821862017e-06 0.6297855584526113 1.71066834694149e-06 0.6267952385336898 1.710668477143629e-06 0.6237652412672913 \
1.710668606160074e-06 0.6207683673242944 1.710668744735633e-06 0.6175525629501428 1.71066889281122e-06 0.6141227553162802 1.710669079138505e-06 0.60981438109949 \
1.710669226822204e-06 0.6064079319686639 1.71066946198641e-06 0.600995965122186 1.710669654434141e-06 0.5965821560879089 1.710669895003955e-06 0.5910808370261941 \
1.710670064051326e-06 0.587228367631822 1.71067020171775e-06 0.5840969866928536 1.710670329822727e-06 0.581191110277254 1.710670443409422e-06 0.5786182870235701 \
1.710670534774226e-06 0.5765512826027382 1.710670624196113e-06 0.5745328691003393 1.710670691457846e-06 0.573016830490748 1.710670757478049e-06 0.5715297341779608 \
1.710670809531724e-06 0.5703577032508095 1.710670873770593e-06 0.5689124506700958 1.710670935307116e-06 0.5675311492520995 1.71067099958866e-06 0.5660899724818867 \
1.710671052779755e-06 0.5648985048860162 1.71067114512554e-06 0.5628316153148989 1.710671221701441e-06 0.5611191615154557 1.710671277545091e-06 0.5598732849310241 \
1.7106713468882e-06 0.5583285932816697 1.710671452739476e-06 0.5559733466166974 1.71067153043128e-06 0.5542469170533902 1.710671631029868e-06 0.5520159549745236 \
1.710671759063078e-06 0.5491849411292137 1.71067185856046e-06 0.5469885705929382 1.710671971125811e-06 0.544508366501287 1.710672074170131e-06 0.5422442603473754 \
1.710672194219017e-06 0.5396115972585003 1.710672295833426e-06 0.5373863339265779 1.710672411457693e-06 0.5348611538529422 1.710672526573874e-06 0.5323536236546169 \
1.710672653010918e-06 0.529604142030661 1.710672778525186e-06 0.5268822104345234 1.710672925204862e-06 0.5237112381511962 1.71067306087557e-06 0.5207845659358002 \
1.710673218641409e-06 0.5173942078023266 1.710673381063349e-06 0.5139116507621072 1.710673561971818e-06 0.5100482739823553 1.710673754563972e-06 0.5059503908118104 \
1.710673967555743e-06 0.5014368974673542 1.710674199988459e-06 0.4965308659362653 1.710674457509373e-06 0.49112491222925 1.710674697473551e-06 0.4861095397820235 \
1.710674998677906e-06 0.4798501326413723 1.710675286975534e-06 0.4738957353990632 1.710675600061861e-06 0.4674739717793394 1.710675919588141e-06 0.4609631488871989 \
1.710676259085406e-06 0.4540919149088484 1.710676585275518e-06 0.4475353831519197 1.71067692175678e-06 0.4408159131180407 1.710677238467587e-06 0.4345373385230166 \
1.71067757255266e-06 0.4279587671099637 1.710677924261529e-06 0.4210864038135054 1.710678238746378e-06 0.4149846225409808 1.710678562192836e-06 0.4087533091618546 \
1.710679003120948e-06 0.400331870031168 1.710679344916025e-06 0.3938679283557566 1.710679644350069e-06 0.3882534014213259 1.710680018872672e-06 0.3812944595528024 \
1.71068034825039e-06 0.375233915169682 1.710680631354694e-06 0.3700684563936956 1.710680931099705e-06 0.3646408765157301 1.710681210595549e-06 0.3596219010422631 \
1.710681434267487e-06 0.3556377385586224 1.710681645979194e-06 0.3518907610576284 1.710681848481927e-06 0.3483292724130969 1.710682049543475e-06 0.3448190020587957 \
1.710682255221384e-06 0.3412518188287665 1.71068247359686e-06 0.3374887625241871 1.710682717359257e-06 0.3333167726275162 1.710682944115829e-06 0.3294678078423895 \
1.710683164026801e-06 0.3257615367192951 1.710683382451408e-06 0.3221060038181086 1.710683586476418e-06 0.318715141566024 1.710683788334207e-06 0.3153870758963987 \
1.710683988657595e-06 0.3121102802474151 1.710684175271502e-06 0.309079115007194 1.710684372573108e-06 0.3058982938882217 1.710684581156335e-06 0.3025606704206737 \
1.710684786791057e-06 0.2992974534031506 1.710685011523137e-06 0.2957609785165763 1.710685228418979e-06 0.2923771984023277 1.710685436098331e-06 0.2891642611511841 \
1.710685667149178e-06 0.2856239464683982 1.710685841949429e-06 0.2829684481899911 1.710686021147604e-06 0.2802647299798244 1.71068619002212e-06 0.2777348429135014 \
1.710686418345393e-06 0.274348458173166 1.710686595082661e-06 0.2717528218126659 1.710686763365392e-06 0.2693020894036587 1.710686935832162e-06 0.2668230333489093 \
1.710687069934441e-06 0.264903804409765 1.710687215894446e-06 0.2628277003548514 1.710687354589946e-06 0.2608803500812688 1.710687476871551e-06 0.2591684246570544 \
1.710687610990381e-06 0.2572942758553639 1.710687740091486e-06 0.2554978336754472 1.71068785952522e-06 0.2538430842138498 1.71068798636042e-06 0.2520939183506197 \
1.710688106001441e-06 0.2504447954274527 1.710688255617635e-06 0.2483797066042054 1.710688390481146e-06 0.2465170278296022 1.71068852003856e-06 0.2447289494531232 \
1.710688677103379e-06 0.2425624627506451 1.710688801099014e-06 0.2408491463446025 1.710688941247149e-06 0.2389135279283614 1.71068907114005e-06 0.2371200701944942 \
1.71068919175767e-06 0.2354534357320198 1.710689354230601e-06 0.2332087289724075 1.710689500284699e-06 0.2311905595759856 1.710689638605484e-06 0.2292825126447264 \
1.710689746532702e-06 0.2277949627009887 1.710689877317609e-06 0.225993474229161 1.710689975823626e-06 0.22463752857886 1.710690079906972e-06 0.2232056532573264 \
1.710690152783836e-06 0.2222046546567725 1.710690234937313e-06 0.2210804129356655 1.710690302346398e-06 0.2201585377209549 1.710690349050661e-06 0.2195201149856669 \
1.71069039846802e-06 0.2188449488487562 1.710690489422163e-06 0.2176035744446363 1.710690555816576e-06 0.2166983392055156 1.710690602779869e-06 0.2160586379972232 \
1.710690653091075e-06 0.2153737902794619 1.710690712240425e-06 0.2145693142997165 1.710690755086328e-06 0.2139870779821451 1.710690798893629e-06 0.2133941263688522 \
1.710690868423894e-06 0.2124566309962414 1.710690955340708e-06 0.2112864027023158 1.710691036529563e-06 0.2101949018929156 1.710691122429026e-06 0.2090416531541652 \
1.710691216575207e-06 0.2077796428137634 1.710691308329081e-06 0.2065517647617813 1.710691403625517e-06 0.2052788208685862 1.710691500104208e-06 0.2039945431316728 \
1.71069160092949e-06 0.2026602783061639 1.710691696885502e-06 0.2013924147365721 1.710691799571213e-06 0.2000377255165624 1.710691902607566e-06 0.1986831378210229 \
1.710692012697906e-06 0.1972405340748948 1.710692121449794e-06 0.1958206085628783 1.710692241171749e-06 0.1942631948714586 1.710692351614651e-06 0.1928328887741874 \
1.710692459617459e-06 0.1914411844406488 1.710692584973803e-06 0.1898318066870429 1.710692677907979e-06 0.1886434908940876 1.710692756278755e-06 0.1876443873000938 \
1.710692832918829e-06 0.1866698667869858 1.710692915430143e-06 0.1856249297118943 1.710692984939759e-06 0.1847473639743596 1.710693050895387e-06 0.1839166514106665 \
1.710693115162722e-06 0.1831089953192083 1.710693227146207e-06 0.1817072258029639 1.710693321200174e-06 0.1805353135896268 1.710693428841935e-06 0.1791985758407087 \
1.710693535314993e-06 0.1778827552324552 1.71069365530692e-06 0.1764073736674057 1.710693793359546e-06 0.174720142305475 1.7106939095201e-06 0.1733081217455876 \
1.710694071616903e-06 0.1713503924599185 1.710694186705419e-06 0.1699688234017716 1.710694326691019e-06 0.1682987764548305 1.710694443897095e-06 0.1669083002780509 \
1.710694554816447e-06 0.1655990025649634 1.710694652444933e-06 0.1644521190704843 1.710694747295481e-06 0.1633427224865242 1.710694863349894e-06 0.161991523106341 \
1.710694954898444e-06 0.1609305136382055 1.71069505100742e-06 0.1598214181625073 1.710695145225553e-06 0.1587403933520305 1.710695238726156e-06 0.1576732160104884 \
1.710695332323478e-06 0.1566104070550305 1.710695428005016e-06 0.1555300824433628 1.710695518592921e-06 0.1545132165873678 1.710695609606078e-06 0.1534969984004868 \
1.710695705154556e-06 0.1524358767948732 1.710695795820268e-06 0.1514342506187442 1.710695898892631e-06 0.1503020548964867 1.71069597134408e-06 0.1495100717445464 \
1.710696050444873e-06 0.148649146151682 1.710696124993091e-06 0.1478424742503694 1.7106961960245e-06 0.1470770917224498 1.710696268788982e-06 0.1462962409077327 \
1.710696343406157e-06 0.1454990959398698 1.710696413389118e-06 0.1447543557055888 1.710696487550038e-06 0.143968261688537 1.710696541295377e-06 0.1434005634796054 \
1.710696594578932e-06 0.1428396203849428 1.71069665977469e-06 0.1421555039833398 1.710696731080731e-06 0.141411576573238 1.710696795450793e-06 0.1407432786314442 \
1.710696868802754e-06 0.1399847409254479 1.710696929420321e-06 0.1393607073002494 1.710697015453805e-06 0.1384787080092832 1.71069709140482e-06 0.1377037134581418 \
1.710697181372726e-06 0.1367902106004182 1.710697263099684e-06 0.1359645165492482 1.710697345789661e-06 0.1351360437760365 1.710697428345969e-06 0.1343145513298757 \
1.710697533908125e-06 0.1332698421778018 1.710697615775408e-06 0.1324642397250402 1.710697713142868e-06 0.1315110876582503 1.710697803143729e-06 0.130634908321232 \
1.710697891113988e-06 0.1297829978838479 1.710697974043842e-06 0.1289892226181523 1.710698048280934e-06 0.1282822873521282 1.710698147931993e-06 0.1273377645104763 \
1.710698243687052e-06 0.1264350619688987 1.710698330534456e-06 0.1256206895242312 1.710698420535994e-06 0.1247808744623497 1.710698500868674e-06 0.1240346855852102 \
1.710698587562703e-06 0.1232365419604467 1.710698686393032e-06 0.1223331159004786 1.71069877647517e-06 0.1215131568528167 1.710698886718427e-06 0.1205141992263624 \
1.710698973949866e-06 0.1197275966302077 1.710699042523e-06 0.1191120727131645 1.710699127185393e-06 0.1183553887582162 1.710699193692874e-06 0.1177634990399222 \
1.710699265148799e-06 0.1171309945267847 1.710699334822604e-06 0.1165184920865242 1.710699412159692e-06 0.1158409171037389 1.710699507902974e-06 0.1150054407698888 \
1.710699579157887e-06 0.1143861389207103 1.71069964652742e-06 0.1138025718558601 1.710699714964191e-06 0.113211685696446 1.710699790554542e-06 0.1125613765304429 \
1.710699881296389e-06 0.1117840233035959 1.710699964000116e-06 0.1110788257213999 1.710700077599187e-06 0.1101151050704521 1.710700187474899e-06 0.1091895325357105 \
1.710700279674213e-06 0.1084169374841771 1.710700403623544e-06 0.1073835127717347 1.710700491987867e-06 0.1066505015902263 1.710700631446837e-06 0.1055001025916527 \
1.710700730743538e-06 0.1046863788921388 1.71070082339359e-06 0.1039306459201802 1.710700933598102e-06 0.1030359883605075 1.710701018892542e-06 0.1023467905686673 \
1.710701103793345e-06 0.101663637589173 1.710701186744308e-06 0.1009989740617136 1.71070130925421e-06 0.1000225794851696 1.710701431196062e-06 0.09905761200121259 \
1.710701557818349e-06 0.09806258992746317 1.710701670630472e-06 0.09718220909187772 1.710701815205956e-06 0.09606278874246346 1.710701952919884e-06 0.09500564015228773 \
1.710702069610674e-06 0.09411672853020667 1.710702197354241e-06 0.0931507147971556 1.710702297018758e-06 0.09240236948627445 1.710702376452637e-06 0.09180921593916676 \
1.710702475187935e-06 0.09107599640376031 1.710702553063239e-06 0.09050081472416407 1.710702634529155e-06 0.08990210528957472 1.710702709246463e-06 0.0893557072655629 \
1.7107027897762e-06 0.08876971652456604 1.710702908608526e-06 0.08791061481419053 1.710702998269062e-06 0.08726673116015753 1.710703103183109e-06 0.08651800316437093 \
1.710703234657667e-06 0.08558693768262025 1.710703395765802e-06 0.08445695903909305 1.710703535947497e-06 0.08348350561263763 1.710703684450103e-06 0.08246223579158835 \
1.710703821170292e-06 0.08153124812726546 1.710703961182002e-06 0.08058696725890066 1.710704098179202e-06 0.07967195061625794 1.710704236789813e-06 0.07875532825288725 \
1.7107043812627e-06 0.07780967510081127 1.710704528808937e-06 0.07685421131041187 1.710704686312648e-06 0.07584560580436887 1.710704850707884e-06 0.07480523464991846 \
1.710705018799982e-06 0.07375451744755303 1.710705199799341e-06 0.07263751640721161 1.710705398512623e-06 0.07142823309373261 1.710705611921415e-06 0.07014922396308329 \
1.7107058380853e-06 0.06881630383186611 1.710706078645622e-06 0.06742468841361035 1.710706356206535e-06 0.06585179211508728 1.710706653410938e-06 0.06420523370201831 \
1.710706971711662e-06 0.06248365192299224 1.710707361695962e-06 0.06043183534616462 1.710707760522748e-06 0.05839861031494715 1.710708202994687e-06 0.05621846258761681 \
1.71070858797559e-06 0.05438828987170503 1.710709000022182e-06 0.05249218901100536 1.710709351759698e-06 0.05092353490091287 1.71070968726435e-06 0.04946969867921969 \
1.710709997763245e-06 0.04816021644386199 1.710710291700064e-06 0.04695194805701195 1.710710584430997e-06 0.04577883625507727 1.710710859274204e-06 0.04470700909733757 \
1.710711133117927e-06 0.04366353526031765 1.710711398807687e-06 0.04267398813878486 1.710711674116703e-06 0.04167180388267511 1.710711958673621e-06 0.04066026046469497 \
1.710712254971736e-06 0.03963283340811159 1.710712513847121e-06 0.03875659098599576 1.710712741803528e-06 0.03800131046948733 1.710712960528722e-06 0.03729095380188759 \
1.710713180383449e-06 0.03659437723507575 1.710713521249513e-06 0.03554043311314246 1.710713797290394e-06 0.03470953269536187 1.710714090721169e-06 0.03384790442147732 \
1.710714373289092e-06 0.03303898052111545 1.710714628198529e-06 0.03232625790162248 1.710714908882988e-06 0.03155947796597136 1.710715154716382e-06 0.03090318379665042 \
1.71071538687767e-06 0.03029616297556957 1.710715627215008e-06 0.02968398395812225 1.710715862851843e-06 0.02909722707395018 1.710716091063021e-06 0.0285403787496557 \
1.710716507835749e-06 0.02755138287878544 1.710716702361127e-06 0.02710176794309662 1.710717088601532e-06 0.02623051698020805 1.710717267770925e-06 0.0258356865503758 \
1.710717618998109e-06 0.02507792837274256 1.710717786904157e-06 0.0247229612172224 1.710718171166812e-06 0.02392944198669211 1.710718286448541e-06 0.02369675911063252 \
1.710718728496378e-06 0.02282172072611499 1.710718950311652e-06 0.02239223679446916 1.710719473931311e-06 0.02139838041889957 1.71071962929382e-06 0.02110714647916685 \
1.710720146999887e-06 0.02015295207761772 1.710720272033152e-06 0.01992792118872039 1.710720796234659e-06 0.01901759738223179 1.710720932454034e-06 0.01879045572456909 \
1.71072153873049e-06 0.01783210191617334 1.710721705739623e-06 0.01758082406519646 1.710722348947267e-06 0.01666064795441237 1.710722528091535e-06 0.0164167113061686 \
