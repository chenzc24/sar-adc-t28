5.179546973671149e-07 0.1261946708524367 5.179547535798413e-07 0.1256664967939027 5.179548160673401e-07 0.125081039250218 5.179548902953231e-07 0.1243877959456236 \
5.179549649763284e-07 0.1236954937854857 5.179550521595407e-07 0.1228905551604285 5.179551205580918e-07 0.1222610287411191 5.17955201128775e-07 0.1215216597888775 \
5.179552824242559e-07 0.120778012781285 5.179553493407808e-07 0.1201677797529914 5.179554321577255e-07 0.1194156054679852 5.179554913464481e-07 0.1188799972037829 \
5.179555572674477e-07 0.1182853617472536 5.179556371414916e-07 0.1175675408705869 5.179557136372899e-07 0.1168828806096336 5.179557950994005e-07 0.1161574242846086 \
5.179558935702815e-07 0.1152852106851665 5.179559686806303e-07 0.114622623867465 5.179560716684202e-07 0.1137180076826871 5.179561458523715e-07 0.1130691786503039 \
5.17956243471825e-07 0.1122190343868764 5.179563392827803e-07 0.1113890351962442 5.179564351312053e-07 0.110562946039519 5.179565160694118e-07 0.1098685209805978 \
5.179566044526832e-07 0.1091134439098378 5.179567030526615e-07 0.108274944429282 5.179567758368655e-07 0.1076586405352824 5.17956865109775e-07 0.1069058608836731 \
5.179569270917884e-07 0.1063852406583179 5.179569896849556e-07 0.1058613310701875 5.179570749071042e-07 0.105150777260444 5.179571803694782e-07 0.1042758147594986 \
5.179572601999606e-07 0.1036167065755082 5.179573409142144e-07 0.1029530974056021 5.179574235279495e-07 0.1022768941101355 5.179574939725617e-07 0.1017026162492672 \
5.179575972319282e-07 0.1008648142128753 5.179576700720535e-07 0.1002767039768694 5.17957755712335e-07 0.09958839426015198 5.179578745140727e-07 0.09863954321822334 \
5.179579421518978e-07 0.09810250133474645 5.179580119020204e-07 0.09755100310752296 5.17958089237e-07 0.09694230106952094 5.179581816572539e-07 0.09621870517595056 \
5.17958253354782e-07 0.09566033062548993 5.179583391719417e-07 0.09499542738017568 5.17958441597192e-07 0.09420660575030523 5.17958534892083e-07 0.09349264652734962 \
5.179586312085565e-07 0.09276005482712441 5.179587081108176e-07 0.09217843893134048 5.179588015908053e-07 0.09147541043939374 5.179588808332317e-07 0.09088281005358793 \
5.17958995455426e-07 0.0900310686188453 5.179591250636858e-07 0.08907580221142102 5.179592583208766e-07 0.08810234090122065 5.179594023507657e-07 0.08705990691030199 \
5.179595595189095e-07 0.08593388720602639 5.179597092953871e-07 0.08487214151476249 5.179598717629786e-07 0.08373303262435308 5.179600149429843e-07 0.08273971668837025 \
5.179601676221069e-07 0.0816913199659166 5.179603018918778e-07 0.08077856892457436 5.179604436441555e-07 0.07982444400446118 5.179605786438163e-07 0.07892500874648442 \
5.179607206012136e-07 0.07798882638923543 5.179608674486441e-07 0.07703088995320664 5.17961019894053e-07 0.07604750978240994 5.179611851127757e-07 0.07499422991502351 \
5.179613492506213e-07 0.07396067809208305 5.17961526112024e-07 0.07286119333145537 5.179617164535802e-07 0.07169407515132428 5.179619274100931e-07 0.07042030845332216 \
5.179621478192316e-07 0.0691121699798517 5.17962383344393e-07 0.06773900533435212 5.179626437937674e-07 0.0662496528900723 5.179629394591772e-07 0.06459579389282195 \
5.179632445814627e-07 0.06292902455725519 5.179636095760241e-07 0.06098725515092194 5.179640044568393e-07 0.05894944116461652 5.179644108474933e-07 0.05692211719668253 \
5.179648265730353e-07 0.05491854459141238 5.179651893793582e-07 0.0532251207245777 5.179655339806477e-07 0.05166301626031383 5.179658491605098e-07 0.05027284652491828 \
5.179661446898748e-07 0.04900240867073854 5.179664426703825e-07 0.04775344010203557 5.179667184691725e-07 0.04662857640242725 5.179669972437683e-07 0.04551884372531381 \
5.179672611786382e-07 0.04449205559535935 5.179675372013766e-07 0.04344260531795661 5.179678161576298e-07 0.04240676967887352 5.179681298509632e-07 0.04127097799875453 \
5.179683658512502e-07 0.04043636567030678 5.179686216459875e-07 0.03955075129286261 5.17968881769487e-07 0.03867033103466553 5.179691519047594e-07 0.03778142289416799 \
5.179694311247467e-07 0.03688501536902895 5.179697129633963e-07 0.03600226561751176 5.17969989839066e-07 0.03515600409566183 5.179702689326649e-07 0.03432349610146775 \
5.179705018102724e-07 0.03364444121149882 5.179707856469893e-07 0.03283527291840588 5.179710257519236e-07 0.03216626441466421 5.179712655507463e-07 0.0315119836023277 \
5.179715048279204e-07 0.03087436846876356 5.179717400849421e-07 0.03026290129608995 5.179719710119639e-07 0.02967475842909434 5.17972186001007e-07 0.02913788335257221 \
5.179725881554596e-07 0.02816043724496065 5.179727868782784e-07 0.02768988489927659 5.179731605612946e-07 0.0268265706552881 5.179733473596173e-07 0.02640514011949098 \
5.179736949193038e-07 0.02563810810034544 5.179738168487671e-07 0.0253740445387235 5.179741993202075e-07 0.02456430406701914 5.179743700282367e-07 0.02421180751242828 \
5.179748271256211e-07 0.02328894863848502 5.179750127580069e-07 0.0229225623309489 5.179753762152598e-07 0.02221803970155307 5.179755965826125e-07 0.02179832126591805 \
5.179760543089696e-07 0.02093867417890744 5.179761897285988e-07 0.02068687731869814 5.179767196240474e-07 0.01972418011126781 5.17976838945017e-07 0.01951377505543128 \
5.179774047306961e-07 0.01856069823426573 5.17977569110437e-07 0.0182962226476828 5.179781876557339e-07 0.01735107502432094 5.179783577099333e-07 0.01710418363667701 \
5.17978889842166e-07 0.01636278834442301 5.179790869261418e-07 0.01610013864443424 5.179798100452149e-07 0.01517806887136661 5.179799746753809e-07 0.01497647803580381 \
5.179807238007678e-07 0.01409711804523418 5.179808571001203e-07 0.01394643716836554 5.179817173537587e-07 0.01301449210748497 5.179818524573793e-07 0.01287422877142914 \
5.179827950348197e-07 0.01193816285908547 5.179829586305738e-07 0.01178202925388569 5.179839599872008e-07 0.0108653384673985 5.179840975299883e-07 0.01074500730514941 \
5.179853196363713e-07 0.009765086624518643 5.179854265890839e-07 0.00968516078425012 5.179868307805774e-07 0.008707372520026449 5.179869356112841e-07 0.008639312158696611 \
5.179884704482461e-07 0.00767719340797631 5.179885657315476e-07 0.007617466071856052 5.179901745288685e-07 0.006680264535635283 5.179903086056076e-07 0.006609506832171614 \
5.179924056185594e-07 0.005610918814474722 5.179926361631908e-07 0.005510783990371394 5.179949591584346e-07 0.004586584533412417 5.179954404886379e-07 0.004413562233393853 \
5.179982780502688e-07 0.003511943147855551 5.179988229699549e-07 0.003360532104877318 5.180029471783516e-07 0.002408309874554541 5.180034909020111e-07 0.002305347543005144 \
5.180093621912368e-07 0.001333291345955189 5.180096050564211e-07 0.001286469439319215 5.180239329487719e-07 0.0002880570268237783 5.180240775074142e-07 0.0002853642807229123 \
5.206613564285128e-07 -0.0006859155495331031 5.206614959836499e-07 -0.000901903561740745 5.206620050775826e-07 -0.001859438188174024 5.206620945650851e-07 -0.002052812934985279 \
5.206624579599451e-07 -0.00291126965001638 5.206625489820155e-07 -0.003143482006111167 5.206629144200523e-07 -0.004127275145644371 5.206630246806194e-07 -0.004436819103926468 \
5.206633367277739e-07 -0.005309594399865315 5.206634394426211e-07 -0.005584800160857357 5.206638032904768e-07 -0.006384516484886619 5.206639680812085e-07 -0.006586298968823262 \
5.206645476774082e-07 -0.005791490933239759 5.206647227875511e-07 -0.004914057272375438 5.206648394794852e-07 -0.004132845175365214 5.206649660640906e-07 -0.003100877896798674 \
5.206650678730126e-07 -0.002132773363901063 5.206651883617228e-07 -0.0008283127610571584 5.206652788087988e-07 0.0002599396317828252 5.206653766989304e-07 0.001541559978017447 \
5.206654757632395e-07 0.002943971508909197 5.206656465705158e-07 0.005594911825788154 5.206658683385387e-07 0.00944046646559993 5.206660642423845e-07 0.01317281463966807 \
5.206662231237664e-07 0.01639870563256729 5.206663875522632e-07 0.01989779506365397 5.206665419182936e-07 0.02331070396473752 5.20666700690818e-07 0.02693200463312963 \
5.20666847428777e-07 0.03036422445567413 5.206669960527481e-07 0.0339113704936035 5.20667151667245e-07 0.03768995713197771 5.206673089092589e-07 0.04156499463828727 \
5.206674738020576e-07 0.04567927910670353 5.206676472215783e-07 0.05005184210758699 5.20667825915293e-07 0.05459761989277153 5.206680145311307e-07 0.05943075613080645 \
5.206682154312735e-07 0.06460909294799391 5.206684348880646e-07 0.0702927970720964 5.206686644343515e-07 0.07626037976612585 5.20668910133291e-07 0.08266408948881369 \
5.206691786982297e-07 0.08967663153997742 5.206694700401444e-07 0.09728936802005522 5.206697917081718e-07 0.1056939239977524 5.20670152022263e-07 0.1150987971742611 \
5.206705430017012e-07 0.1252892839303718 5.206709864165172e-07 0.1368209045172546 5.206715027296045e-07 0.1502062239570841 5.206721089348208e-07 0.16586000516691 \
5.206727801918478e-07 0.1831102247110778 5.206735596915048e-07 0.20301830483439 5.206744320013886e-07 0.2251413938832897 5.206752623367137e-07 0.2460320778586349 \
5.206759936670634e-07 0.264292249712138 5.206766416128433e-07 0.280346965484095 5.206772249233171e-07 0.29469740877147 5.20677760655584e-07 0.3077798509628869 \
5.20678263914169e-07 0.3199778888071559 5.2067874911767e-07 0.3316516836183861 5.206792280403756e-07 0.3430829066939081 5.20679674471008e-07 0.3536501814456421 \
5.206801488007181e-07 0.3647819492304352 5.206805979917124e-07 0.3752331958288908 5.206810884639696e-07 0.3865396207984229 5.206816170367225e-07 0.3985997842463301 \
5.206819881810624e-07 0.4069920784971888 5.20682515935418e-07 0.4188173133762567 5.206829782921778e-07 0.4290642331729484 5.206834506243179e-07 0.4394285229343968 \
5.206839324090407e-07 0.4498981261869666 5.206839654481592e-07 0.4506126593745911 5.206840032071518e-07 0.45142837879914 5.20684078725137e-07 0.4530572051633331 \
5.206842297611073e-07 0.4563088938659436 5.206844372803726e-07 0.460764549126051 5.206846253191842e-07 0.4647825567212808 5.206848443283984e-07 0.469441659996985 \
5.206850871594094e-07 0.4745824626509371 5.206853869350374e-07 0.4808894567257585 5.206856247281871e-07 0.4858624696070272 5.206858879495879e-07 0.4913374535260851 \
5.206861488471327e-07 0.4967277906005185 5.206863784012197e-07 0.5014431429135263 5.206866014614136e-07 0.506003872007333 5.206868030374043e-07 0.5100983586086808 \
5.206869518674631e-07 0.51310967141356 5.206871961785157e-07 0.5180317772556589 5.206873287837491e-07 0.5206893064287169 5.206874681403308e-07 0.5234717264876519 \
5.206876791057241e-07 0.5276623644271943 5.206878539796058e-07 0.5311266030493931 5.206881220278524e-07 0.5364094032095129 5.206883170535098e-07 0.5402319029111832 \
5.206884966150174e-07 0.5437361368949839 5.206887475711459e-07 0.5486228351952749 5.20689024979257e-07 0.5540035987981641 5.206893089285589e-07 0.5594901708581531 \
5.206895645658505e-07 0.5644152233389156 5.206898555480696e-07 0.570006772487656 5.206901158537539e-07 0.5749917787111524 5.206903842978736e-07 0.5801232573974072 \
5.206906270630043e-07 0.5847450403362237 5.206908835942051e-07 0.5896146675871002 5.206911097576483e-07 0.59388771440121 5.206913470991427e-07 0.5983512154742827 \
5.206915564878602e-07 0.6022720321566808 5.206917702606284e-07 0.6062574570422776 5.206920237134688e-07 0.6109557890491497 5.206922265678164e-07 0.6146943332140289 \
5.206924193723378e-07 0.6182333111593361 5.206926096773651e-07 0.6217090173923294 5.20692800335854e-07 0.6251694921350958 5.206930029137796e-07 0.6288260100903066 \
5.206932656625422e-07 0.6335359534764116 5.206934946302321e-07 0.6376100987349322 5.206937145778672e-07 0.6414991146358265 5.206939402625401e-07 0.6454625140719233 \
5.206941491499661e-07 0.6491091855837361 5.206943708035853e-07 0.652957810138281 5.206945556930106e-07 0.6561429680377227 5.206947457075645e-07 0.6594017273991298 \
5.206948958626861e-07 0.6619630641908443 5.206950707405929e-07 0.6649292185271485 5.206952164613095e-07 0.6673855496832628 5.206953524938416e-07 0.6696641287411549 \
5.206955008561211e-07 0.672138295335571 5.206956303038336e-07 0.6742883907026684 5.206957641695307e-07 0.6764996355878535 5.206958925139303e-07 0.6786115243545502 \
5.206960179020585e-07 0.6806677490053815 5.20696147367755e-07 0.6827843190971332 5.206962783489702e-07 0.6849171426143115 5.206964267220724e-07 0.6873221141612875 \
5.206965347848267e-07 0.6890667486235877 5.206966633164996e-07 0.6911333958680312 5.206967987562836e-07 0.6933004139195943 5.206969236906071e-07 0.6952876996714908 \
5.206970494478751e-07 0.6972799977491608 5.206971559637663e-07 0.6989584331773744 5.206972730816549e-07 0.7007929859467624 5.206973916214007e-07 0.7026383448210159 \
5.206975149247975e-07 0.704545102273978 5.206976180976957e-07 0.7061304255463237 5.206977690688591e-07 0.7084341141567283 5.206978853230652e-07 0.7101955266062138 \
5.206980158834539e-07 0.7121605601685687 5.206981344459821e-07 0.7139335830373704 5.206982405198518e-07 0.7155108922888329 5.206983405447915e-07 0.716990346352101 \
5.206984778700066e-07 0.719009255813789 5.206985965313623e-07 0.7207429633399333 5.20698718230586e-07 0.7225107522614664 5.206988434131514e-07 0.7243181860083944 \
5.206989654329652e-07 0.7260693242762759 5.206990934647186e-07 0.7278954552757622 5.20699217946458e-07 0.7296603419865877 5.206993462457807e-07 0.7314685590147565 \
5.20699473339584e-07 0.7332489547570846 5.206995993644231e-07 0.7350034830462163 5.2069970210311e-07 0.7364262918236342 5.206998167758556e-07 0.7380063527755659 \
5.206998981819179e-07 0.7391232259175492 5.207000173814378e-07 0.7407496908814458 5.20700110023778e-07 0.7420059782745783 5.207002481828348e-07 0.7438668850244906 \
5.207003792383344e-07 0.7456179978167152 5.207005093705019e-07 0.7473439783685625 5.207006143445769e-07 0.7487266533969134 5.207007534844189e-07 0.7505456565005918 \
5.207009074287187e-07 0.7525407731682957 5.207010293729987e-07 0.7541080835708853 5.207011769193594e-07 0.7559892974429111 5.20701298924537e-07 0.7575320275232224 \
5.207014476244666e-07 0.7593968175435225 5.207015816710922e-07 0.7610632318338031 5.207017039243472e-07 0.7625711443351471 5.207018167902567e-07 0.763953046884334 \
5.207019596412247e-07 0.7656882893306027 5.207020863641194e-07 0.7672149413549471 5.207022021689945e-07 0.7685995877768005 5.207023319108228e-07 0.7701390587657672 \
5.207024476492106e-07 0.7715019052061673 5.207025706016372e-07 0.7729391548276606 5.20702688317297e-07 0.7743051053122872 5.207027942872733e-07 0.7755262985206828 \
5.207029106984675e-07 0.7768586864857919 5.207030173164004e-07 0.7780703956921795 5.207031295151206e-07 0.7793369495935717 5.207032161836896e-07 0.7803089322889447 \
5.207033195691813e-07 0.7814603789665585 5.207034327334326e-07 0.7827108149434853 5.207035383807155e-07 0.783868819044773 5.207036477202729e-07 0.7850578567336689 \
5.207037548972878e-07 0.786214126597127 5.20703884303365e-07 0.7875981444497275 5.207039967207505e-07 0.7887899291890393 5.207041201084897e-07 0.7900869036018625 \
5.207042375588255e-07 0.7913106402786101 5.207043810857437e-07 0.7927918312347375 5.20704496005322e-07 0.7939667362870242 5.207046347277352e-07 0.7953719780830618 \
5.207047727598755e-07 0.7967562205547866 5.207048822530295e-07 0.7978444364842524 5.207049832714595e-07 0.7988406866985471 5.207050843594198e-07 0.7998302780396641 \
5.207052167466157e-07 0.8011146558616069 5.207053354720369e-07 0.8022550163876687 5.207054572565424e-07 0.8034134048507504 5.207055763463359e-07 0.8045351524060473 \
5.207056975508532e-07 0.8056657048884367 5.207058291946645e-07 0.8068811249615274 5.207059522127028e-07 0.8080052413861453 5.207060798230233e-07 0.8091594649786741 \
5.20706210891683e-07 0.8103325925767672 5.207063342120463e-07 0.8114249716726942 5.207064421363105e-07 0.8123719892944993 5.207065499317031e-07 0.8133095350680949 \
5.20706631652631e-07 0.8140147772069938 5.207067485202474e-07 0.815015186305849 5.207068395812563e-07 0.8157880755829442 5.207069737498875e-07 0.8169164295805346 \
5.2070711832076e-07 0.8181184617099191 5.207072518231266e-07 0.8192158725965917 5.207073617890375e-07 0.8201107352847025 5.207075056546975e-07 0.8212684563313245 \
5.207076589602621e-07 0.8224861772268215 5.207077866985553e-07 0.8234883060891934 5.207079273408909e-07 0.8245786478120171 5.207080531244555e-07 0.8255423809867173 \
5.207082077424273e-07 0.8267124309768116 5.207083401541937e-07 0.8277017767197102 5.207084664337981e-07 0.8286345641820314 5.20708584064113e-07 0.8294941055817234 \
5.207087322309758e-07 0.8305638349826423 5.207088993752207e-07 0.8317531470681401 5.207090319938809e-07 0.832683775428688 5.207092049385689e-07 0.8338803479528284 \
5.207093733252244e-07 0.8350269493631071 5.207095428597542e-07 0.8361634673386688 5.207097242289089e-07 0.8373596561587384 5.207098668614913e-07 0.8382862741713709 \
5.207099807973396e-07 0.8390176620397163 5.207101115711344e-07 0.8398476357987267 5.207102132250742e-07 0.8404856735008092 5.207103297188026e-07 0.8412091703399448 \
5.207104652363492e-07 0.8420405885319162 5.20710662580143e-07 0.8432318270427018 5.20710853245141e-07 0.8443612543037786 5.207110631019802e-07 0.8455804035625291 \
5.207112440391043e-07 0.8466117334714958 5.207114413745908e-07 0.8477160230260256 5.207116151614274e-07 0.8486711109012058 5.207117977428814e-07 0.8496572451898022 \
5.207119690624607e-07 0.850566499179887 5.207121434475075e-07 0.8514760798656241 5.207123188310518e-07 0.8523748177975867 5.207124950632094e-07 0.8532619682996843 \
5.207126849014517e-07 0.8542000584728613 5.207128756376654e-07 0.8551245802328369 5.20713077434399e-07 0.856083442102113 5.207132701277752e-07 0.8569809170305027 \
5.207134797560765e-07 0.857937542729613 5.207137091938401e-07 0.8589615588718806 5.207139749904801e-07 0.8601183337444025 5.207142735657076e-07 0.8613802063570262 \
5.207145514672209e-07 0.8625196921548358 5.207148356776948e-07 0.8636511027355716 5.207151100894824e-07 0.8647118800460076 5.207153822523641e-07 0.8657341977214618 \
5.207156524214556e-07 0.8667205537246333 5.207159096161393e-07 0.8676338760342862 5.207161821558104e-07 0.868575115807136 5.207164581902909e-07 0.8695013130444248 \
5.207167283429861e-07 0.8703818891200001 5.207170280497876e-07 0.8713292845176382 5.207173988672581e-07 0.8724597217497643 5.207176937859212e-07 0.8733269024855727 \
5.207179480301993e-07 0.8740525764960509 5.207182462541985e-07 0.8748787854419284 5.20718519878969e-07 0.8756137195941651 5.207187560179586e-07 0.8762307200963571 \
5.207189963736862e-07 0.8768427579093606 5.207192187193381e-07 0.8773949085683344 5.207194127230722e-07 0.877865919014753 5.207197424471962e-07 0.878644045115768 \
5.207198976198553e-07 0.8790007149587372 5.207202153732479e-07 0.879712598742095 5.207203942386052e-07 0.8801026384247937 5.207207367000935e-07 0.8808283583858193 \
5.207209208412926e-07 0.8812073588304842 5.207213957461144e-07 0.8821499412898334 5.207215631406012e-07 0.8824705695712217 5.207220289718891e-07 0.8833323038036038 \
5.207222097967714e-07 0.8836551183393088 5.207227038300282e-07 0.8845051821644966 5.207228451726029e-07 0.8847400410050358 5.207234515631179e-07 0.8857071861637142 \
5.207236036356849e-07 0.8859397703602404 5.207242503137577e-07 0.8868873789663725 5.207243786102467e-07 0.8870678433440622 5.207250267232453e-07 0.8879435266410994 \
5.207251565285235e-07 0.8881118897635528 5.20725934785608e-07 0.8890711781604964 5.207260497804227e-07 0.8892053868933587 5.207269055110619e-07 0.8901454611437621 \
5.207270507776287e-07 0.8902951528450479 5.207280365337324e-07 0.8912364417375994 5.207282576409459e-07 0.8914302300078862 5.207294027520271e-07 0.892358484239638 \
5.207295339601743e-07 0.8924604119362172 5.207308752633695e-07 0.8934531785430913 5.207310266510304e-07 0.8935579568409697 5.207325081098674e-07 0.8944876667405802 \
5.207327469902294e-07 0.894621531696939 5.207345164619859e-07 0.8954958910368339 5.207349055688235e-07 0.8956641700186337 5.207372993342323e-07 0.8965498195158238 \
5.207377748942228e-07 0.8966991754584082 5.20741837950387e-07 0.8976977719002629 5.207423294244079e-07 0.8977905759376156 5.207506459514872e-07 0.8987839664765119 \
5.207515658053768e-07 0.8988472044554419 5.208777709459031e-07 0.8998441026240215 5.20878784754255e-07 0.8998514601858095 5.210704973474114e-07 0.8990059056521554 \
5.210707273489741e-07 0.8988405173838494 5.210723422215349e-07 0.8978439928078279 5.210725199353886e-07 0.8977495532019018 5.210892857104285e-07 0.8987316330193963 \
5.210894216988253e-07 0.8987497732072308 5.211048844279385e-07 0.8997471920221268 5.211051522925305e-07 0.8997526389354535 5.215889776197985e-07 0.9006560548284696 \
5.215890984089986e-07 0.9007687033315858 5.215898861800374e-07 0.9017381658104292 5.215900203187565e-07 0.901943163319478 5.215905139335305e-07 0.9027850367016239 \
5.21590658833145e-07 0.9030569221572713 5.215910546405301e-07 0.9038490360455199 5.215911744361842e-07 0.9041001886668685 5.215915586097176e-07 0.9049189780371781 \
5.215916707313647e-07 0.9051556495331843 5.215921780523356e-07 0.9061253139956988 5.215922720511916e-07 0.90626859229291 5.215934307008982e-07 0.9055667778886739 \
5.215935336638317e-07 0.9051589876696525 5.215936175067007e-07 0.9047707260375384 5.215937512467522e-07 0.9040404158978201 5.215938519641334e-07 0.9033957423200318 \
5.215939595799192e-07 0.9026166239542108 5.215940771531732e-07 0.9016533104038295 5.21594165418223e-07 0.90085556431878 5.215942850516912e-07 0.8996698288011099 \
5.215943823733892e-07 0.8986166602050341 5.215944933908277e-07 0.8973222354192386 5.215945955004155e-07 0.8960407982554908 5.21594678931815e-07 0.8949326975987755 \
5.215947831128826e-07 0.8934749428758865 5.215948741996462e-07 0.8921321265381427 5.215949667404319e-07 0.8907058396397178 5.215950618944299e-07 0.8891776325191247 \
5.215951764494069e-07 0.88725933118288 5.215952652925089e-07 0.8857137884271823 5.215953635316907e-07 0.8839502506198179 5.215954489018647e-07 0.8823735982707064 \
5.215955298021067e-07 0.8808434949738935 5.215956027633997e-07 0.8794355441897157 5.215956697820454e-07 0.8781198554636557 5.215957383931237e-07 0.8767515715160701 \
5.215958218880357e-07 0.8750591081124355 5.215958840153664e-07 0.8737811510706814 5.215959469979638e-07 0.8724704924326797 5.215960421537153e-07 0.8704632161180945 \
5.215961427643534e-07 0.8683077530860182 5.215962226435446e-07 0.8665738309361769 5.21596306905814e-07 0.8647250601592834 5.215963860160736e-07 0.8629723295901451 \
5.215964488315189e-07 0.8615696597604833 5.215965362885537e-07 0.8596016864744445 5.215966021820844e-07 0.8581079708060287 5.215966702436265e-07 0.856556281928966 \
5.215967195561343e-07 0.8554267461646872 5.215967747929236e-07 0.85415654045335 5.215968155325295e-07 0.8532164928603474 5.215968618342831e-07 0.8521450198670055 \
5.21596892048343e-07 0.8514441160591502 5.215969210896253e-07 0.8507691938976955 5.215969517282201e-07 0.8500558939662993 5.215970130054097e-07 0.8486254874746039 \
5.215970660779718e-07 0.8473828229799116 5.215971197331653e-07 0.8461232012188223 5.215971823904472e-07 0.8446482873934593 5.215972456733951e-07 0.8431545995644786 \
5.21597336171269e-07 0.8410121009440262 5.215974331690495e-07 0.8387078554355326 5.215975161465499e-07 0.8367307351423475 5.215975981509054e-07 0.8347721678896715 \
5.215976872193066e-07 0.8326403548070889 5.215977717326431e-07 0.8306135893189693 5.215978625915234e-07 0.8284303722590877 5.21597954526378e-07 0.8262176456275642 \
5.215980569573085e-07 0.8237486178045141 5.215981570753404e-07 0.8213320995840899 5.215982718962233e-07 0.8185572053828121 5.215983841027604e-07 0.8158423448209959 \
5.215985090963053e-07 0.8128151787794674 5.215986403567133e-07 0.8096337870015397 5.215987856277547e-07 0.8061104108175116 5.215989401353681e-07 0.8023613213197434 \
5.215991115759888e-07 0.7981999722344618 5.215992756257814e-07 0.794217661721315 5.215994600412032e-07 0.7897413884478564 5.215996665335768e-07 0.7847307375046715 \
5.215998560274197e-07 0.7801344622909899 5.216000494211826e-07 0.775444374634302 5.216002499880374e-07 0.7705834242206392 5.21600397552439e-07 0.7670092004965298 \
5.216005275638895e-07 0.7638619034739171 5.216006624283031e-07 0.7605987503374771 5.216007689187539e-07 0.7580234999254772 5.216009006085467e-07 0.7548403390839162 \
5.216010070329759e-07 0.7522693550468039 5.21601150211605e-07 0.7488125398635642 5.216013113387162e-07 0.7449250928176189 5.216014295655331e-07 0.7420746008290786 \
5.216015997983541e-07 0.7379721584775248 5.216017657246235e-07 0.7339761998059781 5.216019852669538e-07 0.7286940862104242 5.216021784540779e-07 0.724050920820232 \
5.216023533680413e-07 0.719851304223293 5.216025203151389e-07 0.7158476177432674 5.216027078061003e-07 0.711355754450834 5.216028952345367e-07 0.7068709122373377 \
5.216030635710959e-07 0.7028473835914892 5.216032564016302e-07 0.6982428782038785 5.216033964513774e-07 0.694901318858167 5.216035527086664e-07 0.6911769338170629 \
5.216037468781132e-07 0.6865540563080536 5.216039059846016e-07 0.6827702245679255 5.216040643446318e-07 0.679008548037742 5.216042596617402e-07 0.6743756772263459 \
5.216044700905194e-07 0.6693917663527935 5.216047227926646e-07 0.6634173774538097 5.216049024606155e-07 0.6591769455535931 5.216051540374889e-07 0.6532475027332399 \
5.21605354410306e-07 0.6485340174553987 5.216055260641582e-07 0.6445032789616798 5.216056847562747e-07 0.6407814961122935 5.21605823964202e-07 0.637522316374186 \
5.216059602882518e-07 0.6343349641335875 5.216060875012759e-07 0.6313646237382058 5.216062169938336e-07 0.6283457899522861 5.216063449851212e-07 0.6253646753452949 \
5.216064760596301e-07 0.6223174651643489 5.216066067717051e-07 0.6192830747181834 5.216067493797575e-07 0.6159760732208495 5.216068921032356e-07 0.612672916206165 \
5.216070446510367e-07 0.6091471600588 5.216071891550245e-07 0.6058158037532523 5.216073531732721e-07 0.6020406322262999 5.216074906379333e-07 0.5988837056407329 \
5.21607625454949e-07 0.5957940466067043 5.216077469535923e-07 0.5930134750293682 5.216078858038966e-07 0.5898448108574432 5.216079994507128e-07 0.5872554148224447 \
5.216081508608854e-07 0.5838116422847746 5.216082645795603e-07 0.5812320812748947 5.216083839926513e-07 0.5785269636915771 5.216084726731778e-07 0.5765205397309219 \
5.216085638182693e-07 0.5744630259469776 5.216086291571447e-07 0.5729901393713442 5.216086936268468e-07 0.5715377831648228 5.21608744447459e-07 0.5703933076453638 \
5.216088034223984e-07 0.569066051987989 5.216088708671064e-07 0.5675516747474645 5.216089379592979e-07 0.5660472084764079 5.216089908797418e-07 0.5648615894615425 \
5.216090865272254e-07 0.5627204246953637 5.216091437083616e-07 0.5614413394337 5.216091975109775e-07 0.5602399192081799 5.216092592530825e-07 0.5588634520375642 \
5.216093450862141e-07 0.5569525037715509 5.216094277818617e-07 0.5551133137453282 5.216095539105889e-07 0.552313430559463 5.216096890096645e-07 0.5493247407981657 \
5.21609787329828e-07 0.5471534914294828 5.216098999078898e-07 0.5446716589975775 5.216100024523052e-07 0.5424173856211837 5.216101225611308e-07 0.5397821662853191 \
5.216102242487819e-07 0.5375541863492928 5.216103397527456e-07 0.5350300289250629 5.216104546438613e-07 0.5325260225312031 5.216105811211341e-07 0.5297740207092871 \
5.216107063383296e-07 0.5270565158317848 5.216108531843122e-07 0.5238798967507053 5.216109886424458e-07 0.5209557060405445 5.216111462030545e-07 0.5175672114705414 \
5.216113083572293e-07 0.5140875588169389 5.216114890683071e-07 0.5102248342695275 5.216116813160603e-07 0.5061308236654174 5.216118940383231e-07 0.5016182665703952 \
5.216121259434839e-07 0.4967183500883584 5.216123831371877e-07 0.4913135654247419 5.216126226904984e-07 0.4863004534671564 5.216129246203734e-07 0.4800178499336004 \
5.216132123868145e-07 0.4740665530855001 5.216135251890574e-07 0.4676409412178996 5.21613845020806e-07 0.4611139840073785 5.21614184657409e-07 0.4542292677834274 \
5.216145118732278e-07 0.4476411633207955 5.216148470347967e-07 0.4409363684817221 5.216151642914576e-07 0.4346351592989786 5.216154981114363e-07 0.4280489847791872 \
5.2161584979678e-07 0.4211625252737479 5.21616163864498e-07 0.4150547397555842 5.216164868937019e-07 0.4088175946446666 5.216169278730989e-07 0.4003732788922496 \
5.216172702759421e-07 0.3938810608698495 5.216175707238305e-07 0.3882325136127223 5.216179460534016e-07 0.3812375944419973 5.216182761286298e-07 0.3751439175705365 \
5.216185594064112e-07 0.3699597784791666 5.216188599137726e-07 0.3645020109013299 5.216191395612329e-07 0.3594637112692664 5.216193634235237e-07 0.3554634414471464 \
5.216195752745134e-07 0.35170280677964 5.216197776231135e-07 0.3481338771034005 5.216199787581392e-07 0.3446120049995081 5.216201845356566e-07 0.3410324794262659 \
5.216204455143708e-07 0.3365252478245505 5.216206850045531e-07 0.3324209773202946 5.21620917679624e-07 0.3284665339262754 5.216211317612159e-07 0.3248537323113044 \
5.21621352906983e-07 0.3211475567840967 5.21621553789873e-07 0.3178053707831449 5.216217571810749e-07 0.3144500223650613 5.216219548494876e-07 0.3112139453100684 \
5.216221410931751e-07 0.3081862077816076 5.216223360742573e-07 0.3050391973134606 5.216225395365023e-07 0.3017803754370622 5.216227174774077e-07 0.2989521325826759 \
5.216229532011123e-07 0.2952356640875101 5.216231513339656e-07 0.2921385263640672 5.216233526780327e-07 0.2890160050544278 5.216235769672297e-07 0.2855690750291008 \
5.216237418971288e-07 0.2830551950838826 5.216239195258139e-07 0.2803657404651576 5.216241039249613e-07 0.2775946687427531 5.216242877463064e-07 0.2748547260732712 \
5.216244662029787e-07 0.2722194282383935 5.216246381032459e-07 0.2696976713509589 5.216247986436533e-07 0.2673699088296289 5.216249201257115e-07 0.265617282026588 \
5.216250730472386e-07 0.2634201198254058 5.21625200480934e-07 0.2616085083773952 5.216253046546046e-07 0.2601317890528609 5.216254215590816e-07 0.2584775571399547 \
5.216255365705729e-07 0.2568557450124987 5.216256609328034e-07 0.2551103168403305 5.216257765070866e-07 0.2534925198640895 5.216259106146075e-07 0.2516172680784447 \
5.216260256018485e-07 0.2500177396912131 5.216261793514453e-07 0.2478798443778067 5.216263161546457e-07 0.2459790966208961 5.216264507404529e-07 0.2441094379339017 \
5.216266066045887e-07 0.2419575875351012 5.216267312534115e-07 0.2402378086535915 5.216268704689347e-07 0.2383186229544463 5.2162700069296e-07 0.236525770455347 \
5.216271210458007e-07 0.2348769158236033 5.216272564390845e-07 0.233027137746051 5.216274076440629e-07 0.2309620730808924 5.216275424005331e-07 0.2291249940296414 \
5.216276470867202e-07 0.2277003186426776 5.216277696228612e-07 0.2260366668203369 5.2162790456742e-07 0.2242086518061946 5.216279996831675e-07 0.2229209267876512 \
5.216281149432224e-07 0.2213657311907907 5.216281974762018e-07 0.2202562617028589 5.216282686815329e-07 0.2192992955643472 5.216283173890172e-07 0.2186449771734718 \
5.216283645839733e-07 0.2180112263680214 5.216284111327915e-07 0.2173864029843717 5.216284645213553e-07 0.2166701476649976 5.216285018980251e-07 0.2161690444847812 \
5.216285392831377e-07 0.2156680710113931 5.21628579604508e-07 0.2151283464800275 5.216286508546475e-07 0.2141753141901174 5.216286850689041e-07 0.2137180869447317 \
5.216287314635346e-07 0.2131018213873352 5.216287919072008e-07 0.2122998083652294 5.216288609101202e-07 0.2113853596849882 5.216289262050716e-07 0.210520730631805 \
5.216289941831954e-07 0.2096212333552783 5.21629110629525e-07 0.2080823984153433 5.216292005517136e-07 0.2068957989735914 5.216293082176197e-07 0.2054771097790837 \
5.216294042789353e-07 0.2042146625011118 5.216295076575089e-07 0.2028641889872041 5.216296043425437e-07 0.2016026287683381 5.216297071523967e-07 0.2002625524503448 \
5.216298079123679e-07 0.1989526210414513 5.216299190580346e-07 0.1975116692735505 5.216300260975285e-07 0.1961279675313261 5.216301440040637e-07 0.1946083430154048 \
5.216302521143875e-07 0.1932197128021231 5.216303614129877e-07 0.1918224631760269 5.216304820447392e-07 0.1902849927564414 5.216305769453309e-07 0.1890796997295432 \
5.216307055062502e-07 0.18745262875399 5.216307985410385e-07 0.1862801166370808 5.216309009375946e-07 0.1849947785893032 5.216309889048857e-07 0.1838942174288659 \
5.216310871755573e-07 0.182668828510528 5.216311837761789e-07 0.1814691026470878 5.216312704146923e-07 0.1803971466393716 5.216313568237044e-07 0.1793305247657973 \
5.216314526608142e-07 0.1781527189679156 5.216315573876885e-07 0.1768710765218302 5.216317031999754e-07 0.1750963017969037 5.216318191679068e-07 0.1736923427161618 \
5.216319756317111e-07 0.1718092975148396 5.2163208681163e-07 0.1704786474822015 5.216322270616306e-07 0.1688098560703619 5.216323500730353e-07 0.1673544160765056 \
5.216324565640335e-07 0.1661007559767333 5.216325528894916e-07 0.1649724583647661 5.216326503229586e-07 0.1638357962207703 5.216327541762373e-07 0.1626293386330815 \
5.216328459768101e-07 0.1615673458739011 5.216329443645254e-07 0.1604337426303964 5.216330272831699e-07 0.1594828374885931 5.216331226515033e-07 0.1583950132920943 \
5.216332052138515e-07 0.1574587876231885 5.216333077985372e-07 0.1563016192679324 5.21633384076854e-07 0.1554454316211293 5.216334726624787e-07 0.1544557264474612 \
5.216335448319839e-07 0.1536532700165102 5.21633626541473e-07 0.1527486200895024 5.216337002202809e-07 0.1519363404455653 5.216337804404094e-07 0.1510573496788611 \
5.216338521684844e-07 0.1502755532525617 5.216339204254628e-07 0.149534520573691 5.216340181414224e-07 0.1484788062294206 5.216340875916062e-07 0.147731872792437 \
5.216341703430852e-07 0.1468455801890639 5.216342303799947e-07 0.1462052652532956 5.216343006186586e-07 0.1454587420502366 5.216343720461929e-07 0.1447037411390827 \
5.216344525596948e-07 0.1438588888651768 5.216345158225991e-07 0.1431977449412327 5.216345934965784e-07 0.1423892845091393 5.216346828063428e-07 0.141463758692191 \
5.216347521699289e-07 0.1407479403162204 5.216348501181492e-07 0.1397418416088305 5.216349404626691e-07 0.1388188591118084 5.216350262429942e-07 0.1379520826379384 \
5.216350938967789e-07 0.1372719511642241 5.216351602046294e-07 0.1366075914250998 5.21635238824321e-07 0.1358227655030745 5.216353195192302e-07 0.135020537018139 \
5.216353779218939e-07 0.1344419857224206 5.216354386744168e-07 0.1338420332148588 5.21635532580729e-07 0.1329184183639811 5.216355749782324e-07 0.1325029080242558 \
5.21635654222426e-07 0.1317336600863391 5.216356945925846e-07 0.1313430593815061 5.216357842934634e-07 0.130477658168832 5.216358232415503e-07 0.1301029732927899 \
5.216359188572358e-07 0.1291862249441596 5.216359577410651e-07 0.1288146335111444 5.21636050975841e-07 0.1279263274670414 5.2163611931843e-07 0.1272775968534341 \
5.216361716392852e-07 0.1267823325594629 5.21636253739999e-07 0.1260075984242486 5.216363249033783e-07 0.1253406747583812 5.216364028563663e-07 0.1246136378429537 \
5.216364819761022e-07 0.1238779526756392 5.21636560619333e-07 0.1231489004754178 5.216366406542416e-07 0.122409328367501 5.216367023886578e-07 0.1218405706457005 \
5.216367759836405e-07 0.1211645344030958 5.216368593634578e-07 0.120401093559758 5.216369234601888e-07 0.1198161795466899 5.216369928987769e-07 0.119184869057559 \
5.216370659217155e-07 0.1185234239195788 5.216371507966272e-07 0.1177582144838446 5.216372301594785e-07 0.117046673033812 5.216373148931361e-07 0.1162898833629492 \
5.216374056044255e-07 0.1154830714735263 5.216374811875037e-07 0.1148135241260771 5.216375469154284e-07 0.1142333070693714 5.216376069752011e-07 0.1137047561823949 \
5.216376765809174e-07 0.1130943456353956 5.216377429999685e-07 0.1125141752866663 5.216378224112315e-07 0.1118230150855203 5.216379126741611e-07 0.1110406875128299 \
5.216379817184612e-07 0.1104447270551955 5.216380562735805e-07 0.1098035355921305 5.216381447575012e-07 0.1090456469739195 5.216382238656483e-07 0.1083709350695736 \
5.216382937340289e-07 0.1077773127978274 5.216383747433988e-07 0.1070920034756896 5.216384309482126e-07 0.106618206733547 5.216384936074922e-07 0.1060916009495399 \
5.216385587540976e-07 0.105545887371837 5.216386300897257e-07 0.1049504956797945 5.216387503861013e-07 0.1039516085561449 5.216388019396736e-07 0.103525508500865 \
5.216388570887417e-07 0.1030709598036589 5.216389477859257e-07 0.1023262935955709 5.216390301757782e-07 0.1016530765296615 5.216391257555855e-07 0.1008759670630478 \
5.216392329651519e-07 0.1000092507657299 5.216393366245585e-07 0.09917656019160864 5.21639422832161e-07 0.09848810438956324 5.216395090743862e-07 0.09780303991321163 \
5.216395886154605e-07 0.09717448010577609 5.216396686283335e-07 0.09654538840876434 5.216397599166613e-07 0.09583163072761708 5.216398416620796e-07 0.09519620281310773 \
5.216399305889172e-07 0.09450872319168514 5.216400203662241e-07 0.09381864801001834 5.216400973288722e-07 0.09323024625953365 5.216401876536891e-07 0.0925435244861572 \
5.216402514624153e-07 0.09206084550525626 5.216403239259826e-07 0.09151514907748673 5.216403880546354e-07 0.09103438864950099 5.216404663020107e-07 0.09045054736970405 \
5.216405660032922e-07 0.08971110930136832 5.216406400564437e-07 0.08916512281998501 5.216407266649787e-07 0.08852997392441805 5.216408729646849e-07 0.08746544055362569 \
5.216409836769482e-07 0.08666684197409438 5.216410939866262e-07 0.08587717033461532 5.216412361822689e-07 0.08486839672072237 5.216413762347203e-07 0.08388450488753585 \
5.216415188805342e-07 0.08289222299161547 5.21641667651249e-07 0.08186778387581196 5.216418043639349e-07 0.08093569403044946 5.21641946484565e-07 0.07997640434545976 \
5.21642081061545e-07 0.07907728405019222 5.21642221281423e-07 0.07814997945867638 5.216423690282294e-07 0.07718353387841098 5.216425189824149e-07 0.07621348085094087 \
5.216426836982467e-07 0.07516037195605636 5.216428472843634e-07 0.07412732798506308 5.216430219327157e-07 0.07303837372665309 5.21643208986408e-07 0.07188781219077654 \
5.216434189729257e-07 0.0706159374129187 5.216436370461739e-07 0.06931715807027321 5.216438703663275e-07 0.06795188046253516 5.216441248458817e-07 0.0664909822812602 \
5.2164441780254e-07 0.06484528303377844 5.21644719953089e-07 0.06318745987130532 5.216450576747916e-07 0.06138078634948794 5.216454527833931e-07 0.05932807220464856 \
5.216458202346361e-07 0.05747953410674719 5.216462378424018e-07 0.05544691527644593 5.216465828383762e-07 0.0538196438399016 5.216469333806655e-07 0.05221302159193914 \
5.21647248341029e-07 0.0508087490907442 5.216475475823956e-07 0.049508488261462 5.216478469482477e-07 0.04824029756235761 5.216481221909583e-07 0.04710512226277328 \
5.216484056545245e-07 0.04596497870754415 5.216486672549465e-07 0.04493681260994405 5.216489447070712e-07 0.04387103439794762 5.216492207665063e-07 0.04283531238677037 \
5.21649529036243e-07 0.04170718945545093 5.216497514688635e-07 0.0409114719535993 5.21650039009947e-07 0.03990505631995635 5.216502752428796e-07 0.0390969788355163 \
5.216505937045547e-07 0.03803800466874574 5.21650844115589e-07 0.03722710566490722 5.216511671003914e-07 0.03620720400565681 5.216514254364062e-07 0.03541203096995557 \
5.216517154102846e-07 0.03454066075983582 5.216519452051025e-07 0.0338658635512188 5.216522301004437e-07 0.03304787219836024 5.216524698465629e-07 0.03237513696606491 \
5.216527104811323e-07 0.03171392889024889 5.216529495996188e-07 0.03107212555077287 5.216531855385298e-07 0.03045460689686571 5.21653416367391e-07 0.02986254663395104 \
5.216536313939186e-07 0.02932175456294728 5.216540335597597e-07 0.0283374222946415 5.2165423211788e-07 0.02786401170979088 5.216546058190658e-07 0.02699470773596776 \
5.216547926322608e-07 0.02657042318767052 5.216551386335081e-07 0.02580176906824739 5.216552605769465e-07 0.02553595448027303 5.216556434299635e-07 0.02472011952872977 \
5.216558038641491e-07 0.02438657631284594 5.216562468653031e-07 0.02348572425118655 5.216564174793446e-07 0.02314627247835563 5.216567380559406e-07 0.02251902970747987 \
5.216569383408681e-07 0.0221336684630111 5.216573852788009e-07 0.02128811173678137 5.216575132229166e-07 0.02104854104185888 5.21658001100276e-07 0.02014826272243131 \
5.216581360775529e-07 0.01990454278080647 5.216586183290713e-07 0.0190640092473091 5.216587806551861e-07 0.01879235028057063 5.216592670495271e-07 0.01801148170254873 \
5.216594300771863e-07 0.01776103207540622 5.216601102988766e-07 0.01676849304257711 5.216602493826144e-07 0.01657541006259178 5.216609818771477e-07 0.01560782569993242 \
5.216611407707804e-07 0.01540693214221847 5.21661923851867e-07 0.01445869962397344 5.216620696444218e-07 0.01428952172302696 5.216629204257814e-07 0.01334248985256295 \
5.21663031529053e-07 0.01322388191882306 5.216639648234166e-07 0.0122699293983148 5.216640986614658e-07 0.01213902814618388 5.21665057199482e-07 0.01123495036716388 \
5.216651783165509e-07 0.01112486091825863 5.216663004003486e-07 0.01017270671243764 5.216664059016017e-07 0.01008921053061839 5.216677349760139e-07 0.009112307258623473 \
5.216678551802884e-07 0.009029744095492466 5.21669403542048e-07 0.008036808760534916 5.216694843298185e-07 0.007986285493236449 5.216710552093519e-07 0.007024564730313319 \
5.216711226255509e-07 0.006986095570813155 5.216730433922295e-07 0.006001386377072119 5.216732301941131e-07 0.005914747648762168 5.216755456080605e-07 0.0049318160947762 \
5.216759451349076e-07 0.004777795182599986 5.216785089444083e-07 0.003889929704329555 5.216790078153284e-07 0.003736330440833864 5.216826375393169e-07 0.002784984367379526 \
5.216831882332917e-07 0.002663729254427667 5.216885866736714e-07 0.001711392372544448 5.216888999412434e-07 0.001662511220227468 5.216938922337914e-07 0.0006970413096974805 \
5.216940762528259e-07 0.0006571176749162138 5.243425553956096e-07 -0.0002691198397987355 5.243427114545721e-07 -0.0004551674219448388 5.243432594384271e-07 -0.001322174727784445 \
5.243433723764199e-07 -0.001539785040943742 5.243438016313498e-07 -0.002474302920374066 5.24343907888515e-07 -0.002730173903076456 5.243441906906666e-07 -0.003454402452283872 \
5.243443042852103e-07 -0.003760966378165151 5.243446428397891e-07 -0.004705104513819927 5.243447552637498e-07 -0.005021586953003071 5.243450835416506e-07 -0.005887841248467669 \
5.243451910801718e-07 -0.006130875888161453 5.243460710062032e-07 -0.005789627805322099 5.243462462122502e-07 -0.004910736584223327 5.243463630430133e-07 -0.004127745010746014 \
5.243464899101376e-07 -0.00309221842859156 5.243465914428628e-07 -0.002125750314016509 5.243467128641333e-07 -0.0008095618968406578 5.243468030290462e-07 0.0002767910803854594 \
5.243469002126957e-07 0.001550247908954045 5.243469982869598e-07 0.002938803805678211 5.243471655080454e-07 0.005530627736217106 5.243473878133234e-07 0.009378371294171852 \
5.243475735517141e-07 0.01290572951649239 5.243477976330495e-07 0.01747895571448658 5.243479572777817e-07 0.02091945933227325 5.243481217671113e-07 0.02459614091902196 \
5.243482715915693e-07 0.0280452875125503 5.243484209914613e-07 0.03156498790849799 5.243485705227667e-07 0.03515592969144176 5.243487246026613e-07 0.03891669635189081 \
5.243488867868089e-07 0.0429309674228065 5.24349053210035e-07 0.0470989728378523 5.243492291435082e-07 0.05154884981278444 5.24349410271779e-07 0.05616867911875007 \
5.243496024027047e-07 0.06110225049351239 5.24349810098117e-07 0.0664648391313285 5.243500320181979e-07 0.07222051812179281 5.243502672196803e-07 0.07834079218654426 \
5.243505194059892e-07 0.08491829088081257 5.24350795545224e-07 0.09213111703448683 5.243510966667008e-07 0.1000001933597138 5.243514285865622e-07 0.1086702418150647 \
5.243518059053303e-07 0.1185147411083515 5.243522041953866e-07 0.1288888856248832 5.243526735037065e-07 0.1410822143415975 5.243532195292308e-07 0.1552200475789812 \
5.243538544895379e-07 0.1715918832733369 5.243545538901292e-07 0.1895291194622146 5.243553721290551e-07 0.2103807608661494 5.243562778230217e-07 0.2332840710921665 \
5.243570673340878e-07 0.253091928008631 5.243577710929056e-07 0.2706124241987875 5.243583889437195e-07 0.2858796548825839 5.243589545671311e-07 0.2997575097153312 \
5.243594763024047e-07 0.3124620269501652 5.243599740861211e-07 0.3244932238414255 5.243604577240811e-07 0.3360954048923613 5.243609145982154e-07 0.3469667650518959 \
5.243613874391095e-07 0.3581213589834248 5.243618270524661e-07 0.3684065070151987 5.24362314929562e-07 0.379719432411247 5.243628457299845e-07 0.3919028193132517 \
5.243633436253595e-07 0.4032143644097119 5.24363775002613e-07 0.41292177789323 5.243642618898012e-07 0.4237731225600331 5.243647619892433e-07 0.4348012155672935 \
5.243651066099338e-07 0.4423321287141763 5.243654600037776e-07 0.4500000647748709 5.243658877736168e-07 0.4592134948422093 5.243662796346881e-07 0.4675816212925634 \
5.243665799290445e-07 0.4739471552041949 5.243669218601248e-07 0.4811428413521782 5.243672651945704e-07 0.4883132334011818 5.24367525955058e-07 0.4937215836208605 \
5.243677680115876e-07 0.4987106167174703 5.243680340100556e-07 0.5041617362307154 5.243682934982395e-07 0.5094435946950286 5.243684834145397e-07 0.5132872703533161 \
5.243686986491408e-07 0.5176241792560061 5.243688371999001e-07 0.5204025546691405 5.243689820806791e-07 0.5232962183003332 5.243691954947458e-07 0.5275364624051522 \
5.243693975193604e-07 0.5315382148201082 5.243695902480239e-07 0.5353370730264509 5.243697755034039e-07 0.5389735557287745 5.243699525009277e-07 0.5424323215059959 \
5.243702617642632e-07 0.5484573594957171 5.243705229123106e-07 0.5535233414883098 5.243708247314806e-07 0.5593562770234363 5.243710801601219e-07 0.5642781701956761 \
5.243713725156194e-07 0.5698968483756405 5.243716319698132e-07 0.5748654731717864 5.243719020897901e-07 0.5800301911327002 5.243721441003479e-07 0.5846380733684551 \
5.243724016101459e-07 0.5895273573494454 5.243726280544834e-07 0.5938057549890672 5.243728649429657e-07 0.5982619499065401 5.24373074987873e-07 0.6021962733001386 \
5.243732879185847e-07 0.6061670177072124 5.24373541397282e-07 0.6108668889270118 5.24373744692931e-07 0.6146150465592417 5.243739363811141e-07 0.6181346807088086 \
5.243741250074785e-07 0.6215812235468744 5.243743123254166e-07 0.6249823889551316 5.243745179374062e-07 0.6286953279350977 5.243747677606249e-07 0.6331759959753138 \
5.243749715724034e-07 0.6368063379741715 5.243751792111211e-07 0.6404826298163093 5.24375371862737e-07 0.6438748386876914 5.243756164748105e-07 0.6481531432733096 \
5.243758643733136e-07 0.6524620620600715 5.243760442082188e-07 0.6555644139995785 5.243762349822552e-07 0.6588391718544121 5.24376388158437e-07 0.6614554104590837 \
5.243765598271469e-07 0.6643705886591137 5.243767102939677e-07 0.6669108747194671 5.243768468979714e-07 0.6692010654183506 5.243769963383726e-07 0.6716954191563786 \
5.243771240725234e-07 0.6738189269502312 5.2437726394477e-07 0.6761323074508511 5.243773880219049e-07 0.6781756764962316 5.243775193832699e-07 0.6803315871556701 \
5.243776435547311e-07 0.6823627547057004 5.243777813315919e-07 0.6846081866267727 5.243779015758123e-07 0.6865586181592046 5.243780436284174e-07 0.6888545186016138 \
5.243781438561225e-07 0.6904668682779994 5.243782651601134e-07 0.6924123325129877 5.243783561353879e-07 0.6938641504265992 5.243784535186708e-07 0.695411869780077 \
5.24378550601538e-07 0.6969507228893711 5.243786398841583e-07 0.6983595753378042 5.243787378559427e-07 0.699898781449533 5.243788681310304e-07 0.7019319515314388 \
5.243790215432551e-07 0.7043083163565919 5.243791571090672e-07 0.7063909659299702 5.24379301449562e-07 0.708591461371511 5.243794273204452e-07 0.710496752775434 \
5.243795523478311e-07 0.712376488910674 5.243796666301914e-07 0.7140841686551523 5.243797776133355e-07 0.7157331888171029 5.243798773084046e-07 0.7172065512867005 \
5.243800143526226e-07 0.7192196995505324 5.243801333798347e-07 0.7209572005600779 5.24380253677943e-07 0.7227029412191364 5.243803801768634e-07 0.7245276185835638 \
5.243805041084668e-07 0.7263044524160376 5.243806283948001e-07 0.7280754330070212 5.24380754759953e-07 0.7298652243312684 5.243808845716946e-07 0.7316925631262517 \
5.243810084102138e-07 0.7334254795816325 5.243811411911006e-07 0.735272086289578 5.243812420423058e-07 0.7366670415914529 5.243813552339755e-07 0.738224777043618 \
5.243814420199563e-07 0.7394137384482823 5.243815586452529e-07 0.7410021813026957 5.243816479345105e-07 0.7422110784210975 5.243817591113937e-07 0.7437075443329063 \
5.243818883701577e-07 0.7454347509364776 5.243820022291937e-07 0.7469455276109591 5.243821066334058e-07 0.74832188588007 5.243822310004373e-07 0.7499498655229884 \
5.243823782406158e-07 0.7518616907275563 5.243824985209068e-07 0.753411006437983 5.243826144254458e-07 0.7548933175676444 5.243827545012897e-07 0.7566706674475765 \
5.243828971129601e-07 0.7584645678799224 5.243830150672032e-07 0.7599365027959469 5.243831418837122e-07 0.7615071445339606 5.243832827668561e-07 0.7632375905494565 \
5.243834025603537e-07 0.7646969139886852 5.243835475192107e-07 0.7664484133613445 5.243836690779962e-07 0.7679052725436226 5.243837881174897e-07 0.7693214142140735 \
5.243839097488533e-07 0.7707575700077021 5.243840377178316e-07 0.772256936813787 5.243841469330139e-07 0.7735272422640712 5.243842718238922e-07 0.774969549136603 \
5.24384378939953e-07 0.7761978171588899 5.243845121931473e-07 0.7777146071439789 5.243846392965933e-07 0.7791497354387434 5.243847610475684e-07 0.7805132846941326 \
5.243848776321507e-07 0.7818078758210534 5.24384983459753e-07 0.7829735233300771 5.243851228258954e-07 0.7844949153190801 5.243852718976944e-07 0.786105286864636 \
5.24385419626362e-07 0.7876841235632186 5.243855389322397e-07 0.7889471147195867 5.243856729390521e-07 0.7903527806482344 5.243857933652268e-07 0.791604423795974 \
5.243859349104043e-07 0.7930616786923709 5.243860823364166e-07 0.7945638089648995 5.243862068109252e-07 0.7958198087139573 5.24386325854918e-07 0.7970105506108808 \
5.243864374452016e-07 0.7981174590942314 5.243865426744905e-07 0.7991530841216606 5.243866381855941e-07 0.8000862307887144 5.243867742475476e-07 0.8014036057482816 \
5.243868911236816e-07 0.8025237700417888 5.243870102773536e-07 0.8036549841722296 5.24387132589548e-07 0.8048050501807249 5.243872558616218e-07 0.8059526272620129 \
5.243873823583984e-07 0.8071184350969989 5.243875078610623e-07 0.8082633544790385 5.243876385869669e-07 0.8094437311890262 5.243877641549387e-07 0.8105658358439867 \
5.243878932098035e-07 0.8117072367686948 5.243879990659606e-07 0.8126345588578442 5.243881002348365e-07 0.8135133322873783 5.243881948546566e-07 0.8143286754242188 \
5.243883191357402e-07 0.8153900871385379 5.243884088474262e-07 0.816149614585347 5.243885078849502e-07 0.8169816577628611 5.243886456628271e-07 0.8181280288377792 \
5.243887801986773e-07 0.81923501721715 5.243888886049436e-07 0.8201180631035904 5.243890385184473e-07 0.8213254631869725 5.243891890970255e-07 0.8225223201378843 \
5.243893145921802e-07 0.8235077122548546 5.243894584387069e-07 0.8246238332260477 5.243895830219706e-07 0.8255790649890803 5.243897318751914e-07 0.8267066458678887 \
5.24389868023775e-07 0.827725029289517 5.243899930476024e-07 0.8286494160599757 5.243901107545823e-07 0.8295103773055483 5.243902563935805e-07 0.8305630309532103 \
5.243904227748753e-07 0.8317484146982921 5.243905533585646e-07 0.8326660250626342 5.243907268806749e-07 0.8338683097812621 5.243908950025776e-07 0.8350147136930499 \
5.243910648651803e-07 0.8361549927788252 5.243912457668832e-07 0.8373497079260466 5.243913888761651e-07 0.8382806519784776 5.24391502965127e-07 0.839013953006387 \
5.243916331276035e-07 0.8398410866028793 5.243917349727342e-07 0.8404811280669765 5.243918517989402e-07 0.8412075886390841 5.243919886903802e-07 0.8420483852080155 \
5.243921864976039e-07 0.843243620449199 5.243923781227506e-07 0.8443797466267589 5.24392587554618e-07 0.8455974227529048 5.243927695012999e-07 0.8466352798309468 \
5.243929666301539e-07 0.8477391449715804 5.243931399710144e-07 0.8486924050423899 5.243933229793209e-07 0.8496814535024207 5.243934941423557e-07 0.8505903669473519 \
5.243936687794506e-07 0.851501688465695 5.243938440392814e-07 0.8524001683007644 5.243940201897297e-07 0.8532872510191711 5.243942104700295e-07 0.8542278331088334 \
5.2439440106916e-07 0.8551519386507073 5.243946016923949e-07 0.8561055033533737 5.243947943009499e-07 0.8570028516027762 5.243950049816413e-07 0.8579644845832216 \
5.243952330831089e-07 0.8589827023971403 5.243954988710916e-07 0.860139640227508 5.243957974838522e-07 0.8614018215255795 5.243960737724907e-07 0.8625348754565382 \
5.243963580090102e-07 0.8636666213345715 5.243966322137804e-07 0.8647267940813509 5.243969044486385e-07 0.8657495569722869 5.243971746527798e-07 0.8667361702337206 \
5.243974318083905e-07 0.867649441901348 5.24397704388604e-07 0.8685908808535525 5.2439798037489e-07 0.8695169452638583 5.24398250477721e-07 0.870397355937691 \
5.243985503347982e-07 0.8713451925332844 5.243989213624563e-07 0.8724761722512941 5.243992162997666e-07 0.8733433185969293 5.243994705892065e-07 0.8740690226522811 \
5.243997688459906e-07 0.874895168896023 5.244000424554269e-07 0.8756299040683481 5.244002785839137e-07 0.8762466977562872 5.244005189298274e-07 0.8768585021646264 \
5.244007412634921e-07 0.8774104263690854 5.244009352691695e-07 0.8778812671168952 5.244012649918855e-07 0.8786590883967833 5.244014201653189e-07 0.8790156160651978 \
5.244017379413894e-07 0.8797272612331356 5.244019168030317e-07 0.8801171459162566 5.244022592648612e-07 0.8808425821290963 5.244024433930206e-07 0.881221400612852 \
5.244029182707539e-07 0.8821634994206867 5.24403085666965e-07 0.8824839765989225 5.244035515089055e-07 0.8833452998114757 5.244037323309576e-07 0.8836679564577563 \
5.244042263693833e-07 0.8845176198113115 5.24404367718007e-07 0.8847523712107549 5.244049740520726e-07 0.8857188576377059 5.244051261213959e-07 0.8859512996759633 \
5.244057728095585e-07 0.8868983431897121 5.244059011041699e-07 0.8870786909355212 5.244065492212318e-07 0.8879538337624689 5.244066790202949e-07 0.8881220828502663 \
5.244074572237723e-07 0.8890807033877333 5.244075722787339e-07 0.8892148977954012 5.244084279402064e-07 0.8901543051721961 5.244085733010758e-07 0.8903040038307473 \
5.244095590571272e-07 0.8912446482480114 5.244097801624957e-07 0.8914382978987679 5.244109252894234e-07 0.8923659558950503 5.244110565064392e-07 0.8924678262926897 \
5.244123977150129e-07 0.8934599079028542 5.244125491142719e-07 0.8935646301988298 5.244140305519949e-07 0.8944937559627255 5.244142694313731e-07 0.8946275407274444 \
5.24416038746979e-07 0.8955013787854181 5.244164278981914e-07 0.8956696032899972 5.244188215611417e-07 0.8965547188539188 5.244192972701398e-07 0.8967039926079825 \
5.244233604302104e-07 0.8977020505850396 5.24423851854269e-07 0.8977948037134476 5.24432168453822e-07 0.898787348739254 5.244330883529499e-07 0.8988506593152591 \
5.245765735834803e-07 0.8998476076348748 5.245776920164557e-07 0.8998537475785264 5.247827836359558e-07 0.898985773748599 5.247830107254573e-07 0.8988224379910277 \
5.247846203322555e-07 0.8978282360369357 5.247847977407988e-07 0.8977338482811539 5.248017048890995e-07 0.8987315468430059 5.248018143281978e-07 0.8987460089186867 \
5.248175950494439e-07 0.8997418097871094 5.248178913753395e-07 0.8997476966799167 5.25301325027745e-07 0.9007060148833608 5.253014540780854e-07 0.9008313386292994 \
5.253021042279306e-07 0.9016292186224167 5.253022937236614e-07 0.9019133038041363 5.253027969456399e-07 0.9027675859898705 5.253029324182996e-07 0.9030208676018907 \
5.253033328770163e-07 0.9038195223753869 5.253034648149532e-07 0.9040958310886574 5.253038660300166e-07 0.9049509627747726 5.253039642901937e-07 0.9051582028152527 \
5.253044301640043e-07 0.9060587574877488 5.253045916627274e-07 0.9063060456044927 5.253057356752505e-07 0.9055153668657776 5.253058806545959e-07 0.9049059606760256 \
5.253060592073535e-07 0.9039396653125833 5.253062394026313e-07 0.9027054491383806 5.253063820935605e-07 0.9015369228101149 5.253064992531646e-07 0.9004524619440171 \
5.253065882345255e-07 0.8995505656965809 5.253066798781777e-07 0.8985529714258781 5.253068129901104e-07 0.8969831049011855 5.253069067111929e-07 0.8957895978311226 \
5.253069978500017e-07 0.8945634483845346 5.253071111423133e-07 0.8929516940777753 5.253072142512257e-07 0.8913998138690341 5.253073105184064e-07 0.8898830246517148 \
5.253074296555228e-07 0.8879200664089764 5.253075982407716e-07 0.8849885378698126 5.253077600122727e-07 0.8820195265790133 5.253079532313317e-07 0.8782956415026882 \
5.253081387944432e-07 0.8745571577041361 5.253083490607478e-07 0.8701566079887386 5.253085313097885e-07 0.8662213066841463 5.253087161731834e-07 0.8621339172744639 \
5.253088888583302e-07 0.8582419637438897 5.253090749664034e-07 0.8539816046497358 5.253092527824913e-07 0.849858603441091 5.253094334990721e-07 0.8456251963850057 \
5.253095986373313e-07 0.8417258760277182 5.253097639114333e-07 0.837798995916667 5.253099271590959e-07 0.8339004324287677 5.253100857493695e-07 0.8300982805770993 \
5.253102626737713e-07 0.8258418712800655 5.253104591875839e-07 0.8211009660847696 5.253106267441254e-07 0.8170498602679914 5.253107934845439e-07 0.8130123908857781 \
5.253109679080616e-07 0.8087844286215062 5.253111372776842e-07 0.8046757316210446 5.253113054767785e-07 0.8005936994537799 5.25311494325046e-07 0.7960093488074458 \
5.253116851408819e-07 0.7913773844868103 5.253118935230917e-07 0.7863203192056716 5.25312119942597e-07 0.7808277108969495 5.253123091427939e-07 0.7762391340290878 \
5.253125192894832e-07 0.7711455503222944 5.253126680579875e-07 0.7675418410361046 5.253127990509761e-07 0.7643705172588006 5.25312936616212e-07 0.7610417440783073 \
5.253130423674414e-07 0.7584842184275663 5.253131771410752e-07 0.7552262509102785 5.253132889738005e-07 0.7525244432456109 5.253134184089644e-07 0.7493992292091655 \
5.253135735976883e-07 0.7456545577979357 5.253136852334406e-07 0.7429626190147979 5.253138448080549e-07 0.7391166470929011 5.253140201296882e-07 0.7348935218456193 \
5.253142325051509e-07 0.7297828120356423 5.253144253876789e-07 0.7251458607116523 5.253145820889711e-07 0.7213823872711312 5.253147687636618e-07 0.716903961299824 \
5.253149576500111e-07 0.7123775767926828 5.253151485342027e-07 0.70780884692282 5.253153352821382e-07 0.7033444557767304 5.253155183669542e-07 0.698972331957095 \
5.253156556859353e-07 0.6956951921588121 5.253158089288925e-07 0.6920418367118417 5.253160040575431e-07 0.6873949992893974 5.253161613518718e-07 0.6836535194673684 \
5.25316320746467e-07 0.6798660670227984 5.253165164902601e-07 0.6752219404489795 5.253167086893939e-07 0.6706682621108646 5.253169436410222e-07 0.6651105611269369 \
5.2531713111727e-07 0.6606839627962382 5.253173683544039e-07 0.6550894036851447 5.253175575343661e-07 0.6506361170423679 5.253177381501785e-07 0.6463915264929231 \
5.253179018447415e-07 0.6425504277539856 5.253180463961504e-07 0.6391628119244788 5.2531818686792e-07 0.6358764726647652 5.253183139687074e-07 0.6329064225879303 \
5.253184462761836e-07 0.6298198307262635 5.253185728632297e-07 0.626870110582017 5.253187034434976e-07 0.62383130535404 5.253188327128966e-07 0.6208285625908692 \
5.253189718197929e-07 0.6176004736356133 5.253191203301029e-07 0.6141606483517721 5.253193098786583e-07 0.6097777958748198 5.253194555819144e-07 0.6064170107178907 \
5.253196906324778e-07 0.601007464699683 5.253198736317494e-07 0.5968099615921 5.253200979734226e-07 0.5916778694808832 5.253202691466717e-07 0.5877753019413697 \
5.253204014804909e-07 0.5847634284691802 5.253205332770303e-07 0.5817721407249107 5.253206398209335e-07 0.5793579518205488 5.25320735711292e-07 0.5771868999037388 \
5.25320828211542e-07 0.5750974572268882 5.25320920638905e-07 0.5730134868920421 5.253209930672115e-07 0.5713818265150021 5.25321048796317e-07 0.5701269325864891 \
5.253211099054046e-07 0.5687522410723198 5.2532120667008e-07 0.5665806864277688 5.253212681615946e-07 0.5652027770813386 5.253213272142164e-07 0.5638802801505602 \
5.253214028408818e-07 0.5621878686488651 5.253214698636601e-07 0.5606896577364279 5.253215434607697e-07 0.5590483558003441 5.253216110667724e-07 0.5575429304381756 \
5.253217271358289e-07 0.5549610936632026 5.253218273422345e-07 0.5527359403974305 5.253219393494243e-07 0.5502565947066531 5.253220338414751e-07 0.5481686943853854 \
5.253221549961726e-07 0.5454955387196141 5.253222551839389e-07 0.5432910220514219 5.253223711744508e-07 0.5407443765731218 5.253224788782884e-07 0.5383833065966291 \
5.253225884569768e-07 0.5359861028148916 5.253227005784206e-07 0.5335400310751951 5.253228275156047e-07 0.5307765704644959 5.253229496651232e-07 0.5281221248815906 \
5.253230894260376e-07 0.525095489155881 5.253232265641539e-07 0.522132778766487 5.253233765292441e-07 0.5189020692106626 5.253235353022474e-07 0.5154923220538846 \
5.253237093279044e-07 0.511765695450105 5.25323896158028e-07 0.5077823379664483 5.253241011259936e-07 0.5034264211640872 5.253243238349422e-07 0.4987133299464507 \
5.25324576739139e-07 0.4933874474923696 5.253248116930461e-07 0.4884604410272814 5.253251079613078e-07 0.4822828691822955 5.253253977512661e-07 0.4762763831984252 \
5.253257040870848e-07 0.4699660956099861 5.253260164056119e-07 0.4635767846525711 5.253263549710683e-07 0.4566963260653934 5.25326678082485e-07 0.4501741115777416 \
5.253270164777878e-07 0.4433881855507311 5.253273403090534e-07 0.4369378830387565 5.25327664703474e-07 0.4305204627449936 5.253280076377603e-07 0.4237851826852676 \
5.253283469185779e-07 0.4171698123421442 5.253286863932123e-07 0.4105997181257849 5.253291295050583e-07 0.4020958655332711 5.253294915732268e-07 0.3952155038183801 \
5.253298121249644e-07 0.3891775711374149 5.253301990595345e-07 0.3819561902961204 5.253305269297949e-07 0.3758957719299574 5.253308120888516e-07 0.3706704968427373 \
5.253311304576463e-07 0.3648820026298218 5.253314132885732e-07 0.3597820188690578 5.253316419773369e-07 0.3556924369094372 5.253318598701416e-07 0.3518226517641353 \
5.253320551194862e-07 0.3483769517668343 5.253322620275856e-07 0.344751588202948 5.253324768243417e-07 0.3410137651016431 5.253327290508921e-07 0.3366564674340092 \
5.253329710462047e-07 0.3325077909124976 5.253332018984844e-07 0.3285822460490526 5.253334167466747e-07 0.3249550452085373 5.253336371033643e-07 0.3212604562488142 \
5.253338386742641e-07 0.3179050685021769 5.253340417582105e-07 0.3145531374773136 5.253342396555968e-07 0.3113121771742085 5.253344267548364e-07 0.3082694484595072 \
5.253346206551794e-07 0.3051385396431291 5.253348257035143e-07 0.3018527636900292 5.253350059382659e-07 0.2989872106339772 5.253352418362774e-07 0.2952669081535775 \
5.253354431238275e-07 0.2921198200609627 5.253356445146313e-07 0.2889965001417216 5.253358691637942e-07 0.2855437159941698 5.253360345437678e-07 0.2830223598911593 \
5.253362123481056e-07 0.280330186126118 5.253363960043191e-07 0.277570343839212 5.253365812460764e-07 0.2748090658167894 5.253367593914542e-07 0.2721781298892599 \
5.253369329835173e-07 0.2696316866093095 5.253370933483699e-07 0.267306655456324 5.253372144595526e-07 0.2655585721882695 5.253373676543406e-07 0.2633570345323199 \
5.253374949857892e-07 0.2615475749425888 5.253375983136284e-07 0.2600830587034867 5.25337715638424e-07 0.2584225376281647 5.253378334453811e-07 0.2567591557214636 \
5.253379574091473e-07 0.2550199666844239 5.253380743933137e-07 0.2533821414201824 5.253382051894417e-07 0.2515535495016885 5.253383223995523e-07 0.2499173892700276 \
5.253384756526766e-07 0.2477853623028658 5.253386111831973e-07 0.2459029165157107 5.253387428644058e-07 0.244074199323236 5.253388994573169e-07 0.2419017673596028 \
5.253390246538746e-07 0.2401755227310949 5.253391603715014e-07 0.2383060149301216 5.253392927986628e-07 0.2364844144139329 5.253394127723238e-07 0.2348355337769661 \
5.253395758201609e-07 0.232606585912384 5.253397146272525e-07 0.230713852557009 5.253398531009718e-07 0.2288300961780371 5.253399586457211e-07 0.2273962817971701 \
5.253400870074011e-07 0.2256537837490921 5.253401911350241e-07 0.2242444877898851 5.253402916510259e-07 0.222886569499566 5.253403666954022e-07 0.2218745444235658 \
5.253404440284576e-07 0.2208349692306942 5.253405187916369e-07 0.2198305887827458 5.253405967553143e-07 0.218785487158918 5.253406516218243e-07 0.2180503923904892 \
5.253407081185998e-07 0.2172938400168352 5.253407515721192e-07 0.2167123195211523 5.253407916131654e-07 0.2161767335077376 5.253408308521132e-07 0.2156521099473339 \
5.2534087172635e-07 0.2151058606261434 5.253409258788401e-07 0.2143825797409383 5.253409642959715e-07 0.2138698309421548 5.253410035846784e-07 0.2133480458229882 \
5.253410651213865e-07 0.2125332203444249 5.253411270989155e-07 0.2117131287842428 5.253411835756643e-07 0.2109664019951111 5.253412482072544e-07 0.2101124842966758 \
5.253413437158761e-07 0.2088522205996687 5.253414310316075e-07 0.207701294711168 5.253415276412079e-07 0.2064291756790013 5.253416248707622e-07 0.2051510266126755 \
5.253417257178229e-07 0.2038307158897115 5.253418263175943e-07 0.2025192706911573 5.253419228088913e-07 0.2012627769767186 5.253420249910648e-07 0.1999338657614989 \
5.253421286307215e-07 0.1985898465970496 5.253422384047342e-07 0.1971698847140261 5.253423475797596e-07 0.1957617939809042 5.253424676778517e-07 0.1942174441246506 \
5.253425776973761e-07 0.1928086337505992 5.253426858092847e-07 0.1914295694688549 5.253428088379842e-07 0.1898652723262108 5.253428989485537e-07 0.1887234630454603 \
5.253430063140445e-07 0.1873671680421656 5.253430831253526e-07 0.1864004060894758 5.253431665706206e-07 0.1853535952511875 5.253432561024323e-07 0.1842338297700716 \
5.253433406678985e-07 0.1831790839553313 5.253434203840386e-07 0.1821880912968773 5.253435217092422e-07 0.1809331989518758 5.253436300564713e-07 0.1795959386230563 \
5.253437265321694e-07 0.1784102562612937 5.253438519099859e-07 0.1768766438339704 5.253439846934562e-07 0.1752616821119887 5.253441024642794e-07 0.1738362801839788 \
5.253442481158562e-07 0.1720835746408261 5.25344358713008e-07 0.1707596463148658 5.25344500843447e-07 0.1690680578777541 5.253446165530702e-07 0.1676985735146403 \
5.253447220270831e-07 0.166456424915798 5.253448165437424e-07 0.1653485352650968 5.253449121811146e-07 0.1642320043563913 5.253450092529585e-07 0.1631032360400927 \
5.253451083042123e-07 0.161956192050434 5.253452022277692e-07 0.1608730077890209 5.253452875034443e-07 0.1598934595213354 5.253453878832364e-07 0.1587475631033795 \
5.253454721860728e-07 0.1577906478848196 5.253455745855819e-07 0.1566342854655733 5.253456519798444e-07 0.1557646215197878 5.253457443247583e-07 0.154731814591042 \
5.253458145762303e-07 0.1539498814072817 5.253459107506593e-07 0.1528844393027091 5.253459875753224e-07 0.152038051282755 5.253460663454741e-07 0.1511758489440315 \
5.253461402383946e-07 0.150370438825067 5.253462079361381e-07 0.1496353997608715 5.253463040000261e-07 0.1485973848112393 5.25346373572453e-07 0.1478489919002561 \
5.253464574616254e-07 0.1469503328160803 5.253465185934615e-07 0.146298213254472 5.253465908615431e-07 0.1455309799806117 5.253466633001063e-07 0.1447677488542132 \
5.253467442811468e-07 0.1439178685120187 5.253468103556157e-07 0.1432275520600639 5.253468877561137e-07 0.1424219220725307 5.253469771315706e-07 0.1414956876531561 \
5.253470479922163e-07 0.1407644282175171 5.253471468792833e-07 0.1397487730030469 5.253472241981922e-07 0.1389620820751095 5.253473062434185e-07 0.1381330876879582 \
5.253473943545299e-07 0.1372467208126059 5.25347461981677e-07 0.1365690714953818 5.253475422788589e-07 0.1357674830239305 5.253476170628882e-07 0.1350239185327315 \
5.253476850640654e-07 0.1343502586094245 5.253477317469739e-07 0.1338891847862563 5.253478209985674e-07 0.1330118383700247 5.253478592216168e-07 0.1326395291833771 \
5.253479282135268e-07 0.1319690872918072 5.253479809615963e-07 0.1314578750898332 5.253480639543783e-07 0.1306559489775353 5.253481041328288e-07 0.1302688434457458 \
5.253481966502028e-07 0.1293805059784019 5.253482353685699e-07 0.1290098403727171 5.253483091292851e-07 0.1283055160094505 5.253483707572868e-07 0.1277188748199021 \
5.253484427849764e-07 0.1270353589407805 5.253485109520081e-07 0.1263909833196726 5.253485855741693e-07 0.1256908956540175 5.253486674266349e-07 0.1249253613889138 \
5.253487508807973e-07 0.124147338931438 5.25348823832511e-07 0.1234692772477456 5.253488965594407e-07 0.122795332839617 5.253489565494355e-07 0.1222410931008323 \
5.253490429174471e-07 0.121445549533078 5.253491038861646e-07 0.1208856452315438 5.253491622719555e-07 0.1203507897957366 5.253492279066196e-07 0.119751336354628 \
5.253492872608612e-07 0.1192111367930785 5.253493552926419e-07 0.1185941868697126 5.253494525870119e-07 0.11771710490035 5.253495310789918e-07 0.1170124163111649 \
5.25349621315123e-07 0.1162055395685231 5.253497171618085e-07 0.1153523005684616 5.253497921195047e-07 0.1146878351828532 5.253498964789213e-07 0.1137670532163148 \
5.25349983267518e-07 0.1130053589403202 5.25350092924934e-07 0.1120476726212376 5.253501744789968e-07 0.1113387926087848 5.253502700926292e-07 0.1105114393564785 \
5.253503468048225e-07 0.10985058581598 5.253504417232868e-07 0.1090364400125625 5.253505175463918e-07 0.1083889268999046 5.253505952460492e-07 0.1077282965354292 \
5.253506775775e-07 0.1070311517075373 5.253507371427637e-07 0.1065286079538068 5.253508009005013e-07 0.1059924133642201 5.253508619951089e-07 0.1054803128126646 \
5.253509578588471e-07 0.1046801683739134 5.253510027219415e-07 0.1043071445723913 5.253510859626872e-07 0.1036173314376927 5.25351135082509e-07 0.1032117000904133 \
5.253512441312713e-07 0.1023149933518279 5.253512889673535e-07 0.1019479364619093 5.253513792285848e-07 0.1012117400678687 5.25351420105203e-07 0.1008795969612472 \
5.25351490563617e-07 0.1003088525914566 5.253515768510381e-07 0.09961307626065434 5.253516686285974e-07 0.09887705578174606 5.253517381566897e-07 0.09832225024344161 \
5.25351816683849e-07 0.09769854072774181 5.253519074125254e-07 0.09698178745350861 5.25351983228664e-07 0.09638605854785212 5.253520652414071e-07 0.09574500473888557 \
5.253521469944435e-07 0.09510943278387665 5.253522375022672e-07 0.09440967388330095 5.253523270615645e-07 0.09372126988887708 5.253524126713984e-07 0.09306698857649189 \
5.253525054508965e-07 0.09236212353634379 5.253525863388571e-07 0.0917510971760913 5.253526874678274e-07 0.09099177263830999 5.253527679613525e-07 0.09039108594384238 \
5.253528522042178e-07 0.08976589684797046 5.253529260492651e-07 0.08922077348043934 5.253530028987433e-07 0.08865632925481931 5.253530910391125e-07 0.08801255002475737 \
5.253531711034815e-07 0.08743108261130086 5.253532641396717e-07 0.08675939571108145 5.253533821403849e-07 0.08591369538214398 5.253535245136124e-07 0.08490278100234279 \
5.253536687619621e-07 0.08388867104764453 5.253538110896711e-07 0.08289807427203813 5.253539606674147e-07 0.08186746790234835 5.253540969811606e-07 0.08093761126893445 \
5.253542391015919e-07 0.0799778356000513 5.253543736550197e-07 0.07907840240745091 5.253545140077296e-07 0.07814980287393705 5.253546616898023e-07 0.0771833418413561 \
5.253548118052992e-07 0.07621180464723754 5.253549765257765e-07 0.07515824360926991 5.253551401551281e-07 0.07412455432658185 5.25355314933688e-07 0.07303438636984133 \
5.253555021863042e-07 0.07188220095900363 5.253557122313081e-07 0.07060976590783831 5.253559304415312e-07 0.06930979572898451 5.253561638986196e-07 0.06794333957253913 \
5.25356418744638e-07 0.06648001693367038 5.253567118391949e-07 0.06483321328442151 5.253570141789572e-07 0.06317411115207273 5.253573287658326e-07 0.06148945259513613 \
5.253577250265267e-07 0.05942677493938087 5.253580587436718e-07 0.05774249301432461 5.253584660545012e-07 0.05574994498853819 5.253587939392599e-07 0.05419380357502902 \
5.253591506298989e-07 0.05254809000207299 5.253594638680598e-07 0.05114243792209583 5.253597668351931e-07 0.04981740498512215 5.253600643757185e-07 0.04854875663330436 \
5.253603431552738e-07 0.04739109061078805 5.253606261551692e-07 0.04624570307560639 5.253608878954772e-07 0.04521055793698023 5.253611671343699e-07 0.04413130357485813 \
5.253614392402902e-07 0.0431040186124033 5.253617466070471e-07 0.04197194005652995 5.25361968409948e-07 0.04117329707315532 5.253622748704282e-07 0.04009446155587663 \
5.253625010598812e-07 0.03931650950691581 5.253627399772065e-07 0.03851359500741255 5.253629644010393e-07 0.03777663690506906 5.253631666633204e-07 0.03712468825868943 \
5.253633677059489e-07 0.03648814235703791 5.253637194799833e-07 0.03540095449820539 5.253639697258209e-07 0.03464776841732944 5.253642160441008e-07 0.03392252499723709 \
5.253644973769646e-07 0.03311308780599518 5.253647404679504e-07 0.03242954897046491 5.253649759417007e-07 0.03178112583711486 5.25365217601206e-07 0.03113119522156456 \
5.253654544834836e-07 0.03050988948014832 5.25365685016041e-07 0.02991733361391674 5.253658989845686e-07 0.02937801894285819 5.253661049271158e-07 0.02886851641492237 \
5.253664976516027e-07 0.02792196059063811 5.253666857292829e-07 0.02747992420741849 5.253670611682488e-07 0.02661861215736662 5.253672360424775e-07 0.02622659266649364 \
5.253676593654915e-07 0.02530049759795254 5.253677806148756e-07 0.02504150687334681 5.253682211765283e-07 0.02412433837770948 5.253683636746477e-07 0.02383402682615681 \
5.253686957281575e-07 0.02316883068419595 5.253688786936821e-07 0.02280879143785283 5.25369267997886e-07 0.02205689891561978 5.253694363435941e-07 0.02173705378531499 \
5.253699084579932e-07 0.02085107653961301 5.253700482027269e-07 0.0205916297664938 5.253705437828048e-07 0.01969297428531048 5.253706710082374e-07 0.01946923320191776 \
5.253712389173419e-07 0.01851512288677271 5.253714031712902e-07 0.0182513999453204 5.253720130430285e-07 0.0173209960017622 5.253721727282572e-07 0.01708922829277545 \
5.253726996397978e-07 0.01635462467776483 5.253729041570907e-07 0.01608193551804103 5.253736276344778e-07 0.01515939662837778 5.253737930766099e-07 0.01495683325581705 \
5.253745396363563e-07 0.01408081084911163 5.253746729395689e-07 0.01393008075245666 5.253755331241552e-07 0.01299799962960837 5.2537566920557e-07 0.01285670227674402 \
5.253766097994594e-07 0.01192267652923807 5.253767735725333e-07 0.01176632439256516 5.253777747514646e-07 0.01084959205883911 5.253779122291872e-07 0.01072929995296418 \
5.253790829267985e-07 0.009787962024485789 5.253791753231659e-07 0.009718668544398181 5.253805933990138e-07 0.008725931027897449 5.253806803751621e-07 0.00866912727384293 \
5.253822213707926e-07 0.00770199130002063 5.253823306868068e-07 0.007633428668288294 5.253839739346293e-07 0.006673746291950173 5.253841067919082e-07 0.006603544020797993 \
5.253862011722062e-07 0.005605323336654431 5.253864095769411e-07 0.00551468736035817 5.25388763913366e-07 0.004577307911602986 5.253892374721227e-07 0.004407121484391641 \
5.253921229089795e-07 0.003492041675788492 5.253926525733264e-07 0.00334538389506189 5.253968608005519e-07 0.00237996320858989 5.253973742348033e-07 0.002283557532494709 \
5.254031334854955e-07 0.001325291758975802 5.254033680667129e-07 0.001279502680325907 5.254180358940879e-07 0.0002809017338477542 5.2541814896418e-07 0.0002788534805396912 \
5.280551690439302e-07 -0.0006849217749926401 5.280553352056058e-07 -0.0009443270389602415 5.28055814074993e-07 -0.001850320037528519 5.280559067946197e-07 -0.002050462221988249 \
5.280562720196971e-07 -0.002913187630468476 5.280563636768137e-07 -0.00314709230904735 5.280567297831652e-07 -0.004133001189868674 5.280568399302907e-07 -0.004442309109773816 \
5.280571506685428e-07 -0.005311341427314526 5.280572524071878e-07 -0.005583925258601597 5.280576161113131e-07 -0.00638370916272213 5.280577809576364e-07 -0.006585924750287024 \
5.280583607549566e-07 -0.005792290386912202 5.280585355894154e-07 -0.004916934050781314 5.280586522790152e-07 -0.00413641027497409 5.280587787087076e-07 -0.00310656561120747 \
5.280588807309105e-07 -0.002137079422087956 5.280590005773929e-07 -0.0008406209844352954 5.280590912146293e-07 0.0002489246187367611 5.280591896346795e-07 0.001536790859923857 \
5.280592893583236e-07 0.002948496343048522 5.280594568423325e-07 0.005545701385567424 5.280596754209339e-07 0.009327395936412004 5.280598614912559e-07 0.0128572688386996 \
5.280600828738638e-07 0.01737012273305725 5.280602435339974e-07 0.02082840415615294 5.280604069996469e-07 0.02447866954313523 5.280605576351642e-07 0.02794359528291388 \
5.280607066909169e-07 0.03145289236167962 5.280608561536706e-07 0.03504014479003619 5.280610101846837e-07 0.03879791952579481 5.28061172300943e-07 0.04280891157365373 \
5.280613383304077e-07 0.04696567134311741 5.280615142832281e-07 0.05141478668696391 5.280616949538655e-07 0.05602187592747932 5.280618867748118e-07 0.06094655248807559 \
5.280620938803164e-07 0.06629309753158302 5.280623154520462e-07 0.07203901748582854 5.280625501862155e-07 0.07814662931008168 5.280628017257829e-07 0.08470684589377442 \
5.280630771678493e-07 0.09190125212984442 5.280633773636676e-07 0.09974607960254324 5.280637082958779e-07 0.108390578238945 5.280640839626117e-07 0.1181923833971668 \
5.280644815454798e-07 0.1285487285136021 5.280649483700824e-07 0.1406786766767902 5.280654913626172e-07 0.1547396794802719 5.2806612478764e-07 0.1710742296429572 \
5.280668207276907e-07 0.1889259607126788 5.280676362848004e-07 0.2097135943149445 5.280685463129037e-07 0.2327316641523666 5.280693395691243e-07 0.2526372689279454 \
5.280700450441999e-07 0.2702038474981599 5.280706639884678e-07 0.2855008995781749 5.280712310944079e-07 0.2994177966724069 5.280717541744141e-07 0.3121574438576628 \
5.280722531532068e-07 0.3242197130846058 5.280727371932143e-07 0.3358335658028451 5.280731924200473e-07 0.3466679577370423 5.280736669320091e-07 0.3578644504627745 \
5.280741068407172e-07 0.368158604789619 5.28074592685345e-07 0.3794271463718566 5.280751242881185e-07 0.3916316501999784 5.280756269514167e-07 0.4030538969706937 \
5.280760560236697e-07 0.4127111343288326 5.280765470403382e-07 0.4236561147984291 5.280770484704186e-07 0.434714731975362 5.280773950150088e-07 0.442288187401736 \
5.280777504243856e-07 0.4500000616404133 5.280781776521144e-07 0.4592019891792938 5.280785698516369e-07 0.4675774400278049 5.280788702333951e-07 0.4739448723400065 \
5.280792120451549e-07 0.4811381049525967 5.280795554849688e-07 0.4883107756756314 5.280798162200955e-07 0.4937186470393492 5.280800582500485e-07 0.4987071765458648 \
5.280803241952915e-07 0.5041573145298286 5.280805814645868e-07 0.509394255416739 5.280807715836905e-07 0.5132422368582924 5.280809851098511e-07 0.5175451019736222 \
5.280811248001571e-07 0.5203466115392713 5.280812710004491e-07 0.5232668091041763 5.280814849883502e-07 0.5275186200231483 5.280816930046097e-07 0.5316389396023125 \
5.28081885465879e-07 0.5354321131715788 5.280820705821105e-07 0.5390651926504321 5.280822449555568e-07 0.5424725330931349 5.280825494976333e-07 0.5484058192982523 \
5.280828100565151e-07 0.5534602958276967 5.280831114875446e-07 0.5592859190791987 5.28083365805138e-07 0.5641865993769294 5.280836586613278e-07 0.5698153316805189 \
5.280839178744799e-07 0.5747800306938655 5.280841889508118e-07 0.579963273174682 5.280844307945714e-07 0.5845680738798381 5.280846882997289e-07 0.5894577538325241 \
5.280849150436047e-07 0.5937419314630586 5.280851520444243e-07 0.5982006324572362 5.280853622309862e-07 0.6021379329905048 5.280855749915204e-07 0.6061060319396779 \
5.280858278702861e-07 0.6107954169450593 5.280860315335544e-07 0.6145509252949414 5.280862222509359e-07 0.6180531102377972 5.280864095873744e-07 0.6214768531423983 \
5.28086598465652e-07 0.6249070011644339 5.280868066654474e-07 0.6286671070650327 5.280870509975622e-07 0.6330499453121026 5.280872505640949e-07 0.6366057789565548 \
5.280874547098357e-07 0.6402215701419991 5.2808763934909e-07 0.643474671963314 5.28087908884781e-07 0.6481901084955864 5.280881365916373e-07 0.652149230294136 \
5.280883242633752e-07 0.6553888277830079 5.280885051635201e-07 0.6584949378977958 5.280886647046019e-07 0.661221510907812 5.280888351670024e-07 0.6641177016088209 \
5.280889869184432e-07 0.6666817235716488 5.280891245614551e-07 0.6689905419339194 5.280892735563186e-07 0.6714784915997724 5.280894012981823e-07 0.6736028790357499 \
5.28089544284695e-07 0.675968899142866 5.280896660677513e-07 0.6779749688503388 5.28089802351161e-07 0.6802121872853304 5.280899221800626e-07 0.682172759947357 \
5.280900687756234e-07 0.6845626218370968 5.280901872485649e-07 0.6864845934661837 5.280902831819268e-07 0.6880368302455475 5.280903757015115e-07 0.6895284278106264 \
5.280904807620225e-07 0.6912169000724893 5.280905788439078e-07 0.6927871490736753 5.280907159592253e-07 0.6949707622226827 5.28090835157868e-07 0.6968607547931925 \
5.280909450978383e-07 0.6985951241089645 5.280910825970815e-07 0.7007503743809057 5.280912140269832e-07 0.7027960765825516 5.280913462564986e-07 0.7048392108129343 \
5.280914594338973e-07 0.7065756917706891 5.280916138667517e-07 0.708927873976708 5.280917446467452e-07 0.7109048231498766 5.280918673154548e-07 0.7127465601965561 \
5.280919735837112e-07 0.7143329262278221 5.280920959637349e-07 0.7161490373358268 5.280921978172318e-07 0.7176517022913665 5.280923319551315e-07 0.7196190116794019 \
5.280924526481716e-07 0.7213783352064487 5.280925717899705e-07 0.7231049829175343 5.280926968079846e-07 0.7249059312823601 5.280928266477907e-07 0.7267645120560844 \
5.280929464599617e-07 0.7284691779696002 5.280930754532131e-07 0.730293808329565 5.280932075602774e-07 0.7321507998840678 5.280933258660953e-07 0.7338038328985433 \
5.280934691267862e-07 0.7357927618453034 5.280935715814729e-07 0.7372070005703254 5.280936677883586e-07 0.7385290937783453 5.280937728059804e-07 0.7399656334130889 \
5.280938835775113e-07 0.7414708009413548 5.280939852560522e-07 0.7428439364018735 5.280940882175066e-07 0.7442258341871242 5.280942051436606e-07 0.7457850038572696 \
5.280943339039365e-07 0.747489965072781 5.28094435062908e-07 0.7488201182152049 5.280945839319522e-07 0.7507626302114226 5.280947316114891e-07 0.75267249971878 \
5.280948509768551e-07 0.7542038164026367 5.280949974606996e-07 0.7560679527984652 5.280951206361903e-07 0.7576223900169708 5.280952614398646e-07 0.7593848990234215 \
5.28095398032531e-07 0.7610800595258669 5.280955201903812e-07 0.7625841275516777 5.280956328467787e-07 0.7639610711610054 5.280957745729197e-07 0.7656796138775311 \
5.280959007394198e-07 0.767196844592689 5.280960161567243e-07 0.768574452686535 5.28096146464904e-07 0.7701179991486644 5.280962621775718e-07 0.7714782821591826 \
5.280963850018603e-07 0.7729116492687436 5.280965028461285e-07 0.7742769236963016 5.280966084761185e-07 0.7754922619072108 5.280967238495534e-07 0.7768108638983861 \
5.280968291127158e-07 0.7780056027231214 5.28096940062529e-07 0.7792565499870431 5.280970264670306e-07 0.7802246528436213 5.280971305008506e-07 0.7813823422463088 \
5.28097244396594e-07 0.7826398494046257 5.280973474300135e-07 0.7837684443710583 5.280974555127141e-07 0.7849432998269023 5.280975637643697e-07 0.7861107422109641 \
5.280976991816163e-07 0.7875582910536544 5.280978118557238e-07 0.7887521292973186 5.280979362797841e-07 0.7900592323105087 5.28098054252648e-07 0.7912877959129118 \
5.280981987206026e-07 0.7927781272271259 5.280983163897418e-07 0.7939806363584788 5.280984522695815e-07 0.7953567374150946 5.280985870139538e-07 0.7967081403609936 \
5.280986980849332e-07 0.7978123285366109 5.280987979742732e-07 0.7987978371087655 5.280988996542306e-07 0.7997937268659365 5.28099032867897e-07 0.8010867894381996 \
5.280991512407162e-07 0.8022243628210853 5.280992727817904e-07 0.8033812848148773 5.280993921454423e-07 0.8045065422543012 5.280995132768187e-07 0.80563739819571 \
5.28099644976236e-07 0.8068544426691319 5.280997679845129e-07 0.8079795872959963 5.280998958281203e-07 0.8091371804586788 5.281000267346398e-07 0.8103101881504271 \
5.281001503277979e-07 0.8114062915203997 5.28100257500303e-07 0.8123479140825919 5.281003649295023e-07 0.8132835730547656 5.281004475986205e-07 0.8139979974227743 \
5.281005653103806e-07 0.8150069815425507 5.281006559159858e-07 0.8157770472204025 5.281007865694307e-07 0.8168774959419571 5.28100930959301e-07 0.8180800468042847 \
5.281010641337151e-07 0.8191766687328477 5.281011740251065e-07 0.8200725423139092 5.281013176239916e-07 0.8212302325252553 5.281014710146833e-07 0.8224508494407716 \
5.281015990929081e-07 0.8234574467428303 5.281017388802764e-07 0.8245431382086058 5.281018651298391e-07 0.8255122018650548 5.281020197283917e-07 0.8266841987320058 \
5.281021519393684e-07 0.8276738265999063 5.281022781661507e-07 0.8286078934539939 5.281023959138743e-07 0.8294698388787296 5.281025449866676e-07 0.8305480062617677 \
5.281027123182206e-07 0.8317406852496945 5.281028455394968e-07 0.8326770812274722 5.281030183208196e-07 0.8338744310092966 5.281031868261935e-07 0.8350236380668206 \
5.281033562054924e-07 0.8361608866600232 5.281035378407611e-07 0.8373606451951652 5.281036801740827e-07 0.8382866867625347 5.281037940110689e-07 0.8390185116470331 \
5.28103925192579e-07 0.8398522525089582 5.28104026724794e-07 0.8404903982372576 5.281041430090543e-07 0.8412135669902132 5.281042776438077e-07 0.8420406924792603 \
5.281044746666439e-07 0.8432316292878405 5.281046647721864e-07 0.8443592803112207 5.281048748954986e-07 0.8455816023960827 5.281050552136042e-07 0.8466107566581813 \
5.281052526767048e-07 0.8477171937062282 5.281054267458196e-07 0.8486750118570332 5.281056090652401e-07 0.8496608982186138 5.281057804803758e-07 0.8505716849290491 \
5.281059545936529e-07 0.8514808063694008 5.281061303246211e-07 0.8523822271368225 5.281063064363214e-07 0.8532696099472232 5.281064960541732e-07 0.8542074684498208 \
5.281066868356705e-07 0.8551330189126392 5.28106888431747e-07 0.8560917259710515 5.281070811660049e-07 0.856990088884472 5.281072900378257e-07 0.8579439907476532 \
5.281075207402632e-07 0.8589743400177088 5.281077851832272e-07 0.8601259267840322 5.281080840059149e-07 0.8613896125360476 5.281083639602158e-07 0.8625380186322354 \
5.281086480860817e-07 0.8636694076724545 5.281089228550569e-07 0.8647317823994775 5.281091947122167e-07 0.8657531067718063 5.281094650893342e-07 0.8667403371654003 \
5.281097221678555e-07 0.8676533221001362 5.281099947926866e-07 0.868594905839151 5.281102707598356e-07 0.8695208838709013 5.281105408640932e-07 0.8704012674911344 \
5.281108407401039e-07 0.8713491368600049 5.281112118011625e-07 0.8724801680184872 5.2811150674079e-07 0.8733472453740196 5.28111761036548e-07 0.8740729094291386 \
5.281120592974738e-07 0.8748989982677786 5.281123329040153e-07 0.8756336613858092 5.281125690299577e-07 0.876250392688866 5.281128093740557e-07 0.8768621356511911 \
5.281130317061818e-07 0.8774140071409635 5.28113225712247e-07 0.8778848105679672 5.281135554349973e-07 0.8786625669521169 5.281137106085256e-07 0.8790190643519731 \
5.281140283876062e-07 0.879730644938159 5.281142072488645e-07 0.8801204696806418 5.28114549710761e-07 0.8808457867651537 5.281147338373631e-07 0.8812245477320809 \
5.28115208711942e-07 0.8821665346129511 5.281153761083518e-07 0.8824869809105039 5.281158419518539e-07 0.883348261932613 5.281160227735482e-07 0.8836708855253055 \
5.281165168126507e-07 0.8845204537290557 5.28116658162059e-07 0.8847551796839913 5.281172645001219e-07 0.8857215808967022 5.281174165693362e-07 0.8859539944113424 \
5.28118063256356e-07 0.8869009218298172 5.281181915512387e-07 0.8870812460539503 5.28118839667745e-07 0.8879562712787433 5.281189694676407e-07 0.8881245027440973 \
5.281197476783404e-07 0.8890830197250962 5.281198627254718e-07 0.8892171882189283 5.281207183963142e-07 0.8901564861234483 5.281208637440773e-07 0.8903061494816453 \
5.281218494996487e-07 0.8912466483555094 5.281220706077111e-07 0.8914402669210102 5.281232157277145e-07 0.892367747196105 5.281233469391586e-07 0.8924695935232408 \
5.281246882116238e-07 0.8934615053489913 5.281248396029001e-07 0.8935661991834861 5.281263210551204e-07 0.8944951400107031 5.28126559934816e-07 0.8946288932334222 \
5.281283293566538e-07 0.895502508848118 5.281287184779452e-07 0.895670668133377 5.281311122106538e-07 0.8965556062201232 5.281315877505925e-07 0.8967047758494365 \
5.281356508198176e-07 0.8977025964496719 5.281361422956535e-07 0.8977953148389237 5.281444588927962e-07 0.8987880790885289 5.281453787942481e-07 0.8988514070442593 \
5.282992423701678e-07 0.8998485708192639 5.283028854964575e-07 0.8998628537402877 5.285296142766716e-07 0.8989664306490068 5.285298446165833e-07 0.8988008565867064 \
5.285314595368805e-07 0.897804750401333 5.285316372691665e-07 0.8977103535805105 5.285484036692715e-07 0.8986978311584225 5.285485397684025e-07 0.8987160394686986 \
5.285637106086718e-07 0.8997133888183054 5.285639877135078e-07 0.899719468756186 5.290480289064218e-07 0.9005852143835333 5.290482022410388e-07 0.9007408621809421 \
5.290488627306383e-07 0.9015135064485434 5.290490287958205e-07 0.9017527716291757 5.29049555130528e-07 0.9026184054967997 5.290497462444475e-07 0.9029704910143604 \
5.290501104654996e-07 0.9036902342402512 5.290502896649214e-07 0.9040628043424317 5.290506515515938e-07 0.9048333795345931 5.290508466611638e-07 0.9052442844328937 \
5.290513790595253e-07 0.9062266394381637 5.290515614131638e-07 0.9064623886473868 5.290525533935561e-07 0.905594670761786 5.290527149341233e-07 0.9049318860608667 \
5.290528829265756e-07 0.9040378649110347 5.290530427580612e-07 0.9029782421366458 5.29053180254799e-07 0.9018984154159868 5.290533131621115e-07 0.9007052793196499 \
5.290534395875788e-07 0.8994328447569792 5.290535469868187e-07 0.8982475863895881 5.290536514834769e-07 0.8970047013543965 5.290537655331467e-07 0.8955451342423859 \
5.290538555027343e-07 0.8943225684615312 5.290539603213726e-07 0.8928208677113324 5.290540497696118e-07 0.891473284704788 5.290541321453926e-07 0.8901820884368528 \
5.290542232383926e-07 0.8887006634027688 5.290543605744706e-07 0.8863657732814155 5.290544590674027e-07 0.8846195012157601 5.290545711411527e-07 0.8825649218508906 \
5.290547020241858e-07 0.880080778639088 5.290548384952159e-07 0.8774018563482072 5.290549919493788e-07 0.8742910281085086 5.290551510437468e-07 0.8709679977889497 \
5.290553153276494e-07 0.867445283300377 5.290554719957506e-07 0.8640104344288071 5.290556240865311e-07 0.860615744772629 5.290557778002064e-07 0.857132398554192 \
5.290559373623813e-07 0.853469801378647 5.290560924510829e-07 0.8498714074018293 5.290562661304016e-07 0.8458039138600054 5.290564291612693e-07 0.8419559450883216 \
5.290565908036839e-07 0.8381170660338335 5.290567534504205e-07 0.8342344554797501 5.290569148689274e-07 0.8303657475978833 5.29057083463406e-07 0.8263109424305363 \
5.290572663565042e-07 0.8219002364007665 5.290574341852182e-07 0.8178440888239877 5.290576024710332e-07 0.8137703061148112 5.290577732990847e-07 0.8096302849976138 \
5.290579454736421e-07 0.8054541271740473 5.290581132355611e-07 0.8013830614994394 5.290582968650184e-07 0.7969255463994016 5.290584682714962e-07 0.7927646873948894 \
5.290586537148024e-07 0.7882638003278283 5.290588203854536e-07 0.7842196820467244 5.290589892715847e-07 0.7801233737411432 5.290591734278818e-07 0.7756572567105651 \
5.290593680379105e-07 0.7709405333854473 5.290595152932414e-07 0.7673736106648734 5.29059641923832e-07 0.7643079795643375 5.290597837806443e-07 0.7608754495129878 \
5.290598881844221e-07 0.7583505812556488 5.290600205770739e-07 0.7551502542766809 5.290601301612705e-07 0.7525028097975122 5.290602633259231e-07 0.7492875979647342 \
5.290604195076851e-07 0.7455190770546114 5.290605327371121e-07 0.7427887939149777 5.290606952584763e-07 0.7388718945951063 5.290608674392915e-07 0.7347246296492568 \
5.290610634440439e-07 0.7300078517193382 5.290612278340228e-07 0.7260553905833119 5.290613802307036e-07 0.7223944885043934 5.290615439058578e-07 0.718466402706526 \
5.290617118315579e-07 0.7144406657912139 5.290618916719358e-07 0.7101336212543717 5.290620679658861e-07 0.7059164985576465 5.290622390405214e-07 0.7018286413152719 \
5.29062407358697e-07 0.6978099102718778 5.290625606248286e-07 0.6941537154717222 5.290627225083983e-07 0.6902960245155986 5.290629014599385e-07 0.6860364417190952 \
5.290630356714899e-07 0.6828448068431195 5.290631391777877e-07 0.6803854168085423 5.290632384622005e-07 0.6780286039046017 5.290633399166766e-07 0.6756220912380299 \
5.290634323732756e-07 0.6734303711245889 5.29063516962075e-07 0.6714267031582685 5.290636105394115e-07 0.6692114082407524 5.290637270816307e-07 0.6664546942583044 \
5.290638365591918e-07 0.6638675763958631 5.29063949672203e-07 0.6611971533414394 5.290640727909702e-07 0.6582923426231613 5.290641970172829e-07 0.6553636581362478 \
5.290643677774271e-07 0.6513432847262797 5.290645262260144e-07 0.6476181700514572 5.290646985138371e-07 0.6435738126612673 5.290648444919037e-07 0.6401512360303271 \
5.290649862851197e-07 0.6368325564797357 5.290651178835739e-07 0.6337564355289309 5.290652480468588e-07 0.630718219665797 5.290653735717996e-07 0.6277924818644975 \
5.290655053547071e-07 0.6247239543970449 5.290656352782026e-07 0.6217046839485236 5.290657715867779e-07 0.6185408917806742 5.290659162003453e-07 0.615188962872713 \
5.29066075692536e-07 0.611499189008522 5.290662491526524e-07 0.6074939486938447 5.290664201599544e-07 0.6035554342946753 5.290666515285226e-07 0.5982402936372396 \
5.290668949905284e-07 0.5926661367297537 5.29067069111016e-07 0.5886942528256315 5.290672153830934e-07 0.5853638081576373 5.290673497553115e-07 0.58231230528805 \
5.290674668502067e-07 0.5796585826255305 5.290675626145531e-07 0.5774900935424465 5.290676614610955e-07 0.5752566196463251 5.290677454384142e-07 0.5733628024369305 \
5.290678230524635e-07 0.571614165956722 5.290678843779373e-07 0.5702331258704825 5.290679490585755e-07 0.5687779664863769 5.290680303667114e-07 0.5669528575016536 \
5.290680804367073e-07 0.5658306078972934 5.290681297572688e-07 0.5647256890740617 5.29068191677069e-07 0.5633393552914843 5.290682395088942e-07 0.5622690492396486 \
5.290682900136796e-07 0.5611395143522533 5.290683500757169e-07 0.559799205480933 5.290684093585124e-07 0.5584782058326896 5.290684844152261e-07 0.5568072508052372 \
5.290685540978827e-07 0.5552574373576753 5.290686396864492e-07 0.5533559356568912 5.290687267538207e-07 0.5514265885063823 5.290688104163413e-07 0.5495763264044081 \
5.290688965613662e-07 0.5476734676082877 5.290689922659868e-07 0.5455621222678217 5.290690965509387e-07 0.5432673229847179 5.290692112181133e-07 0.5407497407899529 \
5.290693199365744e-07 0.5383664115638558 5.290694295088142e-07 0.5359693749054023 5.290695418135745e-07 0.5335193270114367 5.290696685891956e-07 0.530759392645703 \
5.290697908664272e-07 0.5281021910076299 5.290699309524048e-07 0.5250685463469849 5.290700679697626e-07 0.5221084647952599 5.290702182711349e-07 0.5188705764247719 \
5.290703771663761e-07 0.5154582091324615 5.290705515002589e-07 0.5117250894133971 5.29070738517481e-07 0.5077378180012799 5.290709438354859e-07 0.5033745272871338 \
5.290711556776788e-07 0.498891131759938 5.29071408479721e-07 0.4935662239713107 5.2907161056737e-07 0.4893264048484654 5.290718451606752e-07 0.4844277613141263 \
5.290720812752721e-07 0.4795194943790256 5.290723344517689e-07 0.474283574581623 5.290726449817317e-07 0.4679020429045382 5.290728630397102e-07 0.4634451779596257 \
5.290730364853443e-07 0.4599153839204358 5.290732129777809e-07 0.4563351808422506 5.290734924595774e-07 0.4506930409909046 5.290737247034844e-07 0.4460279192631412 \
5.290740117970731e-07 0.44029020239849 5.290742296431809e-07 0.435960758243863 5.290744396957687e-07 0.4318042429497612 5.290746408936045e-07 0.4278406951573778 \
5.290748233137656e-07 0.4242617300271556 5.290749972087507e-07 0.4208637793449936 5.290751620728668e-07 0.4176529694331993 5.290753208268398e-07 0.4145718140694327 \
5.290754870737866e-07 0.4113577680628809 5.290756357189934e-07 0.4084923702366076 5.29075788087249e-07 0.4055658186126443 5.290759301504318e-07 0.4028468403491589 \
5.290760995263099e-07 0.3996150665462138 5.290762199082301e-07 0.3973276483660343 5.290763298814939e-07 0.3952449223617059 5.290764448068948e-07 0.3930732253581283 \
5.290765970484751e-07 0.3902080468194818 5.290767092695403e-07 0.3881039677199808 5.290768164620408e-07 0.386098874836553 5.290769689902897e-07 0.383254723448244 \
5.290770971374193e-07 0.380874963946598 5.290772199854117e-07 0.3786015923730871 5.290773990837881e-07 0.375299968600122 5.290775481684202e-07 0.3725653942578417 \
5.290777158758077e-07 0.3695018296724824 5.290778712734425e-07 0.3666748141177644 5.290779954402882e-07 0.3644243980538668 5.290781093321555e-07 0.3623666676050148 \
5.29078230775526e-07 0.3601804966264144 5.290784109272934e-07 0.3569532670533712 5.290785774151135e-07 0.3539878629329621 5.290787678342229e-07 0.3506138544217919 \
5.290789595908186e-07 0.3472380408565978 5.29079142640212e-07 0.344035729794033 5.290792916122767e-07 0.3414435189591631 5.290794115521823e-07 0.3393660536257183 \
5.290795342136651e-07 0.3372483242714233 5.290796572441514e-07 0.3351324902755385 5.29079802148562e-07 0.3326515017845288 5.290799054613373e-07 0.3308907757076019 \
5.290799991908464e-07 0.3292979229163631 5.290800898511484e-07 0.3277620998585528 5.29080200972602e-07 0.3258853746017661 5.290803081455789e-07 0.3240820510456246 \
5.290804064202303e-07 0.3224338250618513 5.290805188247763e-07 0.3205545940512134 5.290806827646764e-07 0.3178277446588927 5.290808444025551e-07 0.3151576097143818 \
5.290809921893013e-07 0.3127316247504084 5.290811544345159e-07 0.3100832165115083 5.290813144650734e-07 0.3074868334344322 5.290814667283717e-07 0.3050304870660137 \
5.290816201002421e-07 0.3025703731928215 5.29081778808771e-07 0.3000411640344692 5.290819432578998e-07 0.297437246442505 5.290821104849764e-07 0.2948063590562646 \
5.290822635965136e-07 0.292412731930112 5.290824466944405e-07 0.2895700146919417 5.290826370021783e-07 0.2866380344427262 5.290827859052365e-07 0.2843603072871506 \
5.290829598425416e-07 0.2817165165722222 5.290831367199302e-07 0.2790484233348025 5.290832843171486e-07 0.2768363681311815 5.290834739488487e-07 0.2740172295061162 \
5.290836239507675e-07 0.2718052906662373 5.290837610609577e-07 0.2697943906627059 5.290839025914007e-07 0.2677397479842996 5.290840160502698e-07 0.2661005451260196 \
5.290841523405964e-07 0.2641384584581135 5.290842824172175e-07 0.2622807416655737 5.290844006714701e-07 0.2606037730704709 5.290845185270663e-07 0.2589348966568543 \
5.290846494208769e-07 0.2570853888657079 5.290847896596348e-07 0.2551145527343576 5.290849051542211e-07 0.2534976852533538 5.290850340055979e-07 0.2516957519945816 \
5.290851491515796e-07 0.2500885525459272 5.290853024625469e-07 0.2479513765689386 5.290854403163083e-07 0.2460367343642474 5.290855797779604e-07 0.2441002375748529 \
5.29085735245815e-07 0.2419427021952501 5.290858600284303e-07 0.2402176526454788 5.290859998933384e-07 0.2382916534360561 5.290861285955144e-07 0.2365220787132559 \
5.290862495543663e-07 0.234860341242685 5.290863665996657e-07 0.2332541163798121 5.290864926007302e-07 0.2315368940272461 5.290865893203229e-07 0.2302195772445239 \
5.290866814091961e-07 0.2289683907689286 5.290867958266674e-07 0.2274152998827935 5.29086894197314e-07 0.2260807986508055 5.290870113441077e-07 0.2244933520241092 \
5.290871144352256e-07 0.2231010305483718 5.290872199499517e-07 0.2216798666278746 5.290873008680117e-07 0.2205933880575098 5.290873745391968e-07 0.2196046443759679 \
5.290874172684338e-07 0.2190314036349237 5.29087460398579e-07 0.2184540235451489 5.290875111960607e-07 0.217774515685755 5.290875483709393e-07 0.217277430841393 \
5.29087589041954e-07 0.2167338127731004 5.290876318337555e-07 0.2161620985357572 5.29087668244897e-07 0.2156758299561118 5.290877101698877e-07 0.2151161507306283 \
5.290877647120985e-07 0.2143884526296278 5.290878031708565e-07 0.2138756926875936 5.290878427976257e-07 0.2133496230586122 5.290879046301276e-07 0.212531488259555 \
5.290879663565787e-07 0.2117156525305126 5.290880224938542e-07 0.210974237875411 5.290880861490836e-07 0.210134110843225 5.290881802401172e-07 0.2088936328424611 \
5.290882670483761e-07 0.2077505933124353 5.290883610050201e-07 0.2065146061917991 5.290884590472537e-07 0.2052266823513323 5.290885606346195e-07 0.2038976009052371 \
5.290886615435679e-07 0.2025832113009377 5.290887582793767e-07 0.2013244528083448 5.290888604043477e-07 0.1999972806373927 5.290889637359054e-07 0.1986583046056677 \
5.29089073618507e-07 0.1972379690671278 5.290891825607647e-07 0.1958337611883887 5.290893023958847e-07 0.1942937175364915 5.290894126797513e-07 0.1928822800638286 \
5.290895205584963e-07 0.191507108810815 5.290896466212543e-07 0.1899051957406391 5.290897364889608e-07 0.1887671190866151 5.290898469672999e-07 0.1873723090993208 \
5.290899245002487e-07 0.1863971337376019 5.290900088239919e-07 0.1853400660204312 5.2909009641205e-07 0.1842452710069853 5.290901842046441e-07 0.18315095174413 \
5.290902659245155e-07 0.1821357652581398 5.290903634861928e-07 0.1809282658474054 5.290904701973441e-07 0.1796118512064394 5.29090570679026e-07 0.178377576484793 \
5.290906948502375e-07 0.1768595317522179 5.290908287417607e-07 0.1752320886156309 5.290909476539533e-07 0.1737937102924047 5.290910980541468e-07 0.1719851742607024 \
5.290912088892401e-07 0.1706594030660365 5.29091348655982e-07 0.168997130456427 5.290914671812902e-07 0.1675953052211382 5.29091572608521e-07 0.1663548750207849 \
5.290916673183802e-07 0.1652455210322802 5.290917606281544e-07 0.1641568522804657 5.290918615342704e-07 0.1629842804551663 5.290919569521023e-07 0.1618800504313296 \
5.290920541430255e-07 0.1607598891027116 5.290921357045071e-07 0.1598237474547246 5.290922410209518e-07 0.1586229753023833 5.290923245006587e-07 0.1576763029943549 \
5.290924260299495e-07 0.1565306813704828 5.290925032604858e-07 0.1556635090415242 5.290925941325229e-07 0.154647919213242 5.290926634838334e-07 0.1538765336840219 \
5.290927480678846e-07 0.1529397840535594 5.290928224610911e-07 0.1521208717489242 5.290929018312932e-07 0.151251902275755 5.290929764189645e-07 0.1504388356812226 \
5.290930456405211e-07 0.1496871728711989 5.290931403213281e-07 0.1486640077242138 5.29093210087093e-07 0.1479134441579097 5.290932945316558e-07 0.147008717574758 \
5.290933560970016e-07 0.1463518850554192 5.290934301394932e-07 0.1455673550676988 5.290935035250168e-07 0.1447940960774066 5.290935849602586e-07 0.1439395015691976 \
5.290936544094048e-07 0.1432139999234875 5.290937295111024e-07 0.1424323701137583 5.290938194231735e-07 0.1415006120834361 5.290938965067932e-07 0.1407052977810757 \
5.290939956173774e-07 0.1396885207473417 5.290940651574398e-07 0.138983077430453 5.290941464759156e-07 0.1381612812129989 5.290942166443247e-07 0.1374549162714094 \
5.290942956124377e-07 0.1366629455350578 5.290943745907204e-07 0.1358740351737466 5.290944469125105e-07 0.1351544405911459 5.290945162779692e-07 0.1344667589602006 \
5.290945649819766e-07 0.1339854049281765 5.290946557443483e-07 0.1330945614011112 5.290946877658758e-07 0.1327823711724506 5.290947758698441e-07 0.131925672678654 \
5.290948083638864e-07 0.1316105445757083 5.290949070315436e-07 0.1306564447580443 5.290949506875193e-07 0.130235859061297 5.290950286693357e-07 0.1294866595045693 \
5.290950660002936e-07 0.1291289430202982 5.290951681516938e-07 0.128153223240932 5.290952355956539e-07 0.1275115375392494 5.290953007486116e-07 0.1268935577290946 \
5.290953666546259e-07 0.1262729746041904 5.290954378066093e-07 0.1256052797936485 5.290955207439704e-07 0.1248293808775363 5.290956061394507e-07 0.1240331657139879 \
5.290956822268445e-07 0.1233259817834828 5.290957626875214e-07 0.1225806238777534 5.290958207714622e-07 0.1220441728027253 5.29095892104936e-07 0.1213870835332726 \
5.290959768933693e-07 0.1206085709991845 5.290960380484021e-07 0.1200487744399507 5.290961081348534e-07 0.1194096117168642 5.290961706401422e-07 0.1188419501154776 \
5.290962366450903e-07 0.1182453094891599 5.290963054178569e-07 0.1176255789053269 5.290963748744814e-07 0.1170017375875525 5.29096458038731e-07 0.1162574953874909 \
5.290965311562548e-07 0.1156056107435251 5.29096601870241e-07 0.1149774116339468 5.290966612219237e-07 0.1144518657417393 5.290967665191357e-07 0.1135239342411639 \
5.290968123866298e-07 0.1131212254602471 5.290968993406834e-07 0.1123603821649216 5.290969423544638e-07 0.1119852310621949 5.290969872212111e-07 0.1115947726395539 \
5.29097076954706e-07 0.1108164664143028 5.290971478390574e-07 0.110204256460374 5.290972266925708e-07 0.109525796983828 5.290972894703463e-07 0.1089876103666232 \
5.290973494647019e-07 0.1084750215669379 5.290974604624741e-07 0.1075310013968523 5.2909754121676e-07 0.1068475792877216 5.290976536800859e-07 0.1059005796323111 \
5.290977048246292e-07 0.1054717782906781 5.290977878097979e-07 0.1047785948356612 5.290978459745031e-07 0.1042945647727652 5.290979602125029e-07 0.1033482075721767 \
5.290980101159701e-07 0.1029366076865433 5.290980958575694e-07 0.1022320954501846 5.290981448890196e-07 0.1018307629303728 5.290982274554409e-07 0.101157455862875 \
5.290982983877772e-07 0.1005815064560546 5.290983665381274e-07 0.1000302812267231 5.290984441484433e-07 0.0994053199805509 5.290985164918144e-07 0.09882546240595018 \
5.29098594067778e-07 0.09820656846618626 5.290986827384393e-07 0.09750287271560702 5.290987565532273e-07 0.09692010793638871 5.290988381442348e-07 0.09627924899616347 \
5.290989162827031e-07 0.09566870926115327 5.290990020324936e-07 0.09500229249765579 5.290990897294021e-07 0.09432453920671229 5.290991836389668e-07 0.09360304191323381 \
5.290992800982851e-07 0.09286661217778783 5.290993587289458e-07 0.09226977907248698 5.290994614525456e-07 0.09149473120661993 5.290995452801958e-07 0.09086620530027881 \
5.290996660323776e-07 0.08996702094116031 5.29099795302029e-07 0.08901247130467421 5.290999511904931e-07 0.08787237469953549 5.291001062900762e-07 0.08675000010972149 \
5.291002633058824e-07 0.08562614142917294 5.291004433267348e-07 0.08435280068725284 5.291005938476015e-07 0.08330035525696428 5.291007422216237e-07 0.08227363395463329 \
5.291008798388548e-07 0.08133079092382095 5.291010197585049e-07 0.08038162993974078 5.291011563654933e-07 0.07946425488810546 5.291012950927907e-07 0.07854214404995859 \
5.291014404036529e-07 0.07758663187171365 5.29101588151466e-07 0.07662571164688473 5.291017467483332e-07 0.07560598447141591 5.29101911000851e-07 0.07456266320243836 \
5.291020800179273e-07 0.07350246718885647 5.291022619069209e-07 0.07237646636762114 5.291024625290194e-07 0.07115268999588262 5.291026764065622e-07 0.0698691158856425 \
5.291029040406938e-07 0.0685263410462881 5.291031456262355e-07 0.06712722147996912 5.29103427215414e-07 0.06552977831071743 5.291037243695345e-07 0.06388229915275011 \
5.291040478026115e-07 0.06213267023812474 5.29104438962031e-07 0.0600758559534558 5.29104840456333e-07 0.05803293250078725 5.291052173970595e-07 0.05617754872181892 \
5.291055845107909e-07 0.05442503025024555 5.291059346274713e-07 0.05280240270907886 5.291062539331247e-07 0.05136309724710254 5.291065582574072e-07 0.05002640192327024 \
5.291068551633125e-07 0.04875503464657577 5.291071371636386e-07 0.04757867888787161 5.291074175969432e-07 0.04643900623749339 5.291076823205669e-07 0.04538777697325767 \
5.291079582182789e-07 0.04431704973151576 5.291082326831432e-07 0.04327654260273706 5.291085311024235e-07 0.04217254828989973 5.291087576184799e-07 0.04135316230013186 \
5.291090695313176e-07 0.04025053053625379 5.291092897861088e-07 0.03948972371590862 5.291095070508635e-07 0.03875470657060948 5.291097167735126e-07 0.03806113111453101 \
5.291100269559001e-07 0.03705828856757609 5.291102495537778e-07 0.03635538859683734 5.29110496919279e-07 0.03559019656168042 5.291107693256555e-07 0.03476651972027592 \
5.291109899582094e-07 0.03411384091885184 5.291112742384598e-07 0.03329124852897781 5.291115121517525e-07 0.0326183788879464 5.291117502411636e-07 0.03195887699386461 \
5.291119854964916e-07 0.03132132139405813 5.291122142751987e-07 0.03071728735992773 5.291124470059479e-07 0.03011490821398154 5.291126663089891e-07 0.02955843195412813 \
5.291128702520595e-07 0.02905055018162466 5.291132691617956e-07 0.02808303002558106 5.291134563160508e-07 0.02764052191221165 5.29113828521772e-07 0.0267814187683372 \
5.29114015473295e-07 0.02635997027055515 5.291143848272416e-07 0.02554620807076183 5.291145384804101e-07 0.02521471147941385 5.291149546945643e-07 0.02434161493068329 \
5.291151601823807e-07 0.02392065165079968 5.291154991903413e-07 0.02323955384462723 5.291156818850694e-07 0.02287916718068597 5.291161389789784e-07 0.02199597290476789 \
5.291162687197143e-07 0.02174967209293581 5.291167221401377e-07 0.02089828923199067 5.2911686451243e-07 0.0206336680476187 5.291173940791905e-07 0.01967289368906444 \
5.291175202861975e-07 0.01945139161001456 5.291180825206354e-07 0.01850749734048266 5.29118245259022e-07 0.01824627541187189 5.291188094390871e-07 0.01738327200207762 \
5.291189611831539e-07 0.01716165742474803 5.291196628626383e-07 0.01618760396393164 5.291198329517282e-07 0.01596324388168 5.291204880096042e-07 0.01513221026437959 \
5.291206545239164e-07 0.01492874613340729 5.291213876376757e-07 0.01406966818047924 5.291215209008543e-07 0.01391906482409888 5.291223725580289e-07 0.01299647369571925 \
5.291225105004775e-07 0.01285324185793544 5.291234505599668e-07 0.0119198170026788 5.29123614321604e-07 0.01176347583728811 5.291246015550385e-07 0.01085909507266535 \
5.291247361441145e-07 0.0107410715025141 5.291258775835447e-07 0.009819907073012045 5.291259858224434e-07 0.009738548299709823 5.29127309069827e-07 0.00880579379490502 \
5.291274418155253e-07 0.008718202093769473 5.291289643166501e-07 0.007760835273143199 5.29129076858719e-07 0.007690148685505111 5.291307691503061e-07 0.00669558715138598 \
5.291309094168914e-07 0.00662113250846694 5.291329824261937e-07 0.005629132576249021 5.291331749877106e-07 0.005545002188831318 5.291353851975589e-07 0.004656096148610405 \
5.291357919842319e-07 0.004507219767123045 5.291386137242085e-07 0.003590578528330178 5.291391350199587e-07 0.00344214578404881 5.291433471210094e-07 0.002447529662748036 \
5.291438996838773e-07 0.002340875287107731 5.291497829734169e-07 0.001359168649576994 5.291500322464151e-07 0.001311490127959886 5.291631823674653e-07 0.0003136950974005476 \
5.291632991504353e-07 0.0003112730584132499 5.589900000000112e-07 3.042397160644726e-06 6.027466670270133e-07 -0.0009024818035526668 6.027467394426295e-07 -0.001022682652537627 \
6.027471754673471e-07 -0.001858525046639076 6.027472623617301e-07 -0.002046124893065343 6.027476170650433e-07 -0.00288168582347465 6.027477166116442e-07 -0.003135075204051477 \
6.027479768813486e-07 -0.003828199033013717 6.027481172037501e-07 -0.004216406518003108 6.027483446898323e-07 -0.004856871791621592 6.027484818972713e-07 -0.005239031028659006 \
6.0274886679612e-07 -0.006187559915121 6.027489988933068e-07 -0.006423332025500122 6.027496873363354e-07 -0.005917035979538006 6.027498442650688e-07 -0.005202654566481615 \
6.027499719142313e-07 -0.004414133290428114 6.027500994560215e-07 -0.003433350487145549 6.027502171302334e-07 -0.002355902309038119 6.027503162699201e-07 -0.001320627313728655 \
6.027504216526298e-07 -9.507383675133965e-05 6.02750535559933e-07 0.001369964538583592 6.027506666153286e-07 0.003229572948258866 6.027507919785475e-07 0.005172303930030842 \
6.027509838204114e-07 0.008432154569684791 6.027511274902044e-07 0.01107975669588844 6.027512854720173e-07 0.01417105828876112 6.027514340716643e-07 0.01723098336859398 \
6.02751587122593e-07 0.02051714008521248 6.027517461875693e-07 0.02405720796424875 6.027518992577779e-07 0.02756764950178633 6.027520476048421e-07 0.03105219347129199 \
6.027521967112842e-07 0.03462388853332505 6.027523512757131e-07 0.03838854885099419 6.027525119616768e-07 0.04235886888523473 6.027526766408632e-07 0.04647718198980624 \
6.027528531638066e-07 0.05093664320808645 6.027530321756059e-07 0.05549818742091989 6.027532229484479e-07 0.0603932190016783 6.027534277958001e-07 0.06567927942044927 \
6.02753648293053e-07 0.07139554989571946 6.027538812110213e-07 0.07745499876455469 6.027541304587992e-07 0.08395499695136356 6.027544033803265e-07 0.09108394918256098 \
6.027547001733835e-07 0.09884095133633181 6.027550276098956e-07 0.1073964775374675 6.027553974236946e-07 0.1170487607486894 6.027557923699754e-07 0.1273407304921971 \
6.027562504585284e-07 0.1392499850125259 6.027567825583881e-07 0.1530377249371455 6.027574081103967e-07 0.169180864038255 6.027580941024627e-07 0.1867931863309214 \
6.027588969458781e-07 0.2072766958045763 6.027597962582096e-07 0.2300508264895909 6.027606966983226e-07 0.2526618731709107 6.027614985898552e-07 0.2726215666318766 \
6.027621940969961e-07 0.2897857674353052 6.02762826931282e-07 0.3052728323588638 6.027634223397735e-07 0.3197161646377594 6.027639693828152e-07 0.3328722959176427 \
6.027645031431617e-07 0.3455929446372428 6.027650223825863e-07 0.3578476146335662 6.027655297740486e-07 0.3697097539883151 6.027660333952181e-07 0.3813674725871593 \
6.027665451381145e-07 0.3930934709428262 6.027670522991229e-07 0.404595334768291 6.027675825951367e-07 0.4164962117964878 6.027680687086257e-07 0.4272847049163567 \
6.027685468169473e-07 0.437781779057129 6.027689862490711e-07 0.4473362978389137 6.027691094085348e-07 0.4500002106608159 6.027693557274626e-07 0.4553046876287923 \
6.027696989994585e-07 0.4626558934952216 6.02770010436459e-07 0.4692815017887791 6.027702611477242e-07 0.4745855323881177 6.027705319768677e-07 0.480281321066213 \
6.027708684587769e-07 0.4873122872019196 6.027712244673881e-07 0.4946959640027882 6.027715417375557e-07 0.5012322602315481 6.027717806181048e-07 0.506122906570856 \
6.027720216462867e-07 0.5110269393752048 6.027722735779908e-07 0.5161276795544476 6.027725137318346e-07 0.5209621749612534 6.027727364832964e-07 0.5254248476203834 \
6.027729250409435e-07 0.5291850880529715 6.027731397909867e-07 0.5334523706207774 6.027733543393783e-07 0.5376948565446859 6.027736131036701e-07 0.5427871977552768 \
6.027738639312417e-07 0.5477009885064807 6.027741193501039e-07 0.5526782776843104 6.027744703926295e-07 0.5594898819265107 6.027747350009544e-07 0.5645984056527484 \
6.027750014175097e-07 0.569709962982798 6.027752619318197e-07 0.5746801970751495 6.027755290218824e-07 0.5797469183389945 6.027757721599625e-07 0.5843213438768613 \
6.02776027852189e-07 0.5890994944692448 6.027762556711592e-07 0.5933243819692556 6.027764932159793e-07 0.5976999800355528 6.027767046064655e-07 0.6015679915939678 \
6.027769167472246e-07 0.6054277082074113 6.027771059366022e-07 0.6088479815213901 6.027772370949197e-07 0.6112112531841202 6.02777369391478e-07 0.6135871094428261 \
6.02777554614204e-07 0.6169015645304802 6.027777166365907e-07 0.6197943209800671 6.027778750557552e-07 0.6226100751126036 6.027780091676215e-07 0.6249846001944386 \
6.027781814887287e-07 0.6280247049765127 6.027783104275314e-07 0.6302937061188456 6.027784308050438e-07 0.6324061607157294 6.027785713339148e-07 0.634864734791624 \
6.027787644194073e-07 0.6382321981637986 6.027789142301853e-07 0.6408363654380513 6.027790815377795e-07 0.6437327988167145 6.027792625920029e-07 0.6468572757970242 \
6.027794659184327e-07 0.6503523798695617 6.027796487715879e-07 0.6534819287355287 6.027798193958343e-07 0.6563879501053153 6.027799968600741e-07 0.6594029650344411 \
6.027801628390247e-07 0.6622113135173925 6.027803200758144e-07 0.6648594636266301 6.02780460561866e-07 0.6672075432495704 6.027806042919945e-07 0.6695987751186935 \
6.027807373389854e-07 0.6718055529208897 6.02780879311128e-07 0.6741523780906628 6.027809993716612e-07 0.6761293215200647 6.027811443097483e-07 0.6785098354674278 \
6.027812603067976e-07 0.6804095298668216 6.027813798866854e-07 0.6823647593763783 6.027814788466604e-07 0.68397755359623 6.027815973550785e-07 0.6859039329668146 \
6.027816843993602e-07 0.6873150904607619 6.027818064101795e-07 0.6892866586554622 6.027819053327908e-07 0.6908817703737582 6.027819972281661e-07 0.6923536807698466 \
6.027820971967053e-07 0.6939486118486815 6.02782195442366e-07 0.6955126686751646 6.027822871561283e-07 0.6969676095571918 6.027823912890696e-07 0.698613189139943 \
6.02782527015812e-07 0.7007470979739818 6.027826816242742e-07 0.7031613517373301 6.027828167319862e-07 0.7052558942641604 6.027829630685319e-07 0.7075085519458914 \
6.027830915360734e-07 0.7094732734147607 6.02783215720207e-07 0.7113609898537658 6.027833256245073e-07 0.7130225953369277 6.027834422075758e-07 0.7147759898693785 \
6.027835423854066e-07 0.7162749667021007 6.027836794742156e-07 0.7183149847558421 6.027837994632423e-07 0.7200901405411056 6.027839185766902e-07 0.7218426783097279 \
6.02784045072077e-07 0.723693513465353 6.02784170939449e-07 0.7255245570057045 6.027842935604676e-07 0.7272980597885179 6.027844211779915e-07 0.7291334326655684 \
6.027845514267828e-07 0.7309957624152177 6.02784673019733e-07 0.73272442801297 6.027848117884253e-07 0.7346853525547948 6.02784912196869e-07 0.7360963845229137 \
6.027850155842573e-07 0.7375412410987998 6.027851092446996e-07 0.7388443755773992 6.027852208662966e-07 0.7403895158541485 6.027853073348996e-07 0.7415798421827293 \
6.027854081980103e-07 0.7429609798983192 6.027855402947323e-07 0.7447573558536402 6.027856494960337e-07 0.7462323422761349 6.027857540276638e-07 0.747635567415085 \
6.027858776741446e-07 0.7492836897664436 6.027860263705797e-07 0.7512497161812216 6.027861482512389e-07 0.7528480713857697 6.02786261855803e-07 0.7543274008692354 \
6.027864023754882e-07 0.7561429069656862 6.027865435649301e-07 0.7579511824827749 6.027866613111062e-07 0.7594470562859095 6.027867900007656e-07 0.7610693809796742 \
6.027869325554126e-07 0.7628512182523866 6.027870484119641e-07 0.7642872416835913 6.027871941752296e-07 0.7660789429779771 6.02787316007677e-07 0.7675637574673733 \
6.02787434476374e-07 0.7689965471136999 6.02787557264006e-07 0.7704700089613156 6.027876834168885e-07 0.7719718272910862 6.027877937859393e-07 0.7732757954107932 \
6.02787919217035e-07 0.7747465774777432 6.027880246987464e-07 0.775974259539018 6.027881578651758e-07 0.7775122819577122 6.027882805466309e-07 0.7789173428708996 \
6.027884153096743e-07 0.7804473432620218 6.027885259809625e-07 0.7816923373676121 6.027886353025911e-07 0.7829118427552927 6.027887704350255e-07 0.7844048889494442 \
6.027889212140504e-07 0.7860523747618094 6.02789061582958e-07 0.7875692293014268 6.027891812944828e-07 0.7888502570533434 6.027893195488234e-07 0.7903153082715967 \
6.027894429191593e-07 0.7916096503654788 6.027895880177844e-07 0.7931164937536124 6.027897277580435e-07 0.7945521172774316 6.027898549394667e-07 0.7958455533278409 \
6.027899739792201e-07 0.7970449251022731 6.027900863374111e-07 0.7981670522831598 6.027901905661906e-07 0.79919939674296 6.027902859050021e-07 0.8001364844871954 \
6.027904221931121e-07 0.8014634245741865 6.027905390856556e-07 0.8025894467082511 6.02790658725145e-07 0.8037305025474466 6.027907806067166e-07 0.8048811831579785 \
6.027909029850537e-07 0.8060245537852575 6.027910310137332e-07 0.8072081965553952 6.027911556585317e-07 0.8083483262222385 6.027912861572795e-07 0.8095291977395493 \
6.027914126177069e-07 0.8106611567088965 6.027915397436747e-07 0.8117869190804841 6.027916448611512e-07 0.8127087429624065 6.027917501113405e-07 0.8136235164943317 \
6.027918412515906e-07 0.8144090748259969 6.027919646696249e-07 0.8154632009865571 6.027920517482738e-07 0.8162003374872545 6.02792151070959e-07 0.8170344894488412 \
6.027922959927027e-07 0.8182390501293432 6.027924322612063e-07 0.8193582434421302 6.027925417234846e-07 0.8202477434185359 6.027926878435863e-07 0.8214214001843773 \
6.027928392021979e-07 0.8226208465286928 6.027929650061201e-07 0.8236052915965452 6.027931094167793e-07 0.824721541823094 6.027932340177296e-07 0.8256729463037898 \
6.027933847297913e-07 0.8268094083523665 6.027935201010499e-07 0.8278169867326588 6.027936453039791e-07 0.8287379047458127 6.027937629733617e-07 0.829593908450195 \
6.027939088013387e-07 0.8306418458276996 6.027940752973201e-07 0.8318207857986918 6.027942061544082e-07 0.8327345044534114 6.027943796038485e-07 0.833928356718921 \
6.027945477223224e-07 0.8350667646575466 6.027947175961246e-07 0.8361988603660855 6.027948984507537e-07 0.8373843006762304 6.027950416331349e-07 0.8383085120571983 \
6.027951557464787e-07 0.8390361588138326 6.027952858124697e-07 0.8398559950134801 6.027953876877057e-07 0.8404909448220066 6.027955045669982e-07 0.8412116130393378 \
6.027956416789287e-07 0.8420465258793415 6.027958395595721e-07 0.843231707656198 6.027960313457652e-07 0.8443585547012582 6.027962407088286e-07 0.8455646258450146 \
6.027964228224064e-07 0.846593677725298 6.027966199171782e-07 0.8476867969181797 6.02796793185875e-07 0.8486305714188691 6.02796976264561e-07 0.8496104335327738 \
6.027971474015872e-07 0.8505103231661706 6.027973220804384e-07 0.8514128411730317 6.02797497318728e-07 0.8523022053693007 6.027976734583674e-07 0.8531802340241421 \
6.027978638096238e-07 0.8541115036082744 6.027980543867704e-07 0.855025905954957 6.027982548181928e-07 0.8559685891497206 6.027984474106693e-07 0.8568563992305701 \
6.027986582738063e-07 0.8578086227668252 6.027988861871822e-07 0.8588150784816577 6.027991522177188e-07 0.8599606428795262 6.027994507388009e-07 0.8612090806949765 \
6.027997266924816e-07 0.8623286542354505 6.028000109545961e-07 0.8634483918036945 6.028002851030457e-07 0.8644969441068078 6.02800557392313e-07 0.8655088801415273 \
6.028008275580887e-07 0.8664846790737442 6.028010847361862e-07 0.8673881555543895 6.028013572993529e-07 0.868319368003445 6.02801633304697e-07 0.8692355072818493 \
6.028019034186287e-07 0.870106770567397 6.028022032450018e-07 0.8710447971670072 6.028025742222908e-07 0.8721640818024149 6.028028691540118e-07 0.8730224021943973 \
6.028031234323761e-07 0.873740732376842 6.028034216772072e-07 0.8745584461000401 6.028036952852192e-07 0.8752856917963749 6.028039314154438e-07 0.8758961959341748 \
6.028041717609792e-07 0.8765017794770257 6.028043940971676e-07 0.8770481951318053 6.028045881024504e-07 0.8775144010549708 6.028049178237936e-07 0.8782846129827527 \
6.028050729968194e-07 0.8786376896881318 6.028053907524076e-07 0.8793424631377607 6.028055696169827e-07 0.8797286397841958 6.028059120784622e-07 0.8804474051285093 \
6.028060962178168e-07 0.880822800830328 6.028065711184753e-07 0.881756283451624 6.028067385131538e-07 0.8820737784441692 6.028072043462e-07 0.8829272622221894 \
6.028073851704931e-07 0.8832470363605239 6.028078792047928e-07 0.8840891816604841 6.028080205486687e-07 0.8843218944112644 6.028086269405856e-07 0.8852805359894154 \
6.028087790117662e-07 0.8855111592597558 6.028094256914359e-07 0.8864506941541785 6.028095539876422e-07 0.8866295550025313 6.028102021648149e-07 0.8874976172723908 \
6.028103319236755e-07 0.8876644392549727 6.028111001444974e-07 0.8886037370453904 6.02811229881009e-07 0.8887539063021698 6.028120833066544e-07 0.8896836309705964 \
6.028122265650877e-07 0.8898301468060963 6.02813212785821e-07 0.890764641901611 6.02813434267227e-07 0.8909571971396437 6.028145773086277e-07 0.8918770673440963 \
6.028147072981167e-07 0.8919774876506176 6.028160589233886e-07 0.8929731820841386 6.028162092835701e-07 0.89307657739048 6.028176899161688e-07 0.8939986636922405 \
6.028179288179339e-07 0.8941315911431026 6.028196933116327e-07 0.894999985510941 6.02820000994978e-07 0.8951330875684044 6.028225222661808e-07 0.8960612226716312 \
6.028229593174219e-07 0.8961978289811912 6.028268627296431e-07 0.8971619289239613 6.028271095114498e-07 0.8972094058147089 6.028346860012845e-07 0.8981998139535015 \
6.028348019130313e-07 0.8982099955090975 6.028539004457352e-07 0.8992062631372056 6.028542978885091e-07 0.8992194728667773 6.030047133235902e-07 0.9002121614362558 \
6.03004979381947e-07 0.9002436812458944 6.030102475320152e-07 0.8993470931706574 6.030104539029324e-07 0.899191170936528 6.030119320157425e-07 0.8982046351054961 \
6.030121124663985e-07 0.8981003355419954 6.030143349480612e-07 0.8971299612768925 6.030145410405756e-07 0.897079983173831 6.030249493066813e-07 0.8980580240048047 \
6.03025087164257e-07 0.8980839755683444 6.030318845132984e-07 0.8990685088718567 6.030320700847658e-07 0.8990874390200084 6.035282992589679e-07 0.9000706848616691 \
6.035283590548139e-07 0.9000975977971888 6.035296126054321e-07 0.9010828413531861 6.035297182980354e-07 0.9012097231395001 6.035303764287524e-07 0.9021613947651476 \
6.035305136110213e-07 0.9023918767045529 6.035310366376408e-07 0.9033649777562528 6.035310995012334e-07 0.9034908765919824 6.035315720967825e-07 0.904476514442582 \
6.035316234105955e-07 0.9045863669199017 6.035320893739313e-07 0.9055619780118375 6.035321215783922e-07 0.9056252631670594 6.035328386771295e-07 0.9066212416280413 \
6.035329231134019e-07 0.9066528951765993 6.035335231797813e-07 0.9059679814895146 6.035336430373927e-07 0.9055903401525059 6.03533774200172e-07 0.9050640446667092 \
6.035339090199249e-07 0.9043926011431642 6.035340571549842e-07 0.9034897747335404 6.035341947143354e-07 0.902493211317788 6.035343349260954e-07 0.9013135799985507 \
6.035344335882047e-07 0.9003872218501816 6.03534519272014e-07 0.8995148096066522 6.035346018362133e-07 0.8986166894493001 6.035347166188419e-07 0.8972773101170661 \
6.03534797717086e-07 0.8962642459447687 6.03534877134364e-07 0.8952218112132616 6.035349825888917e-07 0.8937633947192651 6.035351052301954e-07 0.8919606744930825 \
6.035352049542743e-07 0.890414036797163 6.035353751486853e-07 0.8876203405523397 6.035355213337766e-07 0.8850727273800474 6.035356895519253e-07 0.8819879035815887 \
6.035358617130214e-07 0.8786780617039783 6.035360460991142e-07 0.8749807502679057 6.035362306654577e-07 0.8711418063496947 6.035364149129437e-07 0.8671917613865908 \
6.035366002486073e-07 0.8631174608718694 6.035367746363354e-07 0.8592060069639053 6.035369573402717e-07 0.8550405244181323 6.035371326873658e-07 0.8509893565349284 \
6.035373150168772e-07 0.8467313026054767 6.035375053303062e-07 0.8422468264612591 6.035376756604352e-07 0.838204894125699 6.035378421840737e-07 0.8342320488410089 \
6.035380047549371e-07 0.830337741667393 6.035381546161599e-07 0.8267359097041467 6.03538305792179e-07 0.8230937075736249 6.035384949376529e-07 0.8185270080344306 \
6.035386406557074e-07 0.8150026134285653 6.035388156466743e-07 0.8107652770601156 6.035389641182174e-07 0.807166938184282 6.035391360056827e-07 0.8029987283123258 \
6.035393050739222e-07 0.7988973224349885 6.035394692526315e-07 0.7949140139776875 6.035396285801686e-07 0.7910485911592836 6.035397890297762e-07 0.7871568543472617 \
6.035399908491573e-07 0.7822630953020117 6.035401392968917e-07 0.7786646206504594 6.03540293464276e-07 0.77492821376164 6.035404305476362e-07 0.7716074476660475 \
6.035405399330824e-07 0.7689587163513494 6.035406458665383e-07 0.7663946531324515 6.035407728808854e-07 0.7633217481666642 6.035408872438541e-07 0.7605561828888391 \
6.035409900916761e-07 0.7580702160470256 6.035411116819926e-07 0.7551325442760125 6.035412224592672e-07 0.7524575925939972 6.035413393080924e-07 0.7496376180588871 \
6.035414500928178e-07 0.7469652567786068 6.035415684589191e-07 0.7441116745915923 6.035416932860144e-07 0.7411038668912771 6.035418458478099e-07 0.7374292753756717 \
6.035419797447979e-07 0.7342062928952946 6.035421007762374e-07 0.7312947572377408 6.035422649737523e-07 0.7273475399259534 6.035424423346988e-07 0.7230877912371642 \
6.035426245451075e-07 0.7187161681757385 6.035428055423725e-07 0.7143786395952922 6.035429862063157e-07 0.7100537072471783 6.035431763578828e-07 0.7055071781827296 \
6.035433641177769e-07 0.7010230964996226 6.035435646508815e-07 0.696237807975249 6.035437733363431e-07 0.6912646166759551 6.035439809799077e-07 0.6863227581165517 \
6.03544208547776e-07 0.6809140411171237 6.035444008226102e-07 0.6763521085712711 6.035446380878582e-07 0.6707310800019505 6.035448313661221e-07 0.6661595641347996 \
6.035450640988686e-07 0.6606646229758047 6.035452696563363e-07 0.6558174602470968 6.035455020097575e-07 0.6503484594495911 6.035456970117276e-07 0.6457674053103037 \
6.035459002403362e-07 0.6410004262200759 6.035460800928814e-07 0.6367906205544323 6.035462591993118e-07 0.6326052789263827 6.035464225765257e-07 0.628795088826817 \
6.035465946259304e-07 0.6247880828503264 6.035467581187693e-07 0.6209892715878097 6.035469339085876e-07 0.6169100951581823 6.035471158475732e-07 0.6126978430086294 \
6.035473043313055e-07 0.6083422542008314 6.035475107637274e-07 0.6035858951323969 6.035476900783897e-07 0.5994633272559844 6.035478872572566e-07 0.5949432360761027 \
6.035480963453974e-07 0.5901646611556908 6.035483020946604e-07 0.5854760387944159 6.035485426053479e-07 0.5800160304866983 6.035487157334496e-07 0.5760958285528379 \
6.035488806274518e-07 0.5723746772837877 6.035490614880267e-07 0.5683014035092815 6.035492187741233e-07 0.5647722902613652 6.035493877569178e-07 0.5609879409349005 \
6.035495678633789e-07 0.5569709657351898 6.03549720846506e-07 0.5535669615732179 6.035498525609507e-07 0.5506462283231492 6.035499999486508e-07 0.5473865746199473 \
6.035500873742421e-07 0.5454560063082221 6.035501722454816e-07 0.5435860258811447 6.035502708746939e-07 0.5414171943998213 6.035503429668553e-07 0.5398340751058975 \
6.035504400578744e-07 0.5377039800781129 6.035505256482576e-07 0.5358302678688993 6.035505907291341e-07 0.5344081412607664 6.035507143295019e-07 0.5317121235594142 \
6.035508087537724e-07 0.52965475734789 6.035509062769941e-07 0.5275349985745696 6.035510791376451e-07 0.5237893654184622 6.035512141331662e-07 0.5208709659121862 \
6.035513683166277e-07 0.5175498113398643 6.03551542781984e-07 0.5138002600288881 6.035516945879704e-07 0.510550000123414 6.03551840818953e-07 0.5074290310664136 \
6.03551984717826e-07 0.5043644611166801 6.035521277396695e-07 0.5013276181140283 6.035522233495175e-07 0.499301733014788 6.035523177934733e-07 0.4973032961550828 \
6.03552438849414e-07 0.4947494705229025 6.035525337277098e-07 0.4927525559781179 6.035526495585533e-07 0.4903172469328811 6.035527368224019e-07 0.4884854516151125 \
6.035528192528481e-07 0.4867593351188191 6.035529146608015e-07 0.484765406725184 6.035530153710815e-07 0.4826639978995959 6.035531122314731e-07 0.4806459052877932 \
6.035532509612246e-07 0.4777646955734051 6.035533866660861e-07 0.4749532752442271 6.035535871508094e-07 0.4708139964547478 6.035538024649621e-07 0.4663911383470885 \
6.03553984040267e-07 0.462674698484628 6.035541830122363e-07 0.4586189944293299 6.035543535777573e-07 0.455154096457448 6.035545279314447e-07 0.4516251957269069 \
6.035546968646987e-07 0.4482170126441485 6.035548694618603e-07 0.4447467276163349 6.035550520681902e-07 0.4410867902598327 6.035552406170554e-07 0.4373240875354826 \
6.035554340845929e-07 0.4334777823509549 6.035556424052317e-07 0.4293535036700135 6.035558567504624e-07 0.4251286740881063 6.035560824557922e-07 0.4207018662297695 \
6.035563089991604e-07 0.4162771402745992 6.035565711759108e-07 0.4111844468197049 6.035568202097347e-07 0.4063709766754009 6.035571213084326e-07 0.4005865607947761 \
6.035574107292502e-07 0.3950673729298416 6.03557718243529e-07 0.3892455819062323 6.035580404399244e-07 0.3831936848847286 6.035583681704071e-07 0.3770882112794804 \
6.035587006001628e-07 0.3709500980558715 6.035590303291706e-07 0.3649083177186754 6.035593515587582e-07 0.3590729273462687 6.03559682375082e-07 0.3531219177045733 \
6.035600247306453e-07 0.3470224718704957 6.035603243716774e-07 0.3417374346434491 6.035606541592421e-07 0.3359723367088904 6.035609810531851e-07 0.3303128110141857 \
6.03561319032532e-07 0.3245206193888226 6.035616280036957e-07 0.3192755432624759 6.035619528016686e-07 0.31382336954194 6.035622684318663e-07 0.3085864885517507 \
6.035625734190322e-07 0.3035810258414895 6.035628287576776e-07 0.2994330834535801 6.035630936208339e-07 0.295170851203172 6.035633807035186e-07 0.2905978071194348 \
6.035636036732975e-07 0.2870801635277143 6.035638032125665e-07 0.2839591363066187 6.035640128685797e-07 0.2807045410859125 6.035641931251209e-07 0.2779290029372279 \
6.035643554698416e-07 0.2754463208250681 6.035645059048155e-07 0.2731629026725527 6.035646569101241e-07 0.2708866524077067 6.035648538007149e-07 0.2679392949564011 \
6.035649849454786e-07 0.2659970646012914 6.035651096820175e-07 0.2641561221543183 6.035652612740599e-07 0.2619266655689588 6.035653572422309e-07 0.2605306204207966 \
6.035654537935995e-07 0.2591282589302421 6.035655784133887e-07 0.2573209601776467 6.035657209899234e-07 0.255257422470362 6.035658799234579e-07 0.25296979123958 \
6.035660125895253e-07 0.251062957019046 6.03566196158294e-07 0.2484301322588876 6.035663773934597e-07 0.2458327969660818 6.035665889075646e-07 0.2428051031600066 \
6.035667914973991e-07 0.2399069804317323 6.035669580538467e-07 0.2375282895552967 6.03567168273059e-07 0.2345337828133105 6.03567341690945e-07 0.2320692345528927 \
6.035675705336728e-07 0.2288260787734411 6.035677911684244e-07 0.2257162440502939 6.035679668301377e-07 0.2232503232699662 6.035681472906433e-07 0.2207258962977968 \
6.035683180470208e-07 0.2183528725291195 6.035684982432871e-07 0.2158619697278009 6.035686649739047e-07 0.2135675266585953 6.035688140953261e-07 0.2115251542210239 \
6.035689699053442e-07 0.2094125291275523 6.035691050857695e-07 0.2075875692769576 6.035692551671966e-07 0.2055694209972212 6.035693876128229e-07 0.2037957203154137 \
6.035695281573595e-07 0.2019220745191926 6.035696452261238e-07 0.2003748851744883 6.035697749337302e-07 0.1986681706274326 6.035698969911991e-07 0.1970700654731777 \
6.035700195346348e-07 0.1954731161836187 6.035701375539584e-07 0.1939418157697267 6.035702725767313e-07 0.1921981789937757 6.035704172011819e-07 0.1903420634523806 \
6.035705455516813e-07 0.1887049708672087 6.03570669186156e-07 0.1871351133418249 6.035707667362788e-07 0.1859021016257166 6.035708818092082e-07 0.1844539912642748 \
6.035709755078878e-07 0.1832809848801438 6.035710742920116e-07 0.1820493959460708 6.035711972265529e-07 0.1805230483556907 6.035712929805559e-07 0.1793400249325384 \
6.035714220681073e-07 0.177753298391591 6.035715245334772e-07 0.1764993061988986 6.035716227869744e-07 0.1753029542432101 6.035717428741866e-07 0.1738483570896001 \
6.035718454234049e-07 0.1726127298531683 6.035719558810641e-07 0.1712877101305652 6.035720843709282e-07 0.1697552709290656 6.035721758557694e-07 0.1686698090598139 \
6.03572280340358e-07 0.1674358120019214 6.035723552770941e-07 0.1665544493622226 6.03572444845591e-07 0.1655049734124585 6.035724954106002e-07 0.164914347906921 \
6.035725453889763e-07 0.1643318187475747 6.035726103580609e-07 0.163576534137217 6.035726458720287e-07 0.1631646263336159 6.035727180712023e-07 0.162329174921529 \
6.035727852002974e-07 0.1615546732967998 6.035728444300317e-07 0.160873195114598 6.035728881756305e-07 0.1603710314414745 6.035729358224586e-07 0.1598254649913795 \
6.03573006202993e-07 0.1590230739426561 6.03573088541159e-07 0.1580883269013631 6.035731667127594e-07 0.1572048664554128 6.035732487657084e-07 0.1562816770844126 \
6.035733414693307e-07 0.1552436243401225 6.035734642494945e-07 0.153877370231325 6.035735633955882e-07 0.1527810927807017 6.035736648959354e-07 0.1516651170047695 \
6.035737661711264e-07 0.1505582666538253 6.035738626629107e-07 0.1495093242781697 6.035739620809455e-07 0.1484346886615803 6.03574046381569e-07 0.1475281828465028 \
6.035741393202594e-07 0.1465342051547719 6.035742219212e-07 0.1456551508734999 6.035743306872851e-07 0.1445034822456445 6.035744363302651e-07 0.1433917535370727 \
6.035745179898545e-07 0.1425365900703354 6.03574611735024e-07 0.1415598856352903 6.035747053029709e-07 0.1405903867550886 6.035747881874616e-07 0.139735765814107 \
6.035748763466362e-07 0.1388313836440244 6.035749561327222e-07 0.1380170907865772 6.035750497281216e-07 0.1370669869522621 6.035751396606458e-07 0.1361590166429519 \
6.035752102110423e-07 0.1354501541392388 6.035752799712188e-07 0.1347521119166949 6.035753941201259e-07 0.1336164586193709 6.035754760987401e-07 0.1328058651355588 \
6.035755637040425e-07 0.1319440719770354 6.035756632052385e-07 0.1309710196939938 6.035757723852409e-07 0.1299110174488692 6.03575874550573e-07 0.1289256009328031 \
6.035759820107789e-07 0.1278959836800649 6.035761020450569e-07 0.1267549558890445 6.035761962530915e-07 0.1258657925752028 6.035763272321949e-07 0.1246390638240933 \
6.035764266598964e-07 0.1237164070883829 6.035765357815822e-07 0.1227104370444639 6.035766446347502e-07 0.1217138859540913 6.035767369441536e-07 0.120874257454373 \
6.035768497844843e-07 0.1198547128626846 6.035769467965243e-07 0.118986084968971 6.035770510628723e-07 0.1180628196869088 6.035771600298026e-07 0.1171053395831002 \
6.035772595693683e-07 0.1162371554254778 6.035773765620782e-07 0.1152245300989246 6.035774636628686e-07 0.1144761644999183 6.0357757295452e-07 0.1135478691973115 \
6.035776544795827e-07 0.1128618460838699 6.035777542545759e-07 0.1120273350449922 6.03577871679726e-07 0.1110526766231405 6.035779734648438e-07 0.1102143708571793 \
6.035780612037922e-07 0.1094962336869811 6.035781420032999e-07 0.1088432886892514 6.035782289543191e-07 0.1081456845520918 6.035783097409447e-07 0.1075007757815706 \
6.035783999475114e-07 0.1067842832273628 6.03578490898266e-07 0.1060655611559195 6.035785795687901e-07 0.1053685613006139 6.035786785836107e-07 0.1045946508745568 \
6.035787722897869e-07 0.1038723470842792 6.035788661490627e-07 0.1031520741219857 6.035789669765109e-07 0.1023817709659086 6.035790716074088e-07 0.1015861061604995 \
6.03579195570165e-07 0.1006484085638475 6.035792929694782e-07 0.09991551135558702 6.035794132274253e-07 0.09901872452754552 6.035795240953005e-07 0.09819831936474602 \
6.035796285683363e-07 0.09742874659471555 6.035797458050451e-07 0.09656937225591002 6.035798475993662e-07 0.09582695326576983 6.035799455749168e-07 0.09511577589263259 \
6.035800860794065e-07 0.09410164141823299 6.035801911572026e-07 0.09334832721827611 6.035802897700187e-07 0.09264549593674179 6.035803824848273e-07 0.09198739948435641 \
6.035804686832123e-07 0.09137785861853052 6.035805625961876e-07 0.09071637432184691 6.035806596969337e-07 0.09003559055802626 6.035807691179881e-07 0.08927317549644689 \
6.035808701015371e-07 0.08857281843916648 6.035809637594832e-07 0.08792605868920525 6.035810379341552e-07 0.08741581771673042 6.03581175834007e-07 0.08647193599618339 \
6.035812481910108e-07 0.08597917321277694 6.035813835122141e-07 0.08506274029062395 6.035814694238194e-07 0.08448410751389913 6.03581614152054e-07 0.08351486081643937 \
6.035817103826189e-07 0.0828744112740944 6.035817982183981e-07 0.08229260392026354 6.035819140173062e-07 0.08152964121883956 6.035820291457576e-07 0.08077575264951149 \
6.035821429121899e-07 0.08003553900012179 6.035822831696828e-07 0.0791300282244784 6.035824245457162e-07 0.07822490276368012 6.035825741817577e-07 0.07727536491519127 \
6.035827186706132e-07 0.07636690312463701 6.035828698447241e-07 0.07542565384097814 6.035830192155436e-07 0.07450459906593411 6.03583168562251e-07 0.0735926433331697 \
6.035833285177668e-07 0.07262574717347114 6.035834846646777e-07 0.07169171823582712 6.035836591531124e-07 0.07065947636250877 6.035838288622191e-07 0.0696671357044583 \
6.035840140413029e-07 0.0685979885997255 6.035842107623799e-07 0.06747763456279594 6.035844212801997e-07 0.06629631776014881 6.03584643312255e-07 0.06507007089066431 \
6.035848735242763e-07 0.0638195278444372 6.035851160353819e-07 0.06252626147401 6.035853766894672e-07 0.06116236403900636 6.035856565885314e-07 0.05972739422233359 \
6.035859501722554e-07 0.05825544847408989 6.035862651082392e-07 0.05671370145268265 6.035866079141644e-07 0.05507846134953124 6.035869573807585e-07 0.0534565727116736 \
6.035873662849151e-07 0.05161746230842366 6.035877129499425e-07 0.05010669351290297 6.035881003649955e-07 0.04846839895323611 6.035884445827877e-07 0.04705645202362623 \
6.035887680090468e-07 0.04576625679949029 6.035890730548091e-07 0.04458093278443617 6.035893659168059e-07 0.04347099288378908 6.035896500577229e-07 0.04242242262004604 \
6.03589926078015e-07 0.04142902112907627 6.03590192930566e-07 0.04049015932812138 6.035904618227892e-07 0.03956531631184226 6.035907378832112e-07 0.03863769040165695 \
6.035910254787821e-07 0.03769451689421055 6.035912650444082e-07 0.03692662498323904 6.03591554211835e-07 0.03602084344675294 6.035917700034379e-07 0.03535960341037672 \
6.035919577204764e-07 0.03479599077274986 6.035921558495825e-07 0.03421285035004928 6.03592518724446e-07 0.03317032497347058 6.035927768662759e-07 0.03244834222605905 \
6.0359308657919e-07 0.0316030971185694 6.035933520493286e-07 0.03089664771451467 6.035936201684081e-07 0.03019941363307669 6.035938990424389e-07 0.02949128999862272 \
6.035941452288756e-07 0.02888043298519722 6.035943758602853e-07 0.02832033800396738 6.035946141502041e-07 0.02775711540944564 6.035948491575684e-07 0.02721270742060762 \
6.03595076940031e-07 0.02669509678424227 6.035954855523029e-07 0.02579039168486155 6.03595661854632e-07 0.02540904040268441 6.03596016332316e-07 0.02465798827491217 \
6.035962002032882e-07 0.02427641469830137 6.035965351520103e-07 0.02359448510613503 6.035966990607275e-07 0.02326678168937357 6.035970913313036e-07 0.02249905491676728 \
6.035972473220689e-07 0.02220010404946675 6.035976789254263e-07 0.02138321689778962 6.035978163148065e-07 0.0211255367654138 6.03598333123589e-07 0.02017559010600388 \
6.035984586594829e-07 0.01995091418019728 6.035989159010076e-07 0.01915998482559782 6.035990750469891e-07 0.01889493739859509 6.035996822854669e-07 0.01793263500095189 \
6.03599816822955e-07 0.01772934138481063 6.036004800869477e-07 0.01678091027541291 6.036006734103788e-07 0.01651856846389665 6.036013410670396e-07 0.01565087920017967 \
6.03601502655887e-07 0.01544858341705342 6.036022578911399e-07 0.01454101846553843 6.036024074521069e-07 0.01436800730673201 6.036032977899311e-07 0.01338293844200974 \
6.036033964478169e-07 0.01327873262558703 6.03604353121314e-07 0.01230993787860994 6.036044742310216e-07 0.01219243157195396 6.036054657237297e-07 0.01126376273051215 \
6.036056292524602e-07 0.01111855113153209 6.036067591745355e-07 0.01018247077230436 6.036068716217739e-07 0.01009565848301377 6.036082494452621e-07 0.009103273453806031 \
6.036083883905334e-07 0.009009747578659758 6.036099427888684e-07 0.008018073335410726 6.0361005485534e-07 0.00794673960805117 6.036116998381698e-07 0.006958154532207958 \
6.036118070906645e-07 0.006899512253112593 6.036137515841525e-07 0.005937533026687714 6.036139584821097e-07 0.005843834961138424 6.036162973698526e-07 0.00487227039639981 \
6.036167213562637e-07 0.004712306502041247 6.036194935894604e-07 0.003780857497341114 6.036199418985521e-07 0.003647790772321777 6.03623582397237e-07 0.00272553831825111 \
6.036240790530716e-07 0.002619503085887757 6.036298301734959e-07 0.001650572925599863 6.036301169553824e-07 0.001609446887446839 6.036354719440668e-07 0.0006353228983793809 \
6.036356773006917e-07 0.0005920420449145349 6.062827120745073e-07 -0.0002718533828215428 6.062828679501106e-07 -0.0004579010352009555 6.062834162652027e-07 -0.001326296959495401 \
6.062835290488787e-07 -0.001543805653187533 6.062839635410184e-07 -0.002491429791030493 6.062840393661749e-07 -0.002673591589873599 6.062843960167732e-07 -0.003590195133438418 \
6.062845230658532e-07 -0.003936807634339821 6.062848015662471e-07 -0.004716444651655622 6.062849096507304e-07 -0.005020876868076652 6.06285253249855e-07 -0.00592430224391268 \
6.062853602437201e-07 -0.006162325733041658 6.062862596141159e-07 -0.005653094509861465 6.062864380475456e-07 -0.004687598829536962 6.062865437709605e-07 -0.003940993102967527 \
6.062866688337378e-07 -0.002883597584075996 6.062867624178337e-07 -0.001971418478057775 6.062868402573964e-07 -0.001132968824455395 6.062869203293945e-07 -0.0001977429743171 \
6.062870427022046e-07 0.001370578777960296 6.062871609580771e-07 0.003041212838230153 6.062872796071872e-07 0.004860750887681821 6.06287393089626e-07 0.006730904986417607 \
6.062874965327644e-07 0.008536402178002854 6.062876111920181e-07 0.01064190690353853 6.062878017758113e-07 0.0143607330143792 6.062879355659492e-07 0.01711819191720031 \
6.062880858195149e-07 0.02033933849841947 6.062882409887625e-07 0.02378599874269359 6.062883963808114e-07 0.0273434151175349 6.062885440880426e-07 0.03080849965087477 \
6.062886930776678e-07 0.03437359286003162 6.062888480687509e-07 0.03814545786868043 6.062890074393647e-07 0.04208062121327779 6.062891723727755e-07 0.04620305710844342 \
6.062893473191045e-07 0.0506208066052034 6.062895264491763e-07 0.05518387280380205 6.062897162384316e-07 0.06005265756871143 6.062899199354002e-07 0.06530840376289772 \
6.062901397459318e-07 0.07100650943730057 6.062903714973765e-07 0.07703584544314998 6.062906193226736e-07 0.08349927754587044 6.062908906436034e-07 0.09058756662233436 \
6.062911853563813e-07 0.09829181712822582 6.062915106140293e-07 0.106792896697727 6.062918768597348e-07 0.1163551101154179 6.062922701564477e-07 0.1266079356677421 \
6.062927228093435e-07 0.1383809089651769 6.062932485245107e-07 0.1520098384503803 6.06293867738049e-07 0.1679979965193872 6.062945484823656e-07 0.1854865650013753 \
6.062953421573203e-07 0.2057488551561759 6.062962309229534e-07 0.2282732214494322 6.062970443122153e-07 0.2487218262351868 6.062977660617924e-07 0.2667261628598245 \
6.062984017258004e-07 0.282460740414376 6.062989734425617e-07 0.2965101025186013 6.062995089968458e-07 0.3095696210007924 6.063000123552588e-07 0.3217495654069301 \
6.063004886827015e-07 0.3331878525640654 6.063009626063057e-07 0.3444754071334732 6.063014200780245e-07 0.3552759747331513 6.06301886058294e-07 0.3661792384270033 \
6.063023350461038e-07 0.376592601923634 6.063028311526457e-07 0.3879857357798637 6.063033509145081e-07 0.3998002499051578 6.063037303191525e-07 0.4083447473225827 \
6.063041703278757e-07 0.4181679450526055 6.063046400968136e-07 0.4285466970600206 6.063051256177522e-07 0.4391589006481625 6.063055650658585e-07 0.4486701556983262 \
6.063056268188068e-07 0.4500002248264944 6.063057503247038e-07 0.4526540461147197 6.063059973364976e-07 0.4579447795386873 6.063062499314088e-07 0.463325462421476 \
6.063064475025243e-07 0.467511453725808 6.063066730742714e-07 0.4722681264242033 6.06306994642268e-07 0.4790073975813253 6.063072634214966e-07 0.4846013351959894 \
6.0630748207297e-07 0.4891262574467725 6.063076921769364e-07 0.4934547887280634 6.063079185824616e-07 0.4980921872304203 6.063081276876522e-07 0.5023516957637455 \
6.063083170899107e-07 0.5061927337048852 6.06308441251129e-07 0.5086969563931187 6.063085680062259e-07 0.5112441466129884 6.06308728004704e-07 0.5144514110933732 \
6.063089756476561e-07 0.5193914248715521 6.063091542341148e-07 0.5229351592435862 6.063093251876918e-07 0.5263079149198099 6.063095865372878e-07 0.5314455197962068 \
6.063098126088702e-07 0.5358634945234868 6.063100157405374e-07 0.5398188128751134 6.063101809712675e-07 0.5430252218652345 6.063103377582878e-07 0.5460612552756139 \
6.063105269149053e-07 0.5497137532216215 6.063107287826584e-07 0.5535976061995346 6.06310952933981e-07 0.5578986282275192 6.063111913163461e-07 0.5624617013850463 \
6.06311426077985e-07 0.566941985223824 6.063116563486904e-07 0.5713275351537204 6.063118621413239e-07 0.5752375533958141 6.063120671255381e-07 0.5791255875933676 \
6.063123099407797e-07 0.5837094709690289 6.063125646983618e-07 0.588493349632063 6.063127929267932e-07 0.5927514274590796 6.063130307656651e-07 0.5971656109489694 \
6.063132430431007e-07 0.6010807441713891 6.063134548365055e-07 0.6049674646600495 6.06313708720774e-07 0.6095919957414236 6.063139133143013e-07 0.6132953190650409 \
6.063141650376543e-07 0.6178178328453598 6.063143528271744e-07 0.6211736970442716 6.063146057002513e-07 0.6256587164710262 6.063148041096133e-07 0.6291560967673944 \
6.06314983842284e-07 0.6323071487074056 6.063152541130913e-07 0.6370161336915187 6.063154713968567e-07 0.6407803561788556 6.063156519232363e-07 0.6438916924996977 \
6.063158530841307e-07 0.6473460740030906 6.063160216675126e-07 0.650231451944099 6.063162260257197e-07 0.6537144072723954 6.063163716887783e-07 0.6561873372238678 \
6.063165362473771e-07 0.6589728476742622 6.063167057165934e-07 0.6618316558839334 6.063168592566751e-07 0.664412775690417 6.06317000490202e-07 0.6667750288922751 \
6.063171440660136e-07 0.6691685747430841 6.063172772961389e-07 0.6713840140331436 6.063174191964593e-07 0.6737368819239464 6.063175394300862e-07 0.6757233098298149 \
6.063176840811384e-07 0.6781085120392751 6.063178002998435e-07 0.6800197521569988 6.063179193821632e-07 0.6819757159594566 6.063180179604767e-07 0.6835903813535821 \
6.063181355581833e-07 0.6855122399681081 6.063182229941461e-07 0.6869376986921233 6.063183477402322e-07 0.6889650632873403 6.063184475472963e-07 0.6905825000046129 \
6.063185400370926e-07 0.6920753042469043 6.063186413211772e-07 0.6937043390836264 6.063187391142832e-07 0.695273833970533 6.063188303850746e-07 0.6967333967490603 \
6.063189328429049e-07 0.6983656370917724 6.063190657521355e-07 0.7004728611232253 6.063192207675414e-07 0.7029137789397926 6.063193556492269e-07 0.7050222373350452 \
6.063195011450183e-07 0.7072806469370021 6.063196289996853e-07 0.709252249158637 6.063197534579805e-07 0.7111597484283609 6.063198647836849e-07 0.7128563623504806 \
6.063199788137126e-07 0.7145852226468989 6.063200793249296e-07 0.7161013069709498 6.063202165260769e-07 0.7181590832501857 6.063203364719788e-07 0.7199473375636642 \
6.06320455641778e-07 0.7217141075019444 6.063205825867916e-07 0.7235855504531626 6.063207073542093e-07 0.7254141264975077 6.063208308495973e-07 0.7272133847865295 \
6.063209576308702e-07 0.7290498056238117 6.063210882203554e-07 0.730930225429108 6.063212104322583e-07 0.7326797786847141 6.063213474902716e-07 0.7346298644824388 \
6.063214487056265e-07 0.7360619656663578 6.063215536745619e-07 0.7375401619041119 6.06321645165995e-07 0.7388229997694907 6.06321758241356e-07 0.7404001534680551 \
6.063218455422403e-07 0.7416107338190071 6.063219500055705e-07 0.7430512000342341 6.063220807687029e-07 0.7448411286358657 6.063221906822003e-07 0.7463352048609909 \
6.063222953419585e-07 0.7477488743938407 6.0632241917362e-07 0.7494094725133206 6.063225679269713e-07 0.751387874302702 6.06322689842132e-07 0.7529958494242643 \
6.063228036963924e-07 0.7544867042370438 6.063229441958499e-07 0.7563117925204224 6.063230855193645e-07 0.7581313010100689 6.063232032989715e-07 0.7596352654099263 \
6.063233316974594e-07 0.7612620174900669 6.063234740211609e-07 0.7630496612437514 6.063235904103157e-07 0.7644991888858087 6.063237361339775e-07 0.7662987831554334 \
6.063238579138671e-07 0.7677897310961733 6.06323976478797e-07 0.7692300520321635 6.063240990922458e-07 0.7707078417740018 6.063242255436292e-07 0.77221964326554 \
6.06324335666584e-07 0.7735261258099556 6.063244611887263e-07 0.7750039859681491 6.06324566849672e-07 0.7762386743660952 6.063247020268293e-07 0.7778058706872942 \
6.063248256373457e-07 0.7792267957652825 6.06324955634725e-07 0.7807078764205345 6.06325068606223e-07 0.7819831642610904 6.063251765001111e-07 0.7831908181350914 \
6.063253130307933e-07 0.7847046126527283 6.063254631517019e-07 0.7863508260127218 6.063256054160057e-07 0.7878933964149381 6.063257249975189e-07 0.7891771019825847 \
6.063258618086489e-07 0.7906313890246753 6.063259843124129e-07 0.7919206245676671 6.063261289843411e-07 0.7934276941869095 6.063262697694143e-07 0.794878360380241 \
6.063263965852094e-07 0.796171745508174 6.063265156326018e-07 0.7973744708066829 6.063266278955628e-07 0.7984986270115709 6.063267322833333e-07 0.7995352562746869 \
6.063268275603949e-07 0.8004739840425704 6.063269639028913e-07 0.8018044219089175 6.063270807679598e-07 0.8029326473252685 6.063272003644895e-07 0.8040757482679398 \
6.063273222502993e-07 0.8052288531124292 6.063274448385593e-07 0.8063765489401953 6.06327572579618e-07 0.8075599074701925 6.06327697362526e-07 0.8087035441861687 \
6.063278278629006e-07 0.8098867241643505 6.063279542295968e-07 0.8110199871086299 6.06328081578389e-07 0.8121498004723215 6.063281867911793e-07 0.8130740322933268 \
6.063282914951838e-07 0.8139855427426806 6.063283830253901e-07 0.8147757515715357 6.063285063983601e-07 0.8158311616195392 6.063285933524084e-07 0.8165684017534872 \
6.063286922082447e-07 0.8173999442793862 6.063288367108844e-07 0.8186029267949408 6.063289730365725e-07 0.8197243345631372 6.063290824450085e-07 0.8206145128367788 \
6.06329228461948e-07 0.821788834531623 6.063293802030074e-07 0.8229927727264784 6.063295061195854e-07 0.8239792970156907 6.063296505686489e-07 0.8250971468990039 \
6.063297752648172e-07 0.8260503472050121 6.063299258788342e-07 0.8271873005969326 6.063300612493022e-07 0.8281959289694237 6.063301864729373e-07 0.8291179217777711 \
6.063303041288969e-07 0.8299746468143927 6.063304499105104e-07 0.8310230722388168 6.063306163942599e-07 0.8322027532553667 6.063307472150236e-07 0.8331167337813133 \
6.063309206750455e-07 0.834311196379941 6.063310887878414e-07 0.8354501125721271 6.063312586689692e-07 0.8365827385393307 6.063314395126276e-07 0.8377685497174457 \
6.063315827046921e-07 0.8386931238161603 6.063316968221893e-07 0.8394210074154138 6.063318268737995e-07 0.8402408682651782 6.063319287535162e-07 0.8408758513273116 \
6.063320456411388e-07 0.841596551294542 6.063321827868591e-07 0.8424315815669623 6.063323806960721e-07 0.8436167827761205 6.063325725154114e-07 0.8447436440637145 \
6.063327818661576e-07 0.8459494874145237 6.06332964017768e-07 0.8469786287449077 6.063331611039906e-07 0.8480715276019779 6.063333343567188e-07 0.8490148531186206 \
6.063335174509634e-07 0.8499943787178993 6.063336885824298e-07 0.8508936588199895 6.063338632702718e-07 0.8517955326875627 6.063340385042872e-07 0.8526841769874772 \
6.063342146411542e-07 0.8535614892404448 6.063344050084938e-07 0.8544920815553035 6.063345955808446e-07 0.8554057038167108 6.063347959768378e-07 0.8563474066245403 \
6.063349885664634e-07 0.8572344253714166 6.06335199466375e-07 0.858185963363946 6.063354273418618e-07 0.8591913103610016 6.063356934247181e-07 0.8603357477151101 \
6.063359919268544e-07 0.8615822374427254 6.063362678163234e-07 0.8627000332972231 6.063365520834927e-07 0.8638181192989086 6.063368262214432e-07 0.8648650323418529 \
6.06337098522366e-07 0.8658754039994767 6.063373686785625e-07 0.8668495780678541 6.063376258626989e-07 0.8677515347235455 6.063378984216134e-07 0.8686810999091764 \
6.063381744693315e-07 0.8695957110915412 6.063384445895985e-07 0.8704649939918846 6.063387444494889e-07 0.8714007440816277 6.063391154301144e-07 0.8725171209518352 \
6.063394103525362e-07 0.8733732402027278 6.063396646282709e-07 0.8740897163373675 6.06339962841735e-07 0.8749052413925265 6.063402364113466e-07 0.8756305047096297 \
6.063404725347486e-07 0.8762394088953867 6.063407128598864e-07 0.8768433401198644 6.063409351938211e-07 0.8773882060838187 6.063411292002539e-07 0.8778530214284207 \
6.063414589096812e-07 0.8786208714695904 6.063416140810901e-07 0.87897283049042 6.063419317234906e-07 0.8796750328643211 6.063421106040349e-07 0.8800599154915705 \
6.063424530647979e-07 0.8807759898408113 6.063426372672098e-07 0.8811501695110489 6.063431122965131e-07 0.8820806183873429 6.06343279683462e-07 0.8823969901232691 \
6.063437454598435e-07 0.8832471741583867 6.063439262991872e-07 0.8835657112976044 6.063444203088052e-07 0.8844044135654346 6.063445616237109e-07 0.8846360992458032 \
6.063451678673266e-07 0.8855901496945974 6.063453199425257e-07 0.8858196526512701 6.063459666625989e-07 0.8867549368993356 6.063460949492666e-07 0.8869330782847171 \
6.063467431586864e-07 0.8877977435561634 6.06346872882985e-07 0.8879638504720397 6.063476413020527e-07 0.8888993076310558 6.063477710739033e-07 0.8890488273083775 \
6.063486247365088e-07 0.8899738047157748 6.063487677615613e-07 0.8901192131187072 6.063497540670479e-07 0.8910487927319016 6.063499755535999e-07 0.8912403904783051 \
6.063511183781384e-07 0.8921548233216382 6.063512482580762e-07 0.8922544308366913 6.063526007584981e-07 0.8932425879319322 6.063527510414313e-07 0.8933452769452155 \
6.063542315756977e-07 0.8942627870546499 6.063544704854918e-07 0.8943950258099049 6.063562525184327e-07 0.8952625983306248 6.063566382658602e-07 0.895426813549116 \
6.063590404240788e-07 0.8963023915260389 6.063595153600486e-07 0.8964490046842035 6.063634332871647e-07 0.8974035634625627 6.063639032474093e-07 0.8974927205890085 \
6.063722720353867e-07 0.8984807567386782 6.063724925457144e-07 0.8984960697096243 6.064170720742926e-07 0.8994905034760702 6.064182734601916e-07 0.8995076493514624 \
6.065540832686942e-07 0.9004821828323031 6.065542622454192e-07 0.9005421539807538 6.065577071203374e-07 0.8996085030263692 6.065578799041918e-07 0.8994755022453073 \
6.065592062238996e-07 0.8985168769831137 6.06559392989208e-07 0.8983970610744239 6.065611771942332e-07 0.8974304740967198 6.065613893245152e-07 0.8973403978332656 \
6.065747300202991e-07 0.8983331062395279 6.065748433081446e-07 0.8983517458922662 6.065835466612414e-07 0.8993273409280406 6.0658409447182e-07 0.8993637478389299 \
6.070766218437148e-07 0.9003542216796759 6.070767175825666e-07 0.9004233209197793 6.070776601319424e-07 0.9014023545001312 6.070778225852538e-07 0.9016297223302431 \
6.070783892915005e-07 0.9025464066367429 6.070784964622121e-07 0.9027401250447874 6.070788897705639e-07 0.9035002370985188 6.07079022567928e-07 0.9037710185404622 \
6.070794021690344e-07 0.9045728679206633 6.070795323837805e-07 0.9048512534150681 6.070799937900729e-07 0.9057878278182891 6.070801130371311e-07 0.9060008176934132 \
6.070815426461655e-07 0.9050557440230738 6.070816263162926e-07 0.9046580283931719 6.07081751622122e-07 0.9039622140338933 6.070818594362906e-07 0.9032622438705011 \
6.070819784306371e-07 0.9023800387125585 6.070820938028541e-07 0.9014106868475621 6.070821838997508e-07 0.900578017289966 6.070822953474548e-07 0.8994526603282017 \
6.070823814266029e-07 0.8985125975436928 6.070824873922515e-07 0.8972736935213672 6.070825871606176e-07 0.8960214106762436 6.070826681562277e-07 0.8949470092681954 \
6.070827778041954e-07 0.8934133399212493 6.070828633916056e-07 0.8921520042367302 6.070829555142148e-07 0.8907345325087322 6.07083043733598e-07 0.8893220116766375 \
6.070831525083507e-07 0.8875100775672261 6.070832354013856e-07 0.8860780350921965 6.070833439750574e-07 0.8841400608632336 6.070834362012525e-07 0.8824412727986957 \
6.070835208217502e-07 0.8808423775446282 6.0708360666218e-07 0.8791839877465467 6.070836858770599e-07 0.8776224824828824 6.070837619650304e-07 0.8760960492665846 \
6.070838543013987e-07 0.874210837196514 6.070839141777347e-07 0.8729702140710593 6.070839715660191e-07 0.8717685933706794 6.070840335611921e-07 0.8704574090763495 \
6.070840968400434e-07 0.8691057216070059 6.07084146911381e-07 0.8680269866686803 6.070841963535335e-07 0.8669542389500936 6.070842600232402e-07 0.8655623656543436 \
6.070843359706592e-07 0.8638877358586781 6.070843848016709e-07 0.8628032002737418 6.070844333256242e-07 0.8617197496806845 6.07084509037347e-07 0.8600184098866027 \
6.070845762461247e-07 0.8584975010852487 6.070846189526311e-07 0.8575263577286506 6.070846628552044e-07 0.8565244243916033 6.070847506603508e-07 0.8545103166059256 \
6.070848135135196e-07 0.8530605771626394 6.070848721831767e-07 0.8517018597088126 6.070849083617784e-07 0.8508614974547222 6.070849431802581e-07 0.8500510151036469 \
6.070849782062432e-07 0.8492340038666518 6.070850482582133e-07 0.8475953578585981 6.07085096728698e-07 0.8464581214772323 6.070851406734992e-07 0.8454248116355969 \
6.070851861912554e-07 0.8443523575543517 6.070852500921663e-07 0.8428433081697474 6.070853162185396e-07 0.8412777165526386 6.07085421348608e-07 0.8387809254526315 \
6.070855092832832e-07 0.8366857089760468 6.070855882285649e-07 0.834800137446173 6.070856763936022e-07 0.8326899670047023 6.070857632095988e-07 0.8306078985741704 \
6.070858511012832e-07 0.8284959280419055 6.070859423503732e-07 0.8262996967350639 6.070860451122409e-07 0.8238226494465998 6.070861436157165e-07 0.8214450402687625 \
6.070862559486315e-07 0.8187302447322098 6.070863689227678e-07 0.8159967029774419 6.070864902106627e-07 0.8130591602364435 6.070866207178166e-07 0.8098958628758253 \
6.070867497637196e-07 0.8067658935936169 6.070869032393198e-07 0.8030416153605923 6.070870685235404e-07 0.799029304640783 6.070872362647446e-07 0.7949567682299736 \
6.070874327883338e-07 0.7901857478752816 6.07087637550659e-07 0.7852160332972318 6.070878502277153e-07 0.7800563994093253 6.070880508476619e-07 0.7751902022758907 \
6.070882517063895e-07 0.7703212856706637 6.070884017284074e-07 0.766686939713112 6.070885322635739e-07 0.7635264252913375 6.070886666810141e-07 0.7602735436595947 \
6.070887728765445e-07 0.7577048602246427 6.070889061828773e-07 0.754482067181252 6.070890132158029e-07 0.7518959494812111 6.070891562917044e-07 0.7484409822837247 \
6.070893207978459e-07 0.7444713482725677 6.070894416150925e-07 0.74155777711076 6.070896127217564e-07 0.7374334100931738 6.070897736123088e-07 0.733558046396253 \
6.070899902049297e-07 0.7283457217000903 6.070901834606309e-07 0.7236999380850822 6.07090362395765e-07 0.7194029726762079 6.070905292123874e-07 0.7154015770462002 \
6.070907154183522e-07 0.7109395231330657 6.070909033515934e-07 0.7064416825495208 6.070910692736986e-07 0.7024749886985119 6.07091261631787e-07 0.6978803202016938 \
6.07091402988682e-07 0.6945068232011449 6.070915599964439e-07 0.6907636199298515 6.070917559760889e-07 0.6860965106368763 6.070919184101942e-07 0.6822325558671515 \
6.070920795863762e-07 0.6784034260021697 6.070922718945738e-07 0.6738409413562468 6.070924895564538e-07 0.6686845685784016 6.070927375777557e-07 0.6628199086538362 \
6.07092915635219e-07 0.6586162961343578 6.070931641790282e-07 0.6527567611811057 6.070933667862709e-07 0.6479896840619462 6.07093536596938e-07 0.6440011601507294 \
6.070936952131239e-07 0.6402799599229552 6.070938337435587e-07 0.637035894415233 6.070939699513215e-07 0.6338503464729111 6.070940962626978e-07 0.6309003762865483 \
6.070942257219331e-07 0.6278810604265532 6.070943540536725e-07 0.6248911458464299 6.070944853836027e-07 0.6218374290191309 6.070946174102147e-07 0.6187713222160208 \
6.070947615700951e-07 0.6154276788919771 6.07094905778687e-07 0.6120888358645944 6.070950534337911e-07 0.6086753592300279 6.070952004901491e-07 0.6052842859263143 \
6.070953583041756e-07 0.6016504852589418 6.070954909098278e-07 0.5986039825107707 6.070956223747947e-07 0.5955897059985247 6.070957418045935e-07 0.5928552647156846 \
6.070958778732863e-07 0.5897484304797134 6.070959928015483e-07 0.5871283594046445 6.070961439122688e-07 0.5836892419704927 6.070962585613367e-07 0.5810871834776226 \
6.070963764990063e-07 0.5784138884735546 6.070964662802944e-07 0.576381560286313 6.070965565996887e-07 0.5743415774978985 6.070966232905592e-07 0.5728373329037385 \
6.070966888523724e-07 0.5713590910263378 6.070967398944957e-07 0.5702089751121119 6.070968015962151e-07 0.5688198806440578 6.070968646860707e-07 0.5674025889664359 \
6.070969290444246e-07 0.5659586381304559 6.070969824382235e-07 0.5647616504486359 6.070970750808062e-07 0.5626864159088959 6.070971516880784e-07 0.5609719030357503 \
6.070972075131406e-07 0.5597256439368602 6.070972765672667e-07 0.5581857825097393 6.070973834553926e-07 0.5558054549196561 6.070974611990176e-07 0.5540764009223496 \
6.070975620491173e-07 0.5518382286767042 6.070976877299716e-07 0.5490568313009737 6.070977879716568e-07 0.5468419758621708 6.070978998893402e-07 0.5443739014182352 \
6.070980031552469e-07 0.5421024366463116 6.070981229045887e-07 0.5394737463112931 6.070982246374689e-07 0.5372436950013484 6.070983401572132e-07 0.5347185748314579 \
6.070984551922987e-07 0.5322102907975605 6.07098581673211e-07 0.529456475824718 6.070987070470086e-07 0.5267350629320526 6.070988538629319e-07 0.5235577714138258 \
6.070989894263806e-07 0.5206304261698983 6.070991471246342e-07 0.5172373565578411 6.070993094436886e-07 0.5137528589513558 6.070994902675846e-07 0.5098871206809381 \
6.070996827159054e-07 0.5057874350093188 6.070998956212086e-07 0.5012700264709963 6.071001278026081e-07 0.4963634062180514 6.071003850931866e-07 0.4909555076455908 \
6.071006247190101e-07 0.4859407514401474 6.071009264344461e-07 0.479662588092526 6.071012143537997e-07 0.4737079198104491 6.071015272426188e-07 0.4672821326282255 \
6.071018469808238e-07 0.4607585360408045 6.071021865759847e-07 0.4538766993710576 6.071025134784829e-07 0.4472977926730654 6.071028490368641e-07 0.4405887635920606 \
6.071031661327867e-07 0.4342949501181722 6.071035003705415e-07 0.4277061431972559 6.071038518016635e-07 0.4208322784122511 6.071041663278176e-07 0.4147233751108969 \
6.071044895053079e-07 0.4084912998479469 6.071049306200656e-07 0.400057814108821 6.071052727361034e-07 0.3935812134363078 6.071055726806328e-07 0.3879522399691127 \
6.071059478116385e-07 0.3809760137481454 6.071062775558776e-07 0.3749002425561211 6.071065607988036e-07 0.3697269896098562 6.071068609450588e-07 0.3642865787664632 \
6.071071405472531e-07 0.3592589179584539 6.071073643233647e-07 0.3552676761685443 6.071075761036954e-07 0.3515151294490645 6.071077785371594e-07 0.3479514629380864 \
6.071079796284271e-07 0.3444362246481504 6.071081853428453e-07 0.3408632458568372 6.071084529657171e-07 0.3362478643926977 6.071086918970112e-07 0.3321601360780691 \
6.071089254030739e-07 0.3281974319442653 6.071091388684736e-07 0.3246000376975314 6.071093602460465e-07 0.3208952602338652 6.071095602096931e-07 0.3175728982722026 \
6.07109764482006e-07 0.3142073831356898 6.071099618288778e-07 0.3109812293225088 6.071101472014048e-07 0.3079732989686547 6.071103433077958e-07 0.3048147723336881 \
6.071105455849362e-07 0.3015820927993307 6.071107212432327e-07 0.2988007390096292 6.0711090711339e-07 0.295878328903569 6.071111140927825e-07 0.2926488196724605 \
6.071112994143739e-07 0.2897857719971084 6.071114946411816e-07 0.2867989994419413 6.07111650415531e-07 0.28443329608414 6.071118291723129e-07 0.2817356906084737 \
6.071120102032329e-07 0.2790344478478936 6.071121601003467e-07 0.2768142575519123 6.071123611437743e-07 0.273859574769726 6.071125102589039e-07 0.2716833853889438 \
6.071126487983334e-07 0.2696726034832688 6.071128006734089e-07 0.2674956304896134 6.071129151475376e-07 0.2658586287383957 6.071130466774683e-07 0.2639823142040156 \
6.071131724359562e-07 0.2622048582339201 6.071132767763623e-07 0.2607341604582348 6.071133897557217e-07 0.2591418073851619 6.071135060842464e-07 0.2575033437579446 \
6.071136490116675e-07 0.2554974228347739 6.071137622731725e-07 0.2539102348881249 6.071138964299053e-07 0.2520298733123076 6.071140069027097e-07 0.2504818583075984 \
6.071141623352846e-07 0.2483006006477398 6.071143032203834e-07 0.2463217957442577 6.071144546129539e-07 0.2441928603691365 6.071146097750345e-07 0.2420086586735095 \
6.071147391842833e-07 0.2401849910837116 6.071148738963765e-07 0.2382868210192302 6.071150115942015e-07 0.2363478190565156 6.071151293462172e-07 0.2346905900295477 \
6.071152886704099e-07 0.2324499447852502 6.071154259326363e-07 0.2305210708572645 6.071155666789934e-07 0.2285488733964877 6.071156724701667e-07 0.2270688194984586 \
6.071158024115645e-07 0.2252532503786337 6.071159029480281e-07 0.2238506847401111 6.071160052817357e-07 0.2224250970611539 6.071160790103171e-07 0.2214012665004395 \
6.071161582442603e-07 0.2203047212273054 6.071162292155075e-07 0.2193236206014474 6.071162806785351e-07 0.218612902325451 6.071163336269881e-07 0.2178825126218075 \
6.071164127819908e-07 0.2167921001391954 6.071164550546258e-07 0.2162104926182252 6.071164948991708e-07 0.2156628374086678 6.071165381228203e-07 0.2150692779925967 \
6.071165790298225e-07 0.2145080585354088 6.071166491522843e-07 0.2135474129702876 6.071166828372557e-07 0.2130867492099046 6.071167276666377e-07 0.212477723463 \
6.071167865237998e-07 0.2116792343136102 6.071168513092605e-07 0.2108017053965978 6.071169087900245e-07 0.2100241135398916 6.071169692190328e-07 0.209207737948094 \
6.071170662554631e-07 0.2078991976528634 6.07117150945123e-07 0.2067595417901527 6.071172598558851e-07 0.2052972881712416 6.071173562566921e-07 0.2040065614180294 \
6.071174512733293e-07 0.2027428333585779 6.071175547051274e-07 0.2013717100485363 6.071176496344728e-07 0.2001158751783069 6.071177526548994e-07 0.198757993281026 \
6.071178577373321e-07 0.1973779917312911 6.071179670461462e-07 0.1959482000350934 6.07118077489628e-07 0.1945091075764383 6.071181937799036e-07 0.1929996650696684 \
6.071183037098964e-07 0.1915811184357085 6.071184133723204e-07 0.1901717999899754 6.071185150889654e-07 0.1888694322720079 6.071186080436791e-07 0.1876837490531375 \
6.07118700772569e-07 0.1865049219968967 6.07118774458125e-07 0.1855719169757668 6.071188572993398e-07 0.1845269810791141 6.071189318853365e-07 0.1835895008849975 \
6.071190016086783e-07 0.1827150226754214 6.071190683270854e-07 0.1818808699270075 6.071191641704113e-07 0.1806871657728035 6.071192468771838e-07 0.1796611249561687 \
6.071193404410075e-07 0.1785035608809835 6.071194353370949e-07 0.1773351434884491 6.071195467074053e-07 0.1759704596301353 6.071196883497589e-07 0.1742450478777388 \
6.071198035966121e-07 0.1728486436789435 6.071199481442513e-07 0.1711076225712051 6.071200597399285e-07 0.1697708811114609 6.071202009589021e-07 0.1680898955975501 \
6.071203166961755e-07 0.1667201145354908 6.071204226568608e-07 0.1654722325850081 6.071205214164775e-07 0.164314417410061 6.071206177596498e-07 0.1631901152369615 \
6.071207064174022e-07 0.1621596955203892 6.071208317516728e-07 0.1607099933926625 6.071209262770884e-07 0.1596224416957933 6.071210240160401e-07 0.1585042187118262 \
6.071211321109171e-07 0.1572745454417887 6.071212267786046e-07 0.1562036643369483 6.071213342264514e-07 0.1549951394274829 6.071214253154951e-07 0.1539767092330788 \
6.071215320872068e-07 0.1527896463435911 6.071216354804728e-07 0.1516469620792683 6.071217465609577e-07 0.1504267727114754 6.071218357869394e-07 0.1494522115900035 \
6.071219212668682e-07 0.1485231035185812 6.071220051920548e-07 0.1476157397758405 6.071220748986192e-07 0.1468658175993407 6.071221535366968e-07 0.1460232248551682 \
6.071222318479541e-07 0.1451880611912267 6.071223024838273e-07 0.1444378248611795 6.071223879746948e-07 0.1435337156153706 6.071224753636722e-07 0.1426139614481139 \
6.071225569511858e-07 0.1417594571206545 6.071226542701372e-07 0.1407454482154784 6.071227349596596e-07 0.139910090776864 6.071228257446906e-07 0.1389752404035735 \
6.07122947088963e-07 0.1377336220260025 6.071230361386038e-07 0.13682812281983 6.071231346554539e-07 0.1358318692385875 6.071232217417229e-07 0.1349560640726983 \
6.071233321526109e-07 0.1338550874529322 6.071234206114333e-07 0.1329791517134813 6.071235213400266e-07 0.1319874611681985 6.071236261295802e-07 0.1309622419763913 \
6.07123720519813e-07 0.1300442429014473 6.07123817024605e-07 0.1291112112475518 6.071239165112583e-07 0.1281591654439075 6.071240029124292e-07 0.1273384721630967 \
6.071240978925598e-07 0.1264411177628728 6.071242020813879e-07 0.1254629331099751 6.071243112001386e-07 0.124445178694 6.071244055505945e-07 0.1235704029653004 \
6.07124517846343e-07 0.1225411084520107 6.071246133096966e-07 0.1216733466577494 6.071247175205873e-07 0.1207311846737792 6.071248068659445e-07 0.1199276649878674 \
6.071248772532174e-07 0.1192980345746366 6.071249526392512e-07 0.1186268760051257 6.071250287714207e-07 0.1179522201461119 6.071250977489183e-07 0.1173458504859956 \
6.071251802680908e-07 0.1166263596898966 6.071252522115779e-07 0.1160015972854393 6.071253342903043e-07 0.1152916772467617 6.0712541862478e-07 0.1145654108773922 \
6.07125496418619e-07 0.113898375935255 6.071255891835211e-07 0.1131065723182637 6.071257047873425e-07 0.1121254933399327 6.071258106929114e-07 0.1112341778178403 \
6.071258883498311e-07 0.1105854195321705 6.071259766463023e-07 0.1098504899494786 6.071260567033545e-07 0.1091866403929743 6.071261536294793e-07 0.1083861389179563 \
6.07126248864964e-07 0.1076031391441806 6.071263374361587e-07 0.1068780200140514 6.071264387442599e-07 0.1060523297458165 6.071265442899472e-07 0.1051963702337609 \
6.071266534843118e-07 0.1043160928234657 6.071267616019328e-07 0.1034503663302994 6.071268815196938e-07 0.1024949450012773 6.071269828815214e-07 0.1016914181115986 \
6.071270888911509e-07 0.100855068690839 6.071272146827803e-07 0.09986840123414902 6.071273442400857e-07 0.09885896724496235 6.071274799154405e-07 0.09780904711780367 \
6.071276559873036e-07 0.09645781830037269 6.071278197878237e-07 0.09521257997344186 6.071279826125652e-07 0.09398642071914091 6.071280677512003e-07 0.09334985726464029 \
6.07128137589223e-07 0.09282999162688726 6.071282070848284e-07 0.09231474740697931 6.071282810434879e-07 0.09176875214326782 6.071283771983754e-07 0.09106241641841166 \
6.071284516137408e-07 0.09051841344162129 6.071285296033096e-07 0.08995079828656057 6.071286060521396e-07 0.08939693755534793 6.071286935462239e-07 0.08876614459792892 \
6.071287957229341e-07 0.08803382885421264 6.071288842873223e-07 0.08740269463919083 6.071289939528099e-07 0.08662585268124241 6.071291100092174e-07 0.08580942306245626 \
6.07129251558034e-07 0.0848216759818637 6.071293844270176e-07 0.08390253510334872 6.071295251873281e-07 0.08293727564630923 6.071296748969478e-07 0.08192024575105315 \
6.071298106088348e-07 0.08100683753927941 6.07129952125717e-07 0.08006309454860433 6.071300872475907e-07 0.07917070961097784 6.071302285200282e-07 0.07824718349428782 \
6.071303756129204e-07 0.07729532867436953 6.07130527122786e-07 0.07632524417621221 6.071306924984999e-07 0.07527819040792309 6.071308562596901e-07 0.07425356708383206 \
6.071310323896319e-07 0.07316505371836476 6.071312215286099e-07 0.07201151367936541 6.071314322022336e-07 0.07074528708793332 6.071316517688556e-07 0.06944624562626683 \
6.071318865352622e-07 0.06808094281860989 6.071321449277002e-07 0.06660616301228137 6.071324395923604e-07 0.06496103773121734 6.071327436716829e-07 0.06330286177969326 \
6.071331045821629e-07 0.06138472526627536 6.071334404990352e-07 0.05964719353945821 6.071338806764061e-07 0.05743991201668189 6.071342590438091e-07 0.05560437501227136 \
6.071347015027716e-07 0.05352996728430704 6.071350555229165e-07 0.05192508193542229 6.071354420396717e-07 0.05022502935509546 6.07135786643729e-07 0.04875485597254389 \
6.071361086186649e-07 0.04741934964807833 6.07136412152492e-07 0.04619304551845941 6.071367070734883e-07 0.04503122626702559 6.071369895557667e-07 0.04394770877170886 \
6.071372666361775e-07 0.04291147062934708 6.071375323636684e-07 0.04194013461971725 6.071378035943552e-07 0.0409708748276704 6.071380798533722e-07 0.04000619535229137 \
6.071383697525942e-07 0.03901828782233653 6.071385981289875e-07 0.03825741181922668 6.071389030130543e-07 0.03726495139513845 6.071391196849104e-07 0.03657573971894532 \
6.071393110416373e-07 0.03597943984071691 6.071395096361558e-07 0.03537298232318693 6.071398395514967e-07 0.03438820140908775 6.071400814971701e-07 0.03368375433354889 \
6.071403968092223e-07 0.03278771666975258 6.071406669292072e-07 0.03203957074185158 6.071409233008807e-07 0.03134567005659093 6.071412033128806e-07 0.03060515313352298 \
6.071414489686567e-07 0.02997014710356035 6.071416817043017e-07 0.02938120249260199 6.07141924434299e-07 0.02878348292867495 6.071421611615635e-07 0.02821317433052753 \
6.071423898079744e-07 0.0276732289298247 6.071428070936345e-07 0.02671456010533928 6.071430022743284e-07 0.02627749693639509 6.071433834414109e-07 0.02544369227895442 \
6.071435606942329e-07 0.02506446942885681 6.071439031456878e-07 0.02434654114125227 6.0714405641412e-07 0.02403127656358269 6.071444314325841e-07 0.02327616399748992 \
6.071445690667252e-07 0.02300530455388665 6.071450533333593e-07 0.02207084195640928 6.071451729527604e-07 0.02184403312078184 6.071455899915636e-07 0.02106026682208277 \
6.07145733393791e-07 0.02079332360769017 6.071462546051726e-07 0.01984598817089831 6.071463823790427e-07 0.0196205814374062 6.071469667914166e-07 0.01863359713481367 \
6.071471392268229e-07 0.01835589372257288 6.071477433235728e-07 0.01743644241612937 6.071479047552142e-07 0.01720262545858322 6.071485447014338e-07 0.01631831686205014 \
6.071487230176005e-07 0.016083210242981 6.071493710016487e-07 0.01526127675881721 6.071495362552397e-07 0.01505930898173208 6.071502725571753e-07 0.01419381259610907 \
6.071504068332254e-07 0.01404154276213586 6.071512039327433e-07 0.01317592498067951 6.071513445303544e-07 0.01302934089458718 6.07152309873577e-07 0.0120661300044765 \
6.071524742123827e-07 0.01190857475316222 6.071534749435119e-07 0.01099048917119646 6.07153612213369e-07 0.01087009009405628 6.071547509078863e-07 0.009949273443646761 \
6.071548650857872e-07 0.009863136028526375 6.071562457306217e-07 0.008889755784408603 6.071564000878327e-07 0.00878832203975914 6.071579465820611e-07 0.00781340401000951 \
6.071580309437644e-07 0.007760176032106158 6.07159716371082e-07 0.006770348169342283 6.071598398995725e-07 0.00670487246831437 6.071618897141387e-07 0.005720970231232756 \
6.071620861142965e-07 0.005634691917282852 6.071644047936537e-07 0.004698942116576918 6.071648654079885e-07 0.004530544077955615 6.071676055035305e-07 0.003639937533647344 \
6.071681236485673e-07 0.00349159181499799 6.071722742898753e-07 0.002502201117031859 6.071728121398824e-07 0.002396807933581942 6.0717889437533e-07 0.001421603691354927 \
6.071791533557405e-07 0.001378272220758726 6.071844761190904e-07 0.0003814093765652445 6.071845892761344e-07 0.0003711807182531981 6.098307063923701e-07 -0.0004615907568095335 \
6.098308688313385e-07 -0.0006852153244161934 6.098313698328069e-07 -0.001554404032531494 6.098314540153697e-07 -0.001725199767551738 6.098318555381938e-07 -0.002626792336557519 \
6.098319448731606e-07 -0.002845673237760077 6.098322314649696e-07 -0.0035898660494722 6.098323590334992e-07 -0.003937855927128601 6.098326777451613e-07 -0.004830400105952924 \
6.098327919463135e-07 -0.00515011308870196 6.098330743466382e-07 -0.005887653497963378 6.098332045728569e-07 -0.006177415671381139 6.098341829257541e-07 -0.005220113099403402 \
6.098343702332871e-07 -0.004004368716724641 6.098345016776888e-07 -0.002901539130564616 6.098346071052425e-07 -0.001869327786897239 6.098346928227261e-07 -0.0009323217369615201 \
6.098347747492127e-07 4.151965372454519e-05 6.098348957860361e-07 0.001618129410352471 6.098349947146828e-07 0.003024565667809575 6.098351531113568e-07 0.005482561958548801 \
6.098353705585867e-07 0.00923691162542661 6.098355517808096e-07 0.0126653356758144 6.09835763874906e-07 0.01697021734206094 6.098359268985627e-07 0.02046388365739064 \
6.098360875209784e-07 0.02403759527126768 6.098362410612209e-07 0.02755862871109176 6.098363891179022e-07 0.031036270750196 6.098365381988111e-07 0.03460722192241437 \
6.098366927287224e-07 0.03837091703902212 6.098368533795379e-07 0.04234026030123839 6.098370180342185e-07 0.04645786783841532 6.098371945751168e-07 0.05091770581196236 \
6.098373735379687e-07 0.05547793877747508 6.098375642811338e-07 0.0603721650098247 6.09837769062163e-07 0.06565647483694508 6.098379895344491e-07 0.07137203566208646 \
6.098382223941741e-07 0.0774299331224613 6.098384715816505e-07 0.08392829098722057 6.098387444237776e-07 0.09105513637423955 6.098390411275777e-07 0.09880974921055499 \
6.098393684539683e-07 0.1073623706929605 6.098397381053548e-07 0.11701033799881 6.098401329771689e-07 0.1273002725707723 6.098405908154096e-07 0.1392030195235975 \
6.098411226222496e-07 0.1529832553757746 6.09841747860046e-07 0.1691182447448397 6.098424336075175e-07 0.1867241161332086 6.098432360033912e-07 0.2071957342970069 \
6.09844134802183e-07 0.2299563735557614 6.098449404156323e-07 0.2501946571168963 6.098456541669657e-07 0.2679877251922811 6.098462837288478e-07 0.2835633151515627 \
6.098468540922982e-07 0.2975737963344939 6.098473850476803e-07 0.3105173405876944 6.098478868351306e-07 0.3226580892822354 6.098483661296844e-07 0.3341673054699896 \
6.098488316851033e-07 0.3452566901045974 6.098492954815109e-07 0.3562094254686541 6.098497512295407e-07 0.3668794056881832 6.098502114496752e-07 0.3775613305945491 \
6.098507497336462e-07 0.3899285626759094 6.098512505841796e-07 0.4013172511919189 6.098516508068632e-07 0.4103337945930838 6.09852157667644e-07 0.421642452039157 \
6.098526436338564e-07 0.4323669409017459 6.098530431485677e-07 0.4410997362599856 6.098534537606271e-07 0.4500002277813482 6.098538826870602e-07 0.4592207708982954 \
6.098542842014423e-07 0.4677760623951868 6.098545915918886e-07 0.4742753916877908 6.098549418336473e-07 0.4816249679276425 6.098552950738506e-07 0.4889795533930016 \
6.0985554824443e-07 0.4942125642332652 6.098557811883199e-07 0.4989990073547648 6.098560228316108e-07 0.5039392821429431 6.098562478222295e-07 0.5085102868389438 \
6.098564398583375e-07 0.5123881070394828 6.098566246700343e-07 0.5161059569497825 6.098568469603498e-07 0.5205538992744256 6.098570136717574e-07 0.5238726938135662 \
6.098572308883524e-07 0.5281726418673847 6.098574339672442e-07 0.5321820613122353 6.098576113786994e-07 0.5356681922482178 6.098577994510863e-07 0.5393528234657015 \
6.098580354832655e-07 0.5439555888699217 6.098583013652895e-07 0.5491186112539347 6.098585231271783e-07 0.5534070305875756 6.098588031850331e-07 0.5588091140818973 \
6.098590461848179e-07 0.5634839438879177 6.09859321538161e-07 0.5687575845994758 6.098595665335015e-07 0.5734440561015828 6.098598068277205e-07 0.5780305526007354 \
6.098600478670233e-07 0.5826153106864888 6.09860305457841e-07 0.5874946531182738 6.098605408246178e-07 0.5919209497705462 6.09860772126727e-07 0.5962518282209535 \
6.098609946534482e-07 0.6003950532231523 6.098612030130559e-07 0.6042587207462122 6.098614408548706e-07 0.6086392006348278 6.098616517150853e-07 0.612499186772883 \
6.09861907322267e-07 0.617151767543529 6.098621060500327e-07 0.620751700070918 6.098623816826772e-07 0.6257066023742009 6.098626044387981e-07 0.6296824120643636 \
6.098628978099215e-07 0.6348814180513288 6.098631305799232e-07 0.6389753720667986 6.098633507813091e-07 0.6428252659334456 6.098635520519211e-07 0.6463216644290061 \
6.098637693407936e-07 0.6500784077528632 6.098639440567036e-07 0.6530842133917786 6.098641303213334e-07 0.6562672470877895 6.098643090603859e-07 0.6593113758161715 \
6.098644717643992e-07 0.6620700940033843 6.098646370334099e-07 0.6648583661366954 6.098647803012238e-07 0.6672607123132118 6.098649195316479e-07 0.669583864918244 \
6.098650593322145e-07 0.6719085596965743 6.098651941074222e-07 0.6741424479378803 6.098653216016632e-07 0.6762463034350935 6.098654545557747e-07 0.6784344250006583 \
6.098655761601248e-07 0.680430207161383 6.098657045733663e-07 0.6825336955632141 6.098658203404208e-07 0.6844241240890321 6.098659183815936e-07 0.686020684362688 \
6.098660190776997e-07 0.687656981754083 6.098661288314626e-07 0.689434454762776 6.098662455994178e-07 0.6913211166705923 6.098663368261915e-07 0.6927889453402305 \
6.098664460316048e-07 0.6945396927028351 6.098665471403262e-07 0.6961566646470493 6.098666425406181e-07 0.6976767415743361 6.098667520226425e-07 0.6994136821864276 \
6.098668864742773e-07 0.7015344809028976 6.098670354932137e-07 0.7038694457768003 6.098671644232324e-07 0.7058755144243859 6.09867311083691e-07 0.7081418729260142 \
6.098674378680718e-07 0.7100885084081828 6.09867562465961e-07 0.7119899232102255 6.098676743197281e-07 0.7136874821928206 6.098677872756922e-07 0.7153928249203609 \
6.098678878290892e-07 0.716903336497302 6.098680251105924e-07 0.7189542886859326 6.098681449794518e-07 0.7207346491296758 6.09868264162204e-07 0.7224952472954583 \
6.098683911643136e-07 0.7243608783177121 6.098685157126648e-07 0.726179956024653 6.098686393836757e-07 0.7279757435764195 6.09868765971953e-07 0.7298035010246171 \
6.098688965411881e-07 0.7316777339938921 6.098690190562223e-07 0.7334262671520465 6.098691552997129e-07 0.7353588786631546 6.09869256742486e-07 0.7367901064855561 \
6.098693627659689e-07 0.7382789144707947 6.098694532971524e-07 0.7395446819117977 6.098695671233782e-07 0.7411267287627761 6.098696547849604e-07 0.742338113895605 \
6.098697606802376e-07 0.7437932991468792 6.098698910335325e-07 0.7455718205320391 6.098700016011402e-07 0.7470699275523445 6.098701062716114e-07 0.7484790865773925 \
6.098702302331429e-07 0.7501360792234356 6.098703787905969e-07 0.752105598322839 6.098705004731933e-07 0.7537054667443914 6.098706145848825e-07 0.7551949470168074 \
6.098707550054835e-07 0.7570132059451244 6.098708965335436e-07 0.7588296197226846 6.098710143228133e-07 0.7603289862386273 6.098711425226351e-07 0.7619481626911874 \
6.098712845904682e-07 0.7637269294216019 6.098714014655762e-07 0.7651780119234867 6.098715471393621e-07 0.7669714049983392 6.098716688778096e-07 0.7684572223066155 \
6.098717875183015e-07 0.7698939375992205 6.098719099845946e-07 0.7713653733660819 6.098720367016846e-07 0.7728756341192486 6.098721466036787e-07 0.7741754302862822 \
6.098722722190223e-07 0.7756497674172792 6.098723780294306e-07 0.7768823528242577 6.098725141995533e-07 0.7784559787239111 6.098726385466015e-07 0.7798807766277074 \
6.098727659718769e-07 0.7813271999647126 6.098728805279563e-07 0.7826155184370988 6.098729872082259e-07 0.7838050786084815 6.098731251508229e-07 0.785328674235108 \
6.098732746003193e-07 0.7869612315653352 6.098734194525364e-07 0.7885256944569791 6.098735388882871e-07 0.7898026796320731 6.0987367431316e-07 0.7912364721526877 \
6.09873795807481e-07 0.7925100718437531 6.098739391665555e-07 0.7939977458315933 6.09874082600237e-07 0.7954699260458764 6.098742084112467e-07 0.7967479640295563 \
6.098743274579285e-07 0.7979459892863545 6.098744394715731e-07 0.7990632136113104 6.098745442634543e-07 0.8000996927221937 6.098746394563032e-07 0.8010335634530776 \
6.098747758668286e-07 0.8023587211299719 6.098748926790049e-07 0.8034813603122919 6.098750121402484e-07 0.8046180202255495 6.098751341806002e-07 0.8057672874017472 \
6.098752570806968e-07 0.8069126780167393 6.098753842000532e-07 0.8080849010520604 6.098755093419151e-07 0.8092265787736463 6.098756398931422e-07 0.8104047139317369 \
6.09875765969389e-07 0.811530109085512 6.098758939660489e-07 0.8126603425876329 6.09875999427297e-07 0.8135823118114501 6.098761026965977e-07 0.814477091043954 \
6.098761953499458e-07 0.8152732203909091 6.098763190441811e-07 0.8163262937528154 6.098764066640956e-07 0.8170655553659417 6.098765053301514e-07 0.8178914289762149 \
6.098766488771538e-07 0.819080619224994 6.098767844633066e-07 0.8201904093102529 6.09876893653288e-07 0.8210742465492874 6.098770411027471e-07 0.8222539401850584 \
6.09877191506449e-07 0.8234410273756358 6.098773169754118e-07 0.8244188977545531 6.098774611413952e-07 0.8255287290252299 6.098775854299598e-07 0.8264738611628292 \
6.098777359002563e-07 0.8276038147969816 6.098778715066145e-07 0.8286089145501508 6.098779966016159e-07 0.8295251220930787 6.098781143174532e-07 0.8303776282987162 \
6.098782602030521e-07 0.8314210189912619 6.098784266961482e-07 0.8325942517713072 6.098785575628508e-07 0.833503494447128 6.098787310074616e-07 0.8346911703335461 \
6.098788991402021e-07 0.8358239212093587 6.098790689939496e-07 0.8369500705213252 6.098792498869552e-07 0.838129582835239 6.098793930212162e-07 0.8390486258646698 \
6.098795071191618e-07 0.8397723391454259 6.098796372463217e-07 0.8405879656882547 6.098797391021787e-07 0.8412191375388212 6.098798559475988e-07 0.8419354178465567 \
6.098799929193963e-07 0.84276453896487 6.098801907591422e-07 0.843942473808897 6.098803824446297e-07 0.8450620046306492 6.09880591850993e-07 0.8462610422160779 \
6.098807738618767e-07 0.8472832413425977 6.098809709773334e-07 0.8483697584184032 6.098811442904468e-07 0.8493077402131245 6.098813273256562e-07 0.8502809338042043 \
6.098814984787831e-07 0.8511747489972419 6.098816731317363e-07 0.8520708361396651 6.098818483828913e-07 0.8529540285731302 6.098820245303913e-07 0.8538259128238825 \
6.098822148367787e-07 0.8547503816925358 6.098824054277479e-07 0.8556583881771193 6.098826059797907e-07 0.8565949481971697 6.098827985825885e-07 0.8574764650234362 \
6.098830093312883e-07 0.8584213553684483 6.098832373621857e-07 0.8594210644592908 6.098835032419522e-07 0.8605573106989262 6.098838018200941e-07 0.8617960322792503 \
6.098840779837292e-07 0.8629075153790151 6.098843622302292e-07 0.8640180616030438 6.098846364142308e-07 0.8650581816846495 6.098849086694401e-07 0.8660616517296992 \
6.098851788589146e-07 0.8670295451208139 6.098854360232381e-07 0.8679256252637404 6.098857085969722e-07 0.8688492356117473 6.098859846024351e-07 0.8697577927663542 \
6.09886254710518e-07 0.8706213441784563 6.098865545689379e-07 0.8715508809746347 6.098869255828164e-07 0.8726599440782473 6.098872205155291e-07 0.873510245983525 \
6.098874748008954e-07 0.8742218447789023 6.098877730441707e-07 0.8750318897722944 6.098880466409288e-07 0.8757523113099853 6.098882827679075e-07 0.8763571312809064 \
6.098885231072054e-07 0.876957042728428 6.098887454408612e-07 0.8774982514557473 6.098889394467937e-07 0.8779599514934209 6.098892691652286e-07 0.8787226653583874 \
6.098894243380191e-07 0.8790722725343518 6.098897420714095e-07 0.8797700114458387 6.098899209390604e-07 0.880152324917399 6.098902634005339e-07 0.8808637455080008 \
6.098904475523682e-07 0.8812353200296749 6.098909224784184e-07 0.8821594045029107 6.098910898716537e-07 0.8824737723885729 6.098915556929605e-07 0.8833186808430151 \
6.098917365204472e-07 0.883635209600208 6.098922305497856e-07 0.8844687288968743 6.098923718877728e-07 0.8846990198924604 6.098929782491027e-07 0.8856473543416146 \
6.098931303209551e-07 0.8858754372639542 6.098937770089477e-07 0.8868048391838264 6.09893905303109e-07 0.8869818633102416 6.098945534965822e-07 0.8878410756373726 \
6.098946832451334e-07 0.8880061989117775 6.09895451498601e-07 0.8889361126992519 6.098955812406254e-07 0.8890847997417872 6.098964346975575e-07 0.8900046759307325 \
6.098965779246734e-07 0.8901495209380393 6.098975641580769e-07 0.8910738355210844 6.09897785636141e-07 0.8912643084423501 6.098989286536885e-07 0.8921737958641509 \
6.098990586319893e-07 0.8922730011388891 6.099004103389882e-07 0.8932565980587214 6.099005606923423e-07 0.8933589605607284 6.099020413157679e-07 0.8942730372387374 \
6.099022802190699e-07 0.8944047337041336 6.099040613442277e-07 0.8952702388217941 6.099044473255946e-07 0.8954343910560414 6.099068488716345e-07 0.896309305076933 \
6.099073238084202e-07 0.8964562995603377 6.099111419701395e-07 0.8973944547681553 6.099116244593364e-07 0.897487269196476 6.099195104748493e-07 0.898471373493449 \
6.099201266375397e-07 0.8985180228791175 6.100152826123788e-07 0.899508178894561 6.100167732145567e-07 0.8995204306067698 6.101280612887406e-07 0.9005118233983579 \
6.101282376257435e-07 0.9005706457326812 6.10131860757067e-07 0.8996048713171836 6.101320419550936e-07 0.8994654179496379 6.101333530765704e-07 0.8985275682722235 \
6.101335349539761e-07 0.8984123497545736 6.101353579441702e-07 0.8974436520388238 6.101355178574244e-07 0.8973766233009967 6.101486686887231e-07 0.8983720910457982 \
6.101487796702765e-07 0.8983905835035384 6.101576012543832e-07 0.8993863063850064 6.101581480238466e-07 0.8994226481040219 6.106507199766804e-07 0.9003987622903815 \
6.106507897691656e-07 0.9004496773542636 6.106516224219291e-07 0.9012853800543292 6.10651748468094e-07 0.9014513953152168 6.106523289889575e-07 0.9023435091985418 \
6.106524699532118e-07 0.9025895326188698 6.106528690912907e-07 0.9033428289365844 6.106530192408316e-07 0.9036449200440446 6.106534623221535e-07 0.9045762589490434 \
6.106536194942561e-07 0.9049121924877023 6.106540651209874e-07 0.9058152254958243 6.106541635773263e-07 0.9059929146639856 6.106555802587203e-07 0.9052304871087643 \
6.10655711415865e-07 0.904616184869324 6.106558804230411e-07 0.9036290332250884 6.106560457149166e-07 0.9024406226812831 6.106561519806978e-07 0.9015554774641358 \
6.106562554175281e-07 0.9006052096506509 6.106563411842469e-07 0.8997486040545581 6.106564306782332e-07 0.8987887485205278 6.106565549226324e-07 0.8973492764100613 \
6.106566730035805e-07 0.8958624931586439 6.106567602196721e-07 0.8946938835082598 6.10656884526716e-07 0.8929289312882503 6.106569915106439e-07 0.8913158670103165 \
6.106570913423478e-07 0.8897378501708729 6.106572176331741e-07 0.8876466417139378 6.106573858217853e-07 0.884705368138502 6.106575415215381e-07 0.8818365157686672 \
6.106577381263672e-07 0.8780362649814708 6.106579217476167e-07 0.8743271923380105 6.106581332550105e-07 0.8698916163736473 6.106583140648106e-07 0.8659808238081558 \
6.106584986458582e-07 0.8618945354625286 6.106586716498537e-07 0.8579913311618118 6.106588570505038e-07 0.8537436868396935 6.106590361336512e-07 0.8495884889292737 \
6.106592197227131e-07 0.8452850234109005 6.106593864844182e-07 0.8413449312544377 6.10659554574996e-07 0.8373487193315756 6.10659717684167e-07 0.8334514816705533 \
6.106598728704026e-07 0.829729402178684 6.10660045969282e-07 0.8255639501984255 6.106602319597377e-07 0.8210763864673301 6.106603965802215e-07 0.8170961425007568 \
6.106605614501323e-07 0.8131038678717658 6.106607367821644e-07 0.8088537582860886 6.106609012086681e-07 0.8048648186953292 6.106610698442787e-07 0.8007719922541914 \
6.106612606476452e-07 0.7961398815555145 6.106614461718184e-07 0.7916360074082958 6.106616551006281e-07 0.7865651471012967 6.106618799176179e-07 0.7811107659751856 \
6.106620697327054e-07 0.77650678233121 6.106622715901883e-07 0.7716133355283564 6.106624158608268e-07 0.76811790639139 6.106625575043926e-07 0.7646880872338248 \
6.106626852021022e-07 0.7615975116975136 6.106627962479435e-07 0.7589113686396982 6.106629248105796e-07 0.7558028559024855 6.106630573760869e-07 0.7525995467138866 \
6.106631706977831e-07 0.7498629233610832 6.106633070324095e-07 0.7465723252212872 6.106634134316607e-07 0.7440058350410135 6.106635726504468e-07 0.7401674766516904 \
6.106637450281421e-07 0.7360137588823189 6.10663907275386e-07 0.7321074183421575 6.106640796243437e-07 0.7279612819449855 6.10664239010527e-07 0.7241302920521341 \
6.106644468157138e-07 0.7191408067115369 6.106646073553789e-07 0.7152908836069264 6.106647998447152e-07 0.7106793324906435 6.10664985361064e-07 0.7062404417184839 \
6.106651552371092e-07 0.7021802791355866 6.106653471069472e-07 0.6975984806629684 6.106654933309623e-07 0.6941099299715526 6.106656536173094e-07 0.6902897983225644 \
6.10665856006145e-07 0.6854719661536142 6.106660372946089e-07 0.681161582477689 6.106662061160356e-07 0.6771536053116509 6.106663919619108e-07 0.6727470762459599 \
6.106665978927511e-07 0.6678715161770782 6.10666765819558e-07 0.6639016226084196 6.106669260812615e-07 0.6601182542089066 6.106671649337354e-07 0.65448589698252 \
6.106673326948486e-07 0.6505369020837752 6.10667513768288e-07 0.6462813620835641 6.106676749231988e-07 0.642499550819208 6.106678211904597e-07 0.6390715923276049 \
6.106679598785689e-07 0.6358268652274862 6.106680892356148e-07 0.6328040340451749 6.106682186201702e-07 0.6297855584526113 6.106683469414899e-07 0.6267952385336898 \
6.106684771436295e-07 0.6237652412672913 6.106686061600735e-07 0.6207683673242944 6.106687447356331e-07 0.6175525629501428 6.106688928112201e-07 0.6141227553162802 \
6.106690791385052e-07 0.60981438109949 6.106692268222044e-07 0.6064079319686639 6.106694619864099e-07 0.600995965122186 6.106696544341406e-07 0.5965821560879089 \
6.106698950039548e-07 0.5910808370261941 6.106700640513256e-07 0.587228367631822 6.1067020171775e-07 0.5840969866928536 6.106703298227265e-07 0.581191110277254 \
6.10670443409422e-07 0.5786182870235701 6.106705347742257e-07 0.5765512826027382 6.106706241961132e-07 0.5745328691003393 6.106706914578463e-07 0.573016830490748 \
6.106707574780489e-07 0.5715297341779608 6.106708095317241e-07 0.5703577032508095 6.106708737705931e-07 0.5689124506700958 6.106709353071159e-07 0.5675311492520995 \
6.106709995886598e-07 0.5660899724818867 6.106710527797555e-07 0.5648985048860162 6.106711451255398e-07 0.5628316153148989 6.106712217014408e-07 0.5611191615154557 \
6.10671277545091e-07 0.5598732849310241 6.106713468881998e-07 0.5583285932816697 6.106714527394756e-07 0.5559733466166974 6.106715304312799e-07 0.5542469170533902 \
6.106716310298676e-07 0.5520159549745236 6.106717590630782e-07 0.5491849411292137 6.106718585604598e-07 0.5469885705929382 6.106719711258113e-07 0.544508366501287 \
6.106720741701315e-07 0.5422442603473754 6.106721942190172e-07 0.5396115972585003 6.106722958334261e-07 0.5373863339265779 6.10672411457693e-07 0.5348611538529422 \
6.106725265738741e-07 0.5323536236546169 6.106726530109181e-07 0.529604142030661 6.106727785251858e-07 0.5268822104345234 6.106729252048618e-07 0.5237112381511962 \
6.106730608755697e-07 0.5207845659358002 6.106732186414087e-07 0.5173942078023266 6.106733810633494e-07 0.5139116507621072 6.106735619718178e-07 0.5100482739823553 \
6.106737545639721e-07 0.5059503908118104 6.106739675557428e-07 0.5014368974673542 6.106741999884594e-07 0.4965308659362653 6.106744575093731e-07 0.49112491222925 \
6.106746974735513e-07 0.4861095397820235 6.106749986779056e-07 0.4798501326413723 6.106752869755342e-07 0.4738957353990632 6.106756000618611e-07 0.4674739717793394 \
6.106759195881406e-07 0.4609631488871989 6.106762590854062e-07 0.4540919149088484 6.106765852755183e-07 0.4475353831519197 6.106769217567802e-07 0.4408159131180407 \
6.106772384675873e-07 0.4345373385230166 6.106775725526604e-07 0.4279587671099637 6.106779242615287e-07 0.4210864038135054 6.106782387463783e-07 0.4149846225409808 \
6.106785621928357e-07 0.4087533091618546 6.106790031209485e-07 0.400331870031168 6.106793449160247e-07 0.3938679283557566 6.106796443500685e-07 0.3882534014213259 \
6.10680018872672e-07 0.3812944595528024 6.106803482503896e-07 0.375233915169682 6.10680631354694e-07 0.3700684563936956 6.106809310997049e-07 0.3646408765157301 \
6.106812105955488e-07 0.3596219010422631 6.10681434267487e-07 0.3556377385586224 6.106816459791946e-07 0.3518907610576284 6.106818484819267e-07 0.3483292724130969 \
6.10682049543475e-07 0.3448190020587957 6.106822552213836e-07 0.3412518188287665 6.106824735968597e-07 0.3374887625241871 6.106827173592566e-07 0.3333167726275162 \
6.106829441158293e-07 0.3294678078423895 6.106831640268007e-07 0.3257615367192951 6.106833824514083e-07 0.3221060038181086 6.106835864764178e-07 0.318715141566024 \
6.106837883342075e-07 0.3153870758963987 6.106839886575955e-07 0.3121102802474151 6.10684175271502e-07 0.309079115007194 6.106843725731086e-07 0.3058982938882217 \
6.10684581156335e-07 0.3025606704206737 6.106847867910569e-07 0.2992974534031506 6.106850115231367e-07 0.2957609785165763 6.106852284189794e-07 0.2923771984023277 \
6.106854360983307e-07 0.2891642611511841 6.106856671491776e-07 0.2856239464683982 6.10685841949429e-07 0.2829684481899911 6.10686021147604e-07 0.2802647299798244 \
6.106861900221201e-07 0.2777348429135014 6.106864183453934e-07 0.274348458173166 6.106865950826614e-07 0.2717528218126659 6.106867633653918e-07 0.2693020894036587 \
6.106869358321621e-07 0.2668230333489093 6.106870699344411e-07 0.264903804409765 6.10687215894446e-07 0.2628277003548514 6.106873545899465e-07 0.2608803500812688 \
6.106874768715512e-07 0.2591684246570544 6.106876109903814e-07 0.2572942758553639 6.106877400914858e-07 0.2554978336754472 6.106878595252204e-07 0.2538430842138498 \
6.106879863604196e-07 0.2520939183506197 6.106881060014414e-07 0.2504447954274527 6.106882556176352e-07 0.2483797066042054 6.106883904811462e-07 0.2465170278296022 \
6.106885200385601e-07 0.2447289494531232 6.106886771033789e-07 0.2425624627506451 6.106888010990138e-07 0.2408491463446025 6.106889412471491e-07 0.2389135279283614 \
6.106890711400503e-07 0.2371200701944942 6.106891917576704e-07 0.2354534357320198 6.106893542306008e-07 0.2332087289724075 6.106895002846996e-07 0.2311905595759856 \
6.106896386054839e-07 0.2292825126447264 6.106897465327019e-07 0.2277949627009887 6.106898773176092e-07 0.225993474229161 6.106899758236256e-07 0.22463752857886 \
6.106900799069717e-07 0.2232056532573264 6.106901527838363e-07 0.2222046546567725 6.10690234937313e-07 0.2210804129356655 6.106903023463979e-07 0.2201585377209549 \
6.106903490506606e-07 0.2195201149856669 6.106903984680203e-07 0.2188449488487562 6.10690489422163e-07 0.2176035744446363 6.106905558165761e-07 0.2166983392055156 \
6.106906027798693e-07 0.2160586379972232 6.106906530910749e-07 0.2153737902794619 6.106907122404248e-07 0.2145693142997165 6.106907550863284e-07 0.2139870779821451 \
6.10690798893629e-07 0.2133941263688522 6.106908684238941e-07 0.2124566309962414 6.106909553407081e-07 0.2112864027023158 6.106910365295633e-07 0.2101949018929156 \
6.106911224290263e-07 0.2090416531541652 6.106912165752074e-07 0.2077796428137634 6.10691308329081e-07 0.2065517647617813 6.106914036255171e-07 0.2052788208685862 \
6.106915001042083e-07 0.2039945431316728 6.106916009294901e-07 0.2026602783061639 6.106916968855022e-07 0.2013924147365721 6.10691799571213e-07 0.2000377255165624 \
6.106919026075665e-07 0.1986831378210229 6.10692012697906e-07 0.1972405340748948 6.106921214497938e-07 0.1958206085628783 6.106922411717489e-07 0.1942631948714586 \
6.106923516146512e-07 0.1928328887741874 6.106924596174587e-07 0.1914411844406488 6.10692584973803e-07 0.1898318066870429 6.106926779079788e-07 0.1886434908940876 \
6.106927562787551e-07 0.1876443873000938 6.10692832918829e-07 0.1866698667869858 6.106929154301432e-07 0.1856249297118943 6.106929849397592e-07 0.1847473639743596 \
6.106930508953872e-07 0.1839166514106665 6.106931151627221e-07 0.1831089953192083 6.106932271462069e-07 0.1817072258029639 6.106933212001736e-07 0.1805353135896268 \
6.106934288419354e-07 0.1791985758407087 6.106935353149934e-07 0.1778827552324552 6.106936553069198e-07 0.1764073736674057 6.106937933595455e-07 0.174720142305475 \
6.106939095201004e-07 0.1733081217455876 6.106940716169029e-07 0.1713503924599185 6.106941867054195e-07 0.1699688234017716 6.106943266910192e-07 0.1682987764548305 \
6.106944438970947e-07 0.1669083002780509 6.106945548164474e-07 0.1655990025649634 6.106946524449328e-07 0.1644521190704843 6.106947472954812e-07 0.1633427224865242 \
6.106948633498935e-07 0.161991523106341 6.106949548984438e-07 0.1609305136382055 6.106950510074198e-07 0.1598214181625073 6.106951452255533e-07 0.1587403933520305 \
6.106952387261563e-07 0.1576732160104884 6.106953323234782e-07 0.1566104070550305 6.106954280050165e-07 0.1555300824433628 6.106955185929211e-07 0.1545132165873678 \
6.106956096060781e-07 0.1534969984004868 6.106957051545556e-07 0.1524358767948732 6.106957958202681e-07 0.1514342506187442 6.106958988926307e-07 0.1503020548964867 \
6.106959713440796e-07 0.1495100717445464 6.106960504448726e-07 0.148649146151682 6.106961249930914e-07 0.1478424742503694 6.106961960245005e-07 0.1470770917224498 \
6.106962687889816e-07 0.1462962409077327 6.106963434061566e-07 0.1454990959398698 6.106964133891184e-07 0.1447543557055888 6.106964875500381e-07 0.143968261688537 \
6.106965412953772e-07 0.1434005634796054 6.106965945789318e-07 0.1428396203849428 6.106966597746903e-07 0.1421555039833398 6.106967310807313e-07 0.141411576573238 \
6.106967954507931e-07 0.1407432786314442 6.106968688027537e-07 0.1399847409254479 6.106969294203206e-07 0.1393607073002494 6.106970154538046e-07 0.1384787080092832 \
6.106970914048206e-07 0.1377037134581418 6.106971813727262e-07 0.1367902106004182 6.106972630996836e-07 0.1359645165492482 6.106973457896614e-07 0.1351360437760365 \
6.106974283459693e-07 0.1343145513298757 6.106975339081246e-07 0.1332698421778018 6.106976157754081e-07 0.1324642397250402 6.106977131428679e-07 0.1315110876582503 \
6.106978031437286e-07 0.130634908321232 6.106978911139876e-07 0.1297829978838479 6.106979740438426e-07 0.1289892226181523 6.106980482809344e-07 0.1282822873521282 \
6.106981479319927e-07 0.1273377645104763 6.106982436870517e-07 0.1264350619688987 6.106983305344566e-07 0.1256206895242312 6.106984205359939e-07 0.1247808744623497 \
6.106985008686744e-07 0.1240346855852102 6.10698587562703e-07 0.1232365419604467 6.106986863930319e-07 0.1223331159004786 6.106987764751697e-07 0.1215131568528167 \
6.106988867184272e-07 0.1205141992263624 6.106989739498662e-07 0.1197275966302077 6.106990425230003e-07 0.1191120727131645 6.106991271853926e-07 0.1183553887582162 \
6.106991936928737e-07 0.1177634990399222 6.106992651487992e-07 0.1171309945267847 6.10699334822604e-07 0.1165184920865242 6.106994121596921e-07 0.1158409171037389 \
6.106995079029744e-07 0.1150054407698888 6.106995791578869e-07 0.1143861389207103 6.106996465274203e-07 0.1138025718558601 6.106997149641909e-07 0.113211685696446 \
6.106997905545423e-07 0.1125613765304429 6.106998812963886e-07 0.1117840233035959 6.106999640001163e-07 0.1110788257213999 6.107000775991873e-07 0.1101151050704521 \
6.107001874748992e-07 0.1091895325357105 6.107002796742132e-07 0.1084169374841771 6.107004036235445e-07 0.1073835127717347 6.107004919878671e-07 0.1066505015902263 \
6.107006314468373e-07 0.1055001025916527 6.107007307435382e-07 0.1046863788921388 6.107008233935897e-07 0.1039306459201802 6.10700933598102e-07 0.1030359883605075 \
6.107010188925421e-07 0.1023467905686673 6.107011037933452e-07 0.101663637589173 6.107011867443086e-07 0.1009989740617136 6.107013092542103e-07 0.1000225794851696 \
6.107014311960625e-07 0.09905761200121259 6.10701557818349e-07 0.09806258992746317 6.107016706304718e-07 0.09718220909187772 6.107018152059563e-07 0.09606278874246346 \
6.107019529198845e-07 0.09500564015228773 6.107020696106743e-07 0.09411672853020667 6.107021973542416e-07 0.0931507147971556 6.107022970187578e-07 0.09240236948627445 \
6.107023764526374e-07 0.09180921593916676 6.107024751879353e-07 0.09107599640376031 6.10702553063239e-07 0.09050081472416407 6.107026345291548e-07 0.08990210528957472 \
6.107027092464628e-07 0.0893557072655629 6.107027897762005e-07 0.08876971652456604 6.107029086085259e-07 0.08791061481419053 6.107029982690621e-07 0.08726673116015753 \
6.107031031831091e-07 0.08651800316437093 6.107032346576667e-07 0.08558693768262025 6.107033957658019e-07 0.08445695903909305 6.107035359474972e-07 0.08348350561263763 \
6.107036844501031e-07 0.08246223579158835 6.10703821170292e-07 0.08153124812726546 6.107039611820024e-07 0.08058696725890066 6.10704098179202e-07 0.07967195061625794 \
6.107042367898133e-07 0.07875532825288725 6.107043812626999e-07 0.07780967510081127 6.107045288089374e-07 0.07685421131041187 6.107046863126477e-07 0.07584560580436887 \
6.107048507078841e-07 0.07480523464991846 6.107050187999819e-07 0.07375451744755303 6.10705199799341e-07 0.07263751640721161 6.107053985126234e-07 0.07142823309373261 \
6.10705611921415e-07 0.07014922396308329 6.107058380853001e-07 0.06881630383186611 6.107060786456225e-07 0.06742468841361035 6.107063562065354e-07 0.06585179211508728 \
6.107066534109385e-07 0.06420523370201831 6.107069717116617e-07 0.06248365192299224 6.107073616959619e-07 0.06043183534616462 6.107077605227481e-07 0.05839861031494715 \
6.107082029946869e-07 0.05621846258761681 6.107085879755897e-07 0.05438828987170503 6.107090000221824e-07 0.05249218901100536 6.10709351759698e-07 0.05092353490091287 \
6.107096872643497e-07 0.04946969867921969 6.107099977632445e-07 0.04816021644386199 6.107102917000643e-07 0.04695194805701195 6.107105844309968e-07 0.04577883625507727 \
6.107108592742044e-07 0.04470700909733757 6.107111331179271e-07 0.04366353526031765 6.107113988076876e-07 0.04267398813878486 6.107116741167033e-07 0.04167180388267511 \
6.107119586736206e-07 0.04066026046469497 6.107122549717362e-07 0.03963283340811159 6.107125138471216e-07 0.03875659098599576 6.107127418035275e-07 0.03800131046948733 \
6.107129605287219e-07 0.03729095380188759 6.107131803834488e-07 0.03659437723507575 6.107135212495136e-07 0.03554043311314246 6.107137972903942e-07 0.03470953269536187 \
6.107140907211692e-07 0.03384790442147732 6.107143732890922e-07 0.03303898052111545 6.107146281985287e-07 0.03232625790162248 6.107149088829883e-07 0.03155947796597136 \
6.107151547163818e-07 0.03090318379665042 6.107153868776701e-07 0.03029616297556957 6.10715627215008e-07 0.02968398395812225 6.107158628518431e-07 0.02909722707395018 \
6.107160910630208e-07 0.0285403787496557 6.107165078357495e-07 0.02755138287878544 6.107167023611269e-07 0.02710176794309662 6.107170886015322e-07 0.02623051698020805 \
6.10717267770925e-07 0.0258356865503758 6.107176189981086e-07 0.02507792837274256 6.107177869041566e-07 0.0247229612172224 6.107181711668122e-07 0.02392944198669211 \
6.107182864485406e-07 0.02369675911063252 6.107187284963782e-07 0.02282172072611499 6.107189503116516e-07 0.02239223679446916 6.107194739313108e-07 0.02139838041889957 \
6.107196292938196e-07 0.02110714647916685 6.107201469998876e-07 0.02015295207761772 6.10720272033152e-07 0.01992792118872039 6.10720796234659e-07 0.01901759738223179 \
6.107209324540342e-07 0.01879045572456909 6.107215387304897e-07 0.01783210191617334 6.10721705739623e-07 0.01758082406519646 6.107223489472666e-07 0.01666064795441237 \
6.107225280915353e-07 0.0164167113061686 6.107232182502689e-07 0.01551958953683085 6.107233818701531e-07 0.01531511209162885 6.107241423508398e-07 0.01440332854054019 \
6.107242893929629e-07 0.01423371673427115 6.107251072646214e-07 0.01333087949608782 6.107252268131342e-07 0.01320411419549955 6.107261426746556e-07 0.01227329163592313 \
6.107262840275722e-07 0.01213544173166964 6.107272325031483e-07 0.01124488043697059 6.107273911425862e-07 0.01110230805801717 6.1072857354363e-07 0.01011356759191894 \
6.107286716440201e-07 0.01003725601038859 6.107299332554799e-07 0.009120360285939955 6.107300676693304e-07 0.009028655389366201 6.107316082406548e-07 0.008043892937307966 \
6.107316892739986e-07 0.007992925041580451 6.107332778679313e-07 0.007023242357651564 6.10733410759078e-07 0.006948518507451114 6.107353874624202e-07 0.005952856104192286 \
6.107355692005682e-07 0.005869662958407677 6.107376715542283e-07 0.004980929874643355 6.107381123459968e-07 0.004810448874467742 6.107407675608551e-07 0.003892108290451164 \
6.107412441403943e-07 0.003745909362026665 6.107448822226149e-07 0.00279447349697209 6.107454077460605e-07 0.002678838783887205 6.107510138108453e-07 0.001700248310874221 \
6.107513248985468e-07 0.001653333728976835 6.107564592262457e-07 0.0006858192122199529 6.107566532060193e-07 0.0006440832883579712 6.134045769148618e-07 -0.0002037173203380238 \
6.134047411152831e-07 -0.0003889174928863678 6.134053144580912e-07 -0.001270938904608877 6.134053893922784e-07 -0.001411855863724778 6.134058499760551e-07 -0.002393592696522268 \
6.134059619168068e-07 -0.002660411672198376 6.134062151887948e-07 -0.003300974950034667 6.134063815720996e-07 -0.003745951779090856 6.134066765678695e-07 -0.004566571567208835 \
6.134067880554425e-07 -0.00488071790655901 6.134070674282164e-07 -0.005641221413069743 6.134071883865554e-07 -0.005938820066262044 6.134082823393884e-07 -0.005180465225493313 \
6.134084064716309e-07 -0.004410796826645887 6.134085308790492e-07 -0.003456122327429311 6.134086504354286e-07 -0.002364170815481491 6.13408748579805e-07 -0.001341064316055312 \
6.13408855004127e-07 -0.0001052154991983786 6.134089672399721e-07 0.001336046702817826 6.134091021958209e-07 0.003249882807978809 6.134092247823306e-07 0.005149402351921401 \
6.134094136442457e-07 0.008353592055059769 6.134095548265784e-07 0.01094873860302964 6.134097081879224e-07 0.01393943619118621 6.134098515614266e-07 0.01687898420971235 \
6.134100057528669e-07 0.02017576688295359 6.134101618928252e-07 0.02363796584892512 6.134103176188778e-07 0.02719811802828209 6.134104651125568e-07 0.03065407560139007 \
6.134106137843234e-07 0.03420778369279751 6.134107691144076e-07 0.03798436241030867 6.134109277402875e-07 0.04189786275883118 6.134110926734479e-07 0.0460171220807938 \
6.134112670963364e-07 0.05041857973200652 6.134114460857363e-07 0.05497510627343041 6.134116353855968e-07 0.05982852266675163 6.134118383936027e-07 0.06506368941101938 \
6.134120578706689e-07 0.07075025585284363 6.134122889353304e-07 0.07675903373893865 6.134125359956494e-07 0.08319974270080552 6.134128064206373e-07 0.0902619122132732 \
6.134130999843244e-07 0.09793335781011638 6.13413424033306e-07 0.1064001814721126 6.134137882548562e-07 0.1159066558703892 6.134141808063258e-07 0.1261372395632307 \
6.134146303042508e-07 0.1378252442462487 6.134151530964837e-07 0.1513754922073403 6.134157666942191e-07 0.1672157090591849 6.134164444550933e-07 0.184625848284817 \
6.134172327202124e-07 0.2047487967247964 6.134181155530715e-07 0.22712469896725 6.134189338390288e-07 0.2476994923478653 6.13419661268608e-07 0.2658503723959502 \
6.134203013816358e-07 0.2817009601644404 6.134208756853502e-07 0.2958213763442377 6.134214132513172e-07 0.3089396094373287 6.134219172487761e-07 0.3211464104224903 \
6.1342239337143e-07 0.3325930942309646 6.134228712594449e-07 0.3439912352478621 6.134233245925507e-07 0.3547121966731367 6.134237958852586e-07 0.3657614311162562 \
6.134242385610846e-07 0.3760518588326446 6.134247570598719e-07 0.3879885572071845 6.134252842219918e-07 0.3999987293386327 6.134256631316234e-07 0.4085537955782026 \
6.134261930471663e-07 0.4204060347738258 6.13426622963746e-07 0.429919877745455 6.134270766645208e-07 0.4398653393542544 6.134275433780367e-07 0.4500002271552926 \
6.134279810592672e-07 0.4594210430579985 6.134283890215308e-07 0.468120704286539 6.134287084545646e-07 0.4748816926501604 6.134290805898365e-07 0.4826992142337162 \
6.134293155719776e-07 0.4876010339127531 6.13429549178225e-07 0.4924491904621348 6.134297971906479e-07 0.4975647713404599 6.134300955920778e-07 0.5036796627825791 \
6.134303519484798e-07 0.5088948470128004 6.134305642417896e-07 0.5131878547336713 6.134307582598616e-07 0.5170959594548015 6.134309052463942e-07 0.5200432695146362 \
6.134310592244046e-07 0.523118600542271 6.134312771061538e-07 0.5274469616807909 6.134315302104802e-07 0.5324525256580425 6.134317400493245e-07 0.5365797337241586 \
6.134319515026335e-07 0.5407247601751553 6.134322337095337e-07 0.5462280430697679 6.134324632548168e-07 0.5506821559930507 6.134326791510236e-07 0.5548604062613707 \
6.134329613725408e-07 0.560308769190463 6.134332126802682e-07 0.5651538146135803 6.134335103411598e-07 0.5708625224168123 6.134337605680607e-07 0.5756519166658941 \
6.134340169315557e-07 0.5805516059354519 6.134342573415698e-07 0.585116682128892 6.134345155213861e-07 0.5900038400537884 6.134347391135916e-07 0.5942175703762435 \
6.134349776231628e-07 0.5986919452581434 6.134351852078614e-07 0.6025689278491061 6.134354017304866e-07 0.6065904171332736 6.134356510330918e-07 0.6111939272561876 \
6.134358561065347e-07 0.6149609706257601 6.134361073788606e-07 0.6195555361399968 6.134363106008859e-07 0.6232455818254186 6.134365074727913e-07 0.6267987644955494 \
6.134367007643072e-07 0.630267737067843 6.134369555427622e-07 0.6348113783570861 6.13437185753374e-07 0.638887973644319 6.134374031071848e-07 0.6427143472883045 \
6.134377015129076e-07 0.6479268061885751 6.134379169157571e-07 0.6516657345437264 6.134381181394756e-07 0.6551344108237934 6.134382930609834e-07 0.6581323437428509 \
6.13438458126254e-07 0.6609495238976936 6.134386275947745e-07 0.6638251431769452 6.134387797316125e-07 0.666392827642013 6.134389176422984e-07 0.6687037209181631 \
6.134390664784122e-07 0.6711867545200138 6.134391945930142e-07 0.6733159837320549 6.134393378158276e-07 0.6756849429836936 6.134394590900775e-07 0.6776819274526149 \
6.134395966887616e-07 0.6799401191146522 6.13439716069216e-07 0.6818929034138137 6.134398631769623e-07 0.6842914131385206 6.134399803786278e-07 0.6861933934268433 \
6.13440073884205e-07 0.6877071857403232 6.134401648738969e-07 0.6891752279197846 6.134402676159613e-07 0.6908280855439021 6.134403691335249e-07 0.6924555900607121 \
6.134404875166308e-07 0.6943444167618776 6.134405996372169e-07 0.6961264383846065 6.134407171927181e-07 0.6979868779962457 6.134409023430049e-07 0.7008959348649784 \
6.13441033535213e-07 0.7029413755586562 6.134411697037527e-07 0.7050491462541959 6.13441291222456e-07 0.7069171228306749 6.134414311454679e-07 0.7090538254196674 \
6.134415350881169e-07 0.7106315721465845 6.134416462491006e-07 0.712309798010818 6.134417505089649e-07 0.7138759052437967 6.134418801470564e-07 0.7158124745844324 \
6.134419770777692e-07 0.7172526339884565 6.134421160000041e-07 0.7193052800722975 6.134422355492926e-07 0.7210612846995991 6.134423551218654e-07 0.7228080613301419 \
6.134424808972429e-07 0.7246353354365959 6.134426076155856e-07 0.7264656873164689 6.134427296554369e-07 0.728218443613998 6.134428578038805e-07 0.7300486655261287 \
6.13442987872205e-07 0.7318956587421809 6.134431088632273e-07 0.7336041830685722 6.134432496338107e-07 0.7355801168346318 6.134433506033799e-07 0.7369898206659778 \
6.134434522042367e-07 0.7384020079314992 6.134435482245479e-07 0.7397310783624924 6.134436591374029e-07 0.7412570822736337 6.134437467850298e-07 0.7424563811251772 \
6.134438466394007e-07 0.7438154404043728 6.134439814045385e-07 0.7456370856934184 6.13444097699018e-07 0.747198032089633 6.13444201190815e-07 0.7485782798032956 \
6.134443254462628e-07 0.7502239458264747 6.134444703592029e-07 0.7521280942578691 6.134445883397714e-07 0.753666143975803 6.134447072708787e-07 0.7552056331692281 \
6.134448468504184e-07 0.7569980918234445 6.13444991202808e-07 0.7588357421297242 6.134451092636163e-07 0.7603265096672839 6.134452340853355e-07 0.7618908200857619 \
6.13445373916531e-07 0.7636286950759973 6.134454986794279e-07 0.7651662633748356 6.134456421928987e-07 0.7669199865864609 6.134457628783765e-07 0.7683824344671055 \
6.13445883722124e-07 0.7698356273746885 6.134460033670484e-07 0.7712633747646481 6.134461330746874e-07 0.7727989859455529 6.134462418184901e-07 0.7740766298596218 \
6.134463644662266e-07 0.7755070372682662 6.134464742429112e-07 0.7767778749889983 6.13446603267025e-07 0.7782599816788072 6.134467350433437e-07 0.7797610257751375 \
6.134468483559198e-07 0.7810403609326458 6.134469694418617e-07 0.7823954393038701 6.134470733144949e-07 0.7835479431998941 6.134472155975174e-07 0.785111775748914 \
6.134473638006658e-07 0.7867227488076519 6.134475226942011e-07 0.7884297907063792 6.134476428872233e-07 0.7897074707829422 6.134477924539297e-07 0.7912811323018302 \
6.134479165691467e-07 0.7925734175081853 6.134480422734439e-07 0.7938699048627912 6.134481452190109e-07 0.7949224966762399 6.134482595901654e-07 0.7960823495211882 \
6.134483720644089e-07 0.7972131756542409 6.134484623369833e-07 0.7981137961420948 6.134485516778793e-07 0.7989989930139054 6.134486769038167e-07 0.800229513878344 \
6.134487846751798e-07 0.8012785338618679 6.134489143429785e-07 0.8025281307685926 6.134490357222573e-07 0.8036855380110038 6.134491522780568e-07 0.8047859282369955 \
6.134492730834528e-07 0.80591497746663 6.134494057087579e-07 0.8071413435168892 6.134495275023783e-07 0.8082555056211007 6.13449654106103e-07 0.8094015704683005 \
6.134497797196214e-07 0.8105266036187198 6.13449899211046e-07 0.8115857443778658 6.134500374092988e-07 0.8127973981963581 6.134501469085475e-07 0.8137473213416323 \
6.134502310566626e-07 0.8144713378799666 6.134503518607202e-07 0.8155017394983226 6.134504473695572e-07 0.8163089346032877 6.134505836603603e-07 0.8174496006492775 \
6.13450726424414e-07 0.8186303638797883 6.13450860857535e-07 0.8197292014569521 6.13450970729519e-07 0.8206175763825388 6.134511146291367e-07 0.8217677661037901 \
6.134512679567201e-07 0.8229768690765377 6.134513958055741e-07 0.8239722812379519 6.134515362029047e-07 0.8250521595273246 6.134516621078439e-07 0.8260088941474263 \
6.134518167240101e-07 0.8271688948348412 6.134519490793395e-07 0.8281489842609937 6.134520753461681e-07 0.8290730392392056 6.134521930066954e-07 0.8299245984162376 \
6.134523414090921e-07 0.8309852945996649 6.134525086032604e-07 0.8321626230293395 6.134526413805716e-07 0.8330844501529713 6.134528142817687e-07 0.8342675727345584 \
6.134529826990627e-07 0.8354015168591284 6.134531521935363e-07 0.8365246342267009 6.134533336304179e-07 0.8377070668209077 6.134534761865593e-07 0.8386219603417975 \
6.134535900974499e-07 0.8393441765511721 6.134537209736586e-07 0.8401643924869071 6.134538225966329e-07 0.8407940582489307 6.134539390368715e-07 0.8415078269750864 \
6.134540743300576e-07 0.8423269142909066 6.134542715951592e-07 0.8435017451489455 6.134544621144827e-07 0.844614933042255 6.13454672039296e-07 0.8458175693076773 \
6.134548528178267e-07 0.8468334846981137 6.134550501858462e-07 0.8479221976595614 6.134552240443405e-07 0.8488638701886076 6.134554065585833e-07 0.8498353939890455 \
6.134555779026935e-07 0.8507314120859523 6.13455752248258e-07 0.8516272398309612 6.134559276512583e-07 0.8525125793730954 6.134561038964483e-07 0.8533864315694911 \
6.134562936653265e-07 0.8543099749208749 6.134564844233441e-07 0.8552205033559714 6.1345668621255e-07 0.8561646193034282 6.134568789161161e-07 0.8570482883232282 \
6.134570883567926e-07 0.8579892478796384 6.134573180985592e-07 0.8589986827500428 6.134575835675109e-07 0.8601360945383778 6.134578822138555e-07 0.8613786760148464 \
6.134581606012222e-07 0.8625023989005415 6.134584447911769e-07 0.8636161469557806 6.134587192857839e-07 0.8646608622318305 6.134589913772806e-07 0.8656672252055042 \
6.134592615937267e-07 0.8666387059277968 6.134595187619145e-07 0.8675381145236246 6.134597913209795e-07 0.8684653318325959 6.1346006734232e-07 0.8693777905953765 \
6.13460337484171e-07 0.8702455402709716 6.134606372319546e-07 0.8711796653984102 6.134610081058124e-07 0.872294745819888 6.134613030287966e-07 0.8731503023941 \
6.134615572848448e-07 0.8738665406311316 6.134618555155771e-07 0.8746822274488602 6.134621291339016e-07 0.8754080260278182 6.134623652695491e-07 0.8760175227551726 \
6.134626056214058e-07 0.876622281264788 6.134628279637853e-07 0.8771680781109068 6.134630219681285e-07 0.8776338860468618 6.134633516912074e-07 0.8784037109613512 \
6.1346350686397e-07 0.8787567114621292 6.134638246164967e-07 0.879461652496718 6.134640034818579e-07 0.8798480920375044 6.134643459433237e-07 0.8805675499479563 \
6.134645300848474e-07 0.8809434933546246 6.134650049902838e-07 0.8818790560183651 6.134651723847029e-07 0.8821975058309585 6.134656382161285e-07 0.8830540251881659 \
6.134658190409674e-07 0.8833751042472839 6.134663130743469e-07 0.8842212008576973 6.134664544170557e-07 0.884455124402366 6.13467060806836e-07 0.8854193259359495 \
6.134672128789829e-07 0.8856514227360587 6.134678595574705e-07 0.8865980751852495 6.134679878538246e-07 0.8867785329419297 6.13468635979926e-07 0.8876550049536978 \
6.134687657724472e-07 0.8878236738033012 6.134695440340947e-07 0.8887860366092379 6.134696590259732e-07 0.8889208282599539 6.134705147583919e-07 0.8898661633196656 \
6.134706600215368e-07 0.8900169066926564 6.13471645777722e-07 0.8909664261264102 6.134718668828627e-07 0.8911622482549515 6.134730119973067e-07 0.8921020388386462 \
6.134731432072641e-07 0.8922053928944147 6.134743308657994e-07 0.8931033243919096 6.134744844860915e-07 0.8932130731307282 6.13475894522803e-07 0.8941348173026452 \
6.13476117329622e-07 0.8942660193790342 6.134777980203303e-07 0.8951452796684343 6.134781256415096e-07 0.8952966652167414 6.134803555826309e-07 0.8961896554712738 \
6.134809084965924e-07 0.8963788593752812 6.134844767111233e-07 0.8973573335043913 6.134848002235382e-07 0.8974284307984646 6.134911566318258e-07 0.8984120886469452 \
6.134917055346726e-07 0.8984686671268907 6.13544207609024e-07 0.8994658645395698 6.135448506378865e-07 0.8994692460188505 6.137369893085194e-07 0.9004073346715066 \
6.137371907224907e-07 0.9004708280105613 6.137411505004318e-07 0.8995366825576255 6.137413345272296e-07 0.8993953949813248 6.137426511245044e-07 0.8984641879157507 \
6.137428231683587e-07 0.8983566564859006 6.137447195446537e-07 0.8973720929359315 6.137448932508418e-07 0.897304621671452 6.137574671778747e-07 0.8982933655523699 \
6.137575523681118e-07 0.8983081509245614 6.137658192411513e-07 0.8993078551592517 6.137662939605718e-07 0.8993433667976791 6.142597948700116e-07 0.9002974142054325 \
6.142599143497356e-07 0.9003767372269074 6.142608071727864e-07 0.9012336455299185 6.142609534294225e-07 0.901423267690772 6.142615483221008e-07 0.9023325668564308 \
6.142616832929176e-07 0.9025673929107925 6.142621879687069e-07 0.9035294259428087 6.142623205796079e-07 0.9038000271808221 6.142627212069726e-07 0.9046475051114249 \
6.142628655723707e-07 0.9049556543240072 6.142632886935802e-07 0.9058123566484279 6.142633841506385e-07 0.9059850892484415 6.142648087094547e-07 0.9052205906349737 \
6.142649337473087e-07 0.9046352442223391 6.14265060157898e-07 0.9039223775493039 6.142651628066418e-07 0.9032486771507763 6.142652900219319e-07 0.9022944222362175 \
6.142654088677579e-07 0.9012801950564071 6.142655065202371e-07 0.9003603330664713 6.142655885222584e-07 0.8995243596151602 6.142656681858213e-07 0.8986589236008835 \
6.142657789639895e-07 0.8973708307079206 6.142658801400036e-07 0.8961049472956977 6.142659630844751e-07 0.8950067229086057 6.142660715298924e-07 0.8934921260891034 \
6.1426617999385e-07 0.8918872687155874 6.14266275049989e-07 0.8904106867557802 6.142663959226416e-07 0.8884444419111864 6.14266516699262e-07 0.8863849482818795 \
6.142666297444326e-07 0.8843763393508186 6.142667329151816e-07 0.8824794505619851 6.142668185153381e-07 0.8808620855018965 6.14266892989399e-07 0.8794251273161163 \
6.142669873129417e-07 0.8775673968166831 6.142670757738576e-07 0.8757888800524039 6.142671548468695e-07 0.8741711975775893 6.142672488342247e-07 0.872216793437976 \
6.142673301795293e-07 0.8704993514258973 6.14267425093555e-07 0.8684673705816817 6.14267518136275e-07 0.8664480751909672 6.142676149220692e-07 0.8643215060814092 \
6.142677382174414e-07 0.8615778533848952 6.142678516644525e-07 0.859022019682563 6.142679775164912e-07 0.8561558571929792 6.142681008446355e-07 0.8533196845306243 \
6.142682300229265e-07 0.850323637950593 6.142683706197831e-07 0.8470370034914 6.142684793995045e-07 0.8444782910716596 6.142686144592575e-07 0.8412850455921466 \
6.142687241195659e-07 0.8386804253780991 6.142688532993453e-07 0.8356002443501571 6.142689794831749e-07 0.8325812421138936 6.142691065735304e-07 0.8295317031556502 \
6.142692355958039e-07 0.826427745883674 6.142693446760448e-07 0.8237985689995477 6.142694845267009e-07 0.8204223029647078 6.142696239548932e-07 0.8170507778356514 \
6.142697567085239e-07 0.8138366863616762 6.142698867771991e-07 0.8106848159989707 6.142700104726457e-07 0.8076853837479523 6.142701474270357e-07 0.8043627031572629 \
6.142702611388824e-07 0.8016030849198694 6.142703886159226e-07 0.7985086235398901 6.142704994169941e-07 0.7958187897651571 6.142706186034521e-07 0.7929254985494992 \
6.142707319825085e-07 0.7901733724735396 6.142708662929012e-07 0.7869138859547327 6.142709733871686e-07 0.7843152933129034 6.142710894043117e-07 0.7815009627552112 \
6.142712185952754e-07 0.778367508739124 6.142713162077106e-07 0.7760002683782802 6.142714217871509e-07 0.773440790716327 6.142715304693198e-07 0.7708069008430674 \
6.142716328855832e-07 0.7683258101021144 6.142717262792412e-07 0.7660641808432364 6.142718458350171e-07 0.7631702213567544 6.142719383073787e-07 0.7609327305817616 \
6.142720309454939e-07 0.7586922094322426 6.142721293703097e-07 0.7563124992069843 6.142722373479616e-07 0.7537030947613649 6.142723336164742e-07 0.7513778334636231 \
6.142724198728768e-07 0.7492952979736797 6.142725227366661e-07 0.7468128004450286 6.14272601580994e-07 0.744910856519283 6.142727023870358e-07 0.7424801602439853 \
6.142728369152764e-07 0.7392377693660663 6.142729741401358e-07 0.7359316755186537 6.142731176199872e-07 0.7324773442723981 6.142732660441767e-07 0.7289066083419234 \
6.142734093054718e-07 0.7254625447335662 6.142735493824513e-07 0.7220977259655398 6.142737058083174e-07 0.7183435968963056 6.142738302100673e-07 0.715360858370426 \
6.14273951271848e-07 0.7124600029613375 6.1427410478411e-07 0.7087850045121084 6.142742395660554e-07 0.7055614325718365 6.142743656650877e-07 0.7025479112911024 \
6.142745088393713e-07 0.6991289103945657 6.142746289211628e-07 0.6962626602560111 6.142747581554914e-07 0.6931807499479741 6.142748646405391e-07 0.6906432840523983 \
6.142749769163615e-07 0.6879696524977363 6.142750732516477e-07 0.6856773754336868 6.142751760613402e-07 0.683232326200841 6.14275270865193e-07 0.6809792012818872 \
6.142753761871231e-07 0.6784784437814733 6.142754846257769e-07 0.6759058899658261 6.142755836350576e-07 0.673558569590366 6.142757003916503e-07 0.6707929011939652 \
6.142758084769277e-07 0.6682347329991606 6.142759184831366e-07 0.6656332609774134 6.142760045709786e-07 0.6635992664604092 6.142761341661182e-07 0.6605400273835189 \
6.142762267673658e-07 0.6583552307294462 6.142763225550924e-07 0.6560965362104854 6.142764075070783e-07 0.6540950852804182 6.142765268016021e-07 0.6512869789851043 \
6.142766140715398e-07 0.6492343850333612 6.142767047785613e-07 0.6471030993779646 6.14276805943536e-07 0.6447280068361273 6.142768857743593e-07 0.6428551652550211 \
6.142769745601937e-07 0.6407732405330839 6.142770522504205e-07 0.6389536101386547 6.142771140193683e-07 0.6375081226244841 6.142771777840134e-07 0.6360167668935747 \
6.142772410182331e-07 0.634538653569437 6.142772802588059e-07 0.6336218002627473 6.142773208978281e-07 0.6326726453797233 6.142774009823624e-07 0.6308039353694699 \
6.142774708865426e-07 0.6291742390428672 6.142775215232567e-07 0.6279942052995945 6.142775602728994e-07 0.6270914175114127 6.142775992678787e-07 0.6261832343283663 \
6.142776438826266e-07 0.6251445623164014 6.142776867390832e-07 0.6241478292286105 6.142777370536867e-07 0.6229782634938205 6.142777889908641e-07 0.6217719122409077 \
6.142778740584486e-07 0.6197972300178722 6.142779340388659e-07 0.6184052992407258 6.142780238260749e-07 0.61632338076978 6.142781002901565e-07 0.6145529519516876 \
6.142781798544472e-07 0.6127119801362371 6.142782608910593e-07 0.6108383709630588 6.142783501053817e-07 0.6087775861620425 6.142784409653938e-07 0.6066826282541496 \
6.142785281841023e-07 0.6046739453334793 6.142786219572931e-07 0.6025158549334848 6.142787236427564e-07 0.6001788642681311 6.142788232408485e-07 0.5978941858483342 \
6.142789350958888e-07 0.5953317151711254 6.14279051129026e-07 0.5926772450523136 6.142791727501318e-07 0.5899020947998995 6.142792771339459e-07 0.5875236635596754 \
6.142794219241658e-07 0.5842296531729801 6.142795345841267e-07 0.5816734289694181 6.14279643596094e-07 0.5792035939892568 6.142797360755373e-07 0.5771100174076607 \
6.142798295261766e-07 0.5749994714793375 6.142799218520404e-07 0.5729181236728181 6.142799944387413e-07 0.571283073141143 6.142800503929671e-07 0.5700232888304386 \
6.142801114612485e-07 0.5686498830286455 6.142802099507645e-07 0.5664400707212188 6.142802731622084e-07 0.5650238531380825 6.142803335881769e-07 0.5636708824310654 \
6.142804105365601e-07 0.5619492451093103 6.142804736951014e-07 0.5605380106414651 6.142805620087098e-07 0.558569506627369 6.14280633210033e-07 0.5569845302974165 \
6.142807197457869e-07 0.555060151797141 6.142808410985601e-07 0.5523665438352664 6.142809690278082e-07 0.5495364947125975 6.142810671584392e-07 0.5473694328713704 \
6.142811802824346e-07 0.5448752016832871 6.14281282350254e-07 0.5426314425864434 6.142814012991245e-07 0.5400217272291628 6.142815043868321e-07 0.5377630705755105 \
6.142816185939865e-07 0.5352670017334624 6.142817320096582e-07 0.532794946211756 6.14281859080713e-07 0.5300302694710822 6.14281982900802e-07 0.5273426867079006 \
6.142821276896071e-07 0.5242103332418484 6.142822635131097e-07 0.5212782585303676 6.142824185679684e-07 0.5179428401013338 6.142825794198527e-07 0.5144913885072363 \
6.142827581493005e-07 0.5106699876709851 6.1428294832834e-07 0.5066200804011861 6.142831582303622e-07 0.5021665212646098 6.142833869363468e-07 0.4973332357952056 \
6.142836408642852e-07 0.4919960258408594 6.142838817977505e-07 0.4869529241725989 6.142841779602358e-07 0.4807889695952298 6.142844679576231e-07 0.4747910561470179 \
6.142847742009557e-07 0.4684976697011882 6.142850948768875e-07 0.4619520863481486 6.142854227440541e-07 0.4553041925245184 6.142857629891091e-07 0.4484521981997251 \
6.142860884146545e-07 0.4419418052309769 6.142864103218021e-07 0.4355465312739703 6.142867405359073e-07 0.4290298934287748 6.142870965284996e-07 0.4220583188787752 \
6.142874154069286e-07 0.4158579595363656 6.14287752858691e-07 0.4093433989943853 6.142881807254075e-07 0.4011531841887147 6.142885294373556e-07 0.3945419525178304 \
6.142888370733194e-07 0.388759214407489 6.142892168998106e-07 0.3816861832573664 6.142895480893721e-07 0.3755780492082042 6.142898316974524e-07 0.370391509977049 \
6.142901425163967e-07 0.3647512908748707 6.142904218330045e-07 0.3597258263082204 6.142906483291526e-07 0.3556836811642302 6.142908640115378e-07 0.3518598964090484 \
6.142910612955428e-07 0.3483842179544538 6.142912662800023e-07 0.3447988491770444 6.142914785019663e-07 0.3411119200457455 6.142917338071541e-07 0.33670771290924 \
6.142919753294026e-07 0.3325734463267218 6.142922067067309e-07 0.3286464933807047 6.142924215592308e-07 0.3250253651850565 6.142926421183882e-07 0.3213332986541765 \
6.142928435443551e-07 0.3179852906236645 6.142930466126061e-07 0.3146379646143546 6.142932445082156e-07 0.3114011111455273 6.142934314693022e-07 0.3083651674074345 \
6.142936252695217e-07 0.3052406640298299 6.142938291861338e-07 0.3019773030815858 6.142940082554677e-07 0.2991336297844484 6.14294243846324e-07 0.2954229173226265 \
6.142944446504233e-07 0.2922868215109002 6.142946458293147e-07 0.2891696385850206 6.142948696390574e-07 0.2857334090862961 6.142950342018032e-07 0.2832271910241367 \
6.142952111291889e-07 0.2805503385691353 6.14295396922194e-07 0.2777610713150803 6.142955787376702e-07 0.2750538970423583 6.142957577624632e-07 0.2724132377985424 \
6.142959251076164e-07 0.2699606650006489 6.142960855365336e-07 0.2676371805838822 6.142962081102854e-07 0.2658719571410424 6.142963578748139e-07 0.2637236906090554 \
6.142964855719403e-07 0.2619099339733745 6.14296592880312e-07 0.2603957336038235 6.142967088809744e-07 0.2587625259947361 6.142968191895705e-07 0.2572125806747212 \
6.14296945068767e-07 0.2554509781935611 6.142970605506182e-07 0.2538402638894013 6.142971951315211e-07 0.2519757335310172 6.142973071947753e-07 0.2504255755821768 \
6.142974575341346e-07 0.2483447107137444 6.142975971599893e-07 0.2464124269747185 6.142977430518096e-07 0.2444035064209518 6.142978760124476e-07 0.2425734862730615 \
6.14297999574161e-07 0.2408709992523319 6.142981467838532e-07 0.2388417729476062 6.142982633706824e-07 0.2372355665500016 6.142984028258316e-07 0.23532008003217 \
6.142985370003013e-07 0.2334768281602104 6.142986629767575e-07 0.2317465561243653 6.142987823761605e-07 0.2301094434087779 6.142988772305854e-07 0.2288105340759602 \
6.142989903681845e-07 0.2272617792622066 6.142990706846421e-07 0.2261626001158484 6.142991582496985e-07 0.2249657246820506 6.142992837868356e-07 0.2232507767215072 \
6.142993894805428e-07 0.2218101326756785 6.142994791350539e-07 0.2205921574607158 6.14299549986253e-07 0.2196300825522397 6.142995930147827e-07 0.2190460135436258 \
6.142996353053263e-07 0.2184724035808872 6.142996776470424e-07 0.2178984240735344 6.142997498424615e-07 0.2169203674089526 6.142997922358173e-07 0.2163464205126744 \
6.14299827490656e-07 0.2158693585303403 6.142998716822395e-07 0.2152716287340076 6.142999412904665e-07 0.2143309212991285 6.142999756337964e-07 0.2138672544767182 \
6.143000200933248e-07 0.2132698436071631 6.143000877718061e-07 0.2123628126304402 6.143001741990649e-07 0.2112058698236149 6.143002488356675e-07 0.2102078598594563 \
6.143003301376756e-07 0.2091219706754807 6.143004270150593e-07 0.2078300362310651 6.143005529985482e-07 0.2061528795789772 6.143006555333841e-07 0.2047906894256944 \
6.143007570169014e-07 0.2034500128132261 6.143008580825969e-07 0.202119416354989 6.143009546968166e-07 0.2008491615811921 6.143010566612396e-07 0.1995112314821507 \
6.143011633834836e-07 0.1981153840927639 6.143012717886237e-07 0.1967018790395962 6.143013837827796e-07 0.1952465002768531 6.14301496249907e-07 0.1937897263683151 \
6.143016083232463e-07 0.1923454332378671 6.143017162157206e-07 0.1909603537828802 6.143018175986493e-07 0.1896629368444172 6.143019092360985e-07 0.1884941330679491 \
6.143020032117073e-07 0.1872990757663449 6.143020744780721e-07 0.1863957871745983 6.1430215115336e-07 0.1854271890400033 6.143022548124749e-07 0.184122202819407 \
6.143023284795955e-07 0.1831974022686171 6.143024018254956e-07 0.1822796569444652 6.143025152158449e-07 0.1808667181969195 6.143026030744851e-07 0.1797760932362061 \
6.143026869231621e-07 0.1787387947787487 6.143028158855897e-07 0.1771515524267008 6.143029177720844e-07 0.1759040172436072 6.143030234727908e-07 0.1746156056808686 \
6.143031251208657e-07 0.1733818993219825 6.143032559825841e-07 0.1718019019596718 6.143033631792215e-07 0.1705140034701537 6.14303492508118e-07 0.168969083715685 \
6.143036042046102e-07 0.167642098072289 6.143037045351886e-07 0.1664555496840579 6.143038003357432e-07 0.1653276075899142 6.143039111480153e-07 0.1640289617085985 \
6.143039985482962e-07 0.1630090521997956 6.143041098694134e-07 0.1617156184952586 6.143042028212721e-07 0.1606409001560029 6.143042903941501e-07 0.1596330843918451 \
6.143043920250233e-07 0.1584700928658864 6.14304476479078e-07 0.1575086241734052 6.143045515834574e-07 0.1566573095634876 6.143046294056999e-07 0.1557789554714152 \
6.143047097635688e-07 0.1548759612316424 6.143048108183989e-07 0.1537464547857493 6.143048932519626e-07 0.1528311848879565 6.143049855565143e-07 0.1518114053368895 \
6.14305062490987e-07 0.150965812476358 6.143051454135576e-07 0.1500585909391909 6.143052169442981e-07 0.1492793026301012 6.143053133277974e-07 0.1482344968214558 \
6.143053835562832e-07 0.1474766665551334 6.143054665365612e-07 0.1465853655470201 6.143055279788245e-07 0.1459298106834085 6.143055996612093e-07 0.1451677491870439 \
6.14305668289752e-07 0.1444408762699853 6.143057185582615e-07 0.1439102090153988 6.143057661380673e-07 0.143409423336876 6.14305820187418e-07 0.1428423132663369 \
6.143058795295158e-07 0.1422216078256897 6.143059475649228e-07 0.1415124633834424 6.14306023828345e-07 0.1407207186008814 6.143060921081446e-07 0.1400161356079559 \
6.143061868943229e-07 0.1390460813732662 6.143062764481352e-07 0.1381341561933974 6.143063481336088e-07 0.1374075731330657 6.143064320850176e-07 0.1365606113096345 \
6.143064973974727e-07 0.1359045398875483 6.143065588405982e-07 0.1352895588344758 6.143066331170967e-07 0.1345490408254265 6.143066953273574e-07 0.1339328028964004 \
6.143067632983657e-07 0.133265236037424 6.143068225054055e-07 0.1326856657519672 6.143068951778785e-07 0.1319767402814105 6.143069701979877e-07 0.1312477270463112 \
6.143070556514106e-07 0.1304208267333309 6.143071417517503e-07 0.1295914604616623 6.143072418772051e-07 0.1286317929389105 6.143073231668748e-07 0.127857435971709 \
6.143074249342227e-07 0.1268981149578782 6.143075091821821e-07 0.1261072369695883 6.143076079989111e-07 0.1251836587365037 6.143076808394557e-07 0.1245055382686853 \
6.143077608655429e-07 0.1237631876254407 6.14307831351338e-07 0.1231117958237987 6.143079038817606e-07 0.1224439308288319 6.143079813507563e-07 0.1217331219782777 \
6.143080887021039e-07 0.1207554316575004 6.143081893401196e-07 0.1198442997624752 6.143082619276735e-07 0.1191899427853172 6.143083307595138e-07 0.1185715582611356 \
6.143083965463339e-07 0.1179824683205609 6.143084661751317e-07 0.1173610347366148 6.143085365588768e-07 0.1167350538439435 6.143086117372496e-07 0.1160688810594495 \
6.143087159914846e-07 0.1151493019715505 6.143087911261386e-07 0.114489769343061 6.143088600412231e-07 0.1138870655592168 6.143089232460945e-07 0.1133369146236164 \
6.143089927874598e-07 0.1127339156958381 6.14309050088964e-07 0.1122385190692166 6.14309121730019e-07 0.1116210355509516 6.143091795650925e-07 0.1111240709857579 \
6.143092516865272e-07 0.1105063809580559 6.1430931410261e-07 0.1099736279351742 6.143093984241316e-07 0.1092565349771765 6.143094660201e-07 0.1086842173446869 \
6.143095748160323e-07 0.1077671916889585 6.143096791265639e-07 0.1068924975608609 6.14309758614772e-07 0.1062289053282379 6.143098461831824e-07 0.1055008617114655 \
6.143099096395349e-07 0.1049752776433979 6.143099713506517e-07 0.10446579874651 6.14310075190416e-07 0.103612238268202 6.143101578711175e-07 0.1029362225408096 \
6.143102563391439e-07 0.1021348761715451 6.14310340785582e-07 0.101450818648051 6.143104572630618e-07 0.1005121841703865 6.143105919965077e-07 0.09943411943161744 \
6.143107280660444e-07 0.0983541971400249 6.143108423854515e-07 0.09745369041838402 6.143109278525961e-07 0.09678457778867394 6.143110381342688e-07 0.09592640631053104 \
6.143111189226223e-07 0.09530159220710262 6.143112184734933e-07 0.09453592511176086 6.143113084215428e-07 0.09384821103094763 6.14311380924943e-07 0.09329669945188329 \
6.143114626670093e-07 0.09267796846073476 6.143115907872446e-07 0.09171467366828615 6.143116721993079e-07 0.09110674702409056 6.143117466312152e-07 0.09055373306570065 \
6.143118216050993e-07 0.08999936228352182 6.143119010240744e-07 0.08941505746347288 6.143120096849317e-07 0.08862052380504259 6.143121040449035e-07 0.08793517800096999 \
6.143121934400264e-07 0.08728987318634121 6.143123002057425e-07 0.086524181682867 6.143124187081826e-07 0.08568073755029131 6.143125602332527e-07 0.08468224831562859 \
6.143126933716761e-07 0.08375174214918565 6.143128342170073e-07 0.08277682112810406 6.143129832689884e-07 0.08175525972387458 6.143131190667175e-07 0.08083369778093191 \
6.143132605232322e-07 0.0798830809748103 6.143133957831475e-07 0.07898330517332906 6.143135371649882e-07 0.07805242629322809 6.143136842327612e-07 0.07709434677344783 \
6.143138359609018e-07 0.07611680364043326 6.143140013092032e-07 0.07506403321855706 6.143141651767208e-07 0.07403332863189842 6.143143414906487e-07 0.07293832728335037 \
6.143145309257505e-07 0.07177777688466977 6.14314741692455e-07 0.07050569389938771 6.143149614649522e-07 0.06920150027616521 6.143151964331044e-07 0.06783224552442871 \
6.143154553336539e-07 0.06635227408830123 6.14315750264117e-07 0.06470266364809808 6.143160546101784e-07 0.06304001691994518 6.143164165564573e-07 0.06111393619706453 \
6.143167326842125e-07 0.05947639552636011 6.143171740066774e-07 0.0572596911373907 6.143174875727196e-07 0.05573556853365672 6.14317911072189e-07 0.0537382660685313 \
6.143182550240425e-07 0.05216649213267931 6.143185952653102e-07 0.05065508790922631 6.143189061028997e-07 0.04931137323461653 6.143192005748017e-07 0.04807062469528345 \
6.143194942742994e-07 0.04686392507224969 6.143197691455355e-07 0.04576537019482012 6.143200446857014e-07 0.04468949010490332 6.143203097762297e-07 0.04367785045825667 \
6.143205865333108e-07 0.04264571401740119 6.143208698014357e-07 0.04161414314527601 6.143211677947347e-07 0.04055545327485047 6.143214272801311e-07 0.03965542606183669 \
6.143216573035691e-07 0.03887446236327848 6.143218769951559e-07 0.03814321686473518 6.14322101935296e-07 0.0374128399305801 6.1432242218897e-07 0.0363978329183388 \
6.143227099868201e-07 0.03550963653148703 6.143229863821537e-07 0.03467738358988744 6.143232702012828e-07 0.03384352473043348 6.143235083105866e-07 0.03315996078327022 \
6.143237926213707e-07 0.03236211345273886 6.143240345332207e-07 0.03169864947531036 6.143242696733945e-07 0.03106710921041438 6.143245113809233e-07 0.03043352335444016 \
6.143247483338565e-07 0.02982731501219571 6.14324978676274e-07 0.02925002048968134 6.143251924268523e-07 0.02872465224286764 6.143253982738151e-07 0.02822791768061097 \
6.143257906108381e-07 0.02730524204782691 6.143259790028487e-07 0.02687312495148303 6.143263546143072e-07 0.02603163971789 6.143265290810819e-07 0.02564950258131362 \
6.143269530155409e-07 0.02474274850847508 6.14327073769958e-07 0.02449086781212801 6.143275440207215e-07 0.02353384026002922 6.143276932357865e-07 0.02323677291035493 \
6.143280868679981e-07 0.02246740853134286 6.143282578943424e-07 0.02213909006726131 6.143287451732745e-07 0.02121869533024997 6.143288872209831e-07 0.02095326544309953 \
6.143294202372519e-07 0.01997576278857772 6.14329542401289e-07 0.01975737097014436 6.143300645590335e-07 0.01885981776906158 6.143302351373363e-07 0.01857989792133653 \
6.143307224503993e-07 0.01781360777737795 6.143308939733227e-07 0.01755501440977742 6.143315137600803e-07 0.01666567753024489 6.143316846844061e-07 0.0164316648397145 \
6.143323902353963e-07 0.01551160061118263 6.14332552852409e-07 0.01530799450170666 6.143333097458993e-07 0.01439879525764199 6.143334506625442e-07 0.01423641007536438 \
6.143343506613842e-07 0.01324361033368418 6.143344380106346e-07 0.01315122959105692 6.14335342363989e-07 0.01223321097894121 6.143354795559379e-07 0.01209984223734439 \
6.14336450212214e-07 0.01118944790767422 6.14336578130092e-07 0.01107451071402888 6.143377285400387e-07 0.01011008206277823 6.143378223420746e-07 0.01003687265682024 \
6.143390783878875e-07 0.009120584045805383 6.143392159292007e-07 0.009026502753623255 6.143407746836019e-07 0.008029670037698805 6.143408584862873e-07 0.007977066150721189 \
6.143424638651058e-07 0.00699828665725172 6.143425747634501e-07 0.006935886594503895 6.143445070098238e-07 0.005959177461785255 6.143446867147595e-07 0.005876661013304485 \
6.143467985058761e-07 0.004981749118765498 6.143471412910116e-07 0.004848482978762325 6.143496544570453e-07 0.003966891390423618 6.143501241787149e-07 0.003819799497680527 \
6.143537644949897e-07 0.002847564273158896 6.143542802321751e-07 0.002731633924241866 6.143596220620139e-07 0.001773027297371861 6.143599073822989e-07 0.001729522787584184 \
6.143651360301289e-07 0.0007540451492352357 6.143653101766958e-07 0.0007162692714263865 6.170136987690021e-07 -0.0001123232525192561 6.170138717942903e-07 -0.0002901710972538241 \
6.170144915460445e-07 -0.001202022686018724 6.170145801152216e-07 -0.001365806793032466 6.170149410863549e-07 -0.002110727959526865 6.1701506578065e-07 -0.002395793696299351 \
6.170154296225314e-07 -0.003299857180474864 6.170156008981996e-07 -0.003758114451912169 6.170158948960377e-07 -0.004576312838821549 6.170160051044431e-07 -0.004886880824040592 \
6.170162833584409e-07 -0.005643955697619643 6.170164046322499e-07 -0.00594200199557267 6.170174982543479e-07 -0.00517389603226481 6.170176213582281e-07 -0.004409713243767066 \
6.170177448263028e-07 -0.003462788751204457 6.170178649920999e-07 -0.002366010162083454 6.170179628537676e-07 -0.001346276287748183 6.170180695561039e-07 -0.0001076498664581183 \
6.170181813974884e-07 0.001328007358939307 6.170183173718548e-07 0.003256083960376262 6.170184394010113e-07 0.00514709866632534 6.170186278172891e-07 0.008343062029134115 \
6.170187688058191e-07 0.01093380316938193 6.170189215775226e-07 0.01391176330477175 6.170190642801505e-07 0.01683596409946878 6.170192186323876e-07 0.02013443377634912 \
6.170193744260431e-07 0.02358734537610087 6.170195304833402e-07 0.02715365164079262 6.170196778877403e-07 0.03060642997674319 6.170198265044852e-07 0.03415780069914553 \
6.170199819257017e-07 0.03793559522944389 6.170201403115321e-07 0.04184227512730877 6.170203052511541e-07 0.04596085539464361 6.170204795004229e-07 0.05035714787605008 \
6.170206584435392e-07 0.05491177248689325 6.170208475830321e-07 0.0597604232635115 6.170210503636104e-07 0.06498910043066243 6.170212697356368e-07 0.07067233091134768 \
6.170215005721333e-07 0.07667464705993039 6.170217473839692e-07 0.0831083675499642 6.170220175160799e-07 0.09016243555275107 6.170223107041881e-07 0.0978236474935409 \
6.170226343596258e-07 0.1062798466079799 6.17022997926912e-07 0.1157689210849182 6.170233902204302e-07 0.1259925151671456 6.170238386999148e-07 0.1376538644086695 \
6.170243603994004e-07 0.1511757390224034 6.170249727720439e-07 0.1669844191341421 6.170256494173591e-07 0.1843663871188266 6.170264363276496e-07 0.2044554566749352 \
6.170273175487439e-07 0.2267919980918504 6.170281372923844e-07 0.2474048556006221 6.170288657453285e-07 0.2655829647002126 6.17029507221317e-07 0.2814688958417333 \
6.170300831444853e-07 0.2956305456066151 6.170306204013019e-07 0.3087428400511723 6.17031124292597e-07 0.3209487846516751 6.170316018961449e-07 0.3324328152479784 \
6.170320800193788e-07 0.343838772307344 6.170325321182285e-07 0.3545331600964184 6.170330038845194e-07 0.365596737404158 6.170334475813599e-07 0.3759140547845509 \
6.170339695498976e-07 0.3879344734281669 6.170344970878305e-07 0.399956933836353 6.170348766025743e-07 0.4085271910771138 6.170354055641745e-07 0.4203606102508351 \
6.170358748832553e-07 0.4307444005277802 6.170363100387911e-07 0.4402814026247405 6.170367575161174e-07 0.4500002273945978 6.170371975395924e-07 0.4594737646471725 \
6.170376008413354e-07 0.4680814138276727 6.170379192411013e-07 0.4748254127722248 6.170382892190148e-07 0.4826007100982719 6.17038525472097e-07 0.4875314737878706 \
6.170387605434932e-07 0.4924129045770672 6.170390118828311e-07 0.4975994385012801 6.170393182698654e-07 0.5038799449729535 6.170395752283189e-07 0.5091120301871851 \
6.170397837026154e-07 0.5133309170973237 6.170399840849047e-07 0.5173683849445317 6.170401264786059e-07 0.5202244049244739 6.170402754030717e-07 0.5231993726577677 \
6.170404869493287e-07 0.5274019882470222 6.170407130069516e-07 0.5318780389403845 6.170409075493335e-07 0.5357103559602913 6.170410966812289e-07 0.539423417888626 \
6.170413261282768e-07 0.5439012399750046 6.170415086340828e-07 0.5474563135343053 6.170417459969519e-07 0.5520623276458133 6.170420149912601e-07 0.5572695987004129 \
6.170422639017101e-07 0.5620706638085723 6.170425079185313e-07 0.5667633705755619 6.170427802737437e-07 0.5719926523718327 6.170430416698736e-07 0.5769928369418796 \
6.170432993012793e-07 0.5819084237686675 6.17043546144628e-07 0.586601202059797 6.170437918903539e-07 0.5912552023551558 6.170440184678743e-07 0.5955288021520931 \
6.170442496200641e-07 0.5998646534936181 6.170444559004441e-07 0.6037202012184053 6.170446840212041e-07 0.6079592993751251 6.170449064011853e-07 0.6120725203834017 \
6.17045133377667e-07 0.6162454422471376 6.170453484306168e-07 0.6201823359462864 6.170455778001903e-07 0.6243500782103125 6.170458468230649e-07 0.6292041961704016 \
6.170460698367118e-07 0.6331993632081415 6.170462820912891e-07 0.6369772451758789 6.170464934888789e-07 0.6407176358819484 6.17046693558109e-07 0.644236566349866 \
6.170469231519586e-07 0.6482486956559365 6.170471639888863e-07 0.6524328529570182 6.170473457382733e-07 0.6555667906748446 6.170475342864999e-07 0.6588018260593631 \
6.170476873661394e-07 0.6614154033769962 6.170478593744212e-07 0.6643352515471471 6.170480095472396e-07 0.6668697017322168 6.170481460645293e-07 0.6691578850264722 \
6.170482956937163e-07 0.6716547631652277 6.170484234340851e-07 0.673777752640997 6.170485630202226e-07 0.6760856948620949 6.170486872589102e-07 0.6781310478824312 \
6.170488184087495e-07 0.6802827752320969 6.170489428500931e-07 0.6823179209931315 6.170490800809157e-07 0.6845542421253382 6.170492003290863e-07 0.6865048414796368 \
6.170493416605294e-07 0.6887891282595083 6.170494419916407e-07 0.6904033553735033 6.170495631093427e-07 0.6923460943304175 6.170496538868777e-07 0.6937948943079848 \
6.170497511453436e-07 0.6953408241330762 6.170498473532237e-07 0.6968660703265798 6.170499359670681e-07 0.6982647859968389 6.170500332550912e-07 0.6997938110311075 \
6.170501657237294e-07 0.7018622871835729 6.170503209139279e-07 0.7042674555997347 6.170504587918793e-07 0.7063866855441746 6.170506036461533e-07 0.7085960165693863 \
6.170507307079098e-07 0.7105202221428537 6.170508553934701e-07 0.7123960184768648 6.170509680988463e-07 0.7140814553427599 6.170510798891907e-07 0.7157437310299281 \
6.170511806678399e-07 0.7172341607972841 6.170513179462954e-07 0.7192525454101454 6.170514376303672e-07 0.7210013704967912 6.170515570598379e-07 0.7227365757678518 \
6.170516839430602e-07 0.7245692610776365 6.17051808360712e-07 0.7263556789600311 6.170519320935366e-07 0.728121726658988 6.170520586890634e-07 0.7299181396522603 \
6.17052189074464e-07 0.7317573312219798 6.170523118842844e-07 0.7334798522758219 6.170524473200596e-07 0.7353678990088863 6.170525486098379e-07 0.7367723836293941 \
6.170526562323338e-07 0.7382576460517265 6.170527457604157e-07 0.7394878879617913 6.170528603087849e-07 0.7410528648863303 6.170529483370413e-07 0.7422487366778059 \
6.170530554151068e-07 0.7436953530868765 6.170531854801004e-07 0.7454403311053276 6.170532967597954e-07 0.7469230742113165 6.170534013783548e-07 0.7483084058091373 \
6.170535254613402e-07 0.7499400420429273 6.170536737621685e-07 0.7518749696944975 6.170537951620327e-07 0.7534462209622173 6.170539096027802e-07 0.7549170836379747 \
6.170540499400977e-07 0.7567069362027918 6.170541917029811e-07 0.7584995177563068 6.170543095039188e-07 0.759977341175643 6.170544374807853e-07 0.761570846386187 \
6.170545791832092e-07 0.7633205808366864 6.170546966945227e-07 0.7647599110190483 6.170548422997917e-07 0.7665289162262866 6.170549639940993e-07 0.7679951561698679 \
6.170550827247088e-07 0.7694149786178283 6.170552050113037e-07 0.7708662727382939 6.170553320558196e-07 0.77236234268503 6.170554416997921e-07 0.7736439866494906 \
6.170555673867047e-07 0.7751025186690397 6.170556734018051e-07 0.776323977486031 6.170558089877718e-07 0.7778743028704433 6.170559339507686e-07 0.7792913979962601 \
6.170560598569209e-07 0.7807070123991936 6.170561751241669e-07 0.7819915514687489 6.170562814286401e-07 0.7831664991275713 6.17056419833432e-07 0.7846822315516878 \
6.170565691298821e-07 0.7862997378875561 6.170567146373276e-07 0.7878588534534761 6.170568340418389e-07 0.7891257303126159 6.170569691346634e-07 0.7905455128963393 \
6.170570903878263e-07 0.7918076974797237 6.170572333811048e-07 0.7932816011184505 6.170573775854105e-07 0.7947523458802197 6.17057503122239e-07 0.7960199014141693 \
6.170576221686118e-07 0.7972110037065316 6.170577341044954e-07 0.7983213107123885 6.170578389760474e-07 0.7993531099923881 6.170579342264591e-07 0.8002831901653534 \
6.170580705697047e-07 0.8016020813281191 6.170581873938354e-07 0.8027203407102198 6.170583067984452e-07 0.803852171037294 6.170584289052493e-07 0.8049980820693966 \
6.170585518602505e-07 0.8061401395390313 6.170586788289509e-07 0.8073073595000361 6.170588040685604e-07 0.8084467645495962 6.17058934640955e-07 0.8096220968518901 \
6.170590606314733e-07 0.8107441738369082 6.170591888173857e-07 0.8118738099374113 6.170592943471138e-07 0.8127947795787664 6.170593972188868e-07 0.8136847278655364 \
6.17059490214057e-07 0.8144826950388273 6.170596140106596e-07 0.8155354283166244 6.170597019789174e-07 0.8162769513478326 6.170598007099885e-07 0.8171027376706747 \
6.170599439751418e-07 0.8182889948057973 6.170600792538271e-07 0.8193962136425846 6.170601883684495e-07 0.8202800249700468 6.170603364517579e-07 0.8214657808291811 \
6.170604862226849e-07 0.8226492530953341 6.170606114572855e-07 0.8236267526687548 6.170607554487031e-07 0.8247372275730155 6.170608795047738e-07 0.8256825756473101 \
6.170610299680322e-07 0.8268152483647575 6.17061165678884e-07 0.8278240064655301 6.17061290697392e-07 0.828742521381556 6.170614084523219e-07 0.8295983347934622 \
6.170615544291349e-07 0.8306466023667578 6.170617209384522e-07 0.8318251482734692 6.170618518610281e-07 0.8327390940956469 6.170620252884657e-07 0.8339327615268647 \
6.170621934353481e-07 0.8350717495747054 6.170623632702772e-07 0.8362042975620877 6.170625441950478e-07 0.8373912937861997 6.170626872933069e-07 0.8383160748488641 \
6.170628013791983e-07 0.8390446117604563 6.170629315531841e-07 0.8398665237782376 6.170630333942663e-07 0.8405024977857931 6.170631502136154e-07 0.8412243379523001 \
6.170632870780449e-07 0.8420597162999857 6.170634848766686e-07 0.8432475311273343 6.170636764807397e-07 0.8443767279905872 6.170638859212216e-07 0.8455874169714939 \
6.170640678468519e-07 0.8466193100105236 6.170642649799575e-07 0.8477171434207121 6.170644383298479e-07 0.8486653666163242 6.170646213292318e-07 0.8496493024239481 \
6.17064792495495e-07 0.8505537352954988 6.170649671272818e-07 0.8514606693963016 6.170651423896692e-07 0.8523550102558151 6.170653185417845e-07 0.8532381479010797 \
6.170655088128237e-07 0.8541746551565574 6.170656994147744e-07 0.85509499218684 6.170659000624008e-07 0.8560449689899254 6.170660926729659e-07 0.8569390259424264 \
6.170663033306522e-07 0.8578972157030333 6.170665314560508e-07 0.8589122247267402 6.170667972133685e-07 0.8600655879592763 6.170670958378129e-07 0.8613244245924475 \
6.170673721693317e-07 0.862454900702886 6.170676564023905e-07 0.8635842083919951 6.17067930614306e-07 0.8646423892283146 6.170682028423722e-07 0.8656634505877856 \
6.170684730511913e-07 0.8666487272755322 6.17068730204067e-07 0.8675609437488442 6.170690027863351e-07 0.868501515423508 6.170692787713349e-07 0.8694269133137555 \
6.170695488729115e-07 0.8703069289141475 6.170698487348628e-07 0.8712546000783432 6.170702197689933e-07 0.8723856543073821 6.170705147067536e-07 0.8732530157608677 \
6.170707689975357e-07 0.8739790309043101 6.170710672549513e-07 0.8748056771600844 6.170713408634847e-07 0.8755409825400007 6.170715769915496e-07 0.8761583495732972 \
6.170718173369303e-07 0.876770807053994 6.170720396702121e-07 0.8773233906735478 6.170722336759598e-07 0.8777948466981503 6.17072563398506e-07 0.8785737911727464 \
6.170727185719444e-07 0.8789308835864816 6.170730363474729e-07 0.8796437246174529 6.1707321520917e-07 0.8800342982281311 6.170735576710471e-07 0.8807611334253193 \
6.170737417995192e-07 0.8811407335605206 6.170742166778565e-07 0.8820849466541889 6.170743840740527e-07 0.8824061830950772 6.170748499154564e-07 0.8832696475595492 \
6.17075030737665e-07 0.8835931319180218 6.170755247759143e-07 0.8844450822729043 6.170756661243274e-07 0.8846804878101884 6.170762724573853e-07 0.8856498028150036 \
6.170764245267248e-07 0.8858829444029697 6.170770712152002e-07 0.8868329272509302 6.170771995097231e-07 0.8870138524519416 6.170778476269278e-07 0.8878919388991984 \
6.170779774257915e-07 0.8880607713689423 6.170787556274809e-07 0.8890227771434612 6.170788706844142e-07 0.8891574578072456 6.170797263428482e-07 0.8901003239091128 \
6.170798717076157e-07 0.8902505899439886 6.1708085746403e-07 0.8911948786459364 6.170810785690402e-07 0.8913892999646706 6.170822236960192e-07 0.8923206810037944 \
6.170823549126186e-07 0.892422953350996 6.170836961242674e-07 0.8934189515818408 6.170838475232108e-07 0.8935240845833778 6.170853289614591e-07 0.8944568913393511 \
6.170855678408922e-07 0.8945912088657246 6.170873371610739e-07 0.8954685138428928 6.170877263108405e-07 0.895637400736999 6.170901199766275e-07 0.896526474291006 \
6.170905956894498e-07 0.8966764365754722 6.17094011699057e-07 0.8975478548673914 6.170946588490716e-07 0.8976786076740833 6.171021370136781e-07 0.8986646932675814 \
6.171028095907965e-07 0.8987192862546014 6.171952539953667e-07 0.8997188196574962 6.171959172280509e-07 0.8997241906476866 6.17385126389945e-07 0.900686595210158 \
6.173852884627892e-07 0.9007292695325627 6.173879339836764e-07 0.8998161167154269 6.173881025331539e-07 0.8996881690130656 6.173893792855451e-07 0.8987393243250013 \
6.173895814518808e-07 0.8986030018074492 6.173911895612673e-07 0.8976721249252815 6.173913816671926e-07 0.8975774045828077 6.174064950498387e-07 0.8985726115129884 \
6.174066831087563e-07 0.8986004060702872 6.174179880377677e-07 0.8995874924221801 6.174183614235164e-07 0.8996034751727418 6.179073737866979e-07 0.9005892719715856 \
6.179074845548976e-07 0.9006868984798269 6.179082372272589e-07 0.9015617873136611 6.179083390219455e-07 0.9017086238768567 6.179088744204902e-07 0.9025814930725723 \
6.179089769296628e-07 0.9027670217776843 6.179093691484816e-07 0.9035254014384071 6.17909509991429e-07 0.9038129158713877 6.179099510288813e-07 0.9047472953155866 \
6.179101365144842e-07 0.9051402477015744 6.179106528276013e-07 0.9061269394579334 6.17910737502694e-07 0.9062564181617988 6.179119721747438e-07 0.9053011091537977 \
6.179121293881559e-07 0.9045688862145235 6.179123212048176e-07 0.9034162411061901 6.179124880453484e-07 0.9021712267446264 6.179126350037462e-07 0.9008824031243315 \
6.179127491199424e-07 0.8997575350477262 6.179128789920322e-07 0.8983446880789033 6.179129901095502e-07 0.8970273815442567 6.179130829140294e-07 0.8958483937359277 \
6.17913171236719e-07 0.8946639786015808 6.179132744174779e-07 0.8932058048613533 6.179133666254135e-07 0.8918333298588224 6.179134541956103e-07 0.8904732289418564 \
6.179135681890765e-07 0.8886245408236838 6.179137299935004e-07 0.8858564722885236 6.179139149921175e-07 0.8825005184224666 6.179141071517853e-07 0.8788219124347386 \
6.179143085991386e-07 0.874780227084481 6.17914515009728e-07 0.8704697801294994 6.179147001816806e-07 0.8664790122147591 6.17914884689405e-07 0.862405115500708 \
6.179150578412963e-07 0.8585071391690239 6.179152428873213e-07 0.8542751393552932 6.179154202615245e-07 0.8501657390392787 6.179155970079552e-07 0.8460284987362284 \
6.179157631666058e-07 0.8421077870518131 6.179159252110445e-07 0.8382599993991456 6.17916091783925e-07 0.8342839555277276 6.179162504376617e-07 0.8304816347052207 \
6.179164413136869e-07 0.8258903812682129 6.179166162972586e-07 0.8216694867670907 6.179167862433925e-07 0.8175615830390965 6.179169514195676e-07 0.8135626411663678 \
6.179171246116744e-07 0.8093650119631921 6.179172956738769e-07 0.8052155696745213 6.179174637749139e-07 0.801136095357175 6.179176541098627e-07 0.7965156511928794 \
6.179178376918066e-07 0.7920591698039 6.179180456827317e-07 0.7870113041480956 6.179182682592422e-07 0.7816114142545842 6.17918457674258e-07 0.7770174196885687 \
6.179186509846539e-07 0.7723312127316435 6.179187944302406e-07 0.7688556734481145 6.179189438535907e-07 0.7652374066097742 6.179190630060629e-07 0.7623536300085233 \
6.179191757225445e-07 0.7596269484184472 6.179192849974512e-07 0.7569846861296079 6.179194210272093e-07 0.753697254849378 6.179195338230239e-07 0.750972995067179 \
6.1791965602098e-07 0.7480232093637929 6.179197676057526e-07 0.7453311011793381 6.179198923122156e-07 0.7423241425761796 6.179200466941669e-07 0.7386034578119585 \
6.179202134782327e-07 0.7345862494782525 6.179204306429212e-07 0.7293605768817599 6.1792062520351e-07 0.7246835946359503 6.179207855343955e-07 0.7208333202545074 \
6.179209609599985e-07 0.7166251500492028 6.179211507235729e-07 0.7120779400724765 6.179213394518974e-07 0.7075610435995559 6.179215212732643e-07 0.7032145396962334 \
6.179217058706759e-07 0.6988062725207448 6.179218429538112e-07 0.6955348514212173 6.179219962420495e-07 0.6918805091472418 6.179221916137951e-07 0.6872279990818534 \
6.179223477705466e-07 0.6835136309588888 6.179225057227664e-07 0.6797605476340507 6.179227039740297e-07 0.6750570282453686 6.179228973199279e-07 0.6704763548785364 \
6.179231338252739e-07 0.6648822204491218 6.179233200303777e-07 0.6604858901039825 6.179235576526979e-07 0.6548824851665868 6.179237444514521e-07 0.6504854738275335 \
6.179239250092116e-07 0.6462424706993735 6.179240880851561e-07 0.6424159959781919 6.179242326967206e-07 0.6390271817202816 6.179243732990705e-07 0.6357379642635244 \
6.179245001086568e-07 0.632774906490579 6.179246322451931e-07 0.6296924762754078 6.179247584891446e-07 0.6267508340255646 6.179248897527744e-07 0.6236963630311418 \
6.179250188505141e-07 0.6206978048938425 6.179251582761787e-07 0.6174624210713571 6.179253066461711e-07 0.6140261568477932 6.179255012030603e-07 0.6095278574984737 \
6.179256446489368e-07 0.6062198040692683 6.179258791091827e-07 0.6008245134060309 6.179260510074948e-07 0.5968818013610552 6.179262639280334e-07 0.5920102583789468 \
6.179264363946513e-07 0.5880775912131976 6.179265667191975e-07 0.5851108450968721 6.179266982755174e-07 0.5821241897920357 6.179268085055991e-07 0.5796262478458715 \
6.179269041598466e-07 0.5774603558442819 6.179270033938061e-07 0.5752182923213994 6.179270863119074e-07 0.5733484809858778 6.179271652275342e-07 0.5715706040143225 \
6.179272281563093e-07 0.5701535626562365 6.179272936647861e-07 0.5686800671140783 6.179273741508387e-07 0.5668736364148982 6.179274240168464e-07 0.5657560592102344 \
6.179274732056154e-07 0.5646541775062763 6.179275346754008e-07 0.5632780399140616 6.179275825969294e-07 0.5622058085646952 6.179276334416479e-07 0.5610687758404553 \
6.179276925419032e-07 0.5597501790023616 6.1792775115623e-07 0.5584442118409422 6.179278267823233e-07 0.5567607189607793 6.17927897341035e-07 0.5551915720267918 \
6.179279864710419e-07 0.5532116467156011 6.1792807569462e-07 0.5512351177508077 6.179281609982305e-07 0.5493490637975145 6.179282486251969e-07 0.5474138635528197 \
6.179283456271202e-07 0.545274424894262 6.179284499728913e-07 0.5429792414815097 6.179285662643155e-07 0.5404269323775457 6.17928672601932e-07 0.5380963700835184 \
6.179287843108152e-07 0.5356536306660374 6.179288966052949e-07 0.5332047801427824 6.179290238028542e-07 0.5304364255197962 6.17929146572528e-07 0.5277698476303582 \
6.179292887969246e-07 0.5246912237717902 6.179294251600566e-07 0.5217463069543907 6.179295773811234e-07 0.5184691491721333 6.179297370173294e-07 0.5150420887864461 \
6.179299129925215e-07 0.5112761258030903 6.179301015011087e-07 0.5072591542828934 6.179303085676898e-07 0.5028616940969075 6.179305335096624e-07 0.4981043078903621 \
6.179307849056188e-07 0.4928144328841237 6.17931021331185e-07 0.4878598554762091 6.179313184949192e-07 0.4816683149127979 6.179316091722113e-07 0.4756487143466775 \
6.17931917027196e-07 0.469313240945046 6.179322308529534e-07 0.4628991126846517 6.17932559994313e-07 0.4562163541974347 6.179328933724197e-07 0.4494927613461197 \
6.179332249990283e-07 0.4428490490857003 6.179335465484252e-07 0.4364504708187015 6.179338742242378e-07 0.4299742838549845 6.179342218438604e-07 0.4231546934710667 \
6.179345550651742e-07 0.4166645133789623 6.179349009744022e-07 0.4099771621835854 6.179353463882216e-07 0.4014400148089548 6.179357041780922e-07 0.3946500490499754 \
6.179360183349117e-07 0.3887397205534429 6.179364027453916e-07 0.3815756289527631 6.179367327200364e-07 0.3754830843203271 6.179370179301253e-07 0.3702633801070484 \
6.179373262203822e-07 0.3646649204592909 6.179376060174434e-07 0.3596257204303125 6.179378320117929e-07 0.3555880084110294 6.179380468497475e-07 0.3517755993421203 \
6.179382452848198e-07 0.3482769933469286 6.179384492243371e-07 0.3447071465415313 6.179386597603963e-07 0.3410461989361561 6.179389167345215e-07 0.3366091000429626 \
6.179391579951288e-07 0.3324763702393667 6.179393895688451e-07 0.3285420159269506 6.179396042222912e-07 0.3249208057821749 6.17939825046275e-07 0.3212218866489027 \
6.179400262928671e-07 0.3178749657716667 6.179402293821204e-07 0.3145250552959265 6.179404272269914e-07 0.3112865758726304 6.179406140799367e-07 0.3082497660855442 \
6.179408080166626e-07 0.3051208532403978 6.179410117613171e-07 0.30185834615803 6.179411904885829e-07 0.2990186060348319 6.179414281343783e-07 0.2952727068736475 \
6.179416278966111e-07 0.2921508861588616 6.179418295254275e-07 0.2890253490052915 6.179420549918856e-07 0.285561995332 6.17942221086285e-07 0.2830312764183137 \
6.17942399705387e-07 0.2803277612349699 6.179425814095885e-07 0.2775983111934518 6.179427700433049e-07 0.2747882307029562 6.179429474665079e-07 0.2721695222189568 \
6.179431246596455e-07 0.2695724116247911 6.179432847315606e-07 0.2672552081803913 6.179434051322386e-07 0.2655193337608355 6.179435529583031e-07 0.2633957862580221 \
6.179436815880755e-07 0.2615692882062232 6.179437837936585e-07 0.2601227034409412 6.179439020289393e-07 0.2584516051170885 6.179440224822997e-07 0.2567534139348401 \
6.179441461906177e-07 0.2550183706610066 6.179442644426428e-07 0.2533694204037282 6.179443922957732e-07 0.2515887492000971 6.179445125816039e-07 0.249915736161692 \
6.179446652612099e-07 0.2477917697339537 6.179448001739883e-07 0.2459264316518071 6.179449288134099e-07 0.2441493177932957 6.17945086528788e-07 0.2419705448111171 \
6.179452132100908e-07 0.2402201997919771 6.179453485361585e-07 0.2383592392624043 6.179454874487268e-07 0.2364550510890953 6.179456052210313e-07 0.2348405558720491 \
6.179457644918496e-07 0.2326580599570062 6.179459010137043e-07 0.2307878375452989 6.179460422456503e-07 0.2288626996658652 6.179461480586929e-07 0.2274220928889542 \
6.179462784016401e-07 0.2256484734765637 6.17946378112453e-07 0.2242944442559471 6.179464809338881e-07 0.2228991027388591 6.179465543495424e-07 0.2219046249368765 \
6.179466341811041e-07 0.2208265149641777 6.179467042283352e-07 0.2198809561195558 6.179467546314264e-07 0.2192009305305119 6.179468068832254e-07 0.2184966408607167 \
6.179468861207429e-07 0.2174292050927151 6.179469279646958e-07 0.2168658036437602 6.179469673046481e-07 0.216336351877609 6.179470103400575e-07 0.2157575332679269 \
6.179470545074838e-07 0.2151638767852215 6.179471282732236e-07 0.2141731338947761 6.179471637852206e-07 0.2136967174286463 6.179472115000211e-07 0.2130606706933813 \
6.17947272229561e-07 0.2122518321687151 6.179473404867867e-07 0.2113438957752176 6.179474130085659e-07 0.2103801801047663 6.179474856831929e-07 0.2094152724966429 \
6.179475939991808e-07 0.2079788886429202 6.179476916703231e-07 0.20668564243436 6.179478032218192e-07 0.2052110974836689 6.179479017572532e-07 0.2039136008387587 \
6.179480052503929e-07 0.2025572972554956 6.179481011521277e-07 0.2013021587886929 6.17948203780057e-07 0.1999606878451601 6.179483066031699e-07 0.1986207062101238 \
6.179484167227972e-07 0.1971897063011611 6.179485254183531e-07 0.1957815523781236 6.179486450955817e-07 0.1942360962608612 6.179487553732606e-07 0.192818053470401 \
6.179488634364806e-07 0.1914343471929882 6.179489885351485e-07 0.1898375077741012 6.179490785049817e-07 0.1886931806549971 6.179491571919347e-07 0.1876950225942949 \
6.17949234476806e-07 0.1867173468865102 6.179493209853825e-07 0.1856271834369256 6.179494199345929e-07 0.1843848109964498 6.179494904434582e-07 0.1835017733581451 \
6.179495618945114e-07 0.1826096997732476 6.179496670398458e-07 0.1813018727451555 6.179497462794754e-07 0.1803200401832796 6.179498273633695e-07 0.1793174195483187 \
6.1794992085531e-07 0.1781663090788374 6.179500216312847e-07 0.1769308188703378 6.179501713433884e-07 0.175105380089017 6.179502871327036e-07 0.1737009932372819 \
6.179504381380806e-07 0.1718807311127691 6.179505492465001e-07 0.1705485445502526 6.179506913729584e-07 0.168854666407182 6.179508090313791e-07 0.167460358327668 \
6.179509139359749e-07 0.1662230887079887 6.179510089985733e-07 0.1651069099307241 6.179511024298278e-07 0.1640147999883682 6.179512034764903e-07 0.1628388413495604 \
6.179512998233979e-07 0.1617223204899406 6.179513969756437e-07 0.1606011553546776 6.179514800242163e-07 0.1596469772300165 6.179515900618698e-07 0.1583897228513109 \
6.179516723644316e-07 0.1574542248873526 6.179517773641412e-07 0.156267858580057 6.179518550602102e-07 0.1553950893374849 6.179519378796887e-07 0.1544690878994293 \
6.179520195415937e-07 0.1535604570452941 6.179521088908843e-07 0.152571060794856 6.1795218460332e-07 0.1517364980793458 6.179522671659343e-07 0.1508307726525361 \
6.179523437473671e-07 0.1499942554682341 6.179524120352535e-07 0.1492531084507001 6.179525054022655e-07 0.1482449401818621 6.179525745556768e-07 0.1475015570698688 \
6.179526501800083e-07 0.1466917482325688 6.179527117291285e-07 0.1460354497178591 6.179527789778923e-07 0.1453208357145237 6.179528500398917e-07 0.1445684785944268 \
6.179529255373203e-07 0.143772322008306 6.179529844488598e-07 0.1431546944759192 6.179530611224699e-07 0.1423563022825049 6.179531414432115e-07 0.1415233898163201 \
6.179532145945195e-07 0.1407682091691316 6.179533087509407e-07 0.139800669784813 6.179533803551247e-07 0.1390684367429364 6.179534538159004e-07 0.1383201464810226 \
6.179535373276515e-07 0.1374732033664194 6.179536268067954e-07 0.1365744208092838 6.179536918717002e-07 0.1359252211013016 6.179538039977228e-07 0.1348115665849295 \
6.179538691838634e-07 0.1341670699454539 6.179539392221084e-07 0.1334770515823289 6.179539995271633e-07 0.1328849371768329 6.179540545379868e-07 0.1323464455745446 \
6.17954142654965e-07 0.1314871014507438 6.179541834412595e-07 0.131090685705856 6.179542871440105e-07 0.1300923774523848 6.179543304565801e-07 0.1296773144713907 \
6.17954391675178e-07 0.1290920262082728 6.179544365118974e-07 0.1286643765206081 6.179545241079233e-07 0.127831527987147 6.179545656618794e-07 0.1274377589706847 \
6.179546255233895e-07 0.1268718307679372 6.179546973671149e-07 0.1261946708524367 6.179547535798413e-07 0.1256664967939027 6.179548160673402e-07 0.125081039250218 \
6.179548902953232e-07 0.1243877959456236 6.179549649763283e-07 0.1236954937854857 6.179550521595408e-07 0.1228905551604285 6.179551205580918e-07 0.1222610287411191 \
6.17955201128775e-07 0.1215216597888775 6.179552824242559e-07 0.120778012781285 6.179553493407808e-07 0.1201677797529914 6.179554321577255e-07 0.1194156054679852 \
6.179554913464481e-07 0.1188799972037829 6.179555572674477e-07 0.1182853617472536 6.179556371414917e-07 0.1175675408705869 6.179557136372898e-07 0.1168828806096336 \
6.179557950994005e-07 0.1161574242846086 6.179558935702815e-07 0.1152852106851665 6.179559686806302e-07 0.114622623867465 6.179560716684202e-07 0.1137180076826871 \
6.179561458523715e-07 0.1130691786503039 6.179562434718251e-07 0.1122190343868764 6.179563392827804e-07 0.1113890351962442 6.179564351312053e-07 0.110562946039519 \
6.179565160694118e-07 0.1098685209805978 6.179566044526832e-07 0.1091134439098378 6.179567030526615e-07 0.108274944429282 6.179567758368655e-07 0.1076586405352824 \
6.17956865109775e-07 0.1069058608836731 6.179569270917884e-07 0.1063852406583179 6.179569896849557e-07 0.1058613310701875 6.179570749071042e-07 0.105150777260444 \
6.179571803694782e-07 0.1042758147594986 6.179572601999606e-07 0.1036167065755082 6.179573409142144e-07 0.1029530974056021 6.179574235279495e-07 0.1022768941101355 \
6.179574939725617e-07 0.1017026162492672 6.179575972319282e-07 0.1008648142128753 6.179576700720535e-07 0.1002767039768694 6.17957755712335e-07 0.09958839426015198 \
6.179578745140727e-07 0.09863954321822334 6.179579421518978e-07 0.09810250133474645 6.179580119020204e-07 0.09755100310752296 6.17958089237e-07 0.09694230106952094 \
6.179581816572539e-07 0.09621870517595056 6.17958253354782e-07 0.09566033062548993 6.179583391719417e-07 0.09499542738017568 6.17958441597192e-07 0.09420660575030523 \
6.17958534892083e-07 0.09349264652734962 6.179586312085565e-07 0.09276005482712441 6.179587081108176e-07 0.09217843893134048 6.179588015908053e-07 0.09147541043939374 \
6.179588808332317e-07 0.09088281005358793 6.17958995455426e-07 0.0900310686188453 6.179591250636858e-07 0.08907580221142102 6.179592583208766e-07 0.08810234090122065 \
6.179594023507656e-07 0.08705990691030199 6.179595595189095e-07 0.08593388720602639 6.179597092953871e-07 0.08487214151476249 6.179598717629786e-07 0.08373303262435308 \
6.179600149429843e-07 0.08273971668837025 6.17960167622107e-07 0.0816913199659166 6.179603018918778e-07 0.08077856892457436 6.179604436441555e-07 0.07982444400446118 \
6.179605786438163e-07 0.07892500874648442 6.179607206012136e-07 0.07798882638923543 6.179608674486441e-07 0.07703088995320664 6.17961019894053e-07 0.07604750978240994 \
6.179611851127757e-07 0.07499422991502351 6.179613492506213e-07 0.07396067809208305 6.17961526112024e-07 0.07286119333145537 6.179617164535802e-07 0.07169407515132428 \
6.17961927410093e-07 0.07042030845332216 6.179621478192316e-07 0.0691121699798517 6.17962383344393e-07 0.06773900533435212 6.179626437937673e-07 0.0662496528900723 \
6.179629394591772e-07 0.06459579389282195 6.179632445814627e-07 0.06292902455725519 6.179636095760241e-07 0.06098725515092194 6.179640044568393e-07 0.05894944116461652 \
6.179644108474932e-07 0.05692211719668253 6.179648265730353e-07 0.05491854459141238 6.179651893793582e-07 0.0532251207245777 6.179655339806477e-07 0.05166301626031383 \
6.179658491605097e-07 0.05027284652491828 6.179661446898747e-07 0.04900240867073854 6.179664426703825e-07 0.04775344010203557 6.179667184691724e-07 0.04662857640242725 \
6.179669972437683e-07 0.04551884372531381 6.179672611786382e-07 0.04449205559535935 6.179675372013766e-07 0.04344260531795661 6.179678161576297e-07 0.04240676967887352 \
6.179681298509632e-07 0.04127097799875453 6.179683658512502e-07 0.04043636567030678 6.179686216459875e-07 0.03955075129286261 6.17968881769487e-07 0.03867033103466553 \
6.179691519047594e-07 0.03778142289416799 6.179694311247467e-07 0.03688501536902895 6.179697129633963e-07 0.03600226561751176 6.17969989839066e-07 0.03515600409566183 \
6.179702689326649e-07 0.03432349610146775 6.179705018102724e-07 0.03364444121149882 6.179707856469893e-07 0.03283527291840588 6.179710257519236e-07 0.03216626441466421 \
6.179712655507463e-07 0.0315119836023277 6.179715048279204e-07 0.03087436846876356 6.179717400849421e-07 0.03026290129608995 6.179719710119639e-07 0.02967475842909434 \
6.17972186001007e-07 0.02913788335257221 6.179725881554596e-07 0.02816043724496065 6.179727868782784e-07 0.02768988489927659 6.179731605612945e-07 0.0268265706552881 \
6.179733473596173e-07 0.02640514011949098 6.179736949193038e-07 0.02563810810034544 6.179738168487671e-07 0.0253740445387235 6.179741993202074e-07 0.02456430406701914 \
6.179743700282367e-07 0.02421180751242828 6.17974827125621e-07 0.02328894863848502 6.179750127580069e-07 0.0229225623309489 6.179753762152598e-07 0.02221803970155307 \
6.179755965826125e-07 0.02179832126591805 6.179760543089696e-07 0.02093867417890744 6.179761897285988e-07 0.02068687731869814 6.179767196240474e-07 0.01972418011126781 \
6.17976838945017e-07 0.01951377505543128 6.179774047306961e-07 0.01856069823426573 6.17977569110437e-07 0.0182962226476828 6.179781876557339e-07 0.01735107502432094 \
6.179783577099333e-07 0.01710418363667701 6.179788898421661e-07 0.01636278834442301 6.179790869261418e-07 0.01610013864443424 6.179798100452149e-07 0.01517806887136661 \
6.179799746753809e-07 0.01497647803580381 6.179807238007678e-07 0.01409711804523418 6.179808571001203e-07 0.01394643716836554 6.179817173537587e-07 0.01301449210748497 \
6.179818524573793e-07 0.01287422877142914 6.179827950348196e-07 0.01193816285908547 6.179829586305737e-07 0.01178202925388569 6.179839599872008e-07 0.0108653384673985 \
6.179840975299883e-07 0.01074500730514941 6.179853196363713e-07 0.009765086624518643 6.179854265890839e-07 0.00968516078425012 6.179868307805774e-07 0.008707372520026449 \
6.179869356112841e-07 0.008639312158696611 6.179884704482461e-07 0.00767719340797631 6.179885657315476e-07 0.007617466071856052 6.179901745288685e-07 0.006680264535635283 \
6.179903086056076e-07 0.006609506832171614 6.179924056185594e-07 0.005610918814474722 6.179926361631908e-07 0.005510783990371394 6.179949591584346e-07 0.004586584533412417 \
6.179954404886379e-07 0.004413562233393853 6.179982780502688e-07 0.003511943147855551 6.179988229699549e-07 0.003360532104877318 6.180029471783515e-07 0.002408309874554541 \
6.180034909020111e-07 0.002305347543005144 6.180093621912368e-07 0.001333291345955189 6.180096050564211e-07 0.001286469439319215 6.180239329487719e-07 0.0002880570268237783 \
6.180240775074142e-07 0.0002853642807229123 6.206613564285127e-07 -0.0006859155495331031 6.206614959836499e-07 -0.000901903561740745 6.206620050775826e-07 -0.001859438188174024 \
6.206620945650851e-07 -0.002052812934985279 6.206624579599451e-07 -0.00291126965001638 6.206625489820155e-07 -0.003143482006111167 6.206629144200523e-07 -0.004127275145644371 \
6.206630246806195e-07 -0.004436819103926468 6.206633367277739e-07 -0.005309594399865315 6.206634394426211e-07 -0.005584800160857357 6.206638032904767e-07 -0.006384516484886619 \
6.206639680812086e-07 -0.006586298968823262 6.206645476774081e-07 -0.005791490933239759 6.206647227875511e-07 -0.004914057272375438 6.206648394794853e-07 -0.004132845175365214 \
6.206649660640906e-07 -0.003100877896798674 6.206650678730126e-07 -0.002132773363901063 6.206651883617227e-07 -0.0008283127610571584 6.206652788087988e-07 0.0002599396317828252 \
6.206653766989305e-07 0.001541559978017447 6.206654757632394e-07 0.002943971508909197 6.206656465705158e-07 0.005594911825788154 6.206658683385387e-07 0.00944046646559993 \
6.206660642423845e-07 0.01317281463966807 6.206662231237664e-07 0.01639870563256729 6.206663875522632e-07 0.01989779506365397 6.206665419182935e-07 0.02331070396473752 \
6.20666700690818e-07 0.02693200463312963 6.206668474287769e-07 0.03036422445567413 6.206669960527481e-07 0.0339113704936035 6.20667151667245e-07 0.03768995713197771 \
6.206673089092589e-07 0.04156499463828727 6.206674738020577e-07 0.04567927910670353 6.206676472215784e-07 0.05005184210758699 6.20667825915293e-07 0.05459761989277153 \
6.206680145311307e-07 0.05943075613080645 6.206682154312735e-07 0.06460909294799391 6.206684348880646e-07 0.0702927970720964 6.206686644343515e-07 0.07626037976612585 \
6.206689101332909e-07 0.08266408948881369 6.206691786982296e-07 0.08967663153997742 6.206694700401445e-07 0.09728936802005522 6.206697917081718e-07 0.1056939239977524 \
6.20670152022263e-07 0.1150987971742611 6.206705430017012e-07 0.1252892839303718 6.206709864165172e-07 0.1368209045172546 6.206715027296045e-07 0.1502062239570841 \
6.206721089348208e-07 0.16586000516691 6.206727801918478e-07 0.1831102247110778 6.206735596915047e-07 0.20301830483439 6.206744320013885e-07 0.2251413938832897 \
6.206752623367137e-07 0.2460320778586349 6.206759936670633e-07 0.264292249712138 6.206766416128433e-07 0.280346965484095 6.206772249233171e-07 0.29469740877147 \
6.20677760655584e-07 0.3077798509628869 6.20678263914169e-07 0.3199778888071559 6.2067874911767e-07 0.3316516836183861 6.206792280403756e-07 0.3430829066939081 \
6.206796744710079e-07 0.3536501814456421 6.206801488007181e-07 0.3647819492304352 6.206805979917124e-07 0.3752331958288908 6.206810884639695e-07 0.3865396207984229 \
6.206816170367225e-07 0.3985997842463301 6.206819881810625e-07 0.4069920784971888 6.206825159354181e-07 0.4188173133762567 6.206829782921778e-07 0.4290642331729484 \
6.206834506243179e-07 0.4394285229343968 6.206839324090407e-07 0.4498981261869666 6.206839654481592e-07 0.4506126593745911 6.206840032071518e-07 0.45142837879914 \
6.20684078725137e-07 0.4530572051633331 6.206842297611073e-07 0.4563088938659436 6.206844372803726e-07 0.460764549126051 6.206846253191843e-07 0.4647825567212808 \
6.206848443283984e-07 0.469441659996985 6.206850871594093e-07 0.4745824626509371 6.206853869350375e-07 0.4808894567257585 6.206856247281872e-07 0.4858624696070272 \
6.206858879495879e-07 0.4913374535260851 6.206861488471327e-07 0.4967277906005185 6.206863784012197e-07 0.5014431429135263 6.206866014614136e-07 0.506003872007333 \
6.206868030374043e-07 0.5100983586086808 6.206869518674631e-07 0.51310967141356 6.206871961785157e-07 0.5180317772556589 6.20687328783749e-07 0.5206893064287169 \
6.206874681403308e-07 0.5234717264876519 6.206876791057241e-07 0.5276623644271943 6.206878539796058e-07 0.5311266030493931 6.206881220278524e-07 0.5364094032095129 \
6.206883170535097e-07 0.5402319029111832 6.206884966150173e-07 0.5437361368949839 6.206887475711458e-07 0.5486228351952749 6.206890249792569e-07 0.5540035987981641 \
6.20689308928559e-07 0.5594901708581531 6.206895645658505e-07 0.5644152233389156 6.206898555480696e-07 0.570006772487656 6.20690115853754e-07 0.5749917787111524 \
6.206903842978736e-07 0.5801232573974072 6.206906270630042e-07 0.5847450403362237 6.206908835942051e-07 0.5896146675871002 6.206911097576483e-07 0.59388771440121 \
6.206913470991427e-07 0.5983512154742827 6.206915564878602e-07 0.6022720321566808 6.206917702606284e-07 0.6062574570422776 6.206920237134688e-07 0.6109557890491497 \
6.206922265678164e-07 0.6146943332140289 6.206924193723378e-07 0.6182333111593361 6.206926096773651e-07 0.6217090173923294 6.20692800335854e-07 0.6251694921350958 \
6.206930029137796e-07 0.6288260100903066 6.206932656625422e-07 0.6335359534764116 6.206934946302321e-07 0.6376100987349322 6.206937145778672e-07 0.6414991146358265 \
6.206939402625401e-07 0.6454625140719233 6.206941491499662e-07 0.6491091855837361 6.206943708035853e-07 0.652957810138281 6.206945556930106e-07 0.6561429680377227 \
6.206947457075645e-07 0.6594017273991298 6.206948958626861e-07 0.6619630641908443 6.206950707405928e-07 0.6649292185271485 6.206952164613094e-07 0.6673855496832628 \
6.206953524938417e-07 0.6696641287411549 6.206955008561211e-07 0.672138295335571 6.206956303038335e-07 0.6742883907026684 6.206957641695307e-07 0.6764996355878535 \
6.206958925139302e-07 0.6786115243545502 6.206960179020584e-07 0.6806677490053815 6.20696147367755e-07 0.6827843190971332 6.206962783489702e-07 0.6849171426143115 \
6.206964267220724e-07 0.6873221141612875 6.206965347848267e-07 0.6890667486235877 6.206966633164996e-07 0.6911333958680312 6.206967987562836e-07 0.6933004139195943 \
6.206969236906071e-07 0.6952876996714908 6.206970494478751e-07 0.6972799977491608 6.206971559637663e-07 0.6989584331773744 6.20697273081655e-07 0.7007929859467624 \
6.206973916214007e-07 0.7026383448210159 6.206975149247975e-07 0.704545102273978 6.206976180976957e-07 0.7061304255463237 6.20697769068859e-07 0.7084341141567283 \
6.206978853230652e-07 0.7101955266062138 6.206980158834538e-07 0.7121605601685687 6.206981344459821e-07 0.7139335830373704 6.206982405198518e-07 0.7155108922888329 \
6.206983405447916e-07 0.716990346352101 6.206984778700065e-07 0.719009255813789 6.206985965313622e-07 0.7207429633399333 6.206987182305859e-07 0.7225107522614664 \
6.206988434131515e-07 0.7243181860083944 6.206989654329653e-07 0.7260693242762759 6.206990934647187e-07 0.7278954552757622 6.20699217946458e-07 0.7296603419865877 \
6.206993462457807e-07 0.7314685590147565 6.206994733395841e-07 0.7332489547570846 6.206995993644231e-07 0.7350034830462163 6.2069970210311e-07 0.7364262918236342 \
6.206998167758557e-07 0.7380063527755659 6.206998981819179e-07 0.7391232259175492 6.207000173814378e-07 0.7407496908814458 6.207001100237781e-07 0.7420059782745783 \
6.207002481828348e-07 0.7438668850244906 6.207003792383344e-07 0.7456179978167152 6.207005093705018e-07 0.7473439783685625 6.207006143445769e-07 0.7487266533969134 \
6.207007534844189e-07 0.7505456565005918 6.207009074287187e-07 0.7525407731682957 6.207010293729987e-07 0.7541080835708853 6.207011769193594e-07 0.7559892974429111 \
6.20701298924537e-07 0.7575320275232224 6.207014476244666e-07 0.7593968175435225 6.207015816710922e-07 0.7610632318338031 6.207017039243471e-07 0.7625711443351471 \
6.207018167902567e-07 0.763953046884334 6.207019596412246e-07 0.7656882893306027 6.207020863641193e-07 0.7672149413549471 6.207022021689945e-07 0.7685995877768005 \
6.207023319108227e-07 0.7701390587657672 6.207024476492105e-07 0.7715019052061673 6.207025706016372e-07 0.7729391548276606 6.20702688317297e-07 0.7743051053122872 \
6.207027942872733e-07 0.7755262985206828 6.207029106984675e-07 0.7768586864857919 6.207030173164003e-07 0.7780703956921795 6.207031295151206e-07 0.7793369495935717 \
6.207032161836896e-07 0.7803089322889447 6.207033195691813e-07 0.7814603789665585 6.207034327334326e-07 0.7827108149434853 6.207035383807155e-07 0.783868819044773 \
6.207036477202728e-07 0.7850578567336689 6.207037548972877e-07 0.786214126597127 6.20703884303365e-07 0.7875981444497275 6.207039967207506e-07 0.7887899291890393 \
6.207041201084898e-07 0.7900869036018625 6.207042375588255e-07 0.7913106402786101 6.207043810857436e-07 0.7927918312347375 6.20704496005322e-07 0.7939667362870242 \
6.207046347277352e-07 0.7953719780830618 6.207047727598755e-07 0.7967562205547866 6.207048822530295e-07 0.7978444364842524 6.207049832714595e-07 0.7988406866985471 \
6.207050843594198e-07 0.7998302780396641 6.207052167466158e-07 0.8011146558616069 6.207053354720369e-07 0.8022550163876687 6.207054572565424e-07 0.8034134048507504 \
6.207055763463359e-07 0.8045351524060473 6.207056975508533e-07 0.8056657048884367 6.207058291946645e-07 0.8068811249615274 6.207059522127029e-07 0.8080052413861453 \
6.207060798230233e-07 0.8091594649786741 6.207062108916829e-07 0.8103325925767672 6.207063342120463e-07 0.8114249716726942 6.207064421363105e-07 0.8123719892944993 \
6.207065499317031e-07 0.8133095350680949 6.20706631652631e-07 0.8140147772069938 6.207067485202474e-07 0.815015186305849 6.207068395812562e-07 0.8157880755829442 \
6.207069737498876e-07 0.8169164295805346 6.2070711832076e-07 0.8181184617099191 6.207072518231266e-07 0.8192158725965917 6.207073617890376e-07 0.8201107352847025 \
6.207075056546974e-07 0.8212684563313245 6.207076589602621e-07 0.8224861772268215 6.207077866985553e-07 0.8234883060891934 6.207079273408908e-07 0.8245786478120171 \
6.207080531244555e-07 0.8255423809867173 6.207082077424273e-07 0.8267124309768116 6.207083401541937e-07 0.8277017767197102 6.207084664337982e-07 0.8286345641820314 \
6.20708584064113e-07 0.8294941055817234 6.207087322309758e-07 0.8305638349826423 6.207088993752207e-07 0.8317531470681401 6.207090319938809e-07 0.832683775428688 \
6.20709204938569e-07 0.8338803479528284 6.207093733252244e-07 0.8350269493631071 6.207095428597541e-07 0.8361634673386688 6.207097242289089e-07 0.8373596561587384 \
6.207098668614912e-07 0.8382862741713709 6.207099807973396e-07 0.8390176620397163 6.207101115711344e-07 0.8398476357987267 6.207102132250742e-07 0.8404856735008092 \
6.207103297188026e-07 0.8412091703399448 6.207104652363492e-07 0.8420405885319162 6.20710662580143e-07 0.8432318270427018 6.20710853245141e-07 0.8443612543037786 \
6.207110631019802e-07 0.8455804035625291 6.207112440391043e-07 0.8466117334714958 6.207114413745909e-07 0.8477160230260256 6.207116151614274e-07 0.8486711109012058 \
6.207117977428814e-07 0.8496572451898022 6.207119690624607e-07 0.850566499179887 6.207121434475075e-07 0.8514760798656241 6.207123188310518e-07 0.8523748177975867 \
6.207124950632094e-07 0.8532619682996843 6.207126849014517e-07 0.8542000584728613 6.207128756376655e-07 0.8551245802328369 6.20713077434399e-07 0.856083442102113 \
6.207132701277752e-07 0.8569809170305027 6.207134797560765e-07 0.857937542729613 6.207137091938401e-07 0.8589615588718806 6.207139749904802e-07 0.8601183337444025 \
6.207142735657075e-07 0.8613802063570262 6.207145514672208e-07 0.8625196921548358 6.207148356776949e-07 0.8636511027355716 6.207151100894824e-07 0.8647118800460076 \
6.207153822523641e-07 0.8657341977214618 6.207156524214556e-07 0.8667205537246333 6.207159096161394e-07 0.8676338760342862 6.207161821558105e-07 0.868575115807136 \
6.207164581902909e-07 0.8695013130444248 6.207167283429861e-07 0.8703818891200001 6.207170280497877e-07 0.8713292845176382 6.207173988672582e-07 0.8724597217497643 \
6.207176937859212e-07 0.8733269024855727 6.207179480301993e-07 0.8740525764960509 6.207182462541985e-07 0.8748787854419284 6.20718519878969e-07 0.8756137195941651 \
6.207187560179586e-07 0.8762307200963571 6.207189963736862e-07 0.8768427579093606 6.207192187193381e-07 0.8773949085683344 6.207194127230722e-07 0.877865919014753 \
6.207197424471962e-07 0.878644045115768 6.207198976198552e-07 0.8790007149587372 6.207202153732478e-07 0.879712598742095 6.207203942386052e-07 0.8801026384247937 \
6.207207367000935e-07 0.8808283583858193 6.207209208412927e-07 0.8812073588304842 6.207213957461143e-07 0.8821499412898334 6.207215631406011e-07 0.8824705695712217 \
6.207220289718891e-07 0.8833323038036038 6.207222097967713e-07 0.8836551183393088 6.207227038300282e-07 0.8845051821644966 6.207228451726029e-07 0.8847400410050358 \
6.207234515631179e-07 0.8857071861637142 6.207236036356849e-07 0.8859397703602404 6.207242503137577e-07 0.8868873789663725 6.207243786102466e-07 0.8870678433440622 \
6.207250267232453e-07 0.8879435266410994 6.207251565285235e-07 0.8881118897635528 6.207259347856079e-07 0.8890711781604964 6.207260497804227e-07 0.8892053868933587 \
6.207269055110619e-07 0.8901454611437621 6.207270507776287e-07 0.8902951528450479 6.207280365337324e-07 0.8912364417375994 6.207282576409459e-07 0.8914302300078862 \
6.207294027520271e-07 0.892358484239638 6.207295339601743e-07 0.8924604119362172 6.207308752633695e-07 0.8934531785430913 6.207310266510305e-07 0.8935579568409697 \
6.207325081098674e-07 0.8944876667405802 6.207327469902294e-07 0.894621531696939 6.207345164619858e-07 0.8954958910368339 6.207349055688234e-07 0.8956641700186337 \
6.207372993342322e-07 0.8965498195158238 6.207377748942228e-07 0.8966991754584082 6.20741837950387e-07 0.8976977719002629 6.207423294244079e-07 0.8977905759376156 \
6.207506459514872e-07 0.8987839664765119 6.207515658053769e-07 0.8988472044554419 6.208777709459031e-07 0.8998441026240215 6.20878784754255e-07 0.8998514601858095 \
6.210704973474114e-07 0.8990059056521554 6.210707273489741e-07 0.8988405173838494 6.210723422215349e-07 0.8978439928078279 6.210725199353886e-07 0.8977495532019018 \
6.210892857104286e-07 0.8987316330193963 6.210894216988253e-07 0.8987497732072308 6.211048844279384e-07 0.8997471920221268 6.211051522925305e-07 0.8997526389354535 \
6.215889776197985e-07 0.9006560548284696 6.215890984089986e-07 0.9007687033315858 6.215898861800373e-07 0.9017381658104292 6.215900203187565e-07 0.901943163319478 \
6.215905139335305e-07 0.9027850367016239 6.21590658833145e-07 0.9030569221572713 6.215910546405301e-07 0.9038490360455199 6.215911744361841e-07 0.9041001886668685 \
6.215915586097176e-07 0.9049189780371781 6.215916707313646e-07 0.9051556495331843 6.215921780523355e-07 0.9061253139956988 6.215922720511915e-07 0.90626859229291 \
6.215934307008982e-07 0.9055667778886739 6.215935336638316e-07 0.9051589876696525 6.215936175067007e-07 0.9047707260375384 6.215937512467521e-07 0.9040404158978201 \
6.215938519641334e-07 0.9033957423200318 6.215939595799193e-07 0.9026166239542108 6.215940771531731e-07 0.9016533104038295 6.21594165418223e-07 0.90085556431878 \
6.215942850516912e-07 0.8996698288011099 6.215943823733893e-07 0.8986166602050341 6.215944933908277e-07 0.8973222354192386 6.215945955004155e-07 0.8960407982554908 \
6.21594678931815e-07 0.8949326975987755 6.215947831128827e-07 0.8934749428758865 6.215948741996462e-07 0.8921321265381427 6.215949667404319e-07 0.8907058396397178 \
6.2159506189443e-07 0.8891776325191247 6.215951764494069e-07 0.88725933118288 6.215952652925088e-07 0.8857137884271823 6.215953635316906e-07 0.8839502506198179 \
6.215954489018647e-07 0.8823735982707064 6.215955298021066e-07 0.8808434949738935 6.215956027633997e-07 0.8794355441897157 6.215956697820454e-07 0.8781198554636557 \
6.215957383931237e-07 0.8767515715160701 6.215958218880357e-07 0.8750591081124355 6.215958840153663e-07 0.8737811510706814 6.215959469979638e-07 0.8724704924326797 \
6.215960421537152e-07 0.8704632161180945 6.215961427643535e-07 0.8683077530860182 6.215962226435446e-07 0.8665738309361769 6.215963069058141e-07 0.8647250601592834 \
6.215963860160736e-07 0.8629723295901451 6.215964488315188e-07 0.8615696597604833 6.215965362885537e-07 0.8596016864744445 6.215966021820844e-07 0.8581079708060287 \
6.215966702436265e-07 0.856556281928966 6.215967195561343e-07 0.8554267461646872 6.215967747929236e-07 0.85415654045335 6.215968155325295e-07 0.8532164928603474 \
6.215968618342831e-07 0.8521450198670055 6.21596892048343e-07 0.8514441160591502 6.215969210896253e-07 0.8507691938976955 6.2159695172822e-07 0.8500558939662993 \
6.215970130054097e-07 0.8486254874746039 6.215970660779718e-07 0.8473828229799116 6.215971197331653e-07 0.8461232012188223 6.215971823904472e-07 0.8446482873934593 \
6.215972456733951e-07 0.8431545995644786 6.21597336171269e-07 0.8410121009440262 6.215974331690495e-07 0.8387078554355326 6.215975161465498e-07 0.8367307351423475 \
6.215975981509054e-07 0.8347721678896715 6.215976872193066e-07 0.8326403548070889 6.215977717326432e-07 0.8306135893189693 6.215978625915233e-07 0.8284303722590877 \
6.215979545263781e-07 0.8262176456275642 6.215980569573084e-07 0.8237486178045141 6.215981570753404e-07 0.8213320995840899 6.215982718962233e-07 0.8185572053828121 \
6.215983841027603e-07 0.8158423448209959 6.215985090963053e-07 0.8128151787794674 6.215986403567133e-07 0.8096337870015397 6.215987856277547e-07 0.8061104108175116 \
6.21598940135368e-07 0.8023613213197434 6.215991115759889e-07 0.7981999722344618 6.215992756257814e-07 0.794217661721315 6.215994600412031e-07 0.7897413884478564 \
6.215996665335767e-07 0.7847307375046715 6.215998560274197e-07 0.7801344622909899 6.216000494211826e-07 0.775444374634302 6.216002499880375e-07 0.7705834242206392 \
6.21600397552439e-07 0.7670092004965298 6.216005275638895e-07 0.7638619034739171 6.216006624283032e-07 0.7605987503374771 6.216007689187539e-07 0.7580234999254772 \
6.216009006085467e-07 0.7548403390839162 6.216010070329759e-07 0.7522693550468039 6.21601150211605e-07 0.7488125398635642 6.216013113387162e-07 0.7449250928176189 \
6.216014295655331e-07 0.7420746008290786 6.216015997983541e-07 0.7379721584775248 6.216017657246235e-07 0.7339761998059781 6.216019852669538e-07 0.7286940862104242 \
6.216021784540778e-07 0.724050920820232 6.216023533680413e-07 0.719851304223293 6.216025203151389e-07 0.7158476177432674 6.216027078061003e-07 0.711355754450834 \
6.216028952345367e-07 0.7068709122373377 6.216030635710959e-07 0.7028473835914892 6.216032564016302e-07 0.6982428782038785 6.216033964513774e-07 0.694901318858167 \
6.216035527086664e-07 0.6911769338170629 6.216037468781132e-07 0.6865540563080536 6.216039059846016e-07 0.6827702245679255 6.216040643446318e-07 0.679008548037742 \
6.216042596617401e-07 0.6743756772263459 6.216044700905194e-07 0.6693917663527935 6.216047227926645e-07 0.6634173774538097 6.216049024606155e-07 0.6591769455535931 \
6.216051540374889e-07 0.6532475027332399 6.21605354410306e-07 0.6485340174553987 6.216055260641581e-07 0.6445032789616798 6.216056847562746e-07 0.6407814961122935 \
6.216058239642021e-07 0.637522316374186 6.216059602882518e-07 0.6343349641335875 6.216060875012759e-07 0.6313646237382058 6.216062169938336e-07 0.6283457899522861 \
6.216063449851212e-07 0.6253646753452949 6.216064760596301e-07 0.6223174651643489 6.216066067717051e-07 0.6192830747181834 6.216067493797576e-07 0.6159760732208495 \
6.216068921032355e-07 0.612672916206165 6.216070446510367e-07 0.6091471600588 6.216071891550244e-07 0.6058158037532523 6.21607353173272e-07 0.6020406322262999 \
6.216074906379333e-07 0.5988837056407329 6.216076254549489e-07 0.5957940466067043 6.216077469535923e-07 0.5930134750293682 6.216078858038965e-07 0.5898448108574432 \
6.216079994507128e-07 0.5872554148224447 6.216081508608854e-07 0.5838116422847746 6.216082645795603e-07 0.5812320812748947 6.216083839926513e-07 0.5785269636915771 \
6.216084726731778e-07 0.5765205397309219 6.216085638182693e-07 0.5744630259469776 6.216086291571447e-07 0.5729901393713442 6.216086936268467e-07 0.5715377831648228 \
6.21608744447459e-07 0.5703933076453638 6.216088034223984e-07 0.569066051987989 6.216088708671064e-07 0.5675516747474645 6.216089379592979e-07 0.5660472084764079 \
6.216089908797418e-07 0.5648615894615425 6.216090865272253e-07 0.5627204246953637 6.216091437083616e-07 0.5614413394337 6.216091975109775e-07 0.5602399192081799 \
6.216092592530825e-07 0.5588634520375642 6.216093450862141e-07 0.5569525037715509 6.216094277818617e-07 0.5551133137453282 6.216095539105889e-07 0.552313430559463 \
6.216096890096645e-07 0.5493247407981657 6.21609787329828e-07 0.5471534914294828 6.216098999078897e-07 0.5446716589975775 6.216100024523052e-07 0.5424173856211837 \
6.216101225611309e-07 0.5397821662853191 6.216102242487819e-07 0.5375541863492928 6.216103397527456e-07 0.5350300289250629 6.216104546438614e-07 0.5325260225312031 \
6.21610581121134e-07 0.5297740207092871 6.216107063383297e-07 0.5270565158317848 6.216108531843122e-07 0.5238798967507053 6.216109886424457e-07 0.5209557060405445 \
6.216111462030545e-07 0.5175672114705414 6.216113083572294e-07 0.5140875588169389 6.21611489068307e-07 0.5102248342695275 6.216116813160604e-07 0.5061308236654174 \
6.216118940383231e-07 0.5016182665703952 6.216121259434839e-07 0.4967183500883584 6.216123831371877e-07 0.4913135654247419 6.216126226904983e-07 0.4863004534671564 \
6.216129246203734e-07 0.4800178499336004 6.216132123868145e-07 0.4740665530855001 6.216135251890574e-07 0.4676409412178996 6.216138450208061e-07 0.4611139840073785 \
6.21614184657409e-07 0.4542292677834274 6.216145118732278e-07 0.4476411633207955 6.216148470347968e-07 0.4409363684817221 6.216151642914575e-07 0.4346351592989786 \
6.216154981114363e-07 0.4280489847791872 6.2161584979678e-07 0.4211625252737479 6.21616163864498e-07 0.4150547397555842 6.216164868937019e-07 0.4088175946446666 \
6.216169278730989e-07 0.4003732788922496 6.21617270275942e-07 0.3938810608698495 6.216175707238304e-07 0.3882325136127223 6.216179460534016e-07 0.3812375944419973 \
6.216182761286299e-07 0.3751439175705365 6.216185594064112e-07 0.3699597784791666 6.216188599137726e-07 0.3645020109013299 6.216191395612329e-07 0.3594637112692664 \
6.216193634235236e-07 0.3554634414471464 6.216195752745134e-07 0.35170280677964 6.216197776231135e-07 0.3481338771034005 6.216199787581391e-07 0.3446120049995081 \
6.216201845356566e-07 0.3410324794262659 6.216204455143708e-07 0.3365252478245505 6.216206850045531e-07 0.3324209773202946 6.216209176796239e-07 0.3284665339262754 \
6.216211317612159e-07 0.3248537323113044 6.21621352906983e-07 0.3211475567840967 6.21621553789873e-07 0.3178053707831449 6.216217571810748e-07 0.3144500223650613 \
6.216219548494876e-07 0.3112139453100684 6.216221410931751e-07 0.3081862077816076 6.216223360742573e-07 0.3050391973134606 6.216225395365022e-07 0.3017803754370622 \
6.216227174774077e-07 0.2989521325826759 6.216229532011122e-07 0.2952356640875101 6.216231513339655e-07 0.2921385263640672 6.216233526780326e-07 0.2890160050544278 \
6.216235769672297e-07 0.2855690750291008 6.216237418971287e-07 0.2830551950838826 6.216239195258139e-07 0.2803657404651576 6.216241039249612e-07 0.2775946687427531 \
6.216242877463063e-07 0.2748547260732712 6.216244662029787e-07 0.2722194282383935 6.216246381032458e-07 0.2696976713509589 6.216247986436534e-07 0.2673699088296289 \
6.216249201257116e-07 0.265617282026588 6.216250730472387e-07 0.2634201198254058 6.216252004809339e-07 0.2616085083773952 6.216253046546046e-07 0.2601317890528609 \
6.216254215590816e-07 0.2584775571399547 6.21625536570573e-07 0.2568557450124987 6.216256609328033e-07 0.2551103168403305 6.216257765070866e-07 0.2534925198640895 \
6.216259106146075e-07 0.2516172680784447 6.216260256018484e-07 0.2500177396912131 6.216261793514453e-07 0.2478798443778067 6.216263161546458e-07 0.2459790966208961 \
6.21626450740453e-07 0.2441094379339017 6.216266066045887e-07 0.2419575875351012 6.216267312534115e-07 0.2402378086535915 6.216268704689347e-07 0.2383186229544463 \
6.2162700069296e-07 0.236525770455347 6.216271210458007e-07 0.2348769158236033 6.216272564390845e-07 0.233027137746051 6.216274076440629e-07 0.2309620730808924 \
6.21627542400533e-07 0.2291249940296414 6.216276470867202e-07 0.2277003186426776 6.216277696228612e-07 0.2260366668203369 6.2162790456742e-07 0.2242086518061946 \
6.216279996831675e-07 0.2229209267876512 6.216281149432224e-07 0.2213657311907907 6.216281974762017e-07 0.2202562617028589 6.216282686815328e-07 0.2192992955643472 \
6.216283173890172e-07 0.2186449771734718 6.216283645839733e-07 0.2180112263680214 6.216284111327914e-07 0.2173864029843717 6.216284645213553e-07 0.2166701476649976 \
6.216285018980252e-07 0.2161690444847812 6.216285392831377e-07 0.2156680710113931 6.21628579604508e-07 0.2151283464800275 6.216286508546474e-07 0.2141753141901174 \
6.216286850689041e-07 0.2137180869447317 6.216287314635346e-07 0.2131018213873352 6.216287919072007e-07 0.2122998083652294 6.216288609101202e-07 0.2113853596849882 \
6.216289262050716e-07 0.210520730631805 6.216289941831954e-07 0.2096212333552783 6.21629110629525e-07 0.2080823984153433 6.216292005517136e-07 0.2068957989735914 \
6.216293082176196e-07 0.2054771097790837 6.216294042789353e-07 0.2042146625011118 6.216295076575089e-07 0.2028641889872041 6.216296043425437e-07 0.2016026287683381 \
6.216297071523967e-07 0.2002625524503448 6.216298079123679e-07 0.1989526210414513 6.216299190580346e-07 0.1975116692735505 6.216300260975286e-07 0.1961279675313261 \
6.216301440040638e-07 0.1946083430154048 6.216302521143875e-07 0.1932197128021231 6.216303614129877e-07 0.1918224631760269 6.216304820447392e-07 0.1902849927564414 \
6.216305769453309e-07 0.1890796997295432 6.216307055062502e-07 0.18745262875399 6.216307985410385e-07 0.1862801166370808 6.216309009375946e-07 0.1849947785893032 \
6.216309889048857e-07 0.1838942174288659 6.216310871755572e-07 0.182668828510528 6.216311837761789e-07 0.1814691026470878 6.216312704146923e-07 0.1803971466393716 \
6.216313568237045e-07 0.1793305247657973 6.216314526608142e-07 0.1781527189679156 6.216315573876885e-07 0.1768710765218302 6.216317031999754e-07 0.1750963017969037 \
6.216318191679069e-07 0.1736923427161618 6.216319756317111e-07 0.1718092975148396 6.2163208681163e-07 0.1704786474822015 6.216322270616306e-07 0.1688098560703619 \
6.216323500730352e-07 0.1673544160765056 6.216324565640334e-07 0.1661007559767333 6.216325528894916e-07 0.1649724583647661 6.216326503229586e-07 0.1638357962207703 \
6.216327541762373e-07 0.1626293386330815 6.216328459768101e-07 0.1615673458739011 6.216329443645254e-07 0.1604337426303964 6.216330272831698e-07 0.1594828374885931 \
6.216331226515033e-07 0.1583950132920943 6.216332052138515e-07 0.1574587876231885 6.216333077985372e-07 0.1563016192679324 6.216333840768539e-07 0.1554454316211293 \
6.216334726624787e-07 0.1544557264474612 6.216335448319839e-07 0.1536532700165102 6.216336265414731e-07 0.1527486200895024 6.216337002202808e-07 0.1519363404455653 \
6.216337804404095e-07 0.1510573496788611 6.216338521684844e-07 0.1502755532525617 6.216339204254628e-07 0.149534520573691 6.216340181414224e-07 0.1484788062294206 \
6.216340875916063e-07 0.147731872792437 6.216341703430852e-07 0.1468455801890639 6.216342303799948e-07 0.1462052652532956 6.216343006186586e-07 0.1454587420502366 \
6.216343720461929e-07 0.1447037411390827 6.216344525596947e-07 0.1438588888651768 6.216345158225991e-07 0.1431977449412327 6.216345934965784e-07 0.1423892845091393 \
6.216346828063428e-07 0.141463758692191 6.216347521699289e-07 0.1407479403162204 6.216348501181492e-07 0.1397418416088305 6.216349404626691e-07 0.1388188591118084 \
6.216350262429942e-07 0.1379520826379384 6.21635093896779e-07 0.1372719511642241 6.216351602046294e-07 0.1366075914250998 6.21635238824321e-07 0.1358227655030745 \
6.216353195192302e-07 0.135020537018139 6.216353779218939e-07 0.1344419857224206 6.216354386744168e-07 0.1338420332148588 6.21635532580729e-07 0.1329184183639811 \
6.216355749782324e-07 0.1325029080242558 6.21635654222426e-07 0.1317336600863391 6.216356945925846e-07 0.1313430593815061 6.216357842934634e-07 0.130477658168832 \
6.216358232415502e-07 0.1301029732927899 6.216359188572358e-07 0.1291862249441596 6.216359577410651e-07 0.1288146335111444 6.216360509758409e-07 0.1279263274670414 \
6.216361193184299e-07 0.1272775968534341 6.216361716392851e-07 0.1267823325594629 6.216362537399991e-07 0.1260075984242486 6.216363249033783e-07 0.1253406747583812 \
6.216364028563662e-07 0.1246136378429537 6.216364819761021e-07 0.1238779526756392 6.21636560619333e-07 0.1231489004754178 6.216366406542415e-07 0.122409328367501 \
6.216367023886577e-07 0.1218405706457005 6.216367759836405e-07 0.1211645344030958 6.216368593634578e-07 0.120401093559758 6.216369234601888e-07 0.1198161795466899 \
6.216369928987769e-07 0.119184869057559 6.216370659217156e-07 0.1185234239195788 6.216371507966272e-07 0.1177582144838446 6.216372301594785e-07 0.117046673033812 \
6.21637314893136e-07 0.1162898833629492 6.216374056044255e-07 0.1154830714735263 6.216374811875037e-07 0.1148135241260771 6.216375469154284e-07 0.1142333070693714 \
6.21637606975201e-07 0.1137047561823949 6.216376765809174e-07 0.1130943456353956 6.216377429999685e-07 0.1125141752866663 6.216378224112316e-07 0.1118230150855203 \
6.216379126741611e-07 0.1110406875128299 6.216379817184613e-07 0.1104447270551955 6.216380562735805e-07 0.1098035355921305 6.216381447575013e-07 0.1090456469739195 \
6.216382238656483e-07 0.1083709350695736 6.216382937340289e-07 0.1077773127978274 6.216383747433988e-07 0.1070920034756896 6.216384309482126e-07 0.106618206733547 \
6.216384936074921e-07 0.1060916009495399 6.216385587540976e-07 0.105545887371837 6.216386300897258e-07 0.1049504956797945 6.216387503861013e-07 0.1039516085561449 \
6.216388019396737e-07 0.103525508500865 6.216388570887417e-07 0.1030709598036589 6.216389477859257e-07 0.1023262935955709 6.216390301757782e-07 0.1016530765296615 \
6.216391257555856e-07 0.1008759670630478 6.216392329651518e-07 0.1000092507657299 6.216393366245584e-07 0.09917656019160864 6.216394228321611e-07 0.09848810438956324 \
6.216395090743862e-07 0.09780303991321163 6.216395886154604e-07 0.09717448010577609 6.216396686283335e-07 0.09654538840876434 6.216397599166613e-07 0.09583163072761708 \
6.216398416620796e-07 0.09519620281310773 6.216399305889171e-07 0.09450872319168514 6.216400203662242e-07 0.09381864801001834 6.216400973288722e-07 0.09323024625953365 \
6.216401876536891e-07 0.0925435244861572 6.216402514624153e-07 0.09206084550525626 6.216403239259827e-07 0.09151514907748673 6.216403880546354e-07 0.09103438864950099 \
6.216404663020107e-07 0.09045054736970405 6.216405660032922e-07 0.08971110930136832 6.216406400564437e-07 0.08916512281998501 6.216407266649787e-07 0.08852997392441805 \
6.216408729646849e-07 0.08746544055362569 6.216409836769483e-07 0.08666684197409438 6.216410939866262e-07 0.08587717033461532 6.216412361822689e-07 0.08486839672072237 \
6.216413762347203e-07 0.08388450488753585 6.216415188805343e-07 0.08289222299161547 6.21641667651249e-07 0.08186778387581196 6.216418043639348e-07 0.08093569403044946 \
6.21641946484565e-07 0.07997640434545976 6.21642081061545e-07 0.07907728405019222 6.216422212814229e-07 0.07814997945867638 6.216423690282293e-07 0.07718353387841098 \
6.216425189824148e-07 0.07621348085094087 6.216426836982467e-07 0.07516037195605636 6.216428472843634e-07 0.07412732798506308 6.216430219327156e-07 0.07303837372665309 \
6.216432089864081e-07 0.07188781219077654 6.216434189729256e-07 0.0706159374129187 6.216436370461739e-07 0.06931715807027321 6.216438703663275e-07 0.06795188046253516 \
6.216441248458817e-07 0.0664909822812602 6.2164441780254e-07 0.06484528303377844 6.21644719953089e-07 0.06318745987130532 6.216450576747915e-07 0.06138078634948794 \
6.216454527833931e-07 0.05932807220464856 6.216458202346361e-07 0.05747953410674719 6.216462378424018e-07 0.05544691527644593 6.216465828383762e-07 0.0538196438399016 \
6.216469333806655e-07 0.05221302159193914 6.21647248341029e-07 0.0508087490907442 6.216475475823956e-07 0.049508488261462 6.216478469482477e-07 0.04824029756235761 \
6.216481221909583e-07 0.04710512226277328 6.216484056545246e-07 0.04596497870754415 6.216486672549465e-07 0.04493681260994405 6.216489447070711e-07 0.04387103439794762 \
6.216492207665063e-07 0.04283531238677037 6.216495290362429e-07 0.04170718945545093 6.216497514688635e-07 0.0409114719535993 6.21650039009947e-07 0.03990505631995635 \
6.216502752428796e-07 0.0390969788355163 6.216505937045547e-07 0.03803800466874574 6.21650844115589e-07 0.03722710566490722 6.216511671003914e-07 0.03620720400565681 \
6.216514254364062e-07 0.03541203096995557 6.216517154102846e-07 0.03454066075983582 6.216519452051024e-07 0.0338658635512188 6.216522301004437e-07 0.03304787219836024 \
6.21652469846563e-07 0.03237513696606491 6.216527104811323e-07 0.03171392889024889 6.216529495996188e-07 0.03107212555077287 6.216531855385298e-07 0.03045460689686571 \
6.216534163673909e-07 0.02986254663395104 6.216536313939185e-07 0.02932175456294728 6.216540335597597e-07 0.0283374222946415 6.2165423211788e-07 0.02786401170979088 \
6.216546058190659e-07 0.02699470773596776 6.216547926322608e-07 0.02657042318767052 6.216551386335082e-07 0.02580176906824739 6.216552605769465e-07 0.02553595448027303 \
6.216556434299635e-07 0.02472011952872977 6.216558038641491e-07 0.02438657631284594 6.21656246865303e-07 0.02348572425118655 6.216564174793445e-07 0.02314627247835563 \
6.216567380559406e-07 0.02251902970747987 6.216569383408681e-07 0.0221336684630111 6.216573852788009e-07 0.02128811173678137 6.216575132229166e-07 0.02104854104185888 \
6.216580011002759e-07 0.02014826272243131 6.216581360775529e-07 0.01990454278080647 6.216586183290713e-07 0.0190640092473091 6.216587806551862e-07 0.01879235028057063 \
6.216592670495271e-07 0.01801148170254873 6.216594300771862e-07 0.01776103207540622 6.216601102988766e-07 0.01676849304257711 6.216602493826144e-07 0.01657541006259178 \
6.216609818771476e-07 0.01560782569993242 6.216611407707804e-07 0.01540693214221847 6.216619238518671e-07 0.01445869962397344 6.216620696444218e-07 0.01428952172302696 \
6.216629204257814e-07 0.01334248985256295 6.216630315290529e-07 0.01322388191882306 6.216639648234166e-07 0.0122699293983148 6.216640986614657e-07 0.01213902814618388 \
6.21665057199482e-07 0.01123495036716388 6.216651783165508e-07 0.01112486091825863 6.216663004003486e-07 0.01017270671243764 6.216664059016017e-07 0.01008921053061839 \
6.216677349760139e-07 0.009112307258623473 6.216678551802884e-07 0.009029744095492466 6.216694035420479e-07 0.008036808760534916 6.216694843298185e-07 0.007986285493236449 \
6.216710552093519e-07 0.007024564730313319 6.216711226255509e-07 0.006986095570813155 6.216730433922295e-07 0.006001386377072119 6.216732301941131e-07 0.005914747648762168 \
6.216755456080606e-07 0.0049318160947762 6.216759451349076e-07 0.004777795182599986 6.216785089444083e-07 0.003889929704329555 6.216790078153284e-07 0.003736330440833864 \
6.21682637539317e-07 0.002784984367379526 6.216831882332918e-07 0.002663729254427667 6.216885866736714e-07 0.001711392372544448 6.216888999412433e-07 0.001662511220227468 \
6.216938922337914e-07 0.0006970413096974805 6.216940762528259e-07 0.0006571176749162138 6.243425553956096e-07 -0.0002691198397987355 6.24342711454572e-07 -0.0004551674219448388 \
6.243432594384272e-07 -0.001322174727784445 6.243433723764198e-07 -0.001539785040943742 6.243438016313498e-07 -0.002474302920374066 6.243439078885149e-07 -0.002730173903076456 \
6.243441906906665e-07 -0.003454402452283872 6.243443042852103e-07 -0.003760966378165151 6.243446428397891e-07 -0.004705104513819927 6.243447552637498e-07 -0.005021586953003071 \
6.243450835416507e-07 -0.005887841248467669 6.243451910801718e-07 -0.006130875888161453 6.243460710062032e-07 -0.005789627805322099 6.243462462122502e-07 -0.004910736584223327 \
6.243463630430134e-07 -0.004127745010746014 6.243464899101376e-07 -0.00309221842859156 6.243465914428629e-07 -0.002125750314016509 6.243467128641333e-07 -0.0008095618968406578 \
6.243468030290462e-07 0.0002767910803854594 6.243469002126957e-07 0.001550247908954045 6.243469982869597e-07 0.002938803805678211 6.243471655080454e-07 0.005530627736217106 \
6.243473878133233e-07 0.009378371294171852 6.24347573551714e-07 0.01290572951649239 6.243477976330495e-07 0.01747895571448658 6.243479572777817e-07 0.02091945933227325 \
6.243481217671112e-07 0.02459614091902196 6.243482715915693e-07 0.0280452875125503 6.243484209914613e-07 0.03156498790849799 6.243485705227667e-07 0.03515592969144176 \
6.243487246026614e-07 0.03891669635189081 6.243488867868089e-07 0.0429309674228065 6.24349053210035e-07 0.0470989728378523 6.243492291435082e-07 0.05154884981278444 \
6.24349410271779e-07 0.05616867911875007 6.243496024027047e-07 0.06110225049351239 6.24349810098117e-07 0.0664648391313285 6.243500320181979e-07 0.07222051812179281 \
6.243502672196803e-07 0.07834079218654426 6.243505194059893e-07 0.08491829088081257 6.243507955452241e-07 0.09213111703448683 6.243510966667008e-07 0.1000001933597138 \
6.243514285865622e-07 0.1086702418150647 6.243518059053303e-07 0.1185147411083515 6.243522041953865e-07 0.1288888856248832 6.243526735037064e-07 0.1410822143415975 \
6.243532195292308e-07 0.1552200475789812 6.243538544895378e-07 0.1715918832733369 6.243545538901292e-07 0.1895291194622146 6.243553721290552e-07 0.2103807608661494 \
6.243562778230217e-07 0.2332840710921665 6.243570673340878e-07 0.253091928008631 6.243577710929056e-07 0.2706124241987875 6.243583889437195e-07 0.2858796548825839 \
6.243589545671311e-07 0.2997575097153312 6.243594763024047e-07 0.3124620269501652 6.243599740861211e-07 0.3244932238414255 6.243604577240811e-07 0.3360954048923613 \
6.243609145982153e-07 0.3469667650518959 6.243613874391094e-07 0.3581213589834248 6.243618270524661e-07 0.3684065070151987 6.24362314929562e-07 0.379719432411247 \
6.243628457299845e-07 0.3919028193132517 6.243633436253595e-07 0.4032143644097119 6.24363775002613e-07 0.41292177789323 6.243642618898012e-07 0.4237731225600331 \
6.243647619892433e-07 0.4348012155672935 6.243651066099338e-07 0.4423321287141763 6.243654600037777e-07 0.4500000647748709 6.243658877736169e-07 0.4592134948422093 \
6.243662796346881e-07 0.4675816212925634 6.243665799290445e-07 0.4739471552041949 6.243669218601248e-07 0.4811428413521782 6.243672651945704e-07 0.4883132334011818 \
6.24367525955058e-07 0.4937215836208605 6.243677680115876e-07 0.4987106167174703 6.243680340100556e-07 0.5041617362307154 6.243682934982395e-07 0.5094435946950286 \
6.243684834145396e-07 0.5132872703533161 6.243686986491409e-07 0.5176241792560061 6.243688371999e-07 0.5204025546691405 6.243689820806791e-07 0.5232962183003332 \
6.243691954947458e-07 0.5275364624051522 6.243693975193605e-07 0.5315382148201082 6.243695902480239e-07 0.5353370730264509 6.243697755034039e-07 0.5389735557287745 \
6.243699525009276e-07 0.5424323215059959 6.243702617642633e-07 0.5484573594957171 6.243705229123106e-07 0.5535233414883098 6.243708247314806e-07 0.5593562770234363 \
6.243710801601219e-07 0.5642781701956761 6.243713725156194e-07 0.5698968483756405 6.243716319698132e-07 0.5748654731717864 6.243719020897901e-07 0.5800301911327002 \
6.243721441003479e-07 0.5846380733684551 6.243724016101459e-07 0.5895273573494454 6.243726280544834e-07 0.5938057549890672 6.243728649429657e-07 0.5982619499065401 \
6.24373074987873e-07 0.6021962733001386 6.243732879185847e-07 0.6061670177072124 6.243735413972821e-07 0.6108668889270118 6.243737446929309e-07 0.6146150465592417 \
6.243739363811142e-07 0.6181346807088086 6.243741250074786e-07 0.6215812235468744 6.243743123254166e-07 0.6249823889551316 6.243745179374062e-07 0.6286953279350977 \
6.243747677606248e-07 0.6331759959753138 6.243749715724035e-07 0.6368063379741715 6.243751792111212e-07 0.6404826298163093 6.24375371862737e-07 0.6438748386876914 \
6.243756164748104e-07 0.6481531432733096 6.243758643733136e-07 0.6524620620600715 6.243760442082187e-07 0.6555644139995785 6.243762349822552e-07 0.6588391718544121 \
6.24376388158437e-07 0.6614554104590837 6.243765598271468e-07 0.6643705886591137 6.243767102939677e-07 0.6669108747194671 6.243768468979714e-07 0.6692010654183506 \
6.243769963383726e-07 0.6716954191563786 6.243771240725235e-07 0.6738189269502312 6.2437726394477e-07 0.6761323074508511 6.243773880219049e-07 0.6781756764962316 \
6.243775193832699e-07 0.6803315871556701 6.243776435547311e-07 0.6823627547057004 6.243777813315919e-07 0.6846081866267727 6.243779015758122e-07 0.6865586181592046 \
6.243780436284175e-07 0.6888545186016138 6.243781438561225e-07 0.6904668682779994 6.243782651601134e-07 0.6924123325129877 6.243783561353879e-07 0.6938641504265992 \
6.243784535186708e-07 0.695411869780077 6.24378550601538e-07 0.6969507228893711 6.243786398841584e-07 0.6983595753378042 6.243787378559428e-07 0.699898781449533 \
6.243788681310304e-07 0.7019319515314388 6.243790215432551e-07 0.7043083163565919 6.243791571090671e-07 0.7063909659299702 6.24379301449562e-07 0.708591461371511 \
6.243794273204452e-07 0.710496752775434 6.243795523478311e-07 0.712376488910674 6.243796666301914e-07 0.7140841686551523 6.243797776133356e-07 0.7157331888171029 \
6.243798773084046e-07 0.7172065512867005 6.243800143526226e-07 0.7192196995505324 6.243801333798347e-07 0.7209572005600779 6.24380253677943e-07 0.7227029412191364 \
6.243803801768633e-07 0.7245276185835638 6.243805041084668e-07 0.7263044524160376 6.243806283948001e-07 0.7280754330070212 6.243807547599529e-07 0.7298652243312684 \
6.243808845716945e-07 0.7316925631262517 6.243810084102138e-07 0.7334254795816325 6.243811411911006e-07 0.735272086289578 6.243812420423057e-07 0.7366670415914529 \
6.243813552339755e-07 0.738224777043618 6.243814420199562e-07 0.7394137384482823 6.243815586452529e-07 0.7410021813026957 6.243816479345105e-07 0.7422110784210975 \
6.243817591113937e-07 0.7437075443329063 6.243818883701577e-07 0.7454347509364776 6.243820022291937e-07 0.7469455276109591 6.243821066334057e-07 0.74832188588007 \
6.243822310004373e-07 0.7499498655229884 6.243823782406159e-07 0.7518616907275563 6.243824985209068e-07 0.753411006437983 6.243826144254458e-07 0.7548933175676444 \
6.243827545012897e-07 0.7566706674475765 6.243828971129601e-07 0.7584645678799224 6.243830150672032e-07 0.7599365027959469 6.243831418837122e-07 0.7615071445339606 \
6.243832827668562e-07 0.7632375905494565 6.243834025603536e-07 0.7646969139886852 6.243835475192107e-07 0.7664484133613445 6.243836690779963e-07 0.7679052725436226 \
6.243837881174897e-07 0.7693214142140735 6.243839097488532e-07 0.7707575700077021 6.243840377178316e-07 0.772256936813787 6.243841469330139e-07 0.7735272422640712 \
6.243842718238923e-07 0.774969549136603 6.24384378939953e-07 0.7761978171588899 6.243845121931473e-07 0.7777146071439789 6.243846392965932e-07 0.7791497354387434 \
6.243847610475684e-07 0.7805132846941326 6.243848776321507e-07 0.7818078758210534 6.243849834597529e-07 0.7829735233300771 6.243851228258954e-07 0.7844949153190801 \
6.243852718976944e-07 0.786105286864636 6.24385419626362e-07 0.7876841235632186 6.243855389322397e-07 0.7889471147195867 6.243856729390521e-07 0.7903527806482344 \
6.243857933652268e-07 0.791604423795974 6.243859349104043e-07 0.7930616786923709 6.243860823364167e-07 0.7945638089648995 6.243862068109251e-07 0.7958198087139573 \
6.243863258549181e-07 0.7970105506108808 6.243864374452017e-07 0.7981174590942314 6.243865426744904e-07 0.7991530841216606 6.243866381855941e-07 0.8000862307887144 \
6.243867742475476e-07 0.8014036057482816 6.243868911236815e-07 0.8025237700417888 6.243870102773537e-07 0.8036549841722296 6.24387132589548e-07 0.8048050501807249 \
6.243872558616218e-07 0.8059526272620129 6.243873823583984e-07 0.8071184350969989 6.243875078610623e-07 0.8082633544790385 6.243876385869669e-07 0.8094437311890262 \
6.243877641549386e-07 0.8105658358439867 6.243878932098036e-07 0.8117072367686948 6.243879990659606e-07 0.8126345588578442 6.243881002348366e-07 0.8135133322873783 \
6.243881948546565e-07 0.8143286754242188 6.243883191357402e-07 0.8153900871385379 6.243884088474262e-07 0.816149614585347 6.243885078849502e-07 0.8169816577628611 \
6.243886456628271e-07 0.8181280288377792 6.243887801986773e-07 0.81923501721715 6.243888886049436e-07 0.8201180631035904 6.243890385184474e-07 0.8213254631869725 \
6.243891890970255e-07 0.8225223201378843 6.243893145921802e-07 0.8235077122548546 6.243894584387069e-07 0.8246238332260477 6.243895830219706e-07 0.8255790649890803 \
6.243897318751913e-07 0.8267066458678887 6.24389868023775e-07 0.827725029289517 6.243899930476023e-07 0.8286494160599757 6.243901107545823e-07 0.8295103773055483 \
6.243902563935804e-07 0.8305630309532103 6.243904227748753e-07 0.8317484146982921 6.243905533585645e-07 0.8326660250626342 6.243907268806749e-07 0.8338683097812621 \
6.243908950025775e-07 0.8350147136930499 6.243910648651803e-07 0.8361549927788252 6.243912457668832e-07 0.8373497079260466 6.243913888761651e-07 0.8382806519784776 \
6.24391502965127e-07 0.839013953006387 6.243916331276035e-07 0.8398410866028793 6.243917349727342e-07 0.8404811280669765 6.243918517989402e-07 0.8412075886390841 \
6.243919886903802e-07 0.8420483852080155 6.243921864976039e-07 0.843243620449199 6.243923781227505e-07 0.8443797466267589 6.243925875546179e-07 0.8455974227529048 \
6.243927695012999e-07 0.8466352798309468 6.243929666301539e-07 0.8477391449715804 6.243931399710143e-07 0.8486924050423899 6.243933229793209e-07 0.8496814535024207 \
6.243934941423557e-07 0.8505903669473519 6.243936687794505e-07 0.851501688465695 6.243938440392814e-07 0.8524001683007644 6.243940201897297e-07 0.8532872510191711 \
6.243942104700295e-07 0.8542278331088334 6.243944010691599e-07 0.8551519386507073 6.243946016923949e-07 0.8561055033533737 6.2439479430095e-07 0.8570028516027762 \
6.243950049816413e-07 0.8579644845832216 6.243952330831088e-07 0.8589827023971403 6.243954988710915e-07 0.860139640227508 6.243957974838521e-07 0.8614018215255795 \
6.243960737724907e-07 0.8625348754565382 6.243963580090103e-07 0.8636666213345715 6.243966322137804e-07 0.8647267940813509 6.243969044486385e-07 0.8657495569722869 \
6.243971746527799e-07 0.8667361702337206 6.243974318083905e-07 0.867649441901348 6.24397704388604e-07 0.8685908808535525 6.2439798037489e-07 0.8695169452638583 \
6.24398250477721e-07 0.870397355937691 6.243985503347982e-07 0.8713451925332844 6.243989213624563e-07 0.8724761722512941 6.243992162997666e-07 0.8733433185969293 \
6.243994705892065e-07 0.8740690226522811 6.243997688459906e-07 0.874895168896023 6.244000424554269e-07 0.8756299040683481 6.244002785839137e-07 0.8762466977562872 \
6.244005189298273e-07 0.8768585021646264 6.244007412634921e-07 0.8774104263690854 6.244009352691695e-07 0.8778812671168952 6.244012649918855e-07 0.8786590883967833 \
6.244014201653189e-07 0.8790156160651978 6.244017379413894e-07 0.8797272612331356 6.244019168030317e-07 0.8801171459162566 6.244022592648612e-07 0.8808425821290963 \
6.244024433930207e-07 0.881221400612852 6.244029182707539e-07 0.8821634994206867 6.24403085666965e-07 0.8824839765989225 6.244035515089056e-07 0.8833452998114757 \
6.244037323309576e-07 0.8836679564577563 6.244042263693832e-07 0.8845176198113115 6.244043677180069e-07 0.8847523712107549 6.244049740520726e-07 0.8857188576377059 \
6.244051261213959e-07 0.8859512996759633 6.244057728095585e-07 0.8868983431897121 6.2440590110417e-07 0.8870786909355212 6.244065492212318e-07 0.8879538337624689 \
6.244066790202949e-07 0.8881220828502663 6.244074572237723e-07 0.8890807033877333 6.24407572278734e-07 0.8892148977954012 6.244084279402064e-07 0.8901543051721961 \
6.244085733010757e-07 0.8903040038307473 6.244095590571272e-07 0.8912446482480114 6.244097801624957e-07 0.8914382978987679 6.244109252894234e-07 0.8923659558950503 \
6.244110565064392e-07 0.8924678262926897 6.244123977150129e-07 0.8934599079028542 6.244125491142719e-07 0.8935646301988298 6.244140305519948e-07 0.8944937559627255 \
6.24414269431373e-07 0.8946275407274444 6.244160387469791e-07 0.8955013787854181 6.244164278981914e-07 0.8956696032899972 6.244188215611417e-07 0.8965547188539188 \
6.244192972701398e-07 0.8967039926079825 6.244233604302104e-07 0.8977020505850396 6.24423851854269e-07 0.8977948037134476 6.24432168453822e-07 0.898787348739254 \
6.244330883529499e-07 0.8988506593152591 6.245765735834803e-07 0.8998476076348748 6.245776920164556e-07 0.8998537475785264 6.247827836359558e-07 0.898985773748599 \
6.247830107254573e-07 0.8988224379910277 6.247846203322555e-07 0.8978282360369357 6.247847977407988e-07 0.8977338482811539 6.248017048890995e-07 0.8987315468430059 \
6.248018143281978e-07 0.8987460089186867 6.248175950494439e-07 0.8997418097871094 6.248178913753395e-07 0.8997476966799167 6.25301325027745e-07 0.9007060148833608 \
6.253014540780854e-07 0.9008313386292994 6.253021042279306e-07 0.9016292186224167 6.253022937236614e-07 0.9019133038041363 6.253027969456399e-07 0.9027675859898705 \
6.253029324182996e-07 0.9030208676018907 6.253033328770163e-07 0.9038195223753869 6.253034648149532e-07 0.9040958310886574 6.253038660300166e-07 0.9049509627747726 \
6.253039642901936e-07 0.9051582028152527 6.253044301640043e-07 0.9060587574877488 6.253045916627274e-07 0.9063060456044927 6.253057356752504e-07 0.9055153668657776 \
6.253058806545959e-07 0.9049059606760256 6.253060592073535e-07 0.9039396653125833 6.253062394026312e-07 0.9027054491383806 6.253063820935605e-07 0.9015369228101149 \
6.253064992531645e-07 0.9004524619440171 6.253065882345255e-07 0.8995505656965809 6.253066798781777e-07 0.8985529714258781 6.253068129901104e-07 0.8969831049011855 \
6.253069067111928e-07 0.8957895978311226 6.253069978500018e-07 0.8945634483845346 6.253071111423132e-07 0.8929516940777753 6.253072142512258e-07 0.8913998138690341 \
6.253073105184064e-07 0.8898830246517148 6.253074296555228e-07 0.8879200664089764 6.253075982407716e-07 0.8849885378698126 6.253077600122728e-07 0.8820195265790133 \
6.253079532313317e-07 0.8782956415026882 6.253081387944432e-07 0.8745571577041361 6.253083490607478e-07 0.8701566079887386 6.253085313097886e-07 0.8662213066841463 \
6.253087161731833e-07 0.8621339172744639 6.253088888583302e-07 0.8582419637438897 6.253090749664033e-07 0.8539816046497358 6.253092527824914e-07 0.849858603441091 \
6.253094334990722e-07 0.8456251963850057 6.253095986373313e-07 0.8417258760277182 6.253097639114333e-07 0.837798995916667 6.253099271590958e-07 0.8339004324287677 \
6.253100857493695e-07 0.8300982805770993 6.253102626737714e-07 0.8258418712800655 6.253104591875838e-07 0.8211009660847696 6.253106267441254e-07 0.8170498602679914 \
6.253107934845439e-07 0.8130123908857781 6.253109679080616e-07 0.8087844286215062 6.253111372776842e-07 0.8046757316210446 6.253113054767785e-07 0.8005936994537799 \
6.25311494325046e-07 0.7960093488074458 6.253116851408819e-07 0.7913773844868103 6.253118935230917e-07 0.7863203192056716 6.25312119942597e-07 0.7808277108969495 \
6.253123091427939e-07 0.7762391340290878 6.253125192894832e-07 0.7711455503222944 6.253126680579874e-07 0.7675418410361046 6.253127990509761e-07 0.7643705172588006 \
6.25312936616212e-07 0.7610417440783073 6.253130423674414e-07 0.7584842184275663 6.253131771410752e-07 0.7552262509102785 6.253132889738004e-07 0.7525244432456109 \
6.253134184089644e-07 0.7493992292091655 6.253135735976882e-07 0.7456545577979357 6.253136852334406e-07 0.7429626190147979 6.253138448080548e-07 0.7391166470929011 \
6.253140201296882e-07 0.7348935218456193 6.253142325051509e-07 0.7297828120356423 6.253144253876788e-07 0.7251458607116523 6.253145820889711e-07 0.7213823872711312 \
6.253147687636618e-07 0.716903961299824 6.253149576500111e-07 0.7123775767926828 6.253151485342027e-07 0.70780884692282 6.253153352821382e-07 0.7033444557767304 \
6.253155183669542e-07 0.698972331957095 6.253156556859354e-07 0.6956951921588121 6.253158089288925e-07 0.6920418367118417 6.253160040575431e-07 0.6873949992893974 \
6.253161613518717e-07 0.6836535194673684 6.253163207464669e-07 0.6798660670227984 6.253165164902601e-07 0.6752219404489795 6.253167086893939e-07 0.6706682621108646 \
6.253169436410222e-07 0.6651105611269369 6.2531713111727e-07 0.6606839627962382 6.253173683544039e-07 0.6550894036851447 6.253175575343661e-07 0.6506361170423679 \
6.253177381501785e-07 0.6463915264929231 6.253179018447415e-07 0.6425504277539856 6.253180463961503e-07 0.6391628119244788 6.2531818686792e-07 0.6358764726647652 \
6.253183139687074e-07 0.6329064225879303 6.253184462761835e-07 0.6298198307262635 6.253185728632297e-07 0.626870110582017 6.253187034434976e-07 0.62383130535404 \
6.253188327128966e-07 0.6208285625908692 6.253189718197929e-07 0.6176004736356133 6.253191203301029e-07 0.6141606483517721 6.253193098786582e-07 0.6097777958748198 \
6.253194555819145e-07 0.6064170107178907 6.253196906324778e-07 0.601007464699683 6.253198736317493e-07 0.5968099615921 6.253200979734226e-07 0.5916778694808832 \
6.253202691466717e-07 0.5877753019413697 6.253204014804908e-07 0.5847634284691802 6.253205332770303e-07 0.5817721407249107 6.253206398209335e-07 0.5793579518205488 \
6.25320735711292e-07 0.5771868999037388 6.25320828211542e-07 0.5750974572268882 6.253209206389049e-07 0.5730134868920421 6.253209930672116e-07 0.5713818265150021 \
6.253210487963169e-07 0.5701269325864891 6.253211099054045e-07 0.5687522410723198 6.2532120667008e-07 0.5665806864277688 6.253212681615945e-07 0.5652027770813386 \
6.253213272142164e-07 0.5638802801505602 6.253214028408818e-07 0.5621878686488651 6.253214698636602e-07 0.5606896577364279 6.253215434607697e-07 0.5590483558003441 \
6.253216110667724e-07 0.5575429304381756 6.253217271358288e-07 0.5549610936632026 6.253218273422345e-07 0.5527359403974305 6.253219393494244e-07 0.5502565947066531 \
6.253220338414751e-07 0.5481686943853854 6.253221549961725e-07 0.5454955387196141 6.253222551839388e-07 0.5432910220514219 6.253223711744508e-07 0.5407443765731218 \
6.253224788782884e-07 0.5383833065966291 6.253225884569768e-07 0.5359861028148916 6.253227005784207e-07 0.5335400310751951 6.253228275156047e-07 0.5307765704644959 \
6.253229496651232e-07 0.5281221248815906 6.253230894260376e-07 0.525095489155881 6.253232265641538e-07 0.522132778766487 6.253233765292441e-07 0.5189020692106626 \
6.253235353022474e-07 0.5154923220538846 6.253237093279043e-07 0.511765695450105 6.25323896158028e-07 0.5077823379664483 6.253241011259935e-07 0.5034264211640872 \
6.253243238349422e-07 0.4987133299464507 6.253245767391391e-07 0.4933874474923696 6.25324811693046e-07 0.4884604410272814 6.253251079613078e-07 0.4822828691822955 \
6.253253977512662e-07 0.4762763831984252 6.253257040870848e-07 0.4699660956099861 6.253260164056119e-07 0.4635767846525711 6.253263549710683e-07 0.4566963260653934 \
6.25326678082485e-07 0.4501741115777416 6.253270164777878e-07 0.4433881855507311 6.253273403090534e-07 0.4369378830387565 6.25327664703474e-07 0.4305204627449936 \
6.253280076377602e-07 0.4237851826852676 6.253283469185779e-07 0.4171698123421442 6.253286863932124e-07 0.4105997181257849 6.253291295050583e-07 0.4020958655332711 \
6.253294915732268e-07 0.3952155038183801 6.253298121249644e-07 0.3891775711374149 6.253301990595345e-07 0.3819561902961204 6.253305269297949e-07 0.3758957719299574 \
6.253308120888516e-07 0.3706704968427373 6.253311304576464e-07 0.3648820026298218 6.253314132885732e-07 0.3597820188690578 6.253316419773369e-07 0.3556924369094372 \
6.253318598701416e-07 0.3518226517641353 6.253320551194862e-07 0.3483769517668343 6.253322620275856e-07 0.344751588202948 6.253324768243417e-07 0.3410137651016431 \
6.253327290508921e-07 0.3366564674340092 6.253329710462048e-07 0.3325077909124976 6.253332018984844e-07 0.3285822460490526 6.253334167466747e-07 0.3249550452085373 \
6.253336371033643e-07 0.3212604562488142 6.253338386742641e-07 0.3179050685021769 6.253340417582106e-07 0.3145531374773136 6.253342396555968e-07 0.3113121771742085 \
6.253344267548364e-07 0.3082694484595072 6.253346206551795e-07 0.3051385396431291 6.253348257035143e-07 0.3018527636900292 6.253350059382659e-07 0.2989872106339772 \
6.253352418362775e-07 0.2952669081535775 6.253354431238274e-07 0.2921198200609627 6.253356445146313e-07 0.2889965001417216 6.253358691637942e-07 0.2855437159941698 \
6.253360345437678e-07 0.2830223598911593 6.253362123481056e-07 0.280330186126118 6.253363960043191e-07 0.277570343839212 6.253365812460764e-07 0.2748090658167894 \
6.253367593914542e-07 0.2721781298892599 6.253369329835173e-07 0.2696316866093095 6.253370933483699e-07 0.267306655456324 6.253372144595526e-07 0.2655585721882695 \
6.253373676543406e-07 0.2633570345323199 6.253374949857891e-07 0.2615475749425888 6.253375983136283e-07 0.2600830587034867 6.25337715638424e-07 0.2584225376281647 \
6.253378334453812e-07 0.2567591557214636 6.253379574091473e-07 0.2550199666844239 6.253380743933138e-07 0.2533821414201824 6.253382051894416e-07 0.2515535495016885 \
6.253383223995523e-07 0.2499173892700276 6.253384756526766e-07 0.2477853623028658 6.253386111831973e-07 0.2459029165157107 6.253387428644058e-07 0.244074199323236 \
6.253388994573169e-07 0.2419017673596028 6.253390246538746e-07 0.2401755227310949 6.253391603715014e-07 0.2383060149301216 6.253392927986628e-07 0.2364844144139329 \
6.253394127723238e-07 0.2348355337769661 6.253395758201609e-07 0.232606585912384 6.253397146272525e-07 0.230713852557009 6.253398531009718e-07 0.2288300961780371 \
6.253399586457212e-07 0.2273962817971701 6.253400870074011e-07 0.2256537837490921 6.253401911350241e-07 0.2242444877898851 6.25340291651026e-07 0.222886569499566 \
6.253403666954022e-07 0.2218745444235658 6.253404440284576e-07 0.2208349692306942 6.253405187916369e-07 0.2198305887827458 6.253405967553143e-07 0.218785487158918 \
6.253406516218243e-07 0.2180503923904892 6.253407081185998e-07 0.2172938400168352 6.253407515721192e-07 0.2167123195211523 6.253407916131654e-07 0.2161767335077376 \
6.253408308521132e-07 0.2156521099473339 6.253408717263501e-07 0.2151058606261434 6.253409258788401e-07 0.2143825797409383 6.253409642959715e-07 0.2138698309421548 \
6.253410035846784e-07 0.2133480458229882 6.253410651213865e-07 0.2125332203444249 6.253411270989154e-07 0.2117131287842428 6.253411835756643e-07 0.2109664019951111 \
6.253412482072544e-07 0.2101124842966758 6.253413437158761e-07 0.2088522205996687 6.253414310316075e-07 0.207701294711168 6.253415276412079e-07 0.2064291756790013 \
6.253416248707623e-07 0.2051510266126755 6.253417257178229e-07 0.2038307158897115 6.253418263175944e-07 0.2025192706911573 6.253419228088913e-07 0.2012627769767186 \
6.253420249910648e-07 0.1999338657614989 6.253421286307215e-07 0.1985898465970496 6.253422384047342e-07 0.1971698847140261 6.253423475797596e-07 0.1957617939809042 \
6.253424676778516e-07 0.1942174441246506 6.253425776973761e-07 0.1928086337505992 6.253426858092848e-07 0.1914295694688549 6.253428088379843e-07 0.1898652723262108 \
6.253428989485537e-07 0.1887234630454603 6.253430063140445e-07 0.1873671680421656 6.253430831253526e-07 0.1864004060894758 6.253431665706206e-07 0.1853535952511875 \
6.253432561024323e-07 0.1842338297700716 6.253433406678985e-07 0.1831790839553313 6.253434203840387e-07 0.1821880912968773 6.253435217092422e-07 0.1809331989518758 \
6.253436300564713e-07 0.1795959386230563 6.253437265321694e-07 0.1784102562612937 6.25343851909986e-07 0.1768766438339704 6.253439846934562e-07 0.1752616821119887 \
6.253441024642794e-07 0.1738362801839788 6.253442481158562e-07 0.1720835746408261 6.253443587130081e-07 0.1707596463148658 6.25344500843447e-07 0.1690680578777541 \
6.253446165530702e-07 0.1676985735146403 6.253447220270832e-07 0.166456424915798 6.253448165437425e-07 0.1653485352650968 6.253449121811145e-07 0.1642320043563913 \
6.253450092529584e-07 0.1631032360400927 6.253451083042124e-07 0.161956192050434 6.253452022277692e-07 0.1608730077890209 6.253452875034442e-07 0.1598934595213354 \
6.253453878832364e-07 0.1587475631033795 6.253454721860728e-07 0.1577906478848196 6.253455745855819e-07 0.1566342854655733 6.253456519798444e-07 0.1557646215197878 \
6.253457443247582e-07 0.154731814591042 6.253458145762303e-07 0.1539498814072817 6.253459107506593e-07 0.1528844393027091 6.253459875753224e-07 0.152038051282755 \
6.253460663454742e-07 0.1511758489440315 6.253461402383946e-07 0.150370438825067 6.253462079361381e-07 0.1496353997608715 6.253463040000261e-07 0.1485973848112393 \
6.25346373572453e-07 0.1478489919002561 6.253464574616254e-07 0.1469503328160803 6.253465185934615e-07 0.146298213254472 6.25346590861543e-07 0.1455309799806117 \
6.253466633001063e-07 0.1447677488542132 6.253467442811468e-07 0.1439178685120187 6.253468103556157e-07 0.1432275520600639 6.253468877561137e-07 0.1424219220725307 \
6.253469771315706e-07 0.1414956876531561 6.253470479922163e-07 0.1407644282175171 6.253471468792833e-07 0.1397487730030469 6.253472241981923e-07 0.1389620820751095 \
6.253473062434185e-07 0.1381330876879582 6.2534739435453e-07 0.1372467208126059 6.25347461981677e-07 0.1365690714953818 6.253475422788589e-07 0.1357674830239305 \
6.253476170628882e-07 0.1350239185327315 6.253476850640654e-07 0.1343502586094245 6.253477317469739e-07 0.1338891847862563 6.253478209985674e-07 0.1330118383700247 \
6.253478592216168e-07 0.1326395291833771 6.253479282135268e-07 0.1319690872918072 6.253479809615962e-07 0.1314578750898332 6.253480639543784e-07 0.1306559489775353 \
6.253481041328287e-07 0.1302688434457458 6.253481966502028e-07 0.1293805059784019 6.253482353685699e-07 0.1290098403727171 6.253483091292851e-07 0.1283055160094505 \
6.253483707572867e-07 0.1277188748199021 6.253484427849764e-07 0.1270353589407805 6.25348510952008e-07 0.1263909833196726 6.253485855741693e-07 0.1256908956540175 \
6.253486674266349e-07 0.1249253613889138 6.253487508807973e-07 0.124147338931438 6.253488238325109e-07 0.1234692772477456 6.253488965594407e-07 0.122795332839617 \
6.253489565494355e-07 0.1222410931008323 6.253490429174471e-07 0.121445549533078 6.253491038861646e-07 0.1208856452315438 6.253491622719555e-07 0.1203507897957366 \
6.253492279066197e-07 0.119751336354628 6.253492872608612e-07 0.1192111367930785 6.253493552926419e-07 0.1185941868697126 6.25349452587012e-07 0.11771710490035 \
6.253495310789917e-07 0.1170124163111649 6.25349621315123e-07 0.1162055395685231 6.253497171618085e-07 0.1153523005684616 6.253497921195047e-07 0.1146878351828532 \
6.253498964789212e-07 0.1137670532163148 6.25349983267518e-07 0.1130053589403202 6.253500929249339e-07 0.1120476726212376 6.253501744789968e-07 0.1113387926087848 \
6.253502700926292e-07 0.1105114393564785 6.253503468048225e-07 0.10985058581598 6.253504417232868e-07 0.1090364400125625 6.253505175463918e-07 0.1083889268999046 \
6.253505952460493e-07 0.1077282965354292 6.253506775775e-07 0.1070311517075373 6.253507371427637e-07 0.1065286079538068 6.253508009005013e-07 0.1059924133642201 \
6.253508619951088e-07 0.1054803128126646 6.253509578588471e-07 0.1046801683739134 6.253510027219415e-07 0.1043071445723913 6.253510859626871e-07 0.1036173314376927 \
6.25351135082509e-07 0.1032117000904133 6.253512441312713e-07 0.1023149933518279 6.253512889673534e-07 0.1019479364619093 6.253513792285848e-07 0.1012117400678687 \
6.25351420105203e-07 0.1008795969612472 6.25351490563617e-07 0.1003088525914566 6.253515768510382e-07 0.09961307626065434 6.253516686285973e-07 0.09887705578174606 \
6.253517381566897e-07 0.09832225024344161 6.25351816683849e-07 0.09769854072774181 6.253519074125254e-07 0.09698178745350861 6.253519832286639e-07 0.09638605854785212 \
6.253520652414071e-07 0.09574500473888557 6.253521469944435e-07 0.09510943278387665 6.253522375022672e-07 0.09440967388330095 6.253523270615646e-07 0.09372126988887708 \
6.253524126713984e-07 0.09306698857649189 6.253525054508964e-07 0.09236212353634379 6.25352586338857e-07 0.0917510971760913 6.253526874678274e-07 0.09099177263830999 \
6.253527679613525e-07 0.09039108594384238 6.253528522042178e-07 0.08976589684797046 6.253529260492652e-07 0.08922077348043934 6.253530028987434e-07 0.08865632925481931 \
6.253530910391124e-07 0.08801255002475737 6.253531711034816e-07 0.08743108261130086 6.253532641396717e-07 0.08675939571108145 6.253533821403849e-07 0.08591369538214398 \
6.253535245136123e-07 0.08490278100234279 6.253536687619621e-07 0.08388867104764453 6.253538110896711e-07 0.08289807427203813 6.253539606674147e-07 0.08186746790234835 \
6.253540969811605e-07 0.08093761126893445 6.253542391015919e-07 0.0799778356000513 6.253543736550196e-07 0.07907840240745091 6.253545140077295e-07 0.07814980287393705 \
6.253546616898023e-07 0.0771833418413561 6.253548118052992e-07 0.07621180464723754 6.253549765257765e-07 0.07515824360926991 6.25355140155128e-07 0.07412455432658185 \
6.25355314933688e-07 0.07303438636984133 6.253555021863042e-07 0.07188220095900363 6.253557122313082e-07 0.07060976590783831 6.253559304415312e-07 0.06930979572898451 \
6.253561638986196e-07 0.06794333957253913 6.25356418744638e-07 0.06648001693367038 6.253567118391949e-07 0.06483321328442151 6.253570141789572e-07 0.06317411115207273 \
6.253573287658325e-07 0.06148945259513613 6.253577250265267e-07 0.05942677493938087 6.253580587436719e-07 0.05774249301432461 6.253584660545011e-07 0.05574994498853819 \
6.253587939392599e-07 0.05419380357502902 6.25359150629899e-07 0.05254809000207299 6.253594638680598e-07 0.05114243792209583 6.25359766835193e-07 0.04981740498512215 \
6.253600643757185e-07 0.04854875663330436 6.253603431552737e-07 0.04739109061078805 6.253606261551693e-07 0.04624570307560639 6.253608878954772e-07 0.04521055793698023 \
6.253611671343698e-07 0.04413130357485813 6.253614392402902e-07 0.0431040186124033 6.253617466070471e-07 0.04197194005652995 6.253619684099479e-07 0.04117329707315532 \
6.253622748704283e-07 0.04009446155587663 6.253625010598812e-07 0.03931650950691581 6.253627399772065e-07 0.03851359500741255 6.253629644010393e-07 0.03777663690506906 \
6.253631666633204e-07 0.03712468825868943 6.253633677059489e-07 0.03648814235703791 6.253637194799833e-07 0.03540095449820539 6.253639697258209e-07 0.03464776841732944 \
6.253642160441007e-07 0.03392252499723709 6.253644973769646e-07 0.03311308780599518 6.253647404679503e-07 0.03242954897046491 6.253649759417007e-07 0.03178112583711486 \
6.25365217601206e-07 0.03113119522156456 6.253654544834836e-07 0.03050988948014832 6.25365685016041e-07 0.02991733361391674 6.253658989845686e-07 0.02937801894285819 \
6.253661049271157e-07 0.02886851641492237 6.253664976516027e-07 0.02792196059063811 6.25366685729283e-07 0.02747992420741849 6.253670611682489e-07 0.02661861215736662 \
6.253672360424775e-07 0.02622659266649364 6.253676593654916e-07 0.02530049759795254 6.253677806148756e-07 0.02504150687334681 6.253682211765282e-07 0.02412433837770948 \
6.253683636746476e-07 0.02383402682615681 6.253686957281575e-07 0.02316883068419595 6.25368878693682e-07 0.02280879143785283 6.25369267997886e-07 0.02205689891561978 \
6.253694363435941e-07 0.02173705378531499 6.253699084579933e-07 0.02085107653961301 6.253700482027269e-07 0.0205916297664938 6.253705437828047e-07 0.01969297428531048 \
6.253706710082374e-07 0.01946923320191776 6.253712389173419e-07 0.01851512288677271 6.253714031712902e-07 0.0182513999453204 6.253720130430286e-07 0.0173209960017622 \
6.253721727282572e-07 0.01708922829277545 6.253726996397978e-07 0.01635462467776483 6.253729041570907e-07 0.01608193551804103 6.253736276344778e-07 0.01515939662837778 \
6.253737930766099e-07 0.01495683325581705 6.253745396363563e-07 0.01408081084911163 6.253746729395689e-07 0.01393008075245666 6.253755331241552e-07 0.01299799962960837 \
6.2537566920557e-07 0.01285670227674402 6.253766097994594e-07 0.01192267652923807 6.253767735725333e-07 0.01176632439256516 6.253777747514646e-07 0.01084959205883911 \
6.253779122291873e-07 0.01072929995296418 6.253790829267985e-07 0.009787962024485789 6.253791753231659e-07 0.009718668544398181 6.253805933990138e-07 0.008725931027897449 \
6.253806803751621e-07 0.00866912727384293 6.253822213707926e-07 0.00770199130002063 6.253823306868068e-07 0.007633428668288294 6.253839739346292e-07 0.006673746291950173 \
6.253841067919082e-07 0.006603544020797993 6.253862011722062e-07 0.005605323336654431 6.25386409576941e-07 0.00551468736035817 6.25388763913366e-07 0.004577307911602986 \
6.253892374721228e-07 0.004407121484391641 6.253921229089796e-07 0.003492041675788492 6.253926525733265e-07 0.00334538389506189 6.253968608005518e-07 0.00237996320858989 \
6.253973742348032e-07 0.002283557532494709 6.254031334854955e-07 0.001325291758975802 6.254033680667129e-07 0.001279502680325907 6.254180358940878e-07 0.0002809017338477542 \
6.2541814896418e-07 0.0002788534805396912 6.280551690439302e-07 -0.0006849217749926401 6.280553352056058e-07 -0.0009443270389602415 6.28055814074993e-07 -0.001850320037528519 \
6.280559067946197e-07 -0.002050462221988249 6.280562720196971e-07 -0.002913187630468476 6.280563636768137e-07 -0.00314709230904735 6.280567297831652e-07 -0.004133001189868674 \
6.280568399302907e-07 -0.004442309109773816 6.280571506685428e-07 -0.005311341427314526 6.280572524071878e-07 -0.005583925258601597 6.280576161113131e-07 -0.00638370916272213 \
6.280577809576365e-07 -0.006585924750287024 6.280583607549566e-07 -0.005792290386912202 6.280585355894154e-07 -0.004916934050781314 6.280586522790152e-07 -0.00413641027497409 \
6.280587787087077e-07 -0.00310656561120747 6.280588807309105e-07 -0.002137079422087956 6.28059000577393e-07 -0.0008406209844352954 6.280590912146293e-07 0.0002489246187367611 \
6.280591896346795e-07 0.001536790859923857 6.280592893583235e-07 0.002948496343048522 6.280594568423325e-07 0.005545701385567424 6.280596754209339e-07 0.009327395936412004 \
6.280598614912559e-07 0.0128572688386996 6.280600828738638e-07 0.01737012273305725 6.280602435339974e-07 0.02082840415615294 6.28060406999647e-07 0.02447866954313523 \
6.280605576351642e-07 0.02794359528291388 6.280607066909169e-07 0.03145289236167962 6.280608561536706e-07 0.03504014479003619 6.280610101846837e-07 0.03879791952579481 \
6.280611723009431e-07 0.04280891157365373 6.280613383304077e-07 0.04696567134311741 6.28061514283228e-07 0.05141478668696391 6.280616949538655e-07 0.05602187592747932 \
6.280618867748117e-07 0.06094655248807559 6.280620938803164e-07 0.06629309753158302 6.280623154520462e-07 0.07203901748582854 6.280625501862155e-07 0.07814662931008168 \
6.280628017257829e-07 0.08470684589377442 6.280630771678493e-07 0.09190125212984442 6.280633773636676e-07 0.09974607960254324 6.280637082958779e-07 0.108390578238945 \
6.280640839626117e-07 0.1181923833971668 6.280644815454798e-07 0.1285487285136021 6.280649483700823e-07 0.1406786766767902 6.280654913626172e-07 0.1547396794802719 \
6.2806612478764e-07 0.1710742296429572 6.280668207276907e-07 0.1889259607126788 6.280676362848005e-07 0.2097135943149445 6.280685463129037e-07 0.2327316641523666 \
6.280693395691242e-07 0.2526372689279454 6.280700450441999e-07 0.2702038474981599 6.280706639884678e-07 0.2855008995781749 6.280712310944079e-07 0.2994177966724069 \
6.28071754174414e-07 0.3121574438576628 6.280722531532068e-07 0.3242197130846058 6.280727371932144e-07 0.3358335658028451 6.280731924200473e-07 0.3466679577370423 \
6.280736669320091e-07 0.3578644504627745 6.280741068407172e-07 0.368158604789619 6.28074592685345e-07 0.3794271463718566 6.280751242881185e-07 0.3916316501999784 \
6.280756269514167e-07 0.4030538969706937 6.280760560236696e-07 0.4127111343288326 6.280765470403382e-07 0.4236561147984291 6.280770484704185e-07 0.434714731975362 \
6.280773950150088e-07 0.442288187401736 6.280777504243856e-07 0.4500000616404133 6.280781776521144e-07 0.4592019891792938 6.28078569851637e-07 0.4675774400278049 \
6.280788702333951e-07 0.4739448723400065 6.280792120451548e-07 0.4811381049525967 6.280795554849687e-07 0.4883107756756314 6.280798162200955e-07 0.4937186470393492 \
6.280800582500486e-07 0.4987071765458648 6.280803241952914e-07 0.5041573145298286 6.280805814645869e-07 0.509394255416739 6.280807715836905e-07 0.5132422368582924 \
6.280809851098511e-07 0.5175451019736222 6.280811248001571e-07 0.5203466115392713 6.28081271000449e-07 0.5232668091041763 6.280814849883502e-07 0.5275186200231483 \
6.280816930046097e-07 0.5316389396023125 6.280818854658791e-07 0.5354321131715788 6.280820705821105e-07 0.5390651926504321 6.280822449555568e-07 0.5424725330931349 \
6.280825494976334e-07 0.5484058192982523 6.280828100565151e-07 0.5534602958276967 6.280831114875445e-07 0.5592859190791987 6.280833658051381e-07 0.5641865993769294 \
6.280836586613277e-07 0.5698153316805189 6.280839178744799e-07 0.5747800306938655 6.280841889508118e-07 0.579963273174682 6.280844307945714e-07 0.5845680738798381 \
6.280846882997289e-07 0.5894577538325241 6.280849150436047e-07 0.5937419314630586 6.280851520444244e-07 0.5982006324572362 6.280853622309863e-07 0.6021379329905048 \
6.280855749915204e-07 0.6061060319396779 6.28085827870286e-07 0.6107954169450593 6.280860315335545e-07 0.6145509252949414 6.280862222509359e-07 0.6180531102377972 \
6.280864095873744e-07 0.6214768531423983 6.28086598465652e-07 0.6249070011644339 6.280868066654474e-07 0.6286671070650327 6.280870509975621e-07 0.6330499453121026 \
6.280872505640949e-07 0.6366057789565548 6.280874547098356e-07 0.6402215701419991 6.280876393490899e-07 0.643474671963314 6.28087908884781e-07 0.6481901084955864 \
6.280881365916373e-07 0.652149230294136 6.280883242633751e-07 0.6553888277830079 6.280885051635202e-07 0.6584949378977958 6.280886647046018e-07 0.661221510907812 \
6.280888351670024e-07 0.6641177016088209 6.280889869184432e-07 0.6666817235716488 6.280891245614551e-07 0.6689905419339194 6.280892735563186e-07 0.6714784915997724 \
6.280894012981822e-07 0.6736028790357499 6.280895442846951e-07 0.675968899142866 6.280896660677513e-07 0.6779749688503388 6.28089802351161e-07 0.6802121872853304 \
6.280899221800625e-07 0.682172759947357 6.280900687756233e-07 0.6845626218370968 6.280901872485649e-07 0.6864845934661837 6.280902831819268e-07 0.6880368302455475 \
6.280903757015115e-07 0.6895284278106264 6.280904807620224e-07 0.6912169000724893 6.280905788439078e-07 0.6927871490736753 6.280907159592253e-07 0.6949707622226827 \
6.28090835157868e-07 0.6968607547931925 6.280909450978383e-07 0.6985951241089645 6.280910825970815e-07 0.7007503743809057 6.280912140269832e-07 0.7027960765825516 \
6.280913462564986e-07 0.7048392108129343 6.280914594338973e-07 0.7065756917706891 6.280916138667517e-07 0.708927873976708 6.280917446467452e-07 0.7109048231498766 \
6.280918673154548e-07 0.7127465601965561 6.280919735837111e-07 0.7143329262278221 6.280920959637349e-07 0.7161490373358268 6.280921978172317e-07 0.7176517022913665 \
6.280923319551315e-07 0.7196190116794019 6.280924526481716e-07 0.7213783352064487 6.280925717899705e-07 0.7231049829175343 6.280926968079846e-07 0.7249059312823601 \
6.280928266477907e-07 0.7267645120560844 6.280929464599617e-07 0.7284691779696002 6.280930754532131e-07 0.730293808329565 6.280932075602773e-07 0.7321507998840678 \
6.280933258660953e-07 0.7338038328985433 6.280934691267862e-07 0.7357927618453034 6.280935715814729e-07 0.7372070005703254 6.280936677883585e-07 0.7385290937783453 \
6.280937728059804e-07 0.7399656334130889 6.280938835775113e-07 0.7414708009413548 6.280939852560522e-07 0.7428439364018735 6.280940882175065e-07 0.7442258341871242 \
6.280942051436606e-07 0.7457850038572696 6.280943339039365e-07 0.747489965072781 6.28094435062908e-07 0.7488201182152049 6.280945839319522e-07 0.7507626302114226 \
6.280947316114891e-07 0.75267249971878 6.280948509768551e-07 0.7542038164026367 6.280949974606996e-07 0.7560679527984652 6.280951206361903e-07 0.7576223900169708 \
6.280952614398646e-07 0.7593848990234215 6.28095398032531e-07 0.7610800595258669 6.280955201903812e-07 0.7625841275516777 6.280956328467786e-07 0.7639610711610054 \
6.280957745729196e-07 0.7656796138775311 6.280959007394198e-07 0.767196844592689 6.280960161567243e-07 0.768574452686535 6.280961464649039e-07 0.7701179991486644 \
6.280962621775717e-07 0.7714782821591826 6.280963850018603e-07 0.7729116492687436 6.280965028461285e-07 0.7742769236963016 6.280966084761185e-07 0.7754922619072108 \
6.280967238495533e-07 0.7768108638983861 6.280968291127157e-07 0.7780056027231214 6.28096940062529e-07 0.7792565499870431 6.280970264670305e-07 0.7802246528436213 \
6.280971305008505e-07 0.7813823422463088 6.28097244396594e-07 0.7826398494046257 6.280973474300136e-07 0.7837684443710583 6.280974555127141e-07 0.7849432998269023 \
6.280975637643696e-07 0.7861107422109641 6.280976991816163e-07 0.7875582910536544 6.280978118557238e-07 0.7887521292973186 6.280979362797841e-07 0.7900592323105087 \
6.28098054252648e-07 0.7912877959129118 6.280981987206026e-07 0.7927781272271259 6.280983163897418e-07 0.7939806363584788 6.280984522695814e-07 0.7953567374150946 \
6.280985870139538e-07 0.7967081403609936 6.280986980849332e-07 0.7978123285366109 6.280987979742731e-07 0.7987978371087655 6.280988996542306e-07 0.7997937268659365 \
6.280990328678971e-07 0.8010867894381996 6.280991512407162e-07 0.8022243628210853 6.280992727817905e-07 0.8033812848148773 6.280993921454424e-07 0.8045065422543012 \
6.280995132768188e-07 0.80563739819571 6.280996449762361e-07 0.8068544426691319 6.280997679845128e-07 0.8079795872959963 6.280998958281203e-07 0.8091371804586788 \
6.281000267346398e-07 0.8103101881504271 6.28100150327798e-07 0.8114062915203997 6.281002575003029e-07 0.8123479140825919 6.281003649295024e-07 0.8132835730547656 \
6.281004475986206e-07 0.8139979974227743 6.281005653103806e-07 0.8150069815425507 6.281006559159858e-07 0.8157770472204025 6.281007865694307e-07 0.8168774959419571 \
6.28100930959301e-07 0.8180800468042847 6.281010641337151e-07 0.8191766687328477 6.281011740251065e-07 0.8200725423139092 6.281013176239916e-07 0.8212302325252553 \
6.281014710146832e-07 0.8224508494407716 6.28101599092908e-07 0.8234574467428303 6.281017388802764e-07 0.8245431382086058 6.281018651298391e-07 0.8255122018650548 \
6.281020197283917e-07 0.8266841987320058 6.281021519393684e-07 0.8276738265999063 6.281022781661507e-07 0.8286078934539939 6.281023959138743e-07 0.8294698388787296 \
6.281025449866676e-07 0.8305480062617677 6.281027123182206e-07 0.8317406852496945 6.281028455394968e-07 0.8326770812274722 6.281030183208196e-07 0.8338744310092966 \
6.281031868261935e-07 0.8350236380668206 6.281033562054924e-07 0.8361608866600232 6.281035378407611e-07 0.8373606451951652 6.281036801740827e-07 0.8382866867625347 \
6.281037940110689e-07 0.8390185116470331 6.28103925192579e-07 0.8398522525089582 6.28104026724794e-07 0.8404903982372576 6.281041430090542e-07 0.8412135669902132 \
6.281042776438077e-07 0.8420406924792603 6.281044746666438e-07 0.8432316292878405 6.281046647721864e-07 0.8443592803112207 6.281048748954985e-07 0.8455816023960827 \
6.281050552136043e-07 0.8466107566581813 6.281052526767047e-07 0.8477171937062282 6.281054267458196e-07 0.8486750118570332 6.2810560906524e-07 0.8496608982186138 \
6.281057804803758e-07 0.8505716849290491 6.281059545936529e-07 0.8514808063694008 6.281061303246211e-07 0.8523822271368225 6.281063064363214e-07 0.8532696099472232 \
6.281064960541732e-07 0.8542074684498208 6.281066868356705e-07 0.8551330189126392 6.28106888431747e-07 0.8560917259710515 6.281070811660048e-07 0.856990088884472 \
6.281072900378257e-07 0.8579439907476532 6.281075207402632e-07 0.8589743400177088 6.281077851832272e-07 0.8601259267840322 6.281080840059149e-07 0.8613896125360476 \
6.281083639602158e-07 0.8625380186322354 6.281086480860816e-07 0.8636694076724545 6.28108922855057e-07 0.8647317823994775 6.281091947122167e-07 0.8657531067718063 \
6.281094650893343e-07 0.8667403371654003 6.281097221678555e-07 0.8676533221001362 6.281099947926866e-07 0.868594905839151 6.281102707598355e-07 0.8695208838709013 \
6.281105408640933e-07 0.8704012674911344 6.281108407401038e-07 0.8713491368600049 6.281112118011625e-07 0.8724801680184872 6.2811150674079e-07 0.8733472453740196 \
6.281117610365479e-07 0.8740729094291386 6.281120592974737e-07 0.8748989982677786 6.281123329040153e-07 0.8756336613858092 6.281125690299577e-07 0.876250392688866 \
6.281128093740556e-07 0.8768621356511911 6.281130317061818e-07 0.8774140071409635 6.28113225712247e-07 0.8778848105679672 6.281135554349973e-07 0.8786625669521169 \
6.281137106085256e-07 0.8790190643519731 6.281140283876061e-07 0.879730644938159 6.281142072488645e-07 0.8801204696806418 6.281145497107611e-07 0.8808457867651537 \
6.281147338373631e-07 0.8812245477320809 6.28115208711942e-07 0.8821665346129511 6.281153761083518e-07 0.8824869809105039 6.281158419518538e-07 0.883348261932613 \
6.281160227735482e-07 0.8836708855253055 6.281165168126507e-07 0.8845204537290557 6.28116658162059e-07 0.8847551796839913 6.281172645001218e-07 0.8857215808967022 \
6.281174165693362e-07 0.8859539944113424 6.28118063256356e-07 0.8869009218298172 6.281181915512387e-07 0.8870812460539503 6.28118839667745e-07 0.8879562712787433 \
6.281189694676407e-07 0.8881245027440973 6.281197476783403e-07 0.8890830197250962 6.281198627254718e-07 0.8892171882189283 6.281207183963142e-07 0.8901564861234483 \
6.281208637440773e-07 0.8903061494816453 6.281218494996487e-07 0.8912466483555094 6.281220706077111e-07 0.8914402669210102 6.281232157277145e-07 0.892367747196105 \
6.281233469391585e-07 0.8924695935232408 6.281246882116237e-07 0.8934615053489913 6.281248396029e-07 0.8935661991834861 6.281263210551204e-07 0.8944951400107031 \
6.281265599348161e-07 0.8946288932334222 6.281283293566539e-07 0.895502508848118 6.281287184779452e-07 0.895670668133377 6.281311122106538e-07 0.8965556062201232 \
6.281315877505926e-07 0.8967047758494365 6.281356508198176e-07 0.8977025964496719 6.281361422956535e-07 0.8977953148389237 6.281444588927963e-07 0.8987880790885289 \
6.281453787942481e-07 0.8988514070442593 6.282992423701678e-07 0.8998485708192639 6.283028854964575e-07 0.8998628537402877 6.285296142766717e-07 0.8989664306490068 \
6.285298446165833e-07 0.8988008565867064 6.285314595368805e-07 0.897804750401333 6.285316372691665e-07 0.8977103535805105 6.285484036692715e-07 0.8986978311584225 \
6.285485397684024e-07 0.8987160394686986 6.285637106086718e-07 0.8997133888183054 6.285639877135078e-07 0.899719468756186 6.290480289064218e-07 0.9005852143835333 \
6.290482022410388e-07 0.9007408621809421 6.290488627306383e-07 0.9015135064485434 6.290490287958205e-07 0.9017527716291757 6.29049555130528e-07 0.9026184054967997 \
6.290497462444476e-07 0.9029704910143604 6.290501104654996e-07 0.9036902342402512 6.290502896649215e-07 0.9040628043424317 6.290506515515937e-07 0.9048333795345931 \
6.290508466611638e-07 0.9052442844328937 6.290513790595253e-07 0.9062266394381637 6.290515614131638e-07 0.9064623886473868 6.290525533935561e-07 0.905594670761786 \
6.290527149341232e-07 0.9049318860608667 6.290528829265756e-07 0.9040378649110347 6.290530427580612e-07 0.9029782421366458 6.29053180254799e-07 0.9018984154159868 \
6.290533131621115e-07 0.9007052793196499 6.290534395875787e-07 0.8994328447569792 6.290535469868187e-07 0.8982475863895881 6.290536514834768e-07 0.8970047013543965 \
6.290537655331467e-07 0.8955451342423859 6.290538555027342e-07 0.8943225684615312 6.290539603213726e-07 0.8928208677113324 6.290540497696119e-07 0.891473284704788 \
6.290541321453926e-07 0.8901820884368528 6.290542232383926e-07 0.8887006634027688 6.290543605744705e-07 0.8863657732814155 6.290544590674027e-07 0.8846195012157601 \
6.290545711411527e-07 0.8825649218508906 6.290547020241858e-07 0.880080778639088 6.290548384952158e-07 0.8774018563482072 6.290549919493788e-07 0.8742910281085086 \
6.290551510437468e-07 0.8709679977889497 6.290553153276493e-07 0.867445283300377 6.290554719957507e-07 0.8640104344288071 6.290556240865311e-07 0.860615744772629 \
6.290557778002063e-07 0.857132398554192 6.290559373623814e-07 0.853469801378647 6.290560924510829e-07 0.8498714074018293 6.290562661304016e-07 0.8458039138600054 \
6.290564291612694e-07 0.8419559450883216 6.29056590803684e-07 0.8381170660338335 6.290567534504205e-07 0.8342344554797501 6.290569148689274e-07 0.8303657475978833 \
6.29057083463406e-07 0.8263109424305363 6.290572663565043e-07 0.8219002364007665 6.290574341852182e-07 0.8178440888239877 6.290576024710332e-07 0.8137703061148112 \
6.290577732990847e-07 0.8096302849976138 6.290579454736421e-07 0.8054541271740473 6.290581132355611e-07 0.8013830614994394 6.290582968650184e-07 0.7969255463994016 \
6.290584682714962e-07 0.7927646873948894 6.290586537148024e-07 0.7882638003278283 6.290588203854535e-07 0.7842196820467244 6.290589892715847e-07 0.7801233737411432 \
6.290591734278819e-07 0.7756572567105651 6.290593680379105e-07 0.7709405333854473 6.290595152932414e-07 0.7673736106648734 6.29059641923832e-07 0.7643079795643375 \
6.290597837806443e-07 0.7608754495129878 6.290598881844221e-07 0.7583505812556488 6.290600205770739e-07 0.7551502542766809 6.290601301612705e-07 0.7525028097975122 \
6.29060263325923e-07 0.7492875979647342 6.290604195076852e-07 0.7455190770546114 6.29060532737112e-07 0.7427887939149777 6.290606952584764e-07 0.7388718945951063 \
6.290608674392915e-07 0.7347246296492568 6.29061063444044e-07 0.7300078517193382 6.290612278340228e-07 0.7260553905833119 6.290613802307035e-07 0.7223944885043934 \
6.290615439058578e-07 0.718466402706526 6.29061711831558e-07 0.7144406657912139 6.290618916719358e-07 0.7101336212543717 6.29062067965886e-07 0.7059164985576465 \
6.290622390405214e-07 0.7018286413152719 6.29062407358697e-07 0.6978099102718778 6.290625606248286e-07 0.6941537154717222 6.290627225083983e-07 0.6902960245155986 \
6.290629014599385e-07 0.6860364417190952 6.290630356714899e-07 0.6828448068431195 6.290631391777878e-07 0.6803854168085423 6.290632384622005e-07 0.6780286039046017 \
6.290633399166766e-07 0.6756220912380299 6.290634323732757e-07 0.6734303711245889 6.29063516962075e-07 0.6714267031582685 6.290636105394115e-07 0.6692114082407524 \
6.290637270816306e-07 0.6664546942583044 6.290638365591918e-07 0.6638675763958631 6.29063949672203e-07 0.6611971533414394 6.290640727909702e-07 0.6582923426231613 \
6.290641970172829e-07 0.6553636581362478 6.29064367777427e-07 0.6513432847262797 6.290645262260143e-07 0.6476181700514572 6.290646985138371e-07 0.6435738126612673 \
6.290648444919037e-07 0.6401512360303271 6.290649862851196e-07 0.6368325564797357 6.290651178835739e-07 0.6337564355289309 6.290652480468588e-07 0.630718219665797 \
6.290653735717995e-07 0.6277924818644975 6.290655053547071e-07 0.6247239543970449 6.290656352782026e-07 0.6217046839485236 6.290657715867779e-07 0.6185408917806742 \
6.290659162003453e-07 0.615188962872713 6.290660756925359e-07 0.611499189008522 6.290662491526524e-07 0.6074939486938447 6.290664201599543e-07 0.6035554342946753 \
6.290666515285226e-07 0.5982402936372396 6.290668949905284e-07 0.5926661367297537 6.29067069111016e-07 0.5886942528256315 6.290672153830935e-07 0.5853638081576373 \
6.290673497553116e-07 0.58231230528805 6.290674668502066e-07 0.5796585826255305 6.290675626145532e-07 0.5774900935424465 6.290676614610955e-07 0.5752566196463251 \
6.290677454384143e-07 0.5733628024369305 6.290678230524634e-07 0.571614165956722 6.290678843779372e-07 0.5702331258704825 6.290679490585756e-07 0.5687779664863769 \
6.290680303667114e-07 0.5669528575016536 6.290680804367073e-07 0.5658306078972934 6.290681297572688e-07 0.5647256890740617 6.29068191677069e-07 0.5633393552914843 \
6.290682395088942e-07 0.5622690492396486 6.290682900136796e-07 0.5611395143522533 6.290683500757169e-07 0.559799205480933 6.290684093585123e-07 0.5584782058326896 \
6.290684844152261e-07 0.5568072508052372 6.290685540978827e-07 0.5552574373576753 6.290686396864492e-07 0.5533559356568912 6.290687267538207e-07 0.5514265885063823 \
6.290688104163413e-07 0.5495763264044081 6.290688965613662e-07 0.5476734676082877 6.290689922659868e-07 0.5455621222678217 6.290690965509387e-07 0.5432673229847179 \
6.290692112181133e-07 0.5407497407899529 6.290693199365745e-07 0.5383664115638558 6.290694295088142e-07 0.5359693749054023 6.290695418135745e-07 0.5335193270114367 \
6.290696685891956e-07 0.530759392645703 6.290697908664272e-07 0.5281021910076299 6.290699309524049e-07 0.5250685463469849 6.290700679697626e-07 0.5221084647952599 \
6.29070218271135e-07 0.5188705764247719 6.290703771663761e-07 0.5154582091324615 6.290705515002589e-07 0.5117250894133971 6.29070738517481e-07 0.5077378180012799 \
6.290709438354859e-07 0.5033745272871338 6.290711556776788e-07 0.498891131759938 6.29071408479721e-07 0.4935662239713107 6.2907161056737e-07 0.4893264048484654 \
6.290718451606752e-07 0.4844277613141263 6.290720812752721e-07 0.4795194943790256 6.290723344517689e-07 0.474283574581623 6.290726449817316e-07 0.4679020429045382 \
6.290728630397102e-07 0.4634451779596257 6.290730364853444e-07 0.4599153839204358 6.290732129777809e-07 0.4563351808422506 6.290734924595774e-07 0.4506930409909046 \
6.290737247034844e-07 0.4460279192631412 6.290740117970731e-07 0.44029020239849 6.290742296431809e-07 0.435960758243863 6.290744396957687e-07 0.4318042429497612 \
6.290746408936045e-07 0.4278406951573778 6.290748233137655e-07 0.4242617300271556 6.290749972087507e-07 0.4208637793449936 6.290751620728668e-07 0.4176529694331993 \
6.290753208268398e-07 0.4145718140694327 6.290754870737866e-07 0.4113577680628809 6.290756357189934e-07 0.4084923702366076 6.29075788087249e-07 0.4055658186126443 \
6.290759301504318e-07 0.4028468403491589 6.290760995263099e-07 0.3996150665462138 6.290762199082301e-07 0.3973276483660343 6.290763298814939e-07 0.3952449223617059 \
6.290764448068948e-07 0.3930732253581283 6.29076597048475e-07 0.3902080468194818 6.290767092695402e-07 0.3881039677199808 6.290768164620408e-07 0.386098874836553 \
6.290769689902896e-07 0.383254723448244 6.290770971374193e-07 0.380874963946598 6.290772199854117e-07 0.3786015923730871 6.290773990837881e-07 0.375299968600122 \
6.290775481684201e-07 0.3725653942578417 6.290777158758077e-07 0.3695018296724824 6.290778712734425e-07 0.3666748141177644 6.290779954402882e-07 0.3644243980538668 \
6.290781093321554e-07 0.3623666676050148 6.29078230775526e-07 0.3601804966264144 6.290784109272934e-07 0.3569532670533712 6.290785774151136e-07 0.3539878629329621 \
6.290787678342229e-07 0.3506138544217919 6.290789595908186e-07 0.3472380408565978 6.29079142640212e-07 0.344035729794033 6.290792916122767e-07 0.3414435189591631 \
6.290794115521823e-07 0.3393660536257183 6.29079534213665e-07 0.3372483242714233 6.290796572441514e-07 0.3351324902755385 6.29079802148562e-07 0.3326515017845288 \
6.290799054613372e-07 0.3308907757076019 6.290799991908464e-07 0.3292979229163631 6.290800898511484e-07 0.3277620998585528 6.29080200972602e-07 0.3258853746017661 \
6.290803081455789e-07 0.3240820510456246 6.290804064202303e-07 0.3224338250618513 6.290805188247763e-07 0.3205545940512134 6.290806827646764e-07 0.3178277446588927 \
6.290808444025551e-07 0.3151576097143818 6.290809921893013e-07 0.3127316247504084 6.290811544345159e-07 0.3100832165115083 6.290813144650734e-07 0.3074868334344322 \
6.290814667283718e-07 0.3050304870660137 6.290816201002421e-07 0.3025703731928215 6.29081778808771e-07 0.3000411640344692 6.290819432578998e-07 0.297437246442505 \
6.290821104849764e-07 0.2948063590562646 6.290822635965136e-07 0.292412731930112 6.290824466944405e-07 0.2895700146919417 6.290826370021783e-07 0.2866380344427262 \
6.290827859052365e-07 0.2843603072871506 6.290829598425416e-07 0.2817165165722222 6.290831367199302e-07 0.2790484233348025 6.290832843171486e-07 0.2768363681311815 \
6.290834739488487e-07 0.2740172295061162 6.290836239507675e-07 0.2718052906662373 6.290837610609577e-07 0.2697943906627059 6.290839025914008e-07 0.2677397479842996 \
6.290840160502698e-07 0.2661005451260196 6.290841523405964e-07 0.2641384584581135 6.290842824172175e-07 0.2622807416655737 6.290844006714701e-07 0.2606037730704709 \
6.290845185270662e-07 0.2589348966568543 6.290846494208768e-07 0.2570853888657079 6.290847896596348e-07 0.2551145527343576 6.290849051542211e-07 0.2534976852533538 \
6.290850340055979e-07 0.2516957519945816 6.290851491515796e-07 0.2500885525459272 6.290853024625469e-07 0.2479513765689386 6.290854403163083e-07 0.2460367343642474 \
6.290855797779604e-07 0.2441002375748529 6.29085735245815e-07 0.2419427021952501 6.290858600284302e-07 0.2402176526454788 6.290859998933384e-07 0.2382916534360561 \
6.290861285955144e-07 0.2365220787132559 6.290862495543663e-07 0.234860341242685 6.290863665996657e-07 0.2332541163798121 6.290864926007301e-07 0.2315368940272461 \
6.290865893203229e-07 0.2302195772445239 6.29086681409196e-07 0.2289683907689286 6.290867958266674e-07 0.2274152998827935 6.290868941973141e-07 0.2260807986508055 \
6.290870113441077e-07 0.2244933520241092 6.290871144352257e-07 0.2231010305483718 6.290872199499517e-07 0.2216798666278746 6.290873008680117e-07 0.2205933880575098 \
6.290873745391968e-07 0.2196046443759679 6.290874172684338e-07 0.2190314036349237 6.29087460398579e-07 0.2184540235451489 6.290875111960607e-07 0.217774515685755 \
6.290875483709394e-07 0.217277430841393 6.29087589041954e-07 0.2167338127731004 6.290876318337555e-07 0.2161620985357572 6.290876682448971e-07 0.2156758299561118 \
6.290877101698877e-07 0.2151161507306283 6.290877647120985e-07 0.2143884526296278 6.290878031708564e-07 0.2138756926875936 6.290878427976257e-07 0.2133496230586122 \
6.290879046301276e-07 0.212531488259555 6.290879663565786e-07 0.2117156525305126 6.290880224938542e-07 0.210974237875411 6.290880861490836e-07 0.210134110843225 \
6.290881802401172e-07 0.2088936328424611 6.290882670483761e-07 0.2077505933124353 6.290883610050201e-07 0.2065146061917991 6.290884590472536e-07 0.2052266823513323 \
6.290885606346195e-07 0.2038976009052371 6.290886615435678e-07 0.2025832113009377 6.290887582793767e-07 0.2013244528083448 6.290888604043477e-07 0.1999972806373927 \
6.290889637359055e-07 0.1986583046056677 6.29089073618507e-07 0.1972379690671278 6.290891825607647e-07 0.1958337611883887 6.290893023958847e-07 0.1942937175364915 \
6.290894126797513e-07 0.1928822800638286 6.290895205584963e-07 0.191507108810815 6.290896466212543e-07 0.1899051957406391 6.290897364889608e-07 0.1887671190866151 \
6.290898469673e-07 0.1873723090993208 6.290899245002487e-07 0.1863971337376019 6.290900088239919e-07 0.1853400660204312 6.2909009641205e-07 0.1842452710069853 \
6.290901842046442e-07 0.18315095174413 6.290902659245155e-07 0.1821357652581398 6.290903634861928e-07 0.1809282658474054 6.290904701973441e-07 0.1796118512064394 \
6.29090570679026e-07 0.178377576484793 6.290906948502375e-07 0.1768595317522179 6.290908287417607e-07 0.1752320886156309 6.290909476539533e-07 0.1737937102924047 \
6.290910980541469e-07 0.1719851742607024 6.290912088892401e-07 0.1706594030660365 6.290913486559821e-07 0.168997130456427 6.290914671812901e-07 0.1675953052211382 \
6.290915726085209e-07 0.1663548750207849 6.290916673183802e-07 0.1652455210322802 6.290917606281543e-07 0.1641568522804657 6.290918615342705e-07 0.1629842804551663 \
6.290919569521023e-07 0.1618800504313296 6.290920541430254e-07 0.1607598891027116 6.29092135704507e-07 0.1598237474547246 6.290922410209518e-07 0.1586229753023833 \
6.290923245006587e-07 0.1576763029943549 6.290924260299495e-07 0.1565306813704828 6.290925032604858e-07 0.1556635090415242 6.29092594132523e-07 0.154647919213242 \
6.290926634838334e-07 0.1538765336840219 6.290927480678846e-07 0.1529397840535594 6.290928224610911e-07 0.1521208717489242 6.290929018312932e-07 0.151251902275755 \
6.290929764189645e-07 0.1504388356812226 6.290930456405211e-07 0.1496871728711989 6.29093140321328e-07 0.1486640077242138 6.29093210087093e-07 0.1479134441579097 \
6.290932945316558e-07 0.147008717574758 6.290933560970016e-07 0.1463518850554192 6.290934301394933e-07 0.1455673550676988 6.290935035250169e-07 0.1447940960774066 \
6.290935849602585e-07 0.1439395015691976 6.290936544094048e-07 0.1432139999234875 6.290937295111024e-07 0.1424323701137583 6.290938194231735e-07 0.1415006120834361 \
6.290938965067932e-07 0.1407052977810757 6.290939956173774e-07 0.1396885207473417 6.290940651574397e-07 0.138983077430453 6.290941464759156e-07 0.1381612812129989 \
6.290942166443246e-07 0.1374549162714094 6.290942956124377e-07 0.1366629455350578 6.290943745907205e-07 0.1358740351737466 6.290944469125105e-07 0.1351544405911459 \
6.290945162779692e-07 0.1344667589602006 6.290945649819765e-07 0.1339854049281765 6.290946557443482e-07 0.1330945614011112 6.290946877658758e-07 0.1327823711724506 \
6.290947758698441e-07 0.131925672678654 6.290948083638864e-07 0.1316105445757083 6.290949070315436e-07 0.1306564447580443 6.290949506875192e-07 0.130235859061297 \
6.290950286693357e-07 0.1294866595045693 6.290950660002936e-07 0.1291289430202982 6.290951681516937e-07 0.128153223240932 6.290952355956539e-07 0.1275115375392494 \
6.290953007486116e-07 0.1268935577290946 6.290953666546259e-07 0.1262729746041904 6.290954378066093e-07 0.1256052797936485 6.290955207439704e-07 0.1248293808775363 \
6.290956061394508e-07 0.1240331657139879 6.290956822268445e-07 0.1233259817834828 6.290957626875213e-07 0.1225806238777534 6.290958207714622e-07 0.1220441728027253 \
6.29095892104936e-07 0.1213870835332726 6.290959768933693e-07 0.1206085709991845 6.290960380484021e-07 0.1200487744399507 6.290961081348534e-07 0.1194096117168642 \
6.290961706401422e-07 0.1188419501154776 6.290962366450903e-07 0.1182453094891599 6.290963054178569e-07 0.1176255789053269 6.290963748744814e-07 0.1170017375875525 \
6.29096458038731e-07 0.1162574953874909 6.290965311562548e-07 0.1156056107435251 6.29096601870241e-07 0.1149774116339468 6.290966612219237e-07 0.1144518657417393 \
6.290967665191357e-07 0.1135239342411639 6.290968123866298e-07 0.1131212254602471 6.290968993406833e-07 0.1123603821649216 6.290969423544638e-07 0.1119852310621949 \
6.290969872212111e-07 0.1115947726395539 6.29097076954706e-07 0.1108164664143028 6.290971478390574e-07 0.110204256460374 6.290972266925708e-07 0.109525796983828 \
6.290972894703462e-07 0.1089876103666232 6.290973494647018e-07 0.1084750215669379 6.290974604624741e-07 0.1075310013968523 6.2909754121676e-07 0.1068475792877216 \
6.290976536800858e-07 0.1059005796323111 6.290977048246292e-07 0.1054717782906781 6.290977878097979e-07 0.1047785948356612 6.290978459745031e-07 0.1042945647727652 \
6.29097960212503e-07 0.1033482075721767 6.290980101159701e-07 0.1029366076865433 6.290980958575694e-07 0.1022320954501846 6.290981448890196e-07 0.1018307629303728 \
6.290982274554409e-07 0.101157455862875 6.290982983877772e-07 0.1005815064560546 6.290983665381274e-07 0.1000302812267231 6.290984441484433e-07 0.0994053199805509 \
6.290985164918144e-07 0.09882546240595018 6.29098594067778e-07 0.09820656846618626 6.290986827384394e-07 0.09750287271560702 6.290987565532273e-07 0.09692010793638871 \
6.290988381442347e-07 0.09627924899616347 6.290989162827031e-07 0.09566870926115327 6.290990020324936e-07 0.09500229249765579 6.290990897294021e-07 0.09432453920671229 \
6.290991836389668e-07 0.09360304191323381 6.290992800982852e-07 0.09286661217778783 6.290993587289458e-07 0.09226977907248698 6.290994614525456e-07 0.09149473120661993 \
6.290995452801959e-07 0.09086620530027881 6.290996660323777e-07 0.08996702094116031 6.29099795302029e-07 0.08901247130467421 6.290999511904932e-07 0.08787237469953549 \
6.291001062900762e-07 0.08675000010972149 6.291002633058824e-07 0.08562614142917294 6.291004433267348e-07 0.08435280068725284 6.291005938476015e-07 0.08330035525696428 \
6.291007422216238e-07 0.08227363395463329 6.291008798388548e-07 0.08133079092382095 6.291010197585049e-07 0.08038162993974078 6.291011563654933e-07 0.07946425488810546 \
6.291012950927907e-07 0.07854214404995859 6.291014404036529e-07 0.07758663187171365 6.29101588151466e-07 0.07662571164688473 6.291017467483332e-07 0.07560598447141591 \
6.291019110008509e-07 0.07456266320243836 6.291020800179273e-07 0.07350246718885647 6.29102261906921e-07 0.07237646636762114 6.291024625290194e-07 0.07115268999588262 \
6.291026764065622e-07 0.0698691158856425 6.291029040406938e-07 0.0685263410462881 6.291031456262355e-07 0.06712722147996912 6.29103427215414e-07 0.06552977831071743 \
6.291037243695346e-07 0.06388229915275011 6.291040478026115e-07 0.06213267023812474 6.29104438962031e-07 0.0600758559534558 6.29104840456333e-07 0.05803293250078725 \
6.291052173970594e-07 0.05617754872181892 6.291055845107909e-07 0.05442503025024555 6.291059346274713e-07 0.05280240270907886 6.291062539331247e-07 0.05136309724710254 \
6.291065582574072e-07 0.05002640192327024 6.291068551633126e-07 0.04875503464657577 6.291071371636386e-07 0.04757867888787161 6.291074175969432e-07 0.04643900623749339 \
6.291076823205669e-07 0.04538777697325767 6.291079582182789e-07 0.04431704973151576 6.291082326831433e-07 0.04327654260273706 6.291085311024235e-07 0.04217254828989973 \
6.291087576184799e-07 0.04135316230013186 6.291090695313175e-07 0.04025053053625379 6.291092897861088e-07 0.03948972371590862 6.291095070508635e-07 0.03875470657060948 \
6.291097167735125e-07 0.03806113111453101 6.291100269559001e-07 0.03705828856757609 6.291102495537778e-07 0.03635538859683734 6.291104969192789e-07 0.03559019656168042 \
6.291107693256556e-07 0.03476651972027592 6.291109899582094e-07 0.03411384091885184 6.291112742384597e-07 0.03329124852897781 6.291115121517525e-07 0.0326183788879464 \
6.291117502411637e-07 0.03195887699386461 6.291119854964916e-07 0.03132132139405813 6.291122142751987e-07 0.03071728735992773 6.291124470059478e-07 0.03011490821398154 \
6.291126663089891e-07 0.02955843195412813 6.291128702520595e-07 0.02905055018162466 6.291132691617956e-07 0.02808303002558106 6.291134563160508e-07 0.02764052191221165 \
6.29113828521772e-07 0.0267814187683372 6.29114015473295e-07 0.02635997027055515 6.291143848272417e-07 0.02554620807076183 6.291145384804101e-07 0.02521471147941385 \
6.291149546945643e-07 0.02434161493068329 6.291151601823807e-07 0.02392065165079968 6.291154991903413e-07 0.02323955384462723 6.291156818850693e-07 0.02287916718068597 \
6.291161389789784e-07 0.02199597290476789 6.291162687197143e-07 0.02174967209293581 6.291167221401377e-07 0.02089828923199067 6.2911686451243e-07 0.0206336680476187 \
6.291173940791906e-07 0.01967289368906444 6.291175202861975e-07 0.01945139161001456 6.291180825206354e-07 0.01850749734048266 6.29118245259022e-07 0.01824627541187189 \
6.291188094390871e-07 0.01738327200207762 6.291189611831538e-07 0.01716165742474803 6.291196628626383e-07 0.01618760396393164 6.291198329517282e-07 0.01596324388168 \
6.291204880096043e-07 0.01513221026437959 6.291206545239163e-07 0.01492874613340729 6.291213876376757e-07 0.01406966818047924 6.291215209008542e-07 0.01391906482409888 \
6.291223725580289e-07 0.01299647369571925 6.291225105004774e-07 0.01285324185793544 6.291234505599668e-07 0.0119198170026788 6.291236143216039e-07 0.01176347583728811 \
6.291246015550385e-07 0.01085909507266535 6.291247361441145e-07 0.0107410715025141 6.291258775835447e-07 0.009819907073012045 6.291259858224433e-07 0.009738548299709823 \
6.29127309069827e-07 0.00880579379490502 6.291274418155253e-07 0.008718202093769473 6.291289643166501e-07 0.007760835273143199 6.29129076858719e-07 0.007690148685505111 \
6.291307691503061e-07 0.00669558715138598 6.291309094168914e-07 0.00662113250846694 6.291329824261937e-07 0.005629132576249021 6.291331749877106e-07 0.005545002188831318 \
6.291353851975589e-07 0.004656096148610405 6.291357919842319e-07 0.004507219767123045 6.291386137242085e-07 0.003590578528330178 6.291391350199587e-07 0.00344214578404881 \
6.291433471210094e-07 0.002447529662748036 6.291438996838773e-07 0.002340875287107731 6.291497829734168e-07 0.001359168649576994 6.291500322464151e-07 0.001311490127959886 \
6.291631823674653e-07 0.0003136950974005476 6.291632991504353e-07 0.0003112730584132499 6.589900000000113e-07 3.042397160644726e-06 7.027466670270133e-07 -0.0009024818035526668 \
7.027467394426294e-07 -0.001022682652537627 7.02747175467347e-07 -0.001858525046639076 7.027472623617301e-07 -0.002046124893065343 7.027476170650433e-07 -0.00288168582347465 \
7.027477166116441e-07 -0.003135075204051477 7.027479768813486e-07 -0.003828199033013717 7.027481172037501e-07 -0.004216406518003108 7.027483446898323e-07 -0.004856871791621592 \
7.027484818972713e-07 -0.005239031028659006 7.0274886679612e-07 -0.006187559915121 7.027489988933069e-07 -0.006423332025500122 7.027496873363354e-07 -0.005917035979538006 \
7.027498442650688e-07 -0.005202654566481615 7.027499719142314e-07 -0.004414133290428114 7.027500994560215e-07 -0.003433350487145549 7.027502171302334e-07 -0.002355902309038119 \
7.0275031626992e-07 -0.001320627313728655 7.027504216526298e-07 -9.507383675133965e-05 7.02750535559933e-07 0.001369964538583592 7.027506666153286e-07 0.003229572948258866 \
7.027507919785475e-07 0.005172303930030842 7.027509838204114e-07 0.008432154569684791 7.027511274902044e-07 0.01107975669588844 7.027512854720173e-07 0.01417105828876112 \
7.027514340716643e-07 0.01723098336859398 7.02751587122593e-07 0.02051714008521248 7.027517461875692e-07 0.02405720796424875 7.027518992577779e-07 0.02756764950178633 \
7.027520476048421e-07 0.03105219347129199 7.027521967112842e-07 0.03462388853332505 7.027523512757131e-07 0.03838854885099419 7.027525119616768e-07 0.04235886888523473 \
7.027526766408632e-07 0.04647718198980624 7.027528531638066e-07 0.05093664320808645 7.027530321756059e-07 0.05549818742091989 7.027532229484479e-07 0.0603932190016783 \
7.027534277958001e-07 0.06567927942044927 7.02753648293053e-07 0.07139554989571946 7.027538812110213e-07 0.07745499876455469 7.027541304587991e-07 0.08395499695136356 \
7.027544033803265e-07 0.09108394918256098 7.027547001733835e-07 0.09884095133633181 7.027550276098956e-07 0.1073964775374675 7.027553974236945e-07 0.1170487607486894 \
7.027557923699755e-07 0.1273407304921971 7.027562504585283e-07 0.1392499850125259 7.02756782558388e-07 0.1530377249371455 7.027574081103967e-07 0.169180864038255 \
7.027580941024627e-07 0.1867931863309214 7.027588969458781e-07 0.2072766958045763 7.027597962582096e-07 0.2300508264895909 7.027606966983226e-07 0.2526618731709107 \
7.027614985898552e-07 0.2726215666318766 7.027621940969962e-07 0.2897857674353052 7.02762826931282e-07 0.3052728323588638 7.027634223397734e-07 0.3197161646377594 \
7.027639693828152e-07 0.3328722959176427 7.027645031431616e-07 0.3455929446372428 7.027650223825863e-07 0.3578476146335662 7.027655297740486e-07 0.3697097539883151 \
7.027660333952181e-07 0.3813674725871593 7.027665451381145e-07 0.3930934709428262 7.027670522991229e-07 0.404595334768291 7.027675825951367e-07 0.4164962117964878 \
7.027680687086257e-07 0.4272847049163567 7.027685468169473e-07 0.437781779057129 7.027689862490711e-07 0.4473362978389137 7.027691094085349e-07 0.4500002106608159 \
7.027693557274626e-07 0.4553046876287923 7.027696989994585e-07 0.4626558934952216 7.027700104364589e-07 0.4692815017887791 7.027702611477243e-07 0.4745855323881177 \
7.027705319768676e-07 0.480281321066213 7.027708684587769e-07 0.4873122872019196 7.027712244673881e-07 0.4946959640027882 7.027715417375557e-07 0.5012322602315481 \
7.027717806181048e-07 0.506122906570856 7.027720216462867e-07 0.5110269393752048 7.027722735779908e-07 0.5161276795544476 7.027725137318346e-07 0.5209621749612534 \
7.027727364832964e-07 0.5254248476203834 7.027729250409435e-07 0.5291850880529715 7.027731397909866e-07 0.5334523706207774 7.027733543393783e-07 0.5376948565446859 \
7.0277361310367e-07 0.5427871977552768 7.027738639312417e-07 0.5477009885064807 7.027741193501039e-07 0.5526782776843104 7.027744703926294e-07 0.5594898819265107 \
7.027747350009544e-07 0.5645984056527484 7.027750014175097e-07 0.569709962982798 7.027752619318197e-07 0.5746801970751495 7.027755290218824e-07 0.5797469183389945 \
7.027757721599624e-07 0.5843213438768613 7.02776027852189e-07 0.5890994944692448 7.027762556711592e-07 0.5933243819692556 7.027764932159792e-07 0.5976999800355528 \
7.027767046064655e-07 0.6015679915939678 7.027769167472246e-07 0.6054277082074113 7.027771059366022e-07 0.6088479815213901 7.027772370949197e-07 0.6112112531841202 \
7.027773693914781e-07 0.6135871094428261 7.02777554614204e-07 0.6169015645304802 7.027777166365907e-07 0.6197943209800671 7.027778750557552e-07 0.6226100751126036 \
7.027780091676215e-07 0.6249846001944386 7.027781814887287e-07 0.6280247049765127 7.027783104275314e-07 0.6302937061188456 7.027784308050438e-07 0.6324061607157294 \
7.027785713339148e-07 0.634864734791624 7.027787644194074e-07 0.6382321981637986 7.027789142301853e-07 0.6408363654380513 7.027790815377796e-07 0.6437327988167145 \
7.027792625920029e-07 0.6468572757970242 7.027794659184327e-07 0.6503523798695617 7.027796487715879e-07 0.6534819287355287 7.027798193958343e-07 0.6563879501053153 \
7.027799968600742e-07 0.6594029650344411 7.027801628390247e-07 0.6622113135173925 7.027803200758144e-07 0.6648594636266301 7.02780460561866e-07 0.6672075432495704 \
7.027806042919945e-07 0.6695987751186935 7.027807373389854e-07 0.6718055529208897 7.02780879311128e-07 0.6741523780906628 7.027809993716612e-07 0.6761293215200647 \
7.027811443097483e-07 0.6785098354674278 7.027812603067977e-07 0.6804095298668216 7.027813798866854e-07 0.6823647593763783 7.027814788466604e-07 0.68397755359623 \
7.027815973550785e-07 0.6859039329668146 7.027816843993602e-07 0.6873150904607619 7.027818064101794e-07 0.6892866586554622 7.027819053327907e-07 0.6908817703737582 \
7.027819972281661e-07 0.6923536807698466 7.027820971967053e-07 0.6939486118486815 7.02782195442366e-07 0.6955126686751646 7.027822871561283e-07 0.6969676095571918 \
7.027823912890697e-07 0.698613189139943 7.02782527015812e-07 0.7007470979739818 7.027826816242741e-07 0.7031613517373301 7.027828167319862e-07 0.7052558942641604 \
7.027829630685318e-07 0.7075085519458914 7.027830915360734e-07 0.7094732734147607 7.02783215720207e-07 0.7113609898537658 7.027833256245073e-07 0.7130225953369277 \
7.027834422075758e-07 0.7147759898693785 7.027835423854066e-07 0.7162749667021007 7.027836794742156e-07 0.7183149847558421 7.027837994632423e-07 0.7200901405411056 \
7.027839185766902e-07 0.7218426783097279 7.02784045072077e-07 0.723693513465353 7.02784170939449e-07 0.7255245570057045 7.027842935604676e-07 0.7272980597885179 \
7.027844211779915e-07 0.7291334326655684 7.027845514267828e-07 0.7309957624152177 7.02784673019733e-07 0.73272442801297 7.027848117884253e-07 0.7346853525547948 \
7.02784912196869e-07 0.7360963845229137 7.027850155842573e-07 0.7375412410987998 7.027851092446997e-07 0.7388443755773992 7.027852208662966e-07 0.7403895158541485 \
7.027853073348996e-07 0.7415798421827293 7.027854081980103e-07 0.7429609798983192 7.027855402947323e-07 0.7447573558536402 7.027856494960337e-07 0.7462323422761349 \
7.027857540276638e-07 0.747635567415085 7.027858776741446e-07 0.7492836897664436 7.027860263705797e-07 0.7512497161812216 7.027861482512389e-07 0.7528480713857697 \
7.02786261855803e-07 0.7543274008692354 7.027864023754882e-07 0.7561429069656862 7.027865435649301e-07 0.7579511824827749 7.027866613111062e-07 0.7594470562859095 \
7.027867900007657e-07 0.7610693809796742 7.027869325554126e-07 0.7628512182523866 7.027870484119641e-07 0.7642872416835913 7.027871941752297e-07 0.7660789429779771 \
7.02787316007677e-07 0.7675637574673733 7.02787434476374e-07 0.7689965471136999 7.027875572640059e-07 0.7704700089613156 7.027876834168886e-07 0.7719718272910862 \
7.027877937859393e-07 0.7732757954107932 7.02787919217035e-07 0.7747465774777432 7.027880246987463e-07 0.775974259539018 7.027881578651758e-07 0.7775122819577122 \
7.027882805466309e-07 0.7789173428708996 7.027884153096743e-07 0.7804473432620218 7.027885259809625e-07 0.7816923373676121 7.027886353025911e-07 0.7829118427552927 \
7.027887704350255e-07 0.7844048889494442 7.027889212140503e-07 0.7860523747618094 7.02789061582958e-07 0.7875692293014268 7.027891812944828e-07 0.7888502570533434 \
7.027893195488234e-07 0.7903153082715967 7.027894429191593e-07 0.7916096503654788 7.027895880177844e-07 0.7931164937536124 7.027897277580434e-07 0.7945521172774316 \
7.027898549394667e-07 0.7958455533278409 7.027899739792201e-07 0.7970449251022731 7.02790086337411e-07 0.7981670522831598 7.027901905661906e-07 0.79919939674296 \
7.027902859050021e-07 0.8001364844871954 7.027904221931121e-07 0.8014634245741865 7.027905390856556e-07 0.8025894467082511 7.02790658725145e-07 0.8037305025474466 \
7.027907806067166e-07 0.8048811831579785 7.027909029850537e-07 0.8060245537852575 7.027910310137332e-07 0.8072081965553952 7.027911556585317e-07 0.8083483262222385 \
7.027912861572794e-07 0.8095291977395493 7.027914126177069e-07 0.8106611567088965 7.027915397436747e-07 0.8117869190804841 7.027916448611512e-07 0.8127087429624065 \
7.027917501113405e-07 0.8136235164943317 7.027918412515906e-07 0.8144090748259969 7.027919646696249e-07 0.8154632009865571 7.027920517482738e-07 0.8162003374872545 \
7.02792151070959e-07 0.8170344894488412 7.027922959927027e-07 0.8182390501293432 7.027924322612063e-07 0.8193582434421302 7.027925417234846e-07 0.8202477434185359 \
7.027926878435863e-07 0.8214214001843773 7.02792839202198e-07 0.8226208465286928 7.027929650061201e-07 0.8236052915965452 7.027931094167793e-07 0.824721541823094 \
7.027932340177296e-07 0.8256729463037898 7.027933847297913e-07 0.8268094083523665 7.027935201010499e-07 0.8278169867326588 7.027936453039791e-07 0.8287379047458127 \
7.027937629733617e-07 0.829593908450195 7.027939088013387e-07 0.8306418458276996 7.027940752973201e-07 0.8318207857986918 7.027942061544082e-07 0.8327345044534114 \
7.027943796038484e-07 0.833928356718921 7.027945477223224e-07 0.8350667646575466 7.027947175961246e-07 0.8361988603660855 7.027948984507537e-07 0.8373843006762304 \
7.027950416331349e-07 0.8383085120571983 7.027951557464787e-07 0.8390361588138326 7.027952858124697e-07 0.8398559950134801 7.027953876877057e-07 0.8404909448220066 \
7.027955045669982e-07 0.8412116130393378 7.027956416789287e-07 0.8420465258793415 7.027958395595721e-07 0.843231707656198 7.027960313457652e-07 0.8443585547012582 \
7.027962407088286e-07 0.8455646258450146 7.027964228224063e-07 0.846593677725298 7.027966199171782e-07 0.8476867969181797 7.02796793185875e-07 0.8486305714188691 \
7.02796976264561e-07 0.8496104335327738 7.027971474015872e-07 0.8505103231661706 7.027973220804384e-07 0.8514128411730317 7.02797497318728e-07 0.8523022053693007 \
7.027976734583674e-07 0.8531802340241421 7.027978638096238e-07 0.8541115036082744 7.027980543867704e-07 0.855025905954957 7.027982548181928e-07 0.8559685891497206 \
7.027984474106693e-07 0.8568563992305701 7.027986582738063e-07 0.8578086227668252 7.027988861871822e-07 0.8588150784816577 7.027991522177188e-07 0.8599606428795262 \
7.027994507388009e-07 0.8612090806949765 7.027997266924815e-07 0.8623286542354505 7.028000109545961e-07 0.8634483918036945 7.028002851030457e-07 0.8644969441068078 \
7.028005573923129e-07 0.8655088801415273 7.028008275580887e-07 0.8664846790737442 7.028010847361862e-07 0.8673881555543895 7.028013572993529e-07 0.868319368003445 \
7.02801633304697e-07 0.8692355072818493 7.028019034186287e-07 0.870106770567397 7.028022032450018e-07 0.8710447971670072 7.028025742222908e-07 0.8721640818024149 \
7.028028691540118e-07 0.8730224021943973 7.028031234323761e-07 0.873740732376842 7.028034216772072e-07 0.8745584461000401 7.028036952852192e-07 0.8752856917963749 \
7.028039314154438e-07 0.8758961959341748 7.028041717609792e-07 0.8765017794770257 7.028043940971677e-07 0.8770481951318053 7.028045881024505e-07 0.8775144010549708 \
7.028049178237936e-07 0.8782846129827527 7.028050729968194e-07 0.8786376896881318 7.028053907524075e-07 0.8793424631377607 7.028055696169827e-07 0.8797286397841958 \
7.028059120784622e-07 0.8804474051285093 7.028060962178168e-07 0.880822800830328 7.028065711184754e-07 0.881756283451624 7.028067385131538e-07 0.8820737784441692 \
7.028072043462e-07 0.8829272622221894 7.028073851704931e-07 0.8832470363605239 7.028078792047928e-07 0.8840891816604841 7.028080205486687e-07 0.8843218944112644 \
7.028086269405856e-07 0.8852805359894154 7.028087790117662e-07 0.8855111592597558 7.028094256914359e-07 0.8864506941541785 7.028095539876422e-07 0.8866295550025313 \
7.028102021648148e-07 0.8874976172723908 7.028103319236754e-07 0.8876644392549727 7.028111001444974e-07 0.8886037370453904 7.02811229881009e-07 0.8887539063021698 \
7.028120833066544e-07 0.8896836309705964 7.028122265650877e-07 0.8898301468060963 7.02813212785821e-07 0.890764641901611 7.028134342672269e-07 0.8909571971396437 \
7.028145773086277e-07 0.8918770673440963 7.028147072981167e-07 0.8919774876506176 7.028160589233886e-07 0.8929731820841386 7.028162092835701e-07 0.89307657739048 \
7.028176899161688e-07 0.8939986636922405 7.028179288179339e-07 0.8941315911431026 7.028196933116327e-07 0.894999985510941 7.02820000994978e-07 0.8951330875684044 \
7.028225222661808e-07 0.8960612226716312 7.02822959317422e-07 0.8961978289811912 7.028268627296431e-07 0.8971619289239613 7.028271095114498e-07 0.8972094058147089 \
7.028346860012844e-07 0.8981998139535015 7.028348019130314e-07 0.8982099955090975 7.028539004457352e-07 0.8992062631372056 7.028542978885091e-07 0.8992194728667773 \
7.030047133235902e-07 0.9002121614362558 7.03004979381947e-07 0.9002436812458944 7.030102475320152e-07 0.8993470931706574 7.030104539029324e-07 0.899191170936528 \
7.030119320157425e-07 0.8982046351054961 7.030121124663984e-07 0.8981003355419954 7.030143349480612e-07 0.8971299612768925 7.030145410405756e-07 0.897079983173831 \
7.030249493066813e-07 0.8980580240048047 7.03025087164257e-07 0.8980839755683444 7.030318845132984e-07 0.8990685088718567 7.030320700847659e-07 0.8990874390200084 \
7.035282992589679e-07 0.9000706848616691 7.03528359054814e-07 0.9000975977971888 7.03529612605432e-07 0.9010828413531861 7.035297182980354e-07 0.9012097231395001 \
7.035303764287524e-07 0.9021613947651476 7.035305136110213e-07 0.9023918767045529 7.035310366376408e-07 0.9033649777562528 7.035310995012334e-07 0.9034908765919824 \
7.035315720967825e-07 0.904476514442582 7.035316234105955e-07 0.9045863669199017 7.035320893739313e-07 0.9055619780118375 7.035321215783922e-07 0.9056252631670594 \
7.035328386771295e-07 0.9066212416280413 7.035329231134018e-07 0.9066528951765993 7.035335231797813e-07 0.9059679814895146 7.035336430373927e-07 0.9055903401525059 \
7.035337742001719e-07 0.9050640446667092 7.035339090199249e-07 0.9043926011431642 7.035340571549842e-07 0.9034897747335404 7.035341947143354e-07 0.902493211317788 \
7.035343349260954e-07 0.9013135799985507 7.035344335882047e-07 0.9003872218501816 7.035345192720141e-07 0.8995148096066522 7.035346018362133e-07 0.8986166894493001 \
7.035347166188419e-07 0.8972773101170661 7.03534797717086e-07 0.8962642459447687 7.03534877134364e-07 0.8952218112132616 7.035349825888917e-07 0.8937633947192651 \
7.035351052301954e-07 0.8919606744930825 7.035352049542743e-07 0.890414036797163 7.035353751486854e-07 0.8876203405523397 7.035355213337766e-07 0.8850727273800474 \
7.035356895519253e-07 0.8819879035815887 7.035358617130214e-07 0.8786780617039783 7.035360460991142e-07 0.8749807502679057 7.035362306654577e-07 0.8711418063496947 \
7.035364149129436e-07 0.8671917613865908 7.035366002486073e-07 0.8631174608718694 7.035367746363354e-07 0.8592060069639053 7.035369573402717e-07 0.8550405244181323 \
7.035371326873658e-07 0.8509893565349284 7.035373150168772e-07 0.8467313026054767 7.035375053303061e-07 0.8422468264612591 7.035376756604352e-07 0.838204894125699 \
7.035378421840737e-07 0.8342320488410089 7.035380047549371e-07 0.830337741667393 7.035381546161599e-07 0.8267359097041467 7.03538305792179e-07 0.8230937075736249 \
7.035384949376529e-07 0.8185270080344306 7.035386406557074e-07 0.8150026134285653 7.035388156466743e-07 0.8107652770601156 7.035389641182174e-07 0.807166938184282 \
7.035391360056827e-07 0.8029987283123258 7.035393050739222e-07 0.7988973224349885 7.035394692526315e-07 0.7949140139776875 7.035396285801686e-07 0.7910485911592836 \
7.035397890297763e-07 0.7871568543472617 7.035399908491573e-07 0.7822630953020117 7.035401392968917e-07 0.7786646206504594 7.03540293464276e-07 0.77492821376164 \
7.035404305476362e-07 0.7716074476660475 7.035405399330824e-07 0.7689587163513494 7.035406458665383e-07 0.7663946531324515 7.035407728808854e-07 0.7633217481666642 \
7.035408872438541e-07 0.7605561828888391 7.03540990091676e-07 0.7580702160470256 7.035411116819926e-07 0.7551325442760125 7.035412224592672e-07 0.7524575925939972 \
7.035413393080924e-07 0.7496376180588871 7.035414500928178e-07 0.7469652567786068 7.035415684589191e-07 0.7441116745915923 7.035416932860144e-07 0.7411038668912771 \
7.035418458478099e-07 0.7374292753756717 7.035419797447979e-07 0.7342062928952946 7.035421007762374e-07 0.7312947572377408 7.035422649737523e-07 0.7273475399259534 \
7.035424423346987e-07 0.7230877912371642 7.035426245451075e-07 0.7187161681757385 7.035428055423725e-07 0.7143786395952922 7.035429862063158e-07 0.7100537072471783 \
7.035431763578828e-07 0.7055071781827296 7.035433641177768e-07 0.7010230964996226 7.035435646508815e-07 0.696237807975249 7.035437733363431e-07 0.6912646166759551 \
7.035439809799077e-07 0.6863227581165517 7.03544208547776e-07 0.6809140411171237 7.035444008226102e-07 0.6763521085712711 7.035446380878581e-07 0.6707310800019505 \
7.035448313661221e-07 0.6661595641347996 7.035450640988686e-07 0.6606646229758047 7.035452696563363e-07 0.6558174602470968 7.035455020097575e-07 0.6503484594495911 \
7.035456970117276e-07 0.6457674053103037 7.035459002403361e-07 0.6410004262200759 7.035460800928814e-07 0.6367906205544323 7.035462591993118e-07 0.6326052789263827 \
7.035464225765257e-07 0.628795088826817 7.035465946259304e-07 0.6247880828503264 7.035467581187693e-07 0.6209892715878097 7.035469339085876e-07 0.6169100951581823 \
