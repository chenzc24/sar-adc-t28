2.010661655100628e-06 0.7865651471012967 2.010661879917618e-06 0.7811107659751856 2.010662069732706e-06 0.77650678233121 2.010662271590188e-06 0.7716133355283564 \
2.010662415860827e-06 0.76811790639139 2.010662557504393e-06 0.7646880872338248 2.010662685202102e-06 0.7615975116975136 2.010662796247944e-06 0.7589113686396982 \
2.010662924810579e-06 0.7558028559024855 2.010663057376087e-06 0.7525995467138866 2.010663170697783e-06 0.7498629233610832 2.01066330703241e-06 0.7465723252212872 \
2.010663413431661e-06 0.7440058350410135 2.010663572650447e-06 0.7401674766516904 2.010663745028142e-06 0.7360137588823189 2.010663907275386e-06 0.7321074183421575 \
2.010664079624344e-06 0.7279612819449855 2.010664239010527e-06 0.7241302920521341 2.010664446815714e-06 0.7191408067115369 2.010664607355379e-06 0.7152908836069264 \
2.010664799844715e-06 0.7106793324906435 2.010664985361064e-06 0.7062404417184839 2.01066515523711e-06 0.7021802791355866 2.010665347106947e-06 0.6975984806629684 \
2.010665493330962e-06 0.6941099299715526 2.010665653617309e-06 0.6902897983225644 2.010665856006145e-06 0.6854719661536142 2.010666037294609e-06 0.681161582477689 \
2.010666206116036e-06 0.6771536053116509 2.010666391961911e-06 0.6727470762459599 2.010666597892751e-06 0.6678715161770782 2.010666765819558e-06 0.6639016226084196 \
2.010666926081262e-06 0.6601182542089066 2.010667164933735e-06 0.65448589698252 2.010667332694849e-06 0.6505369020837752 2.010667513768288e-06 0.6462813620835641 \
2.010667674923199e-06 0.642499550819208 2.01066782119046e-06 0.6390715923276049 2.010667959878569e-06 0.6358268652274862 2.010668089235615e-06 0.6328040340451749 \
2.01066821862017e-06 0.6297855584526113 2.01066834694149e-06 0.6267952385336898 2.01066847714363e-06 0.6237652412672913 2.010668606160073e-06 0.6207683673242944 \
2.010668744735633e-06 0.6175525629501428 2.01066889281122e-06 0.6141227553162802 2.010669079138505e-06 0.60981438109949 2.010669226822204e-06 0.6064079319686639 \
2.01066946198641e-06 0.600995965122186 2.010669654434141e-06 0.5965821560879089 2.010669895003955e-06 0.5910808370261941 2.010670064051325e-06 0.587228367631822 \
2.01067020171775e-06 0.5840969866928536 2.010670329822726e-06 0.581191110277254 2.010670443409422e-06 0.5786182870235701 2.010670534774226e-06 0.5765512826027382 \
2.010670624196113e-06 0.5745328691003393 2.010670691457846e-06 0.573016830490748 2.010670757478049e-06 0.5715297341779608 2.010670809531724e-06 0.5703577032508095 \
2.010670873770593e-06 0.5689124506700958 2.010670935307116e-06 0.5675311492520995 2.01067099958866e-06 0.5660899724818867 2.010671052779755e-06 0.5648985048860162 \
2.01067114512554e-06 0.5628316153148989 2.010671221701441e-06 0.5611191615154557 2.010671277545091e-06 0.5598732849310241 2.0106713468882e-06 0.5583285932816697 \
2.010671452739476e-06 0.5559733466166974 2.01067153043128e-06 0.5542469170533902 2.010671631029867e-06 0.5520159549745236 2.010671759063078e-06 0.5491849411292137 \
2.01067185856046e-06 0.5469885705929382 2.010671971125811e-06 0.544508366501287 2.010672074170131e-06 0.5422442603473754 2.010672194219017e-06 0.5396115972585003 \
2.010672295833426e-06 0.5373863339265779 2.010672411457693e-06 0.5348611538529422 2.010672526573874e-06 0.5323536236546169 2.010672653010918e-06 0.529604142030661 \
2.010672778525186e-06 0.5268822104345234 2.010672925204862e-06 0.5237112381511962 2.01067306087557e-06 0.5207845659358002 2.010673218641409e-06 0.5173942078023266 \
2.01067338106335e-06 0.5139116507621072 2.010673561971818e-06 0.5100482739823553 2.010673754563972e-06 0.5059503908118104 2.010673967555743e-06 0.5014368974673542 \
2.01067419998846e-06 0.4965308659362653 2.010674457509373e-06 0.49112491222925 2.010674697473551e-06 0.4861095397820235 2.010674998677906e-06 0.4798501326413723 \
2.010675286975534e-06 0.4738957353990632 2.010675600061861e-06 0.4674739717793394 2.010675919588141e-06 0.4609631488871989 2.010676259085406e-06 0.4540919149088484 \
2.010676585275518e-06 0.4475353831519197 2.01067692175678e-06 0.4408159131180407 2.010677238467587e-06 0.4345373385230166 2.01067757255266e-06 0.4279587671099637 \
2.010677924261529e-06 0.4210864038135054 2.010678238746378e-06 0.4149846225409808 2.010678562192836e-06 0.4087533091618546 2.010679003120949e-06 0.400331870031168 \
2.010679344916025e-06 0.3938679283557566 2.010679644350068e-06 0.3882534014213259 2.010680018872672e-06 0.3812944595528024 2.01068034825039e-06 0.375233915169682 \
2.010680631354694e-06 0.3700684563936956 2.010680931099705e-06 0.3646408765157301 2.010681210595549e-06 0.3596219010422631 2.010681434267487e-06 0.3556377385586224 \
2.010681645979195e-06 0.3518907610576284 2.010681848481927e-06 0.3483292724130969 2.010682049543475e-06 0.3448190020587957 2.010682255221384e-06 0.3412518188287665 \
2.01068247359686e-06 0.3374887625241871 2.010682717359257e-06 0.3333167726275162 2.010682944115829e-06 0.3294678078423895 2.010683164026801e-06 0.3257615367192951 \
2.010683382451408e-06 0.3221060038181086 2.010683586476418e-06 0.318715141566024 2.010683788334208e-06 0.3153870758963987 2.010683988657595e-06 0.3121102802474151 \
2.010684175271502e-06 0.309079115007194 2.010684372573109e-06 0.3058982938882217 2.010684581156335e-06 0.3025606704206737 2.010684786791057e-06 0.2992974534031506 \
2.010685011523137e-06 0.2957609785165763 2.01068522841898e-06 0.2923771984023277 2.010685436098331e-06 0.2891642611511841 2.010685667149178e-06 0.2856239464683982 \
2.010685841949429e-06 0.2829684481899911 2.010686021147604e-06 0.2802647299798244 2.01068619002212e-06 0.2777348429135014 2.010686418345394e-06 0.274348458173166 \
2.010686595082661e-06 0.2717528218126659 2.010686763365392e-06 0.2693020894036587 2.010686935832162e-06 0.2668230333489093 2.010687069934441e-06 0.264903804409765 \
2.010687215894446e-06 0.2628277003548514 2.010687354589946e-06 0.2608803500812688 2.010687476871551e-06 0.2591684246570544 2.010687610990381e-06 0.2572942758553639 \
2.010687740091486e-06 0.2554978336754472 2.01068785952522e-06 0.2538430842138498 2.01068798636042e-06 0.2520939183506197 2.010688106001442e-06 0.2504447954274527 \
2.010688255617635e-06 0.2483797066042054 2.010688390481146e-06 0.2465170278296022 2.01068852003856e-06 0.2447289494531232 2.010688677103379e-06 0.2425624627506451 \
2.010688801099014e-06 0.2408491463446025 2.010688941247149e-06 0.2389135279283614 2.01068907114005e-06 0.2371200701944942 2.01068919175767e-06 0.2354534357320198 \
2.010689354230601e-06 0.2332087289724075 2.0106895002847e-06 0.2311905595759856 2.010689638605484e-06 0.2292825126447264 2.010689746532702e-06 0.2277949627009887 \
2.01068987731761e-06 0.225993474229161 2.010689975823625e-06 0.22463752857886 2.010690079906972e-06 0.2232056532573264 2.010690152783837e-06 0.2222046546567725 \
2.010690234937313e-06 0.2210804129356655 2.010690302346398e-06 0.2201585377209549 2.010690349050661e-06 0.2195201149856669 2.01069039846802e-06 0.2188449488487562 \
2.010690489422163e-06 0.2176035744446363 2.010690555816576e-06 0.2166983392055156 2.010690602779869e-06 0.2160586379972232 2.010690653091075e-06 0.2153737902794619 \
2.010690712240425e-06 0.2145693142997165 2.010690755086328e-06 0.2139870779821451 2.010690798893629e-06 0.2133941263688522 2.010690868423894e-06 0.2124566309962414 \
2.010690955340708e-06 0.2112864027023158 2.010691036529563e-06 0.2101949018929156 2.010691122429026e-06 0.2090416531541652 2.010691216575207e-06 0.2077796428137634 \
2.010691308329081e-06 0.2065517647617813 2.010691403625517e-06 0.2052788208685862 2.010691500104209e-06 0.2039945431316728 2.01069160092949e-06 0.2026602783061639 \
2.010691696885502e-06 0.2013924147365721 2.010691799571213e-06 0.2000377255165624 2.010691902607567e-06 0.1986831378210229 2.010692012697906e-06 0.1972405340748948 \
2.010692121449794e-06 0.1958206085628783 2.010692241171749e-06 0.1942631948714586 2.010692351614651e-06 0.1928328887741874 2.010692459617459e-06 0.1914411844406488 \
2.010692584973803e-06 0.1898318066870429 2.010692677907979e-06 0.1886434908940876 2.010692756278755e-06 0.1876443873000938 2.010692832918829e-06 0.1866698667869858 \
2.010692915430143e-06 0.1856249297118943 2.010692984939759e-06 0.1847473639743596 2.010693050895387e-06 0.1839166514106665 2.010693115162722e-06 0.1831089953192083 \
2.010693227146207e-06 0.1817072258029639 2.010693321200174e-06 0.1805353135896268 2.010693428841935e-06 0.1791985758407087 2.010693535314993e-06 0.1778827552324552 \
2.01069365530692e-06 0.1764073736674057 2.010693793359545e-06 0.174720142305475 2.010693909520101e-06 0.1733081217455876 2.010694071616903e-06 0.1713503924599185 \
2.01069418670542e-06 0.1699688234017716 2.010694326691019e-06 0.1682987764548305 2.010694443897095e-06 0.1669083002780509 2.010694554816447e-06 0.1655990025649634 \
2.010694652444933e-06 0.1644521190704843 2.010694747295481e-06 0.1633427224865242 2.010694863349893e-06 0.161991523106341 2.010694954898444e-06 0.1609305136382055 \
2.01069505100742e-06 0.1598214181625073 2.010695145225554e-06 0.1587403933520305 2.010695238726156e-06 0.1576732160104884 2.010695332323478e-06 0.1566104070550305 \
2.010695428005017e-06 0.1555300824433628 2.010695518592921e-06 0.1545132165873678 2.010695609606078e-06 0.1534969984004868 2.010695705154556e-06 0.1524358767948732 \
2.010695795820268e-06 0.1514342506187442 2.010695898892631e-06 0.1503020548964867 2.01069597134408e-06 0.1495100717445464 2.010696050444873e-06 0.148649146151682 \
2.010696124993091e-06 0.1478424742503694 2.010696196024501e-06 0.1470770917224498 2.010696268788982e-06 0.1462962409077327 2.010696343406157e-06 0.1454990959398698 \
2.010696413389119e-06 0.1447543557055888 2.010696487550038e-06 0.143968261688537 2.010696541295377e-06 0.1434005634796054 2.010696594578932e-06 0.1428396203849428 \
2.01069665977469e-06 0.1421555039833398 2.010696731080731e-06 0.141411576573238 2.010696795450793e-06 0.1407432786314442 2.010696868802754e-06 0.1399847409254479 \
2.010696929420321e-06 0.1393607073002494 2.010697015453805e-06 0.1384787080092832 2.010697091404821e-06 0.1377037134581418 2.010697181372726e-06 0.1367902106004182 \
2.010697263099683e-06 0.1359645165492482 2.010697345789661e-06 0.1351360437760365 2.010697428345969e-06 0.1343145513298757 2.010697533908125e-06 0.1332698421778018 \
2.010697615775408e-06 0.1324642397250402 2.010697713142868e-06 0.1315110876582503 2.010697803143729e-06 0.130634908321232 2.010697891113987e-06 0.1297829978838479 \
2.010697974043843e-06 0.1289892226181523 2.010698048280934e-06 0.1282822873521282 2.010698147931993e-06 0.1273377645104763 2.010698243687052e-06 0.1264350619688987 \
2.010698330534457e-06 0.1256206895242312 2.010698420535994e-06 0.1247808744623497 2.010698500868674e-06 0.1240346855852102 2.010698587562703e-06 0.1232365419604467 \
2.010698686393032e-06 0.1223331159004786 2.01069877647517e-06 0.1215131568528167 2.010698886718427e-06 0.1205141992263624 2.010698973949866e-06 0.1197275966302077 \
2.010699042523e-06 0.1191120727131645 2.010699127185393e-06 0.1183553887582162 2.010699193692874e-06 0.1177634990399222 2.010699265148799e-06 0.1171309945267847 \
2.010699334822604e-06 0.1165184920865242 2.010699412159692e-06 0.1158409171037389 2.010699507902974e-06 0.1150054407698888 2.010699579157887e-06 0.1143861389207103 \
2.010699646527421e-06 0.1138025718558601 2.010699714964191e-06 0.113211685696446 2.010699790554542e-06 0.1125613765304429 2.010699881296389e-06 0.1117840233035959 \
2.010699964000116e-06 0.1110788257213999 2.010700077599187e-06 0.1101151050704521 2.010700187474899e-06 0.1091895325357105 2.010700279674213e-06 0.1084169374841771 \
2.010700403623545e-06 0.1073835127717347 2.010700491987867e-06 0.1066505015902263 2.010700631446837e-06 0.1055001025916527 2.010700730743538e-06 0.1046863788921388 \
2.01070082339359e-06 0.1039306459201802 2.010700933598102e-06 0.1030359883605075 2.010701018892542e-06 0.1023467905686673 2.010701103793345e-06 0.101663637589173 \
2.010701186744309e-06 0.1009989740617136 2.01070130925421e-06 0.1000225794851696 2.010701431196063e-06 0.09905761200121259 2.010701557818349e-06 0.09806258992746317 \
2.010701670630472e-06 0.09718220909187772 2.010701815205956e-06 0.09606278874246346 2.010701952919885e-06 0.09500564015228773 2.010702069610674e-06 0.09411672853020667 \
2.010702197354242e-06 0.0931507147971556 2.010702297018758e-06 0.09240236948627445 2.010702376452638e-06 0.09180921593916676 2.010702475187935e-06 0.09107599640376031 \
2.010702553063239e-06 0.09050081472416407 2.010702634529155e-06 0.08990210528957472 2.010702709246463e-06 0.0893557072655629 2.010702789776201e-06 0.08876971652456604 \
2.010702908608526e-06 0.08791061481419053 2.010702998269062e-06 0.08726673116015753 2.010703103183109e-06 0.08651800316437093 2.010703234657667e-06 0.08558693768262025 \
2.010703395765802e-06 0.08445695903909305 2.010703535947497e-06 0.08348350561263763 2.010703684450103e-06 0.08246223579158835 2.010703821170292e-06 0.08153124812726546 \
2.010703961182002e-06 0.08058696725890066 2.010704098179202e-06 0.07967195061625794 2.010704236789813e-06 0.07875532825288725 2.0107043812627e-06 0.07780967510081127 \
2.010704528808937e-06 0.07685421131041187 2.010704686312648e-06 0.07584560580436887 2.010704850707884e-06 0.07480523464991846 2.010705018799982e-06 0.07375451744755303 \
2.010705199799341e-06 0.07263751640721161 2.010705398512623e-06 0.07142823309373261 2.010705611921415e-06 0.07014922396308329 2.0107058380853e-06 0.06881630383186611 \
2.010706078645623e-06 0.06742468841361035 2.010706356206536e-06 0.06585179211508728 2.010706653410938e-06 0.06420523370201831 2.010706971711662e-06 0.06248365192299224 \
2.010707361695962e-06 0.06043183534616462 2.010707760522748e-06 0.05839861031494715 2.010708202994687e-06 0.05621846258761681 2.01070858797559e-06 0.05438828987170503 \
2.010709000022183e-06 0.05249218901100536 2.010709351759698e-06 0.05092353490091287 2.01070968726435e-06 0.04946969867921969 2.010709997763245e-06 0.04816021644386199 \
2.010710291700065e-06 0.04695194805701195 2.010710584430997e-06 0.04577883625507727 2.010710859274204e-06 0.04470700909733757 2.010711133117927e-06 0.04366353526031765 \
2.010711398807688e-06 0.04267398813878486 2.010711674116703e-06 0.04167180388267511 2.010711958673621e-06 0.04066026046469497 2.010712254971736e-06 0.03963283340811159 \
2.010712513847122e-06 0.03875659098599576 2.010712741803528e-06 0.03800131046948733 2.010712960528722e-06 0.03729095380188759 2.010713180383449e-06 0.03659437723507575 \
2.010713521249514e-06 0.03554043311314246 2.010713797290394e-06 0.03470953269536187 2.010714090721169e-06 0.03384790442147732 2.010714373289092e-06 0.03303898052111545 \
2.010714628198529e-06 0.03232625790162248 2.010714908882989e-06 0.03155947796597136 2.010715154716382e-06 0.03090318379665042 2.01071538687767e-06 0.03029616297556957 \
2.010715627215008e-06 0.02968398395812225 2.010715862851843e-06 0.02909722707395018 2.010716091063021e-06 0.0285403787496557 2.01071650783575e-06 0.02755138287878544 \
2.010716702361127e-06 0.02710176794309662 2.010717088601532e-06 0.02623051698020805 2.010717267770925e-06 0.0258356865503758 2.010717618998109e-06 0.02507792837274256 \
2.010717786904156e-06 0.0247229612172224 2.010718171166812e-06 0.02392944198669211 2.01071828644854e-06 0.02369675911063252 2.010718728496378e-06 0.02282172072611499 \
2.010718950311652e-06 0.02239223679446916 2.010719473931311e-06 0.02139838041889957 2.01071962929382e-06 0.02110714647916685 2.010720146999888e-06 0.02015295207761772 \
2.010720272033152e-06 0.01992792118872039 2.010720796234659e-06 0.01901759738223179 2.010720932454034e-06 0.01879045572456909 2.01072153873049e-06 0.01783210191617334 \
2.010721705739623e-06 0.01758082406519646 2.010722348947266e-06 0.01666064795441237 2.010722528091536e-06 0.0164167113061686 2.010723218250269e-06 0.01551958953683085 \
2.010723381870153e-06 0.01531511209162885 2.01072414235084e-06 0.01440332854054019 2.010724289392963e-06 0.01423371673427115 2.010725107264621e-06 0.01333087949608782 \
2.010725226813134e-06 0.01320411419549955 2.010726142674656e-06 0.01227329163592313 2.010726284027572e-06 0.01213544173166964 2.010727232503148e-06 0.01124488043697059 \
2.010727391142586e-06 0.01110230805801717 2.01072857354363e-06 0.01011356759191894 2.01072867164402e-06 0.01003725601038859 2.01072993325548e-06 0.009120360285939955 \
2.010730067669331e-06 0.009028655389366201 2.010731608240655e-06 0.008043892937307966 2.010731689273999e-06 0.007992925041580451 2.010733277867931e-06 0.007023242357651564 \
2.010733410759078e-06 0.006948518507451114 2.01073538746242e-06 0.005952856104192286 2.010735569200568e-06 0.005869662958407677 2.010737671554229e-06 0.004980929874643355 \
2.010738112345997e-06 0.004810448874467742 2.010740767560855e-06 0.003892108290451164 2.010741244140394e-06 0.003745909362026665 2.010744882222615e-06 0.00279447349697209 \
2.01074540774606e-06 0.002678838783887205 2.010751013810846e-06 0.001700248310874221 2.010751324898547e-06 0.001653333728976835 2.010756459226246e-06 0.0006858192122199529 \
2.010756653206019e-06 0.0006440832883579712 2.013404576914862e-06 -0.0002037173203380238 2.013404741115283e-06 -0.0003889174928863678 2.013405314458091e-06 -0.001270938904608877 \
2.013405389392278e-06 -0.001411855863724778 2.013405849976055e-06 -0.002393592696522268 2.013405961916807e-06 -0.002660411672198376 2.013406215188795e-06 -0.003300974950034667 \
2.013406381572099e-06 -0.003745951779090856 2.01340667656787e-06 -0.004566571567208835 2.013406788055443e-06 -0.00488071790655901 2.013407067428216e-06 -0.005641221413069743 \
2.013407188386555e-06 -0.005938820066262044 2.013408282339389e-06 -0.005180465225493313 2.013408406471631e-06 -0.004410796826645887 2.013408530879049e-06 -0.003456122327429311 \
2.013408650435429e-06 -0.002364170815481491 2.013408748579805e-06 -0.001341064316055312 2.013408855004127e-06 -0.0001052154991983786 2.013408967239972e-06 0.001336046702817826 \
2.013409102195821e-06 0.003249882807978809 2.013409224782331e-06 0.005149402351921401 2.013409413644246e-06 0.008353592055059769 2.013409554826579e-06 0.01094873860302964 \
2.013409708187922e-06 0.01393943619118621 2.013409851561427e-06 0.01687898420971235 2.013410005752867e-06 0.02017576688295359 2.013410161892825e-06 0.02363796584892512 \
2.013410317618878e-06 0.02719811802828209 2.013410465112557e-06 0.03065407560139007 2.013410613784323e-06 0.03420778369279751 2.013410769114408e-06 0.03798436241030867 \
2.013410927740287e-06 0.04189786275883118 2.013411092673448e-06 0.0460171220807938 2.013411267096336e-06 0.05041857973200652 2.013411446085736e-06 0.05497510627343041 \
2.013411635385597e-06 0.05982852266675163 2.013411838393603e-06 0.06506368941101938 2.013412057870669e-06 0.07075025585284363 2.01341228893533e-06 0.07675903373893865 \
2.013412535995649e-06 0.08319974270080552 2.013412806420637e-06 0.0902619122132732 2.013413099984325e-06 0.09793335781011638 2.013413424033306e-06 0.1064001814721126 \
2.013413788254856e-06 0.1159066558703892 2.013414180806326e-06 0.1261372395632307 2.013414630304251e-06 0.1378252442462487 2.013415153096484e-06 0.1513754922073403 \
2.013415766694219e-06 0.1672157090591849 2.013416444455093e-06 0.184625848284817 2.013417232720213e-06 0.2047487967247964 2.013418115553072e-06 0.22712469896725 \
2.013418933839029e-06 0.2476994923478653 2.013419661268608e-06 0.2658503723959502 2.013420301381636e-06 0.2817009601644404 2.01342087568535e-06 0.2958213763442377 \
2.013421413251317e-06 0.3089396094373287 2.013421917248776e-06 0.3211464104224903 2.01342239337143e-06 0.3325930942309646 2.013422871259445e-06 0.3439912352478621 \
2.013423324592551e-06 0.3547121966731367 2.013423795885259e-06 0.3657614311162562 2.013424238561085e-06 0.3760518588326446 2.013424757059872e-06 0.3879885572071845 \
2.013425284221992e-06 0.3999987293386327 2.013425663131624e-06 0.4085537955782026 2.013426193047166e-06 0.4204060347738258 2.013426622963746e-06 0.429919877745455 \
2.013427076664521e-06 0.4398653393542544 2.013427543378037e-06 0.4500002271552926 2.013427981059267e-06 0.4594210430579985 2.013428389021531e-06 0.468120704286539 \
2.013428708454564e-06 0.4748816926501604 2.013429080589837e-06 0.4826992142337162 2.013429315571977e-06 0.4876010339127531 2.013429549178225e-06 0.4924491904621348 \
2.013429797190648e-06 0.4975647713404599 2.013430095592078e-06 0.5036796627825791 2.01343035194848e-06 0.5088948470128004 2.01343056424179e-06 0.5131878547336713 \
2.013430758259862e-06 0.5170959594548015 2.013430905246394e-06 0.5200432695146362 2.013431059224405e-06 0.523118600542271 2.013431277106154e-06 0.5274469616807909 \
2.01343153021048e-06 0.5324525256580425 2.013431740049324e-06 0.5365797337241586 2.013431951502634e-06 0.5407247601751553 2.013432233709534e-06 0.5462280430697679 \
2.013432463254817e-06 0.5506821559930507 2.013432679151024e-06 0.5548604062613707 2.013432961372541e-06 0.560308769190463 2.013433212680268e-06 0.5651538146135803 \
2.01343351034116e-06 0.5708625224168123 2.013433760568061e-06 0.5756519166658941 2.013434016931556e-06 0.5805516059354519 2.01343425734157e-06 0.585116682128892 \
2.013434515521386e-06 0.5900038400537884 2.013434739113592e-06 0.5942175703762435 2.013434977623163e-06 0.5986919452581434 2.013435185207862e-06 0.6025689278491061 \
2.013435401730487e-06 0.6065904171332736 2.013435651033092e-06 0.6111939272561876 2.013435856106535e-06 0.6149609706257601 2.013436107378861e-06 0.6195555361399968 \
2.013436310600886e-06 0.6232455818254186 2.013436507472791e-06 0.6267987644955494 2.013436700764307e-06 0.630267737067843 2.013436955542762e-06 0.6348113783570861 \
2.013437185753374e-06 0.638887973644319 2.013437403107185e-06 0.6427143472883045 2.013437701512908e-06 0.6479268061885751 2.013437916915757e-06 0.6516657345437264 \
2.013438118139476e-06 0.6551344108237934 2.013438293060983e-06 0.6581323437428509 2.013438458126254e-06 0.6609495238976936 2.013438627594775e-06 0.6638251431769452 \
2.013438779731613e-06 0.666392827642013 2.013438917642298e-06 0.6687037209181631 2.013439066478412e-06 0.6711867545200138 2.013439194593014e-06 0.6733159837320549 \
2.013439337815828e-06 0.6756849429836936 2.013439459090077e-06 0.6776819274526149 2.013439596688762e-06 0.6799401191146522 2.013439716069216e-06 0.6818929034138137 \
2.013439863176962e-06 0.6842914131385206 2.013439980378628e-06 0.6861933934268433 2.013440073884205e-06 0.6877071857403232 2.013440164873897e-06 0.6891752279197846 \
2.013440267615961e-06 0.6908280855439021 2.013440369133525e-06 0.6924555900607121 2.013440487516631e-06 0.6943444167618776 2.013440599637217e-06 0.6961264383846065 \
2.013440717192718e-06 0.6979868779962457 2.013440902343005e-06 0.7008959348649784 2.013441033535213e-06 0.7029413755586562 2.013441169703753e-06 0.7050491462541959 \
2.013441291222456e-06 0.7069171228306749 2.013441431145468e-06 0.7090538254196674 2.013441535088117e-06 0.7106315721465845 2.013441646249101e-06 0.712309798010818 \
2.013441750508965e-06 0.7138759052437967 2.013441880147056e-06 0.7158124745844324 2.013441977077769e-06 0.7172526339884565 2.013442116000004e-06 0.7193052800722975 \
2.013442235549293e-06 0.7210612846995991 2.013442355121865e-06 0.7228080613301419 2.013442480897243e-06 0.7246353354365959 2.013442607615586e-06 0.7264656873164689 \
2.013442729655437e-06 0.728218443613998 2.01344285780388e-06 0.7300486655261287 2.013442987872205e-06 0.7318956587421809 2.013443108863228e-06 0.7336041830685722 \
2.013443249633811e-06 0.7355801168346318 2.01344335060338e-06 0.7369898206659778 2.013443452204237e-06 0.7384020079314992 2.013443548224548e-06 0.7397310783624924 \
2.013443659137403e-06 0.7412570822736337 2.01344374678503e-06 0.7424563811251772 2.013443846639401e-06 0.7438154404043728 2.013443981404539e-06 0.7456370856934184 \
2.013444097699018e-06 0.747198032089633 2.013444201190815e-06 0.7485782798032956 2.013444325446263e-06 0.7502239458264747 2.013444470359203e-06 0.7521280942578691 \
2.013444588339772e-06 0.753666143975803 2.013444707270879e-06 0.7552056331692281 2.013444846850418e-06 0.7569980918234445 2.013444991202808e-06 0.7588357421297242 \
2.013445109263616e-06 0.7603265096672839 2.013445234085336e-06 0.7618908200857619 2.013445373916531e-06 0.7636286950759973 2.013445498679428e-06 0.7651662633748356 \
2.013445642192899e-06 0.7669199865864609 2.013445762878376e-06 0.7683824344671055 2.013445883722124e-06 0.7698356273746885 2.013446003367048e-06 0.7712633747646481 \
2.013446133074688e-06 0.7727989859455529 2.01344624181849e-06 0.7740766298596218 2.013446364466227e-06 0.7755070372682662 2.013446474242911e-06 0.7767778749889983 \
2.013446603267025e-06 0.7782599816788072 2.013446735043344e-06 0.7797610257751375 2.01344684835592e-06 0.7810403609326458 2.013446969441862e-06 0.7823954393038701 \
2.013447073314495e-06 0.7835479431998941 2.013447215597517e-06 0.785111775748914 2.013447363800666e-06 0.7867227488076519 2.013447522694201e-06 0.7884297907063792 \
2.013447642887223e-06 0.7897074707829422 2.01344779245393e-06 0.7912811323018302 2.013447916569147e-06 0.7925734175081853 2.013448042273444e-06 0.7938699048627912 \
2.013448145219011e-06 0.7949224966762399 2.013448259590165e-06 0.7960823495211882 2.013448372064409e-06 0.7972131756542409 2.013448462336983e-06 0.7981137961420948 \
2.013448551677879e-06 0.7989989930139054 2.013448676903817e-06 0.800229513878344 2.01344878467518e-06 0.8012785338618679 2.013448914342978e-06 0.8025281307685926 \
2.013449035722257e-06 0.8036855380110038 2.013449152278057e-06 0.8047859282369955 2.013449273083453e-06 0.80591497746663 2.013449405708758e-06 0.8071413435168892 \
2.013449527502378e-06 0.8082555056211007 2.013449654106103e-06 0.8094015704683005 2.013449779719621e-06 0.8105266036187198 2.013449899211046e-06 0.8115857443778658 \
2.013450037409299e-06 0.8127973981963581 2.013450146908548e-06 0.8137473213416323 2.013450231056663e-06 0.8144713378799666 2.01345035186072e-06 0.8155017394983226 \
2.013450447369557e-06 0.8163089346032877 2.01345058366036e-06 0.8174496006492775 2.013450726424414e-06 0.8186303638797883 2.013450860857535e-06 0.8197292014569521 \
2.013450970729519e-06 0.8206175763825388 2.013451114629137e-06 0.8217677661037901 2.01345126795672e-06 0.8229768690765377 2.013451395805574e-06 0.8239722812379519 \
2.013451536202905e-06 0.8250521595273246 2.013451662107844e-06 0.8260088941474263 2.01345181672401e-06 0.8271688948348412 2.013451949079339e-06 0.8281489842609937 \
2.013452075346168e-06 0.8290730392392056 2.013452193006695e-06 0.8299245984162376 2.013452341409092e-06 0.8309852945996649 2.013452508603261e-06 0.8321626230293395 \
2.013452641380572e-06 0.8330844501529713 2.013452814281769e-06 0.8342675727345584 2.013452982699063e-06 0.8354015168591284 2.013453152193536e-06 0.8365246342267009 \
2.013453333630418e-06 0.8377070668209077 2.01345347618656e-06 0.8386219603417975 2.01345359009745e-06 0.8393441765511721 2.013453720973659e-06 0.8401643924869071 \
2.013453822596633e-06 0.8407940582489307 2.013453939036872e-06 0.8415078269750864 2.013454074330058e-06 0.8423269142909066 2.013454271595159e-06 0.8435017451489455 \
2.013454462114483e-06 0.844614933042255 2.013454672039296e-06 0.8458175693076773 2.013454852817827e-06 0.8468334846981137 2.013455050185846e-06 0.8479221976595614 \
2.013455224044341e-06 0.8488638701886076 2.013455406558584e-06 0.8498353939890455 2.013455577902694e-06 0.8507314120859523 2.013455752248258e-06 0.8516272398309612 \
2.013455927651258e-06 0.8525125793730954 2.013456103896448e-06 0.8533864315694911 2.013456293665327e-06 0.8543099749208749 2.013456484423344e-06 0.8552205033559714 \
2.01345668621255e-06 0.8561646193034282 2.013456878916116e-06 0.8570482883232282 2.013457088356793e-06 0.8579892478796384 2.013457318098559e-06 0.8589986827500428 \
2.013457583567511e-06 0.8601360945383778 2.013457882213856e-06 0.8613786760148464 2.013458160601222e-06 0.8625023989005415 2.013458444791177e-06 0.8636161469557806 \
2.013458719285784e-06 0.8646608622318305 2.013458991377281e-06 0.8656672252055042 2.013459261593727e-06 0.8666387059277968 2.013459518761915e-06 0.8675381145236246 \
2.01345979132098e-06 0.8684653318325959 2.01346006734232e-06 0.8693777905953765 2.013460337484171e-06 0.8702455402709716 2.013460637231955e-06 0.8711796653984102 \
2.013461008105813e-06 0.872294745819888 2.013461303028797e-06 0.8731503023941 2.013461557284845e-06 0.8738665406311316 2.013461855515577e-06 0.8746822274488602 \
2.013462129133902e-06 0.8754080260278182 2.013462365269549e-06 0.8760175227551726 2.013462605621406e-06 0.876622281264788 2.013462827963785e-06 0.8771680781109068 \
2.013463021968128e-06 0.8776338860468618 2.013463351691208e-06 0.8784037109613512 2.01346350686397e-06 0.8787567114621292 2.013463824616497e-06 0.879461652496718 \
2.013464003481858e-06 0.8798480920375044 2.013464345943324e-06 0.8805675499479563 2.013464530084847e-06 0.8809434933546246 2.013465004990284e-06 0.8818790560183651 \
2.013465172384703e-06 0.8821975058309585 2.013465638216128e-06 0.8830540251881659 2.013465819040967e-06 0.8833751042472839 2.013466313074347e-06 0.8842212008576973 \
2.013466454417056e-06 0.884455124402366 2.013467060806836e-06 0.8854193259359495 2.013467212878983e-06 0.8856514227360587 2.01346785955747e-06 0.8865980751852495 \
2.013467987853825e-06 0.8867785329419297 2.013468635979926e-06 0.8876550049536978 2.013468765772447e-06 0.8878236738033012 2.013469544034095e-06 0.8887860366092379 \
2.013469659025973e-06 0.8889208282599539 2.013470514758392e-06 0.8898661633196656 2.013470660021537e-06 0.8900169066926564 2.013471645777722e-06 0.8909664261264102 \
2.013471866882863e-06 0.8911622482549515 2.013473011997307e-06 0.8921020388386462 2.013473143207264e-06 0.8922053928944147 2.0134743308658e-06 0.8931033243919096 \
2.013474484486092e-06 0.8932130731307282 2.013475894522803e-06 0.8941348173026452 2.013476117329622e-06 0.8942660193790342 2.01347779802033e-06 0.8951452796684343 \
2.01347812564151e-06 0.8952966652167414 2.013480355582631e-06 0.8961896554712738 2.013480908496593e-06 0.8963788593752812 2.013484476711123e-06 0.8973573335043913 \
2.013484800223538e-06 0.8974284307984646 2.013491156631826e-06 0.8984120886469452 2.013491705534673e-06 0.8984686671268907 2.013544207609024e-06 0.8994658645395698 \
2.013544850637887e-06 0.8994692460188505 2.01373698930852e-06 0.9004073346715066 2.013737190722491e-06 0.9004708280105613 2.013741150500432e-06 0.8995366825576255 \
2.01374133452723e-06 0.8993953949813248 2.013742651124504e-06 0.8984641879157507 2.013742823168359e-06 0.8983566564859006 2.013744719544654e-06 0.8973720929359315 \
2.013744893250842e-06 0.897304621671452 2.013757467177875e-06 0.8982933655523699 2.013757552368112e-06 0.8983081509245614 2.013765819241151e-06 0.8993078551592517 \
2.013766293960572e-06 0.8993433667976791 2.014259794870012e-06 0.9002974142054325 2.014259914349736e-06 0.9003767372269074 2.014260807172786e-06 0.9012336455299185 \
2.014260953429422e-06 0.901423267690772 2.014261548322101e-06 0.9023325668564308 2.014261683292917e-06 0.9025673929107925 2.014262187968707e-06 0.9035294259428087 \
2.014262320579608e-06 0.9038000271808221 2.014262721206973e-06 0.9046475051114249 2.014262865572371e-06 0.9049556543240072 2.01426328869358e-06 0.9058123566484279 \
2.014263384150639e-06 0.9059850892484415 2.014264808709455e-06 0.9052205906349737 2.014264933747309e-06 0.9046352442223391 2.014265060157898e-06 0.9039223775493039 \
2.014265162806642e-06 0.9032486771507763 2.014265290021932e-06 0.9022944222362175 2.014265408867758e-06 0.9012801950564071 2.014265506520237e-06 0.9003603330664713 \
2.014265588522259e-06 0.8995243596151602 2.014265668185821e-06 0.8986589236008835 2.01426577896399e-06 0.8973708307079206 2.014265880140004e-06 0.8961049472956977 \
2.014265963084475e-06 0.8950067229086057 2.014266071529893e-06 0.8934921260891034 2.01426617999385e-06 0.8918872687155874 2.014266275049989e-06 0.8904106867557802 \
2.014266395922642e-06 0.8884444419111864 2.014266516699262e-06 0.8863849482818795 2.014266629744433e-06 0.8843763393508186 2.014266732915182e-06 0.8824794505619851 \
2.014266818515338e-06 0.8808620855018965 2.014266892989399e-06 0.8794251273161163 2.014266987312942e-06 0.8775673968166831 2.014267075773858e-06 0.8757888800524039 \
2.014267154846869e-06 0.8741711975775893 2.014267248834225e-06 0.872216793437976 2.014267330179529e-06 0.8704993514258973 2.014267425093555e-06 0.8684673705816817 \
2.014267518136275e-06 0.8664480751909672 2.014267614922069e-06 0.8643215060814092 2.014267738217441e-06 0.8615778533848952 2.014267851664452e-06 0.859022019682563 \
2.014267977516491e-06 0.8561558571929792 2.014268100844636e-06 0.8533196845306243 2.014268230022926e-06 0.850323637950593 2.014268370619783e-06 0.8470370034914 \
2.014268479399504e-06 0.8444782910716596 2.014268614459258e-06 0.8412850455921466 2.014268724119566e-06 0.8386804253780991 2.014268853299346e-06 0.8356002443501571 \
2.014268979483175e-06 0.8325812421138936 2.014269106573531e-06 0.8295317031556502 2.014269235595804e-06 0.826427745883674 2.014269344676045e-06 0.8237985689995477 \
2.014269484526701e-06 0.8204223029647078 2.014269623954893e-06 0.8170507778356514 2.014269756708524e-06 0.8138366863616762 2.014269886777199e-06 0.8106848159989707 \
2.014270010472646e-06 0.8076853837479523 2.014270147427036e-06 0.8043627031572629 2.014270261138882e-06 0.8016030849198694 2.014270388615923e-06 0.7985086235398901 \
2.014270499416994e-06 0.7958187897651571 2.014270618603452e-06 0.7929254985494992 2.014270731982508e-06 0.7901733724735396 2.014270866292901e-06 0.7869138859547327 \
2.014270973387169e-06 0.7843152933129034 2.014271089404312e-06 0.7815009627552112 2.014271218595276e-06 0.778367508739124 2.014271316207711e-06 0.7760002683782802 \
2.014271421787151e-06 0.773440790716327 2.01427153046932e-06 0.7708069008430674 2.014271632885583e-06 0.7683258101021144 2.014271726279241e-06 0.7660641808432364 \
2.014271845835017e-06 0.7631702213567544 2.014271938307379e-06 0.7609327305817616 2.014272030945494e-06 0.7586922094322426 2.01427212937031e-06 0.7563124992069843 \
2.014272237347962e-06 0.7537030947613649 2.014272333616474e-06 0.7513778334636231 2.014272419872877e-06 0.7492952979736797 2.014272522736666e-06 0.7468128004450286 \
2.014272601580994e-06 0.744910856519283 2.014272702387036e-06 0.7424801602439853 2.014272836915276e-06 0.7392377693660663 2.014272974140136e-06 0.7359316755186537 \
2.014273117619987e-06 0.7324773442723981 2.014273266044177e-06 0.7289066083419234 2.014273409305472e-06 0.7254625447335662 2.014273549382451e-06 0.7220977259655398 \
2.014273705808317e-06 0.7183435968963056 2.014273830210067e-06 0.715360858370426 2.014273951271848e-06 0.7124600029613375 2.01427410478411e-06 0.7087850045121084 \
2.014274239566055e-06 0.7055614325718365 2.014274365665088e-06 0.7025479112911024 2.014274508839371e-06 0.6991289103945657 2.014274628921163e-06 0.6962626602560111 \
2.014274758155492e-06 0.6931807499479741 2.014274864640539e-06 0.6906432840523983 2.014274976916362e-06 0.6879696524977363 2.014275073251648e-06 0.6856773754336868 \
2.01427517606134e-06 0.683232326200841 2.014275270865193e-06 0.6809792012818872 2.014275376187123e-06 0.6784784437814733 2.014275484625777e-06 0.6759058899658261 \
2.014275583635057e-06 0.673558569590366 2.01427570039165e-06 0.6707929011939652 2.014275808476928e-06 0.6682347329991606 2.014275918483137e-06 0.6656332609774134 \
2.014276004570979e-06 0.6635992664604092 2.014276134166118e-06 0.6605400273835189 2.014276226767366e-06 0.6583552307294462 2.014276322555092e-06 0.6560965362104854 \
2.014276407507078e-06 0.6540950852804182 2.014276526801602e-06 0.6512869789851043 2.01427661407154e-06 0.6492343850333612 2.014276704778561e-06 0.6471030993779646 \
2.014276805943536e-06 0.6447280068361273 2.014276885774359e-06 0.6428551652550211 2.014276974560194e-06 0.6407732405330839 2.01427705225042e-06 0.6389536101386547 \
2.014277114019368e-06 0.6375081226244841 2.014277177784013e-06 0.6360167668935747 2.014277241018233e-06 0.634538653569437 2.014277280258806e-06 0.6336218002627473 \
2.014277320897828e-06 0.6326726453797233 2.014277400982362e-06 0.6308039353694699 2.014277470886543e-06 0.6291742390428672 2.014277521523257e-06 0.6279942052995945 \
2.014277560272899e-06 0.6270914175114127 2.014277599267879e-06 0.6261832343283663 2.014277643882627e-06 0.6251445623164014 2.014277686739083e-06 0.6241478292286105 \
2.014277737053687e-06 0.6229782634938205 2.014277788990864e-06 0.6217719122409077 2.014277874058449e-06 0.6197972300178722 2.014277934038866e-06 0.6184052992407258 \
2.014278023826075e-06 0.61632338076978 2.014278100290156e-06 0.6145529519516876 2.014278179854447e-06 0.6127119801362371 2.014278260891059e-06 0.6108383709630588 \
2.014278350105382e-06 0.6087775861620425 2.014278440965394e-06 0.6066826282541496 2.014278528184102e-06 0.6046739453334793 2.014278621957293e-06 0.6025158549334848 \
2.014278723642756e-06 0.6001788642681311 2.014278823240849e-06 0.5978941858483342 2.014278935095889e-06 0.5953317151711254 2.014279051129026e-06 0.5926772450523136 \
2.014279172750132e-06 0.5899020947998995 2.014279277133946e-06 0.5875236635596754 2.014279421924166e-06 0.5842296531729801 2.014279534584127e-06 0.5816734289694181 \
2.014279643596094e-06 0.5792035939892568 2.014279736075537e-06 0.5771100174076607 2.014279829526177e-06 0.5749994714793375 2.01427992185204e-06 0.5729181236728181 \
2.014279994438741e-06 0.571283073141143 2.014280050392967e-06 0.5700232888304386 2.014280111461249e-06 0.5686498830286455 2.014280209950764e-06 0.5664400707212188 \
2.014280273162208e-06 0.5650238531380825 2.014280333588177e-06 0.5636708824310654 2.01428041053656e-06 0.5619492451093103 2.014280473695102e-06 0.5605380106414651 \
2.01428056200871e-06 0.558569506627369 2.014280633210033e-06 0.5569845302974165 2.014280719745787e-06 0.555060151797141 2.01428084109856e-06 0.5523665438352664 \
2.014280969027808e-06 0.5495364947125975 2.014281067158439e-06 0.5473694328713704 2.014281180282435e-06 0.5448752016832871 2.014281282350254e-06 0.5426314425864434 \
2.014281401299125e-06 0.5400217272291628 2.014281504386832e-06 0.5377630705755105 2.014281618593986e-06 0.5352670017334624 2.014281732009658e-06 0.532794946211756 \
2.014281859080713e-06 0.5300302694710822 2.014281982900802e-06 0.5273426867079006 2.014282127689607e-06 0.5242103332418484 2.01428226351311e-06 0.5212782585303676 \
2.014282418567969e-06 0.5179428401013338 2.014282579419853e-06 0.5144913885072363 2.0142827581493e-06 0.5106699876709851 2.01428294832834e-06 0.5066200804011861 \
2.014283158230362e-06 0.5021665212646098 2.014283386936347e-06 0.4973332357952056 2.014283640864285e-06 0.4919960258408594 2.014283881797751e-06 0.4869529241725989 \
2.014284177960236e-06 0.4807889695952298 2.014284467957623e-06 0.4747910561470179 2.014284774200956e-06 0.4684976697011882 2.014285094876887e-06 0.4619520863481486 \
2.014285422744054e-06 0.4553041925245184 2.014285762989109e-06 0.4484521981997251 2.014286088414655e-06 0.4419418052309769 2.014286410321802e-06 0.4355465312739703 \
2.014286740535907e-06 0.4290298934287748 2.0142870965285e-06 0.4220583188787752 2.014287415406929e-06 0.4158579595363656 2.014287752858691e-06 0.4093433989943853 \
2.014288180725408e-06 0.4011531841887147 2.014288529437355e-06 0.3945419525178304 2.01428883707332e-06 0.388759214407489 2.01428921689981e-06 0.3816861832573664 \
2.014289548089372e-06 0.3755780492082042 2.014289831697452e-06 0.370391509977049 2.014290142516397e-06 0.3647512908748707 2.014290421833005e-06 0.3597258263082204 \
2.014290648329153e-06 0.3556836811642302 2.014290864011538e-06 0.3518598964090484 2.014291061295543e-06 0.3483842179544538 2.014291266280002e-06 0.3447988491770444 \
2.014291478501966e-06 0.3411119200457455 2.014291733807154e-06 0.33670771290924 2.014291975329403e-06 0.3325734463267218 2.014292206706731e-06 0.3286464933807047 \
2.014292421559231e-06 0.3250253651850565 2.014292642118388e-06 0.3213332986541765 2.014292843544355e-06 0.3179852906236645 2.014293046612606e-06 0.3146379646143546 \
2.014293244508216e-06 0.3114011111455273 2.014293431469302e-06 0.3083651674074345 2.014293625269522e-06 0.3052406640298299 2.014293829186134e-06 0.3019773030815858 \
2.014294008255468e-06 0.2991336297844484 2.014294243846324e-06 0.2954229173226265 2.014294444650423e-06 0.2922868215109002 2.014294645829315e-06 0.2891696385850206 \
2.014294869639057e-06 0.2857334090862961 2.014295034201803e-06 0.2832271910241367 2.014295211129189e-06 0.2805503385691353 2.014295396922194e-06 0.2777610713150803 \
2.01429557873767e-06 0.2750538970423583 2.014295757762463e-06 0.2724132377985424 2.014295925107616e-06 0.2699606650006489 2.014296085536534e-06 0.2676371805838822 \
2.014296208110286e-06 0.2658719571410424 2.014296357874814e-06 0.2637236906090554 2.01429648557194e-06 0.2619099339733745 2.014296592880312e-06 0.2603957336038235 \
2.014296708880974e-06 0.2587625259947361 2.014296819189571e-06 0.2572125806747212 2.014296945068767e-06 0.2554509781935611 2.014297060550618e-06 0.2538402638894013 \
2.014297195131521e-06 0.2519757335310172 2.014297307194775e-06 0.2504255755821768 2.014297457534135e-06 0.2483447107137444 2.014297597159989e-06 0.2464124269747185 \
2.01429774305181e-06 0.2444035064209518 2.014297876012447e-06 0.2425734862730615 2.014297999574161e-06 0.2408709992523319 2.014298146783853e-06 0.2388417729476062 \
2.014298263370682e-06 0.2372355665500016 2.014298402825832e-06 0.23532008003217 2.014298537000301e-06 0.2334768281602104 2.014298662976758e-06 0.2317465561243653 \
2.014298782376161e-06 0.2301094434087779 2.014298877230585e-06 0.2288105340759602 2.014298990368184e-06 0.2272617792622066 2.014299070684642e-06 0.2261626001158484 \
2.014299158249699e-06 0.2249657246820506 2.014299283786836e-06 0.2232507767215072 2.014299389480543e-06 0.2218101326756785 2.014299479135054e-06 0.2205921574607158 \
2.014299549986253e-06 0.2196300825522397 2.014299593014783e-06 0.2190460135436258 2.014299635305326e-06 0.2184724035808872 2.014299677647042e-06 0.2178984240735344 \
2.014299749842462e-06 0.2169203674089526 2.014299792235817e-06 0.2163464205126744 2.014299827490656e-06 0.2158693585303403 2.01429987168224e-06 0.2152716287340076 \
2.014299941290467e-06 0.2143309212991285 2.014299975633797e-06 0.2138672544767182 2.014300020093325e-06 0.2132698436071631 2.014300087771806e-06 0.2123628126304402 \
2.014300174199065e-06 0.2112058698236149 2.014300248835667e-06 0.2102078598594563 2.014300330137676e-06 0.2091219706754807 2.014300427015059e-06 0.2078300362310651 \
2.014300552998548e-06 0.2061528795789772 2.014300655533384e-06 0.2047906894256944 2.014300757016901e-06 0.2034500128132261 2.014300858082597e-06 0.202119416354989 \
2.014300954696817e-06 0.2008491615811921 2.01430105666124e-06 0.1995112314821507 2.014301163383484e-06 0.1981153840927639 2.014301271788624e-06 0.1967018790395962 \
2.01430138378278e-06 0.1952465002768531 2.014301496249907e-06 0.1937897263683151 2.014301608323246e-06 0.1923454332378671 2.01430171621572e-06 0.1909603537828802 \
2.014301817598649e-06 0.1896629368444172 2.014301909236099e-06 0.1884941330679491 2.014302003211708e-06 0.1872990757663449 2.014302074478072e-06 0.1863957871745983 \
2.01430215115336e-06 0.1854271890400033 2.014302254812475e-06 0.184122202819407 2.014302328479595e-06 0.1831974022686171 2.014302401825495e-06 0.1822796569444652 \
2.014302515215845e-06 0.1808667181969195 2.014302603074485e-06 0.1797760932362061 2.014302686923162e-06 0.1787387947787487 2.01430281588559e-06 0.1771515524267008 \
2.014302917772084e-06 0.1759040172436072 2.014303023472791e-06 0.1746156056808686 2.014303125120866e-06 0.1733818993219825 2.014303255982584e-06 0.1718019019596718 \
2.014303363179222e-06 0.1705140034701537 2.014303492508118e-06 0.168969083715685 2.01430360420461e-06 0.167642098072289 2.014303704535189e-06 0.1664555496840579 \
2.014303800335743e-06 0.1653276075899142 2.014303911148015e-06 0.1640289617085985 2.014303998548296e-06 0.1630090521997956 2.014304109869414e-06 0.1617156184952586 \
2.014304202821272e-06 0.1606409001560029 2.01430429039415e-06 0.1596330843918451 2.014304392025023e-06 0.1584700928658864 2.014304476479078e-06 0.1575086241734052 \
2.014304551583457e-06 0.1566573095634876 2.0143046294057e-06 0.1557789554714152 2.014304709763569e-06 0.1548759612316424 2.014304810818399e-06 0.1537464547857493 \
2.014304893251962e-06 0.1528311848879565 2.014304985556514e-06 0.1518114053368895 2.014305062490987e-06 0.150965812476358 2.014305145413558e-06 0.1500585909391909 \
2.014305216944298e-06 0.1492793026301012 2.014305313327798e-06 0.1482344968214558 2.014305383556283e-06 0.1474766665551334 2.014305466536561e-06 0.1465853655470201 \
2.014305527978825e-06 0.1459298106834085 2.01430559966121e-06 0.1451677491870439 2.014305668289752e-06 0.1444408762699853 2.014305718558261e-06 0.1439102090153988 \
2.014305766138068e-06 0.143409423336876 2.014305820187418e-06 0.1428423132663369 2.014305879529516e-06 0.1422216078256897 2.014305947564923e-06 0.1415124633834424 \
2.014306023828345e-06 0.1407207186008814 2.014306092108145e-06 0.1400161356079559 2.014306186894323e-06 0.1390460813732662 2.014306276448135e-06 0.1381341561933974 \
2.014306348133609e-06 0.1374075731330657 2.014306432085018e-06 0.1365606113096345 2.014306497397473e-06 0.1359045398875483 2.014306558840598e-06 0.1352895588344758 \
2.014306633117097e-06 0.1345490408254265 2.014306695327357e-06 0.1339328028964004 2.014306763298366e-06 0.133265236037424 2.014306822505405e-06 0.1326856657519672 \
2.014306895177879e-06 0.1319767402814105 2.014306970197988e-06 0.1312477270463112 2.014307055651411e-06 0.1304208267333309 2.014307141751751e-06 0.1295914604616623 \
2.014307241877205e-06 0.1286317929389105 2.014307323166875e-06 0.127857435971709 2.014307424934223e-06 0.1268981149578782 2.014307509182182e-06 0.1261072369695883 \
2.014307607998911e-06 0.1251836587365037 2.014307680839456e-06 0.1245055382686853 2.014307760865543e-06 0.1237631876254407 2.014307831351338e-06 0.1231117958237987 \
2.014307903881761e-06 0.1224439308288319 2.014307981350756e-06 0.1217331219782777 2.014308088702104e-06 0.1207554316575004 2.01430818934012e-06 0.1198442997624752 \
2.014308261927674e-06 0.1191899427853172 2.014308330759514e-06 0.1185715582611356 2.014308396546334e-06 0.1179824683205609 2.014308466175132e-06 0.1173610347366148 \
2.014308536558877e-06 0.1167350538439435 2.01430861173725e-06 0.1160688810594495 2.014308715991485e-06 0.1151493019715505 2.014308791126139e-06 0.114489769343061 \
2.014308860041223e-06 0.1138870655592168 2.014308923246095e-06 0.1133369146236164 2.01430899278746e-06 0.1127339156958381 2.014309050088964e-06 0.1122385190692166 \
2.014309121730019e-06 0.1116210355509516 2.014309179565092e-06 0.1111240709857579 2.014309251686527e-06 0.1105063809580559 2.01430931410261e-06 0.1099736279351742 \
2.014309398424132e-06 0.1092565349771765 2.0143094660201e-06 0.1086842173446869 2.014309574816032e-06 0.1077671916889585 2.014309679126564e-06 0.1068924975608609 \
2.014309758614772e-06 0.1062289053282379 2.014309846183183e-06 0.1055008617114655 2.014309909639535e-06 0.1049752776433979 2.014309971350652e-06 0.10446579874651 \
2.014310075190416e-06 0.103612238268202 2.014310157871118e-06 0.1029362225408096 2.014310256339144e-06 0.1021348761715451 2.014310340785582e-06 0.101450818648051 \
2.014310457263062e-06 0.1005121841703865 2.014310591996508e-06 0.09943411943161744 2.014310728066044e-06 0.0983541971400249 2.014310842385451e-06 0.09745369041838402 \
2.014310927852596e-06 0.09678457778867394 2.014311038134269e-06 0.09592640631053104 2.014311118922622e-06 0.09530159220710262 2.014311218473493e-06 0.09453592511176086 \
2.014311308421543e-06 0.09384821103094763 2.014311380924943e-06 0.09329669945188329 2.014311462667009e-06 0.09267796846073476 2.014311590787245e-06 0.09171467366828615 \
2.014311672199308e-06 0.09110674702409056 2.014311746631215e-06 0.09055373306570065 2.0143118216051e-06 0.08999936228352182 2.014311901024075e-06 0.08941505746347288 \
2.014312009684932e-06 0.08862052380504259 2.014312104044904e-06 0.08793517800096999 2.014312193440026e-06 0.08728987318634121 2.014312300205743e-06 0.086524181682867 \
2.014312418708183e-06 0.08568073755029131 2.014312560233253e-06 0.08468224831562859 2.014312693371676e-06 0.08375174214918565 2.014312834217007e-06 0.08277682112810406 \
2.014312983268989e-06 0.08175525972387458 2.014313119066718e-06 0.08083369778093191 2.014313260523232e-06 0.0798830809748103 2.014313395783148e-06 0.07898330517332906 \
2.014313537164988e-06 0.07805242629322809 2.014313684232761e-06 0.07709434677344783 2.014313835960902e-06 0.07611680364043326 2.014314001309203e-06 0.07506403321855706 \
2.014314165176721e-06 0.07403332863189842 2.014314341490649e-06 0.07293832728335037 2.014314530925751e-06 0.07177777688466977 2.014314741692455e-06 0.07050569389938771 \
2.014314961464952e-06 0.06920150027616521 2.014315196433104e-06 0.06783224552442871 2.014315455333654e-06 0.06635227408830123 2.014315750264117e-06 0.06470266364809808 \
2.014316054610178e-06 0.06304001691994518 2.014316416556457e-06 0.06111393619706453 2.014316732684213e-06 0.05947639552636011 2.014317174006677e-06 0.0572596911373907 \
2.01431748757272e-06 0.05573556853365672 2.014317911072189e-06 0.0537382660685313 2.014318255024043e-06 0.05216649213267931 2.01431859526531e-06 0.05065508790922631 \
2.0143189061029e-06 0.04931137323461653 2.014319200574802e-06 0.04807062469528345 2.014319494274299e-06 0.04686392507224969 2.014319769145535e-06 0.04576537019482012 \
2.014320044685701e-06 0.04468949010490332 2.01432030977623e-06 0.04367785045825667 2.014320586533311e-06 0.04264571401740119 2.014320869801436e-06 0.04161414314527601 \
2.014321167794735e-06 0.04055545327485047 2.014321427280131e-06 0.03965542606183669 2.014321657303569e-06 0.03887446236327848 2.014321876995156e-06 0.03814321686473518 \
2.014322101935296e-06 0.0374128399305801 2.01432242218897e-06 0.0363978329183388 2.01432270998682e-06 0.03550963653148703 2.014322986382154e-06 0.03467738358988744 \
2.014323270201283e-06 0.03384352473043348 2.014323508310587e-06 0.03315996078327022 2.014323792621371e-06 0.03236211345273886 2.014324034533221e-06 0.03169864947531036 \
2.014324269673394e-06 0.03106710921041438 2.014324511380923e-06 0.03043352335444016 2.014324748333857e-06 0.02982731501219571 2.014324978676274e-06 0.02925002048968134 \
2.014325192426852e-06 0.02872465224286764 2.014325398273815e-06 0.02822791768061097 2.014325790610838e-06 0.02730524204782691 2.014325979002849e-06 0.02687312495148303 \
2.014326354614307e-06 0.02603163971789 2.014326529081082e-06 0.02564950258131362 2.014326953015541e-06 0.02474274850847508 2.014327073769958e-06 0.02449086781212801 \
2.014327544020722e-06 0.02353384026002922 2.014327693235786e-06 0.02323677291035493 2.014328086867998e-06 0.02246740853134286 2.014328257894343e-06 0.02213909006726131 \
2.014328745173274e-06 0.02121869533024997 2.014328887220983e-06 0.02095326544309953 2.014329420237252e-06 0.01997576278857772 2.014329542401289e-06 0.01975737097014436 \
2.014330064559033e-06 0.01885981776906158 2.014330235137336e-06 0.01857989792133653 2.014330722450399e-06 0.01781360777737795 2.014330893973323e-06 0.01755501440977742 \
2.01433151376008e-06 0.01666567753024489 2.014331684684406e-06 0.0164316648397145 2.014332390235396e-06 0.01551160061118263 2.014332552852409e-06 0.01530799450170666 \
2.014333309745899e-06 0.01439879525764199 2.014333450662544e-06 0.01423641007536438 2.014334350661384e-06 0.01324361033368418 2.014334438010635e-06 0.01315122959105692 \
2.014335342363989e-06 0.01223321097894121 2.014335479555938e-06 0.01209984223734439 2.014336450212214e-06 0.01118944790767422 2.014336578130092e-06 0.01107451071402888 \
2.014337728540039e-06 0.01011008206277823 2.014337822342075e-06 0.01003687265682024 2.014339078387887e-06 0.009120584045805383 2.014339215929201e-06 0.009026502753623255 \
2.014340774683602e-06 0.008029670037698805 2.014340858486287e-06 0.007977066150721189 2.014342463865106e-06 0.00699828665725172 2.01434257476345e-06 0.006935886594503895 \
2.014344507009824e-06 0.005959177461785255 2.014344686714759e-06 0.005876661013304485 2.014346798505876e-06 0.004981749118765498 2.014347141291011e-06 0.004848482978762325 \
2.014349654457045e-06 0.003966891390423618 2.014350124178715e-06 0.003819799497680527 2.01435376449499e-06 0.002847564273158896 2.014354280232175e-06 0.002731633924241866 \
2.014359622062014e-06 0.001773027297371861 2.014359907382299e-06 0.001729522787584184 2.014365136030129e-06 0.0007540451492352357 2.014365310176696e-06 0.0007162692714263865 \
2.017013698769002e-06 -0.0001123232525192561 2.01701387179429e-06 -0.0002901710972538241 2.017014491546045e-06 -0.001202022686018724 2.017014580115222e-06 -0.001365806793032466 \
2.017014941086355e-06 -0.002110727959526865 2.01701506578065e-06 -0.002395793696299351 2.017015429622531e-06 -0.003299857180474864 2.017015600898199e-06 -0.003758114451912169 \
2.017015894896038e-06 -0.004576312838821549 2.017016005104443e-06 -0.004886880824040592 2.017016283358441e-06 -0.005643955697619643 2.01701640463225e-06 -0.00594200199557267 \
2.017017498254348e-06 -0.00517389603226481 2.017017621358228e-06 -0.004409713243767066 2.017017744826303e-06 -0.003462788751204457 2.0170178649921e-06 -0.002366010162083454 \
2.017017962853768e-06 -0.001346276287748183 2.017018069556104e-06 -0.0001076498664581183 2.017018181397489e-06 0.001328007358939307 2.017018317371855e-06 0.003256083960376262 \
2.017018439401011e-06 0.00514709866632534 2.017018627817289e-06 0.008343062029134115 2.017018768805819e-06 0.01093380316938193 2.017018921577523e-06 0.01391176330477175 \
2.017019064280151e-06 0.01683596409946878 2.017019218632388e-06 0.02013443377634912 2.017019374426043e-06 0.02358734537610087 2.01701953048334e-06 0.02715365164079262 \
2.01701967788774e-06 0.03060642997674319 2.017019826504485e-06 0.03415780069914553 2.017019981925702e-06 0.03793559522944389 2.017020140311532e-06 0.04184227512730877 \
2.017020305251154e-06 0.04596085539464361 2.017020479500423e-06 0.05035714787605008 2.017020658443539e-06 0.05491177248689325 2.017020847583032e-06 0.0597604232635115 \
2.01702105036361e-06 0.06498910043066243 2.017021269735637e-06 0.07067233091134768 2.017021500572133e-06 0.07667464705993039 2.017021747383969e-06 0.0831083675499642 \
2.01702201751608e-06 0.09016243555275107 2.017022310704188e-06 0.0978236474935409 2.017022634359626e-06 0.1062798466079799 2.017022997926912e-06 0.1157689210849182 \
2.01702339022043e-06 0.1259925151671456 2.017023838699915e-06 0.1376538644086695 2.0170243603994e-06 0.1511757390224034 2.017024972772044e-06 0.1669844191341421 \
2.017025649417359e-06 0.1843663871188266 2.01702643632765e-06 0.2044554566749352 2.017027317548744e-06 0.2267919980918504 2.017028137292385e-06 0.2474048556006221 \
2.017028865745328e-06 0.2655829647002126 2.017029507221317e-06 0.2814688958417333 2.017030083144485e-06 0.2956305456066151 2.017030620401302e-06 0.3087428400511723 \
2.017031124292597e-06 0.3209487846516751 2.017031601896145e-06 0.3324328152479784 2.017032080019379e-06 0.343838772307344 2.017032532118229e-06 0.3545331600964184 \
2.01703300388452e-06 0.365596737404158 2.01703344758136e-06 0.3759140547845509 2.017033969549898e-06 0.3879344734281669 2.017034497087831e-06 0.399956933836353 \
2.017034876602574e-06 0.4085271910771138 2.017035405564175e-06 0.4203606102508351 2.017035874883255e-06 0.4307444005277802 2.017036310038791e-06 0.4402814026247405 \
2.017036757516117e-06 0.4500002273945978 2.017037197539592e-06 0.4594737646471725 2.017037600841335e-06 0.4680814138276727 2.017037919241102e-06 0.4748254127722248 \
2.017038289219015e-06 0.4826007100982719 2.017038525472097e-06 0.4875314737878706 2.017038760543493e-06 0.4924129045770672 2.017039011882831e-06 0.4975994385012801 \
2.017039318269866e-06 0.5038799449729535 2.017039575228319e-06 0.5091120301871851 2.017039783702615e-06 0.5133309170973237 2.017039984084905e-06 0.5173683849445317 \
2.017040126478606e-06 0.5202244049244739 2.017040275403072e-06 0.5231993726577677 2.017040486949329e-06 0.5274019882470222 2.017040713006952e-06 0.5318780389403845 \
2.017040907549334e-06 0.5357103559602913 2.017041096681229e-06 0.539423417888626 2.017041326128277e-06 0.5439012399750046 2.017041508634083e-06 0.5474563135343053 \
2.017041745996952e-06 0.5520623276458133 2.01704201499126e-06 0.5572695987004129 2.01704226390171e-06 0.5620706638085723 2.017042507918531e-06 0.5667633705755619 \
2.017042780273744e-06 0.5719926523718327 2.017043041669874e-06 0.5769928369418796 2.017043299301279e-06 0.5819084237686675 2.017043546144628e-06 0.586601202059797 \
2.017043791890354e-06 0.5912552023551558 2.017044018467874e-06 0.5955288021520931 2.017044249620064e-06 0.5998646534936181 2.017044455900444e-06 0.6037202012184053 \
2.017044684021204e-06 0.6079592993751251 2.017044906401185e-06 0.6120725203834017 2.017045133377667e-06 0.6162454422471376 2.017045348430617e-06 0.6201823359462864 \
2.01704557780019e-06 0.6243500782103125 2.017045846823065e-06 0.6292041961704016 2.017046069836712e-06 0.6331993632081415 2.017046282091289e-06 0.6369772451758789 \
2.017046493488879e-06 0.6407176358819484 2.017046693558109e-06 0.644236566349866 2.017046923151959e-06 0.6482486956559365 2.017047163988886e-06 0.6524328529570182 \
2.017047345738274e-06 0.6555667906748446 2.0170475342865e-06 0.6588018260593631 2.01704768736614e-06 0.6614154033769962 2.017047859374421e-06 0.6643352515471471 \
2.01704800954724e-06 0.6668697017322168 2.017048146064529e-06 0.6691578850264722 2.017048295693716e-06 0.6716547631652277 2.017048423434085e-06 0.673777752640997 \
2.017048563020222e-06 0.6760856948620949 2.01704868725891e-06 0.6781310478824312 2.017048818408749e-06 0.6802827752320969 2.017048942850093e-06 0.6823179209931315 \
2.017049080080916e-06 0.6845542421253382 2.017049200329086e-06 0.6865048414796368 2.017049341660529e-06 0.6887891282595083 2.017049441991641e-06 0.6904033553735033 \
2.017049563109343e-06 0.6923460943304175 2.017049653886878e-06 0.6937948943079848 2.017049751145344e-06 0.6953408241330762 2.017049847353224e-06 0.6968660703265798 \
2.017049935967068e-06 0.6982647859968389 2.017050033255091e-06 0.6997938110311075 2.01705016572373e-06 0.7018622871835729 2.017050320913928e-06 0.7042674555997347 \
2.017050458791879e-06 0.7063866855441746 2.017050603646153e-06 0.7085960165693863 2.01705073070791e-06 0.7105202221428537 2.01705085539347e-06 0.7123960184768648 \
2.017050968098846e-06 0.7140814553427599 2.017051079889191e-06 0.7157437310299281 2.01705118066784e-06 0.7172341607972841 2.017051317946296e-06 0.7192525454101454 \
2.017051437630367e-06 0.7210013704967912 2.017051557059838e-06 0.7227365757678518 2.01705168394306e-06 0.7245692610776365 2.017051808360712e-06 0.7263556789600311 \
2.017051932093536e-06 0.728121726658988 2.017052058689063e-06 0.7299181396522603 2.017052189074464e-06 0.7317573312219798 2.017052311884284e-06 0.7334798522758219 \
2.01705244732006e-06 0.7353678990088863 2.017052548609838e-06 0.7367723836293941 2.017052656232334e-06 0.7382576460517265 2.017052745760416e-06 0.7394878879617913 \
2.017052860308785e-06 0.7410528648863303 2.017052948337041e-06 0.7422487366778059 2.017053055415107e-06 0.7436953530868765 2.0170531854801e-06 0.7454403311053276 \
2.017053296759795e-06 0.7469230742113165 2.017053401378355e-06 0.7483084058091373 2.01705352546134e-06 0.7499400420429273 2.017053673762168e-06 0.7518749696944975 \
2.017053795162033e-06 0.7534462209622173 2.01705390960278e-06 0.7549170836379747 2.017054049940098e-06 0.7567069362027918 2.017054191702981e-06 0.7584995177563068 \
2.017054309503919e-06 0.759977341175643 2.017054437480785e-06 0.761570846386187 2.017054579183209e-06 0.7633205808366864 2.017054696694523e-06 0.7647599110190483 \
2.017054842299792e-06 0.7665289162262866 2.017054963994099e-06 0.7679951561698679 2.017055082724709e-06 0.7694149786178283 2.017055205011304e-06 0.7708662727382939 \
2.01705533205582e-06 0.77236234268503 2.017055441699792e-06 0.7736439866494906 2.017055567386705e-06 0.7751025186690397 2.017055673401805e-06 0.776323977486031 \
2.017055808987772e-06 0.7778743028704433 2.017055933950768e-06 0.7792913979962601 2.017056059856921e-06 0.7807070123991936 2.017056175124167e-06 0.7819915514687489 \
2.01705628142864e-06 0.7831664991275713 2.017056419833432e-06 0.7846822315516878 2.017056569129882e-06 0.7862997378875561 2.017056714637328e-06 0.7878588534534761 \
2.017056834041839e-06 0.7891257303126159 2.017056969134664e-06 0.7905455128963393 2.017057090387826e-06 0.7918076974797237 2.017057233381105e-06 0.7932816011184505 \
2.01705737758541e-06 0.7947523458802197 2.017057503122239e-06 0.7960199014141693 2.017057622168612e-06 0.7972110037065316 2.017057734104495e-06 0.7983213107123885 \
2.017057838976047e-06 0.7993531099923881 2.017057934226459e-06 0.8002831901653534 2.017058070569705e-06 0.8016020813281191 2.017058187393835e-06 0.8027203407102198 \
2.017058306798445e-06 0.803852171037294 2.017058428905249e-06 0.8049980820693966 2.017058551860251e-06 0.8061401395390313 2.017058678828951e-06 0.8073073595000361 \
2.01705880406856e-06 0.8084467645495962 2.017058934640955e-06 0.8096220968518901 2.017059060631474e-06 0.8107441738369082 2.017059188817386e-06 0.8118738099374113 \
2.017059294347114e-06 0.8127947795787664 2.017059397218887e-06 0.8136847278655364 2.017059490214057e-06 0.8144826950388273 2.017059614010659e-06 0.8155354283166244 \
2.017059701978918e-06 0.8162769513478326 2.017059800709989e-06 0.8171027376706747 2.017059943975142e-06 0.8182889948057973 2.017060079253827e-06 0.8193962136425846 \
2.01706018836845e-06 0.8202800249700468 2.017060336451758e-06 0.8214657808291811 2.017060486222685e-06 0.8226492530953341 2.017060611457286e-06 0.8236267526687548 \
2.017060755448703e-06 0.8247372275730155 2.017060879504774e-06 0.8256825756473101 2.017061029968032e-06 0.8268152483647575 2.017061165678884e-06 0.8278240064655301 \
2.017061290697392e-06 0.828742521381556 2.017061408452322e-06 0.8295983347934622 2.017061554429135e-06 0.8306466023667578 2.017061720938452e-06 0.8318251482734692 \
2.017061851861028e-06 0.8327390940956469 2.017062025288466e-06 0.8339327615268647 2.017062193435348e-06 0.8350717495747054 2.017062363270277e-06 0.8362042975620877 \
2.017062544195048e-06 0.8373912937861997 2.017062687293307e-06 0.8383160748488641 2.017062801379198e-06 0.8390446117604563 2.017062931553184e-06 0.8398665237782376 \
2.017063033394266e-06 0.8405024977857931 2.017063150213615e-06 0.8412243379523001 2.017063287078045e-06 0.8420597162999857 2.017063484876669e-06 0.8432475311273343 \
2.01706367648074e-06 0.8443767279905872 2.017063885921221e-06 0.8455874169714939 2.017064067846852e-06 0.8466193100105236 2.017064264979958e-06 0.8477171434207121 \
2.017064438329848e-06 0.8486653666163242 2.017064621329232e-06 0.8496493024239481 2.017064792495495e-06 0.8505537352954988 2.017064967127282e-06 0.8514606693963016 \
2.017065142389669e-06 0.8523550102558151 2.017065318541785e-06 0.8532381479010797 2.017065508812824e-06 0.8541746551565574 2.017065699414775e-06 0.85509499218684 \
2.017065900062401e-06 0.8560449689899254 2.017066092672966e-06 0.8569390259424264 2.017066303330652e-06 0.8578972157030333 2.017066531456051e-06 0.8589122247267402 \
2.017066797213369e-06 0.8600655879592763 2.017067095837813e-06 0.8613244245924475 2.017067372169332e-06 0.862454900702886 2.01706765640239e-06 0.8635842083919951 \
2.017067930614306e-06 0.8646423892283146 2.017068202842372e-06 0.8656634505877856 2.017068473051191e-06 0.8666487272755322 2.017068730204067e-06 0.8675609437488442 \
2.017069002786335e-06 0.868501515423508 2.017069278771335e-06 0.8694269133137555 2.017069548872912e-06 0.8703069289141475 2.017069848734863e-06 0.8712546000783432 \
2.017070219768993e-06 0.8723856543073821 2.017070514706754e-06 0.8732530157608677 2.017070768997536e-06 0.8739790309043101 2.017071067254951e-06 0.8748056771600844 \
2.017071340863485e-06 0.8755409825400007 2.017071576991549e-06 0.8761583495732972 2.017071817336931e-06 0.876770807053994 2.017072039670212e-06 0.8773233906735478 \
2.01707223367596e-06 0.8777948466981503 2.017072563398506e-06 0.8785737911727464 2.017072718571944e-06 0.8789308835864816 2.017073036347473e-06 0.8796437246174529 \
2.01707321520917e-06 0.8800342982281311 2.017073557671047e-06 0.8807611334253193 2.017073741799519e-06 0.8811407335605206 2.017074216677857e-06 0.8820849466541889 \
2.017074384074053e-06 0.8824061830950772 2.017074849915457e-06 0.8832696475595492 2.017075030737665e-06 0.8835931319180218 2.017075524775914e-06 0.8844450822729043 \
2.017075666124327e-06 0.8846804878101884 2.017076272457385e-06 0.8856498028150036 2.017076424526725e-06 0.8858829444029697 2.0170770712152e-06 0.8868329272509302 \
2.017077199509723e-06 0.8870138524519416 2.017077847626928e-06 0.8878919388991984 2.017077977425792e-06 0.8880607713689423 2.017078755627481e-06 0.8890227771434612 \
2.017078870684414e-06 0.8891574578072456 2.017079726342848e-06 0.8901003239091128 2.017079871707616e-06 0.8902505899439886 2.01708085746403e-06 0.8911948786459364 \
2.01708107856904e-06 0.8913892999646706 2.017082223696019e-06 0.8923206810037944 2.017082354912619e-06 0.892422953350996 2.017083696124267e-06 0.8934189515818408 \
2.017083847523211e-06 0.8935240845833778 2.017085328961459e-06 0.8944568913393511 2.017085567840892e-06 0.8945912088657246 2.017087337161074e-06 0.8954685138428928 \
2.017087726310841e-06 0.895637400736999 2.017090119976628e-06 0.896526474291006 2.01709059568945e-06 0.8966764365754722 2.017094011699057e-06 0.8975478548673914 \
2.017094658849072e-06 0.8976786076740833 2.017102137013678e-06 0.8986646932675814 2.017102809590797e-06 0.8987192862546014 2.017195253995367e-06 0.8997188196574962 \
2.017195917228051e-06 0.8997241906476866 2.017385126389945e-06 0.900686595210158 2.017385288462789e-06 0.9007292695325627 2.017387933983676e-06 0.8998161167154269 \
2.017388102533154e-06 0.8996881690130656 2.017389379285545e-06 0.8987393243250013 2.017389581451881e-06 0.8986030018074492 2.017391189561267e-06 0.8976721249252815 \
2.017391381667193e-06 0.8975774045828077 2.017406495049839e-06 0.8985726115129884 2.017406683108756e-06 0.8986004060702872 2.017417988037768e-06 0.8995874924221801 \
2.017418361423516e-06 0.8996034751727418 2.017907373786698e-06 0.9005892719715856 2.017907484554897e-06 0.9006868984798269 2.017908237227259e-06 0.9015617873136611 \
2.017908339021945e-06 0.9017086238768567 2.01790887442049e-06 0.9025814930725723 2.017908976929663e-06 0.9027670217776843 2.017909369148482e-06 0.9035254014384071 \
2.017909509991429e-06 0.9038129158713877 2.017909951028881e-06 0.9047472953155866 2.017910136514484e-06 0.9051402477015744 2.017910652827601e-06 0.9061269394579334 \
2.017910737502694e-06 0.9062564181617988 2.017911972174744e-06 0.9053011091537977 2.017912129388156e-06 0.9045688862145235 2.017912321204818e-06 0.9034162411061901 \
2.017912488045349e-06 0.9021712267446264 2.017912635003746e-06 0.9008824031243315 2.017912749119943e-06 0.8997575350477262 2.017912878992032e-06 0.8983446880789033 \
2.01791299010955e-06 0.8970273815442567 2.017913082914029e-06 0.8958483937359277 2.017913171236719e-06 0.8946639786015808 2.017913274417478e-06 0.8932058048613533 \
2.017913366625413e-06 0.8918333298588224 2.01791345419561e-06 0.8904732289418564 2.017913568189077e-06 0.8886245408236838 2.017913729993501e-06 0.8858564722885236 \
2.017913914992117e-06 0.8825005184224666 2.017914107151785e-06 0.8788219124347386 2.017914308599139e-06 0.874780227084481 2.017914515009728e-06 0.8704697801294994 \
2.017914700181681e-06 0.8664790122147591 2.017914884689405e-06 0.862405115500708 2.017915057841296e-06 0.8585071391690239 2.017915242887321e-06 0.8542751393552932 \
2.017915420261525e-06 0.8501657390392787 2.017915597007955e-06 0.8460284987362284 2.017915763166606e-06 0.8421077870518131 2.017915925211044e-06 0.8382599993991456 \
2.017916091783925e-06 0.8342839555277276 2.017916250437662e-06 0.8304816347052207 2.017916441313687e-06 0.8258903812682129 2.017916616297258e-06 0.8216694867670907 \
2.017916786243393e-06 0.8175615830390965 2.017916951419568e-06 0.8135626411663678 2.017917124611674e-06 0.8093650119631921 2.017917295673877e-06 0.8052155696745213 \
2.017917463774914e-06 0.801136095357175 2.017917654109863e-06 0.7965156511928794 2.017917837691807e-06 0.7920591698039 2.017918045682732e-06 0.7870113041480956 \
2.017918268259242e-06 0.7816114142545842 2.017918457674258e-06 0.7770174196885687 2.017918650984654e-06 0.7723312127316435 2.017918794430241e-06 0.7688556734481145 \
2.017918943853591e-06 0.7652374066097742 2.017919063006063e-06 0.7623536300085233 2.017919175722544e-06 0.7596269484184472 2.017919284997451e-06 0.7569846861296079 \
2.017919421027209e-06 0.753697254849378 2.017919533823024e-06 0.750972995067179 2.01791965602098e-06 0.7480232093637929 2.017919767605753e-06 0.7453311011793381 \
2.017919892312215e-06 0.7423241425761796 2.017920046694167e-06 0.7386034578119585 2.017920213478233e-06 0.7345862494782525 2.017920430642921e-06 0.7293605768817599 \
2.01792062520351e-06 0.7246835946359503 2.017920785534396e-06 0.7208333202545074 2.017920960959998e-06 0.7166251500492028 2.017921150723573e-06 0.7120779400724765 \
2.017921339451897e-06 0.7075610435995559 2.017921521273264e-06 0.7032145396962334 2.017921705870676e-06 0.6988062725207448 2.017921842953811e-06 0.6955348514212173 \
2.017921996242049e-06 0.6918805091472418 2.017922191613795e-06 0.6872279990818534 2.017922347770547e-06 0.6835136309588888 2.017922505722766e-06 0.6797605476340507 \
2.01792270397403e-06 0.6750570282453686 2.017922897319928e-06 0.6704763548785364 2.017923133825274e-06 0.6648822204491218 2.017923320030378e-06 0.6604858901039825 \
2.017923557652698e-06 0.6548824851665868 2.017923744451452e-06 0.6504854738275335 2.017923925009212e-06 0.6462424706993735 2.017924088085156e-06 0.6424159959781919 \
2.017924232696721e-06 0.6390271817202816 2.017924373299071e-06 0.6357379642635244 2.017924500108657e-06 0.632774906490579 2.017924632245193e-06 0.6296924762754078 \
2.017924758489145e-06 0.6267508340255646 2.017924889752774e-06 0.6236963630311418 2.017925018850514e-06 0.6206978048938425 2.017925158276179e-06 0.6174624210713571 \
2.017925306646171e-06 0.6140261568477932 2.01792550120306e-06 0.6095278574984737 2.017925644648937e-06 0.6062198040692683 2.017925879109183e-06 0.6008245134060309 \
2.017926051007495e-06 0.5968818013610552 2.017926263928033e-06 0.5920102583789468 2.017926436394651e-06 0.5880775912131976 2.017926566719198e-06 0.5851108450968721 \
2.017926698275517e-06 0.5821241897920357 2.017926808505599e-06 0.5796262478458715 2.017926904159847e-06 0.5774603558442819 2.017927003393806e-06 0.5752182923213994 \
2.017927086311908e-06 0.5733484809858778 2.017927165227534e-06 0.5715706040143225 2.017927228156309e-06 0.5701535626562365 2.017927293664786e-06 0.5686800671140783 \
2.017927374150839e-06 0.5668736364148982 2.017927424016846e-06 0.5657560592102344 2.017927473205615e-06 0.5646541775062763 2.017927534675401e-06 0.5632780399140616 \
2.01792758259693e-06 0.5622058085646952 2.017927633441648e-06 0.5610687758404553 2.017927692541903e-06 0.5597501790023616 2.01792775115623e-06 0.5584442118409422 \
2.017927826782323e-06 0.5567607189607793 2.017927897341035e-06 0.5551915720267918 2.017927986471042e-06 0.5532116467156011 2.01792807569462e-06 0.5512351177508077 \
2.017928160998231e-06 0.5493490637975145 2.017928248625197e-06 0.5474138635528197 2.01792834562712e-06 0.545274424894262 2.017928449972891e-06 0.5429792414815097 \
2.017928566264316e-06 0.5404269323775457 2.017928672601932e-06 0.5380963700835184 2.017928784310815e-06 0.5356536306660374 2.017928896605295e-06 0.5332047801427824 \
2.017929023802854e-06 0.5304364255197962 2.017929146572528e-06 0.5277698476303582 2.017929288796925e-06 0.5246912237717902 2.017929425160057e-06 0.5217463069543907 \
2.017929577381124e-06 0.5184691491721333 2.017929737017329e-06 0.5150420887864461 2.017929912992522e-06 0.5112761258030903 2.017930101501109e-06 0.5072591542828934 \
2.01793030856769e-06 0.5028616940969075 2.017930533509663e-06 0.4981043078903621 2.017930784905619e-06 0.4928144328841237 2.017931021331185e-06 0.4878598554762091 \
2.017931318494919e-06 0.4816683149127979 2.017931609172212e-06 0.4756487143466775 2.017931917027196e-06 0.469313240945046 2.017932230852953e-06 0.4628991126846517 \
2.017932559994313e-06 0.4562163541974347 2.01793289337242e-06 0.4494927613461197 2.017933224999028e-06 0.4428490490857003 2.017933546548425e-06 0.4364504708187015 \
2.017933874224238e-06 0.4299742838549845 2.017934221843861e-06 0.4231546934710667 2.017934555065174e-06 0.4166645133789623 2.017934900974402e-06 0.4099771621835854 \
2.017935346388222e-06 0.4014400148089548 2.017935704178092e-06 0.3946500490499754 2.017936018334912e-06 0.3887397205534429 2.017936402745391e-06 0.3815756289527631 \
2.017936732720036e-06 0.3754830843203271 2.017937017930125e-06 0.3702633801070484 2.017937326220382e-06 0.3646649204592909 2.017937606017443e-06 0.3596257204303125 \
2.017937832011793e-06 0.3555880084110294 2.017938046849748e-06 0.3517755993421203 2.01793824528482e-06 0.3482769933469286 2.017938449224337e-06 0.3447071465415313 \
2.017938659760396e-06 0.3410461989361561 2.017938916734521e-06 0.3366091000429626 2.017939157995129e-06 0.3324763702393667 2.017939389568845e-06 0.3285420159269506 \
2.017939604222291e-06 0.3249208057821749 2.017939825046275e-06 0.3212218866489027 2.017940026292867e-06 0.3178749657716667 2.017940229382121e-06 0.3145250552959265 \
2.017940427226992e-06 0.3112865758726304 2.017940614079937e-06 0.3082497660855442 2.017940808016662e-06 0.3051208532403978 2.017941011761317e-06 0.30185834615803 \
2.017941190488583e-06 0.2990186060348319 2.017941428134379e-06 0.2952727068736475 2.017941627896611e-06 0.2921508861588616 2.017941829525427e-06 0.2890253490052915 \
2.017942054991886e-06 0.285561995332 2.017942221086285e-06 0.2830312764183137 2.017942399705387e-06 0.2803277612349699 2.017942581409589e-06 0.2775983111934518 \
2.017942770043305e-06 0.2747882307029562 2.017942947466508e-06 0.2721695222189568 2.017943124659645e-06 0.2695724116247911 2.01794328473156e-06 0.2672552081803913 \
2.017943405132239e-06 0.2655193337608355 2.017943552958303e-06 0.2633957862580221 2.017943681588076e-06 0.2615692882062232 2.017943783793658e-06 0.2601227034409412 \
2.017943902028939e-06 0.2584516051170885 2.0179440224823e-06 0.2567534139348401 2.017944146190618e-06 0.2550183706610066 2.017944264442643e-06 0.2533694204037282 \
2.017944392295773e-06 0.2515887492000971 2.017944512581604e-06 0.249915736161692 2.01794466526121e-06 0.2477917697339537 2.017944800173988e-06 0.2459264316518071 \
2.01794492881341e-06 0.2441493177932957 2.017945086528788e-06 0.2419705448111171 2.017945213210091e-06 0.2402201997919771 2.017945348536159e-06 0.2383592392624043 \
2.017945487448727e-06 0.2364550510890953 2.017945605221031e-06 0.2348405558720491 2.01794576449185e-06 0.2326580599570062 2.017945901013704e-06 0.2307878375452989 \
2.01794604224565e-06 0.2288626996658652 2.017946148058693e-06 0.2274220928889542 2.01794627840164e-06 0.2256484734765637 2.017946378112453e-06 0.2242944442559471 \
2.017946480933888e-06 0.2228991027388591 2.017946554349542e-06 0.2219046249368765 2.017946634181104e-06 0.2208265149641777 2.017946704228335e-06 0.2198809561195558 \
2.017946754631426e-06 0.2192009305305119 2.017946806883225e-06 0.2184966408607167 2.017946886120743e-06 0.2174292050927151 2.017946927964696e-06 0.2168658036437602 \
2.017946967304648e-06 0.216336351877609 2.017947010340057e-06 0.2157575332679269 2.017947054507484e-06 0.2151638767852215 2.017947128273224e-06 0.2141731338947761 \
2.017947163785221e-06 0.2136967174286463 2.017947211500021e-06 0.2130606706933813 2.017947272229561e-06 0.2122518321687151 2.017947340486787e-06 0.2113438957752176 \
2.017947413008566e-06 0.2103801801047663 2.017947485683193e-06 0.2094152724966429 2.017947593999181e-06 0.2079788886429202 2.017947691670323e-06 0.20668564243436 \
2.017947803221819e-06 0.2052110974836689 2.017947901757253e-06 0.2039136008387587 2.017948005250393e-06 0.2025572972554956 2.017948101152128e-06 0.2013021587886929 \
2.017948203780057e-06 0.1999606878451601 2.01794830660317e-06 0.1986207062101238 2.017948416722797e-06 0.1971897063011611 2.017948525418353e-06 0.1957815523781236 \
2.017948645095582e-06 0.1942360962608612 2.01794875537326e-06 0.192818053470401 2.017948863436481e-06 0.1914343471929882 2.017948988535149e-06 0.1898375077741012 \
2.017949078504982e-06 0.1886931806549971 2.017949157191935e-06 0.1876950225942949 2.017949234476806e-06 0.1867173468865102 2.017949320985383e-06 0.1856271834369256 \
2.017949419934593e-06 0.1843848109964498 2.017949490443458e-06 0.1835017733581451 2.017949561894512e-06 0.1826096997732476 2.017949667039846e-06 0.1813018727451555 \
2.017949746279476e-06 0.1803200401832796 2.01794982736337e-06 0.1793174195483187 2.01794992085531e-06 0.1781663090788374 2.017950021631285e-06 0.1769308188703378 \
2.017950171343389e-06 0.175105380089017 2.017950287132704e-06 0.1737009932372819 2.017950438138081e-06 0.1718807311127691 2.0179505492465e-06 0.1705485445502526 \
2.017950691372958e-06 0.168854666407182 2.017950809031379e-06 0.167460358327668 2.017950913935975e-06 0.1662230887079887 2.017951008998573e-06 0.1651069099307241 \
2.017951102429828e-06 0.1640147999883682 2.01795120347649e-06 0.1628388413495604 2.017951299823398e-06 0.1617223204899406 2.017951396975644e-06 0.1606011553546776 \
2.017951480024216e-06 0.1596469772300165 2.01795159006187e-06 0.1583897228513109 2.017951672364432e-06 0.1574542248873526 2.017951777364141e-06 0.156267858580057 \
2.01795185506021e-06 0.1553950893374849 2.017951937879689e-06 0.1544690878994293 2.017952019541594e-06 0.1535604570452941 2.017952108890885e-06 0.152571060794856 \
2.01795218460332e-06 0.1517364980793458 2.017952267165934e-06 0.1508307726525361 2.017952343747367e-06 0.1499942554682341 2.017952412035254e-06 0.1492531084507001 \
2.017952505402266e-06 0.1482449401818621 2.017952574555677e-06 0.1475015570698688 2.017952650180008e-06 0.1466917482325688 2.017952711729129e-06 0.1460354497178591 \
2.017952778977892e-06 0.1453208357145237 2.017952850039892e-06 0.1445684785944268 2.01795292553732e-06 0.143772322008306 2.01795298444886e-06 0.1431546944759192 \
2.01795306112247e-06 0.1423563022825049 2.017953141443211e-06 0.1415233898163201 2.01795321459452e-06 0.1407682091691316 2.017953308750941e-06 0.139800669784813 \
2.017953380355125e-06 0.1390684367429364 2.017953453815901e-06 0.1383201464810226 2.017953537327651e-06 0.1374732033664194 2.017953626806796e-06 0.1365744208092838 \
2.0179536918717e-06 0.1359252211013016 2.017953803997723e-06 0.1348115665849295 2.017953869183864e-06 0.1341670699454539 2.017953939222108e-06 0.1334770515823289 \
2.017953999527163e-06 0.1328849371768329 2.017954054537987e-06 0.1323464455745446 2.017954142654965e-06 0.1314871014507438 2.01795418344126e-06 0.131090685705856 \
2.017954287144011e-06 0.1300923774523848 2.01795433045658e-06 0.1296773144713907 2.017954391675178e-06 0.1290920262082728 2.017954436511897e-06 0.1286643765206081 \
2.017954524107923e-06 0.127831527987147 2.017954565661879e-06 0.1274377589706847 2.017954625523389e-06 0.1268718307679372 2.017954697367115e-06 0.1261946708524367 \
2.017954753579841e-06 0.1256664967939027 2.01795481606734e-06 0.125081039250218 2.017954890295323e-06 0.1243877959456236 2.017954964976328e-06 0.1236954937854857 \
2.017955052159541e-06 0.1228905551604285 2.017955120558092e-06 0.1222610287411191 2.017955201128775e-06 0.1215216597888775 2.017955282424256e-06 0.120778012781285 \
2.017955349340781e-06 0.1201677797529914 2.017955432157726e-06 0.1194156054679852 2.017955491346448e-06 0.1188799972037829 2.017955557267448e-06 0.1182853617472536 \
2.017955637141492e-06 0.1175675408705869 2.01795571363729e-06 0.1168828806096336 2.0179557950994e-06 0.1161574242846086 2.017955893570281e-06 0.1152852106851665 \
2.01795596868063e-06 0.114622623867465 2.01795607166842e-06 0.1137180076826871 2.017956145852371e-06 0.1130691786503039 2.017956243471825e-06 0.1122190343868764 \
2.01795633928278e-06 0.1113890351962442 2.017956435131205e-06 0.110562946039519 2.017956516069412e-06 0.1098685209805978 2.017956604452683e-06 0.1091134439098378 \
2.017956703052661e-06 0.108274944429282 2.017956775836866e-06 0.1076586405352824 2.017956865109775e-06 0.1069058608836731 2.017956927091788e-06 0.1063852406583179 \
2.017956989684956e-06 0.1058613310701875 2.017957074907104e-06 0.105150777260444 2.017957180369478e-06 0.1042758147594986 2.017957260199961e-06 0.1036167065755082 \
2.017957340914214e-06 0.1029530974056021 2.01795742352795e-06 0.1022768941101355 2.017957493972562e-06 0.1017026162492672 2.017957597231928e-06 0.1008648142128753 \
2.017957670072054e-06 0.1002767039768694 2.017957755712335e-06 0.09958839426015198 2.017957874514073e-06 0.09863954321822334 2.017957942151898e-06 0.09810250133474645 \
2.01795801190202e-06 0.09755100310752296 2.017958089237e-06 0.09694230106952094 2.017958181657254e-06 0.09621870517595056 2.017958253354782e-06 0.09566033062548993 \
2.017958339171942e-06 0.09499542738017568 2.017958441597192e-06 0.09420660575030523 2.017958534892083e-06 0.09349264652734962 2.017958631208556e-06 0.09276005482712441 \
2.017958708110817e-06 0.09217843893134048 2.017958801590805e-06 0.09147541043939374 2.017958880833232e-06 0.09088281005358793 2.017958995455426e-06 0.0900310686188453 \
2.017959125063686e-06 0.08907580221142102 2.017959258320877e-06 0.08810234090122065 2.017959402350766e-06 0.08705990691030199 2.01795955951891e-06 0.08593388720602639 \
2.017959709295387e-06 0.08487214151476249 2.017959871762979e-06 0.08373303262435308 2.017960014942984e-06 0.08273971668837025 2.017960167622107e-06 0.0816913199659166 \
2.017960301891878e-06 0.08077856892457436 2.017960443644156e-06 0.07982444400446118 2.017960578643816e-06 0.07892500874648442 2.017960720601214e-06 0.07798882638923543 \
2.017960867448644e-06 0.07703088995320664 2.017961019894053e-06 0.07604750978240994 2.017961185112776e-06 0.07499422991502351 2.017961349250621e-06 0.07396067809208305 \
2.017961526112024e-06 0.07286119333145537 2.01796171645358e-06 0.07169407515132428 2.017961927410093e-06 0.07042030845332216 2.017962147819232e-06 0.0691121699798517 \
2.017962383344393e-06 0.06773900533435212 2.017962643793767e-06 0.0662496528900723 2.017962939459177e-06 0.06459579389282195 2.017963244581463e-06 0.06292902455725519 \
2.017963609576024e-06 0.06098725515092194 2.017964004456839e-06 0.05894944116461652 2.017964410847493e-06 0.05692211719668253 2.017964826573035e-06 0.05491854459141238 \
2.017965189379358e-06 0.0532251207245777 2.017965533980648e-06 0.05166301626031383 2.01796584916051e-06 0.05027284652491828 2.017966144689875e-06 0.04900240867073854 \
2.017966442670383e-06 0.04775344010203557 2.017966718469173e-06 0.04662857640242725 2.017966997243768e-06 0.04551884372531381 2.017967261178638e-06 0.04449205559535935 \
2.017967537201376e-06 0.04344260531795661 2.01796781615763e-06 0.04240676967887352 2.017968129850963e-06 0.04127097799875453 2.01796836585125e-06 0.04043636567030678 \
2.017968621645988e-06 0.03955075129286261 2.017968881769487e-06 0.03867033103466553 2.01796915190476e-06 0.03778142289416799 2.017969431124747e-06 0.03688501536902895 \
2.017969712963396e-06 0.03600226561751176 2.017969989839066e-06 0.03515600409566183 2.017970268932665e-06 0.03432349610146775 2.017970501810273e-06 0.03364444121149882 \
2.017970785646989e-06 0.03283527291840588 2.017971025751924e-06 0.03216626441466421 2.017971265550747e-06 0.0315119836023277 2.01797150482792e-06 0.03087436846876356 \
2.017971740084942e-06 0.03026290129608995 2.017971971011964e-06 0.02967475842909434 2.017972186001007e-06 0.02913788335257221 2.017972588155459e-06 0.02816043724496065 \
2.017972786878278e-06 0.02768988489927659 2.017973160561294e-06 0.0268265706552881 2.017973347359617e-06 0.02640514011949098 2.017973694919304e-06 0.02563810810034544 \
2.017973816848767e-06 0.0253740445387235 2.017974199320207e-06 0.02456430406701914 2.017974370028237e-06 0.02421180751242828 2.017974827125621e-06 0.02328894863848502 \
2.017975012758007e-06 0.0229225623309489 2.01797537621526e-06 0.02221803970155307 2.017975596582613e-06 0.02179832126591805 2.017976054308969e-06 0.02093867417890744 \
2.017976189728599e-06 0.02068687731869814 2.017976719624047e-06 0.01972418011126781 2.017976838945017e-06 0.01951377505543128 2.017977404730696e-06 0.01856069823426573 \
2.017977569110437e-06 0.0182962226476828 2.017978187655734e-06 0.01735107502432094 2.017978357709933e-06 0.01710418363667701 2.017978889842166e-06 0.01636278834442301 \
2.017979086926142e-06 0.01610013864443424 2.017979810045215e-06 0.01517806887136661 2.017979974675381e-06 0.01497647803580381 2.017980723800768e-06 0.01409711804523418 \
2.01798085710012e-06 0.01394643716836554 2.017981717353759e-06 0.01301449210748497 2.017981852457379e-06 0.01287422877142914 2.01798279503482e-06 0.01193816285908547 \
2.017982958630574e-06 0.01178202925388569 2.017983959987201e-06 0.0108653384673985 2.017984097529988e-06 0.01074500730514941 2.017985319636371e-06 0.009765086624518643 \
2.017985426589084e-06 0.00968516078425012 2.017986830780578e-06 0.008707372520026449 2.017986935611284e-06 0.008639312158696611 2.017988470448246e-06 0.00767719340797631 \
2.017988565731548e-06 0.007617466071856052 2.017990174528868e-06 0.006680264535635283 2.017990308605608e-06 0.006609506832171614 2.017992405618559e-06 0.005610918814474722 \
2.017992636163191e-06 0.005510783990371394 2.017994959158435e-06 0.004586584533412417 2.017995440488638e-06 0.004413562233393853 2.017998278050269e-06 0.003511943147855551 \
2.017998822969955e-06 0.003360532104877318 2.018002947178351e-06 0.002408309874554541 2.018003490902011e-06 0.002305347543005144 2.018009362191237e-06 0.001333291345955189 \
2.018009605056421e-06 0.001286469439319215 2.018023932948772e-06 0.0002880570268237783 2.018024077507414e-06 0.0002853642807229123 2.020661356428513e-06 -0.0006859155495331031 \
2.02066149598365e-06 -0.000901903561740745 2.020662005077582e-06 -0.001859438188174024 2.020662094565085e-06 -0.002052812934985279 2.020662457959945e-06 -0.00291126965001638 \
2.020662548982015e-06 -0.003143482006111167 2.020662914420052e-06 -0.004127275145644371 2.020663024680619e-06 -0.004436819103926468 2.020663336727774e-06 -0.005309594399865315 \
2.020663439442621e-06 -0.005584800160857357 2.020663803290477e-06 -0.006384516484886619 2.020663968081209e-06 -0.006586298968823262 2.020664547677408e-06 -0.005791490933239759 \
2.020664722787551e-06 -0.004914057272375438 2.020664839479485e-06 -0.004132845175365214 2.02066496606409e-06 -0.003100877896798674 2.020665067873013e-06 -0.002132773363901063 \
2.020665188361723e-06 -0.0008283127610571584 2.020665278808799e-06 0.0002599396317828252 2.020665376698931e-06 0.001541559978017447 2.02066547576324e-06 0.002943971508909197 \
2.020665646570516e-06 0.005594911825788154 2.020665868338539e-06 0.00944046646559993 2.020666064242385e-06 0.01317281463966807 2.020666223123766e-06 0.01639870563256729 \
2.020666387552263e-06 0.01989779506365397 2.020666541918293e-06 0.02331070396473752 2.020666700690818e-06 0.02693200463312963 2.020666847428777e-06 0.03036422445567413 \
2.020666996052748e-06 0.0339113704936035 2.020667151667245e-06 0.03768995713197771 2.020667308909259e-06 0.04156499463828727 2.020667473802058e-06 0.04567927910670353 \
2.020667647221578e-06 0.05005184210758699 2.020667825915293e-06 0.05459761989277153 2.020668014531131e-06 0.05943075613080645 2.020668215431274e-06 0.06460909294799391 \
2.020668434888065e-06 0.0702927970720964 2.020668664434352e-06 0.07626037976612585 2.020668910133291e-06 0.08266408948881369 2.02066917869823e-06 0.08967663153997742 \
2.020669470040145e-06 0.09728936802005522 2.020669791708172e-06 0.1056939239977524 2.020670152022263e-06 0.1150987971742611 2.020670543001701e-06 0.1252892839303718 \
2.020670986416517e-06 0.1368209045172546 2.020671502729605e-06 0.1502062239570841 2.020672108934821e-06 0.16586000516691 2.020672780191848e-06 0.1831102247110778 \
2.020673559691505e-06 0.20301830483439 2.020674432001389e-06 0.2251413938832897 2.020675262336714e-06 0.2460320778586349 2.020675993667063e-06 0.264292249712138 \
2.020676641612843e-06 0.280346965484095 2.020677224923317e-06 0.29469740877147 2.020677760655584e-06 0.3077798509628869 2.020678263914169e-06 0.3199778888071559 \
2.02067874911767e-06 0.3316516836183861 2.020679228040376e-06 0.3430829066939081 2.020679674471008e-06 0.3536501814456421 2.020680148800718e-06 0.3647819492304352 \
2.020680597991712e-06 0.3752331958288908 2.020681088463969e-06 0.3865396207984229 2.020681617036723e-06 0.3985997842463301 2.020681988181062e-06 0.4069920784971888 \
2.020682515935418e-06 0.4188173133762567 2.020682978292178e-06 0.4290642331729484 2.020683450624318e-06 0.4394285229343968 2.020683932409041e-06 0.4498981261869666 \
2.020683965448159e-06 0.4506126593745911 2.020684003207152e-06 0.45142837879914 2.020684078725137e-06 0.4530572051633331 2.020684229761107e-06 0.4563088938659436 \
2.020684437280373e-06 0.460764549126051 2.020684625319184e-06 0.4647825567212808 2.020684844328399e-06 0.469441659996985 2.020685087159409e-06 0.4745824626509371 \
2.020685386935038e-06 0.4808894567257585 2.020685624728187e-06 0.4858624696070272 2.020685887949588e-06 0.4913374535260851 2.020686148847133e-06 0.4967277906005185 \
2.02068637840122e-06 0.5014431429135263 2.020686601461414e-06 0.506003872007333 2.020686803037404e-06 0.5100983586086808 2.020686951867463e-06 0.51310967141356 \
2.020687196178516e-06 0.5180317772556589 2.020687328783749e-06 0.5206893064287169 2.020687468140331e-06 0.5234717264876519 2.020687679105724e-06 0.5276623644271943 \
2.020687853979606e-06 0.5311266030493931 2.020688122027852e-06 0.5364094032095129 2.02068831705351e-06 0.5402319029111832 2.020688496615017e-06 0.5437361368949839 \
2.020688747571146e-06 0.5486228351952749 2.020689024979257e-06 0.5540035987981641 2.020689308928559e-06 0.5594901708581531 2.02068956456585e-06 0.5644152233389156 \
2.020689855548069e-06 0.570006772487656 2.020690115853754e-06 0.5749917787111524 2.020690384297874e-06 0.5801232573974072 2.020690627063004e-06 0.5847450403362237 \
2.020690883594205e-06 0.5896146675871002 2.020691109757648e-06 0.59388771440121 2.020691347099143e-06 0.5983512154742827 2.02069155648786e-06 0.6022720321566808 \
2.020691770260628e-06 0.6062574570422776 2.020692023713469e-06 0.6109557890491497 2.020692226567817e-06 0.6146943332140289 2.020692419372338e-06 0.6182333111593361 \
2.020692609677365e-06 0.6217090173923294 2.020692800335854e-06 0.6251694921350958 2.02069300291378e-06 0.6288260100903066 2.020693265662542e-06 0.6335359534764116 \
2.020693494630232e-06 0.6376100987349322 2.020693714577867e-06 0.6414991146358265 2.02069394026254e-06 0.6454625140719233 2.020694149149966e-06 0.6491091855837361 \
2.020694370803585e-06 0.652957810138281 2.020694555693011e-06 0.6561429680377227 2.020694745707565e-06 0.6594017273991298 2.020694895862686e-06 0.6619630641908443 \
2.020695070740593e-06 0.6649292185271485 2.020695216461309e-06 0.6673855496832628 2.020695352493842e-06 0.6696641287411549 2.020695500856121e-06 0.672138295335571 \
2.020695630303834e-06 0.6742883907026684 2.020695764169531e-06 0.6764996355878535 2.02069589251393e-06 0.6786115243545502 2.020696017902059e-06 0.6806677490053815 \
2.020696147367755e-06 0.6827843190971332 2.02069627834897e-06 0.6849171426143115 2.020696426722072e-06 0.6873221141612875 2.020696534784827e-06 0.6890667486235877 \
2.0206966633165e-06 0.6911333958680312 2.020696798756284e-06 0.6933004139195943 2.020696923690607e-06 0.6952876996714908 2.020697049447875e-06 0.6972799977491608 \
2.020697155963766e-06 0.6989584331773744 2.020697273081655e-06 0.7007929859467624 2.020697391621401e-06 0.7026383448210159 2.020697514924797e-06 0.704545102273978 \
2.020697618097696e-06 0.7061304255463237 2.020697769068859e-06 0.7084341141567283 2.020697885323065e-06 0.7101955266062138 2.020698015883454e-06 0.7121605601685687 \
2.020698134445982e-06 0.7139335830373704 2.020698240519852e-06 0.7155108922888329 2.020698340544792e-06 0.716990346352101 2.020698477870006e-06 0.719009255813789 \
2.020698596531362e-06 0.7207429633399333 2.020698718230586e-06 0.7225107522614664 2.020698843413151e-06 0.7243181860083944 2.020698965432965e-06 0.7260693242762759 \
2.020699093464719e-06 0.7278954552757622 2.020699217946458e-06 0.7296603419865877 2.020699346245781e-06 0.7314685590147565 2.020699473339584e-06 0.7332489547570846 \
2.020699599364423e-06 0.7350034830462163 2.02069970210311e-06 0.7364262918236342 2.020699816775856e-06 0.7380063527755659 2.020699898181918e-06 0.7391232259175492 \
2.020700017381438e-06 0.7407496908814458 2.020700110023778e-06 0.7420059782745783 2.020700248182835e-06 0.7438668850244906 2.020700379238335e-06 0.7456179978167152 \
2.020700509370502e-06 0.7473439783685625 2.020700614344577e-06 0.7487266533969134 2.020700753484419e-06 0.7505456565005918 2.020700907428719e-06 0.7525407731682957 \
2.020701029372999e-06 0.7541080835708853 2.020701176919359e-06 0.7559892974429111 2.020701298924537e-06 0.7575320275232224 2.020701447624466e-06 0.7593968175435225 \
2.020701581671092e-06 0.7610632318338031 2.020701703924347e-06 0.7625711443351471 2.020701816790257e-06 0.763953046884334 2.020701959641225e-06 0.7656882893306027 \
2.020702086364119e-06 0.7672149413549471 2.020702202168995e-06 0.7685995877768005 2.020702331910823e-06 0.7701390587657672 2.020702447649211e-06 0.7715019052061673 \
2.020702570601637e-06 0.7729391548276606 2.020702688317297e-06 0.7743051053122872 2.020702794287274e-06 0.7755262985206828 2.020702910698467e-06 0.7768586864857919 \
2.0207030173164e-06 0.7780703956921795 2.020703129515121e-06 0.7793369495935717 2.02070321618369e-06 0.7803089322889447 2.020703319569181e-06 0.7814603789665585 \
2.020703432733432e-06 0.7827108149434853 2.020703538380716e-06 0.783868819044773 2.020703647720273e-06 0.7850578567336689 2.020703754897288e-06 0.786214126597127 \
2.020703884303365e-06 0.7875981444497275 2.020703996720751e-06 0.7887899291890393 2.02070412010849e-06 0.7900869036018625 2.020704237558825e-06 0.7913106402786101 \
2.020704381085744e-06 0.7927918312347375 2.020704496005322e-06 0.7939667362870242 2.020704634727735e-06 0.7953719780830618 2.020704772759876e-06 0.7967562205547866 \
2.02070488225303e-06 0.7978444364842524 2.02070498327146e-06 0.7988406866985471 2.02070508435942e-06 0.7998302780396641 2.020705216746616e-06 0.8011146558616069 \
2.020705335472037e-06 0.8022550163876687 2.020705457256542e-06 0.8034134048507504 2.020705576346336e-06 0.8045351524060473 2.020705697550853e-06 0.8056657048884367 \
2.020705829194665e-06 0.8068811249615274 2.020705952212703e-06 0.8080052413861453 2.020706079823023e-06 0.8091594649786741 2.020706210891683e-06 0.8103325925767672 \
2.020706334212047e-06 0.8114249716726942 2.020706442136311e-06 0.8123719892944993 2.020706549931703e-06 0.8133095350680949 2.020706631652631e-06 0.8140147772069938 \
2.020706748520248e-06 0.815015186305849 2.020706839581256e-06 0.8157880755829442 2.020706973749888e-06 0.8169164295805346 2.02070711832076e-06 0.8181184617099191 \
2.020707251823126e-06 0.8192158725965917 2.020707361789038e-06 0.8201107352847025 2.020707505654698e-06 0.8212684563313245 2.020707658960262e-06 0.8224861772268215 \
2.020707786698555e-06 0.8234883060891934 2.020707927340891e-06 0.8245786478120171 2.020708053124456e-06 0.8255423809867173 2.020708207742427e-06 0.8267124309768116 \
2.020708340154194e-06 0.8277017767197102 2.020708466433798e-06 0.8286345641820314 2.020708584064113e-06 0.8294941055817234 2.020708732230976e-06 0.8305638349826423 \
2.020708899375221e-06 0.8317531470681401 2.020709031993881e-06 0.832683775428688 2.020709204938569e-06 0.8338803479528284 2.020709373325224e-06 0.8350269493631071 \
2.020709542859754e-06 0.8361634673386688 2.020709724228909e-06 0.8373596561587384 2.020709866861491e-06 0.8382862741713709 2.020709980797339e-06 0.8390176620397163 \
2.020710111571134e-06 0.8398476357987267 2.020710213225074e-06 0.8404856735008092 2.020710329718803e-06 0.8412091703399448 2.020710465236349e-06 0.8420405885319162 \
2.020710662580143e-06 0.8432318270427018 2.020710853245141e-06 0.8443612543037786 2.02071106310198e-06 0.8455804035625291 2.020711244039104e-06 0.8466117334714958 \
2.020711441374591e-06 0.8477160230260256 2.020711615161427e-06 0.8486711109012058 2.020711797742881e-06 0.8496572451898022 2.020711969062461e-06 0.850566499179887 \
2.020712143447508e-06 0.8514760798656241 2.020712318831052e-06 0.8523748177975867 2.02071249506321e-06 0.8532619682996843 2.020712684901452e-06 0.8542000584728613 \
2.020712875637666e-06 0.8551245802328369 2.020713077434399e-06 0.856083442102113 2.020713270127775e-06 0.8569809170305027 2.020713479756077e-06 0.857937542729613 \
2.02071370919384e-06 0.8589615588718806 2.02071397499048e-06 0.8601183337444025 2.020714273565707e-06 0.8613802063570262 2.020714551467221e-06 0.8625196921548358 \
2.020714835677695e-06 0.8636511027355716 2.020715110089482e-06 0.8647118800460076 2.020715382252364e-06 0.8657341977214618 2.020715652421456e-06 0.8667205537246333 \
2.020715909616139e-06 0.8676338760342862 2.02071618215581e-06 0.868575115807136 2.020716458190291e-06 0.8695013130444248 2.020716728342986e-06 0.8703818891200001 \
2.020717028049788e-06 0.8713292845176382 2.020717398867258e-06 0.8724597217497643 2.020717693785921e-06 0.8733269024855727 2.020717948030199e-06 0.8740525764960509 \
2.020718246254199e-06 0.8748787854419284 2.020718519878969e-06 0.8756137195941651 2.020718756017959e-06 0.8762307200963571 2.020718996373686e-06 0.8768427579093606 \
2.020719218719338e-06 0.8773949085683344 2.020719412723072e-06 0.877865919014753 2.020719742447196e-06 0.878644045115768 2.020719897619855e-06 0.8790007149587372 \
2.020720215373248e-06 0.879712598742095 2.020720394238605e-06 0.8801026384247937 2.020720736700094e-06 0.8808283583858193 2.020720920841293e-06 0.8812073588304842 \
2.020721395746114e-06 0.8821499412898334 2.020721563140601e-06 0.8824705695712217 2.020722028971889e-06 0.8833323038036038 2.020722209796771e-06 0.8836551183393088 \
2.020722703830028e-06 0.8845051821644966 2.020722845172603e-06 0.8847400410050358 2.020723451563118e-06 0.8857071861637142 2.020723603635685e-06 0.8859397703602404 \
2.020724250313758e-06 0.8868873789663725 2.020724378610247e-06 0.8870678433440622 2.020725026723245e-06 0.8879435266410994 2.020725156528523e-06 0.8881118897635528 \
2.020725934785608e-06 0.8890711781604964 2.020726049780423e-06 0.8892053868933587 2.020726905511062e-06 0.8901454611437621 2.020727050777629e-06 0.8902951528450479 \
2.020728036533732e-06 0.8912364417375994 2.020728257640946e-06 0.8914302300078862 2.020729402752027e-06 0.892358484239638 2.020729533960174e-06 0.8924604119362172 \
2.02073087526337e-06 0.8934531785430913 2.02073102665103e-06 0.8935579568409697 2.020732508109868e-06 0.8944876667405802 2.020732746990229e-06 0.894621531696939 \
2.020734516461986e-06 0.8954958910368339 2.020734905568824e-06 0.8956641700186337 2.020737299334232e-06 0.8965498195158238 2.020737774894223e-06 0.8966991754584082 \
2.020741837950387e-06 0.8976977719002629 2.020742329424408e-06 0.8977905759376156 2.020750645951487e-06 0.8987839664765119 2.020751565805377e-06 0.8988472044554419 \
2.020877770945903e-06 0.8998441026240215 2.020878784754255e-06 0.8998514601858095 2.021070497347411e-06 0.8990059056521554 2.021070727348974e-06 0.8988405173838494 \
2.021072342221535e-06 0.8978439928078279 2.021072519935389e-06 0.8977495532019018 2.021089285710429e-06 0.8987316330193963 2.021089421698825e-06 0.8987497732072308 \
2.021104884427938e-06 0.8997471920221268 2.021105152292531e-06 0.8997526389354535 2.021588977619799e-06 0.9006560548284696 2.021589098408999e-06 0.9007687033315858 \
2.021589886180037e-06 0.9017381658104292 2.021590020318756e-06 0.901943163319478 2.02159051393353e-06 0.9027850367016239 2.021590658833145e-06 0.9030569221572713 \
2.02159105464053e-06 0.9038490360455199 2.021591174436184e-06 0.9041001886668685 2.021591558609718e-06 0.9049189780371781 2.021591670731365e-06 0.9051556495331843 \
2.021592178052336e-06 0.9061253139956988 2.021592272051191e-06 0.90626859229291 2.021593430700898e-06 0.9055667778886739 2.021593533663832e-06 0.9051589876696525 \
2.021593617506701e-06 0.9047707260375384 2.021593751246752e-06 0.9040404158978201 2.021593851964134e-06 0.9033957423200318 2.021593959579919e-06 0.9026166239542108 \
2.021594077153173e-06 0.9016533104038295 2.021594165418223e-06 0.90085556431878 2.021594285051691e-06 0.8996698288011099 2.021594382373389e-06 0.8986166602050341 \
2.021594493390828e-06 0.8973222354192386 2.021594595500415e-06 0.8960407982554908 2.021594678931815e-06 0.8949326975987755 2.021594783112883e-06 0.8934749428758865 \
2.021594874199646e-06 0.8921321265381427 2.021594966740432e-06 0.8907058396397178 2.02159506189443e-06 0.8891776325191247 2.021595176449407e-06 0.88725933118288 \
2.021595265292509e-06 0.8857137884271823 2.021595363531691e-06 0.8839502506198179 2.021595448901865e-06 0.8823735982707064 2.021595529802107e-06 0.8808434949738935 \
2.0215956027634e-06 0.8794355441897157 2.021595669782045e-06 0.8781198554636557 2.021595738393124e-06 0.8767515715160701 2.021595821888036e-06 0.8750591081124355 \
2.021595884015367e-06 0.8737811510706814 2.021595946997964e-06 0.8724704924326797 2.021596042153715e-06 0.8704632161180945 2.021596142764354e-06 0.8683077530860182 \
2.021596222643545e-06 0.8665738309361769 2.021596306905814e-06 0.8647250601592834 2.021596386016074e-06 0.8629723295901451 2.021596448831519e-06 0.8615696597604833 \
2.021596536288554e-06 0.8596016864744445 2.021596602182085e-06 0.8581079708060287 2.021596670243626e-06 0.856556281928966 2.021596719556134e-06 0.8554267461646872 \
2.021596774792923e-06 0.85415654045335 2.021596815532529e-06 0.8532164928603474 2.021596861834283e-06 0.8521450198670055 2.021596892048343e-06 0.8514441160591502 \
2.021596921089625e-06 0.8507691938976955 2.02159695172822e-06 0.8500558939662993 2.02159701300541e-06 0.8486254874746039 2.021597066077972e-06 0.8473828229799116 \
2.021597119733165e-06 0.8461232012188223 2.021597182390447e-06 0.8446482873934593 2.021597245673395e-06 0.8431545995644786 2.021597336171269e-06 0.8410121009440262 \
2.02159743316905e-06 0.8387078554355326 2.02159751614655e-06 0.8367307351423475 2.021597598150906e-06 0.8347721678896715 2.021597687219307e-06 0.8326403548070889 \
2.021597771732643e-06 0.8306135893189693 2.021597862591523e-06 0.8284303722590877 2.021597954526378e-06 0.8262176456275642 2.021598056957309e-06 0.8237486178045141 \
2.02159815707534e-06 0.8213320995840899 2.021598271896223e-06 0.8185572053828121 2.02159838410276e-06 0.8158423448209959 2.021598509096305e-06 0.8128151787794674 \
2.021598640356714e-06 0.8096337870015397 2.021598785627755e-06 0.8061104108175116 2.021598940135368e-06 0.8023613213197434 2.021599111575989e-06 0.7981999722344618 \
2.021599275625781e-06 0.794217661721315 2.021599460041203e-06 0.7897413884478564 2.021599666533577e-06 0.7847307375046715 2.02159985602742e-06 0.7801344622909899 \
2.021600049421183e-06 0.775444374634302 2.021600249988037e-06 0.7705834242206392 2.021600397552439e-06 0.7670092004965298 2.021600527563889e-06 0.7638619034739171 \
2.021600662428303e-06 0.7605987503374771 2.021600768918754e-06 0.7580234999254772 2.021600900608547e-06 0.7548403390839162 2.021601007032976e-06 0.7522693550468039 \
2.021601150211605e-06 0.7488125398635642 2.021601311338716e-06 0.7449250928176189 2.021601429565533e-06 0.7420746008290786 2.021601599798354e-06 0.7379721584775248 \
2.021601765724623e-06 0.7339761998059781 2.021601985266954e-06 0.7286940862104242 2.021602178454078e-06 0.724050920820232 2.021602353368042e-06 0.719851304223293 \
2.021602520315139e-06 0.7158476177432674 2.0216027078061e-06 0.711355754450834 2.021602895234537e-06 0.7068709122373377 2.021603063571096e-06 0.7028473835914892 \
2.02160325640163e-06 0.6982428782038785 2.021603396451377e-06 0.694901318858167 2.021603552708666e-06 0.6911769338170629 2.021603746878113e-06 0.6865540563080536 \
2.021603905984602e-06 0.6827702245679255 2.021604064344632e-06 0.679008548037742 2.02160425966174e-06 0.6743756772263459 2.02160447009052e-06 0.6693917663527935 \
2.021604722792665e-06 0.6634173774538097 2.021604902460616e-06 0.6591769455535931 2.021605154037489e-06 0.6532475027332399 2.021605354410306e-06 0.6485340174553987 \
2.021605526064158e-06 0.6445032789616798 2.021605684756275e-06 0.6407814961122935 2.021605823964202e-06 0.637522316374186 2.021605960288252e-06 0.6343349641335875 \
2.021606087501276e-06 0.6313646237382058 2.021606216993833e-06 0.6283457899522861 2.021606344985121e-06 0.6253646753452949 2.02160647605963e-06 0.6223174651643489 \
2.021606606771705e-06 0.6192830747181834 2.021606749379758e-06 0.6159760732208495 2.021606892103236e-06 0.612672916206165 2.021607044651037e-06 0.6091471600588 \
2.021607189155024e-06 0.6058158037532523 2.021607353173272e-06 0.6020406322262999 2.021607490637933e-06 0.5988837056407329 2.021607625454949e-06 0.5957940466067043 \
2.021607746953592e-06 0.5930134750293682 2.021607885803896e-06 0.5898448108574432 2.021607999450713e-06 0.5872554148224447 2.021608150860885e-06 0.5838116422847746 \
2.02160826457956e-06 0.5812320812748947 2.021608383992651e-06 0.5785269636915771 2.021608472673178e-06 0.5765205397309219 2.021608563818269e-06 0.5744630259469776 \
2.021608629157145e-06 0.5729901393713442 2.021608693626847e-06 0.5715377831648228 2.021608744447459e-06 0.5703933076453638 2.021608803422399e-06 0.569066051987989 \
2.021608870867106e-06 0.5675516747474645 2.021608937959298e-06 0.5660472084764079 2.021608990879742e-06 0.5648615894615425 2.021609086527225e-06 0.5627204246953637 \
2.021609143708361e-06 0.5614413394337 2.021609197510977e-06 0.5602399192081799 2.021609259253083e-06 0.5588634520375642 2.021609345086214e-06 0.5569525037715509 \
2.021609427781862e-06 0.5551133137453282 2.021609553910589e-06 0.552313430559463 2.021609689009665e-06 0.5493247407981657 2.021609787329828e-06 0.5471534914294828 \
2.02160989990789e-06 0.5446716589975775 2.021610002452305e-06 0.5424173856211837 2.021610122561131e-06 0.5397821662853191 2.021610224248782e-06 0.5375541863492928 \
2.021610339752746e-06 0.5350300289250629 2.021610454643861e-06 0.5325260225312031 2.021610581121134e-06 0.5297740207092871 2.02161070633833e-06 0.5270565158317848 \
2.021610853184312e-06 0.5238798967507053 2.021610988642446e-06 0.5209557060405445 2.021611146203055e-06 0.5175672114705414 2.02161130835723e-06 0.5140875588169389 \
2.021611489068307e-06 0.5102248342695275 2.02161168131606e-06 0.5061308236654174 2.021611894038323e-06 0.5016182665703952 2.021612125943484e-06 0.4967183500883584 \
2.021612383137188e-06 0.4913135654247419 2.021612622690498e-06 0.4863004534671564 2.021612924620373e-06 0.4800178499336004 2.021613212386814e-06 0.4740665530855001 \
2.021613525189057e-06 0.4676409412178996 2.021613845020806e-06 0.4611139840073785 2.021614184657409e-06 0.4542292677834274 2.021614511873228e-06 0.4476411633207955 \
2.021614847034797e-06 0.4409363684817221 2.021615164291457e-06 0.4346351592989786 2.021615498111436e-06 0.4280489847791872 2.02161584979678e-06 0.4211625252737479 \
2.021616163864498e-06 0.4150547397555842 2.021616486893702e-06 0.4088175946446666 2.021616927873099e-06 0.4003732788922496 2.021617270275942e-06 0.3938810608698495 \
2.021617570723831e-06 0.3882325136127223 2.021617946053402e-06 0.3812375944419973 2.02161827612863e-06 0.3751439175705365 2.021618559406411e-06 0.3699597784791666 \
2.021618859913773e-06 0.3645020109013299 2.021619139561233e-06 0.3594637112692664 2.021619363423524e-06 0.3554634414471464 2.021619575274513e-06 0.35170280677964 \
2.021619777623113e-06 0.3481338771034005 2.021619978758139e-06 0.3446120049995081 2.021620184535657e-06 0.3410324794262659 2.021620445514371e-06 0.3365252478245505 \
2.021620685004553e-06 0.3324209773202946 2.021620917679624e-06 0.3284665339262754 2.021621131761216e-06 0.3248537323113044 2.021621352906983e-06 0.3211475567840967 \
2.021621553789873e-06 0.3178053707831449 2.021621757181075e-06 0.3144500223650613 2.021621954849488e-06 0.3112139453100684 2.021622141093175e-06 0.3081862077816076 \
2.021622336074257e-06 0.3050391973134606 2.021622539536502e-06 0.3017803754370622 2.021622717477408e-06 0.2989521325826759 2.021622953201112e-06 0.2952356640875101 \
2.021623151333966e-06 0.2921385263640672 2.021623352678033e-06 0.2890160050544278 2.02162357696723e-06 0.2855690750291008 2.021623741897129e-06 0.2830551950838826 \
2.021623919525814e-06 0.2803657404651576 2.021624103924961e-06 0.2775946687427531 2.021624287746306e-06 0.2748547260732712 2.021624466202979e-06 0.2722194282383935 \
2.021624638103246e-06 0.2696976713509589 2.021624798643653e-06 0.2673699088296289 2.021624920125712e-06 0.265617282026588 2.021625073047239e-06 0.2634201198254058 \
2.021625200480934e-06 0.2616085083773952 2.021625304654605e-06 0.2601317890528609 2.021625421559082e-06 0.2584775571399547 2.021625536570573e-06 0.2568557450124987 \
2.021625660932803e-06 0.2551103168403305 2.021625776507087e-06 0.2534925198640895 2.021625910614608e-06 0.2516172680784447 2.021626025601848e-06 0.2500177396912131 \
2.021626179351445e-06 0.2478798443778067 2.021626316154646e-06 0.2459790966208961 2.021626450740453e-06 0.2441094379339017 2.021626606604589e-06 0.2419575875351012 \
2.021626731253411e-06 0.2402378086535915 2.021626870468935e-06 0.2383186229544463 2.02162700069296e-06 0.236525770455347 2.021627121045801e-06 0.2348769158236033 \
2.021627256439085e-06 0.233027137746051 2.021627407644063e-06 0.2309620730808924 2.021627542400533e-06 0.2291249940296414 2.02162764708672e-06 0.2277003186426776 \
2.021627769622861e-06 0.2260366668203369 2.02162790456742e-06 0.2242086518061946 2.021627999683168e-06 0.2229209267876512 2.021628114943222e-06 0.2213657311907907 \
2.021628197476202e-06 0.2202562617028589 2.021628268681533e-06 0.2192992955643472 2.021628317389017e-06 0.2186449771734718 2.021628364583973e-06 0.2180112263680214 \
2.021628411132792e-06 0.2173864029843717 2.021628464521355e-06 0.2166701476649976 2.021628501898025e-06 0.2161690444847812 2.021628539283138e-06 0.2156680710113931 \
2.021628579604508e-06 0.2151283464800275 2.021628650854648e-06 0.2141753141901174 2.021628685068904e-06 0.2137180869447317 2.021628731463535e-06 0.2131018213873352 \
2.021628791907201e-06 0.2122998083652294 2.02162886091012e-06 0.2113853596849882 2.021628926205072e-06 0.210520730631805 2.021628994183196e-06 0.2096212333552783 \
2.021629110629525e-06 0.2080823984153433 2.021629200551714e-06 0.2068957989735914 2.02162930821762e-06 0.2054771097790837 2.021629404278935e-06 0.2042146625011118 \
2.021629507657509e-06 0.2028641889872041 2.021629604342544e-06 0.2016026287683381 2.021629707152397e-06 0.2002625524503448 2.021629807912368e-06 0.1989526210414513 \
2.021629919058035e-06 0.1975116692735505 2.021630026097529e-06 0.1961279675313261 2.021630144004064e-06 0.1946083430154048 2.021630252114387e-06 0.1932197128021231 \
2.021630361412988e-06 0.1918224631760269 2.021630482044739e-06 0.1902849927564414 2.021630576945331e-06 0.1890796997295432 2.02163070550625e-06 0.18745262875399 \
2.021630798541038e-06 0.1862801166370808 2.021630900937594e-06 0.1849947785893032 2.021630988904886e-06 0.1838942174288659 2.021631087175557e-06 0.182668828510528 \
2.021631183776179e-06 0.1814691026470878 2.021631270414692e-06 0.1803971466393716 2.021631356823704e-06 0.1793305247657973 2.021631452660814e-06 0.1781527189679156 \
2.021631557387689e-06 0.1768710765218302 2.021631703199975e-06 0.1750963017969037 2.021631819167907e-06 0.1736923427161618 2.021631975631711e-06 0.1718092975148396 \
2.02163208681163e-06 0.1704786474822015 2.02163222706163e-06 0.1688098560703619 2.021632350073036e-06 0.1673544160765056 2.021632456564034e-06 0.1661007559767333 \
2.021632552889492e-06 0.1649724583647661 2.021632650322959e-06 0.1638357962207703 2.021632754176237e-06 0.1626293386330815 2.02163284597681e-06 0.1615673458739011 \
2.021632944364525e-06 0.1604337426303964 2.02163302728317e-06 0.1594828374885931 2.021633122651503e-06 0.1583950132920943 2.021633205213852e-06 0.1574587876231885 \
2.021633307798537e-06 0.1563016192679324 2.021633384076854e-06 0.1554454316211293 2.021633472662479e-06 0.1544557264474612 2.021633544831984e-06 0.1536532700165102 \
2.021633626541473e-06 0.1527486200895024 2.021633700220281e-06 0.1519363404455653 2.02163378044041e-06 0.1510573496788611 2.021633852168484e-06 0.1502755532525617 \
2.021633920425463e-06 0.149534520573691 2.021634018141423e-06 0.1484788062294206 2.021634087591606e-06 0.147731872792437 2.021634170343085e-06 0.1468455801890639 \
2.021634230379995e-06 0.1462052652532956 2.021634300618659e-06 0.1454587420502366 2.021634372046193e-06 0.1447037411390827 2.021634452559695e-06 0.1438588888651768 \
2.021634515822599e-06 0.1431977449412327 2.021634593496578e-06 0.1423892845091393 2.021634682806343e-06 0.141463758692191 2.021634752169929e-06 0.1407479403162204 \
2.021634850118149e-06 0.1397418416088305 2.021634940462669e-06 0.1388188591118084 2.021635026242994e-06 0.1379520826379384 2.021635093896779e-06 0.1372719511642241 \
2.02163516020463e-06 0.1366075914250998 2.021635238824321e-06 0.1358227655030745 2.02163531951923e-06 0.135020537018139 2.021635377921894e-06 0.1344419857224206 \
2.021635438674417e-06 0.1338420332148588 2.021635532580729e-06 0.1329184183639811 2.021635574978232e-06 0.1325029080242558 2.021635654222426e-06 0.1317336600863391 \
2.021635694592585e-06 0.1313430593815061 2.021635784293464e-06 0.130477658168832 2.02163582324155e-06 0.1301029732927899 2.021635918857236e-06 0.1291862249441596 \
2.021635957741065e-06 0.1288146335111444 2.021636050975841e-06 0.1279263274670414 2.02163611931843e-06 0.1272775968534341 2.021636171639285e-06 0.1267823325594629 \
2.021636253739999e-06 0.1260075984242486 2.021636324903378e-06 0.1253406747583812 2.021636402856366e-06 0.1246136378429537 2.021636481976102e-06 0.1238779526756392 \
2.021636560619333e-06 0.1231489004754178 2.021636640654242e-06 0.122409328367501 2.021636702388658e-06 0.1218405706457005 2.021636775983641e-06 0.1211645344030958 \
2.021636859363458e-06 0.120401093559758 2.021636923460189e-06 0.1198161795466899 2.021636992898777e-06 0.119184869057559 2.021637065921716e-06 0.1185234239195788 \
2.021637150796627e-06 0.1177582144838446 2.021637230159479e-06 0.117046673033812 2.021637314893136e-06 0.1162898833629492 2.021637405604426e-06 0.1154830714735263 \
2.021637481187504e-06 0.1148135241260771 2.021637546915429e-06 0.1142333070693714 2.021637606975201e-06 0.1137047561823949 2.021637676580917e-06 0.1130943456353956 \
2.021637742999968e-06 0.1125141752866663 2.021637822411232e-06 0.1118230150855203 2.021637912674161e-06 0.1110406875128299 2.021637981718461e-06 0.1104447270551955 \
2.02163805627358e-06 0.1098035355921305 2.021638144757501e-06 0.1090456469739195 2.021638223865648e-06 0.1083709350695736 2.021638293734029e-06 0.1077773127978274 \
2.021638374743399e-06 0.1070920034756896 2.021638430948213e-06 0.106618206733547 2.021638493607492e-06 0.1060916009495399 2.021638558754097e-06 0.105545887371837 \
2.021638630089726e-06 0.1049504956797945 2.021638750386101e-06 0.1039516085561449 2.021638801939674e-06 0.103525508500865 2.021638857088742e-06 0.1030709598036589 \
2.021638947785926e-06 0.1023262935955709 2.021639030175778e-06 0.1016530765296615 2.021639125755586e-06 0.1008759670630478 2.021639232965152e-06 0.1000092507657299 \
2.021639336624559e-06 0.09917656019160864 2.021639422832161e-06 0.09848810438956324 2.021639509074386e-06 0.09780303991321163 2.02163958861546e-06 0.09717448010577609 \
2.021639668628333e-06 0.09654538840876434 2.021639759916661e-06 0.09583163072761708 2.02163984166208e-06 0.09519620281310773 2.021639930588917e-06 0.09450872319168514 \
2.021640020366224e-06 0.09381864801001834 2.021640097328872e-06 0.09323024625953365 2.021640187653689e-06 0.0925435244861572 2.021640251462415e-06 0.09206084550525626 \
2.021640323925983e-06 0.09151514907748673 2.021640388054636e-06 0.09103438864950099 2.021640466302011e-06 0.09045054736970405 2.021640566003292e-06 0.08971110930136832 \
2.021640640056444e-06 0.08916512281998501 2.021640726664979e-06 0.08852997392441805 2.021640872964685e-06 0.08746544055362569 2.021640983676948e-06 0.08666684197409438 \
2.021641093986626e-06 0.08587717033461532 2.021641236182269e-06 0.08486839672072237 2.02164137623472e-06 0.08388450488753585 2.021641518880534e-06 0.08289222299161547 \
2.021641667651249e-06 0.08186778387581196 2.021641804363935e-06 0.08093569403044946 2.021641946484565e-06 0.07997640434545976 2.021642081061545e-06 0.07907728405019222 \
2.021642221281423e-06 0.07814997945867638 2.02164236902823e-06 0.07718353387841098 2.021642518982415e-06 0.07621348085094087 2.021642683698247e-06 0.07516037195605636 \
2.021642847284363e-06 0.07412732798506308 2.021643021932716e-06 0.07303837372665309 2.021643208986408e-06 0.07188781219077654 2.021643418972926e-06 0.0706159374129187 \
2.021643637046174e-06 0.06931715807027321 2.021643870366328e-06 0.06795188046253516 2.021644124845882e-06 0.0664909822812602 2.02164441780254e-06 0.06484528303377844 \
2.021644719953089e-06 0.06318745987130532 2.021645057674791e-06 0.06138078634948794 2.021645452783393e-06 0.05932807220464856 2.021645820234636e-06 0.05747953410674719 \
2.021646237842402e-06 0.05544691527644593 2.021646582838376e-06 0.0538196438399016 2.021646933380666e-06 0.05221302159193914 2.021647248341029e-06 0.0508087490907442 \
2.021647547582396e-06 0.049508488261462 2.021647846948248e-06 0.04824029756235761 2.021648122190958e-06 0.04710512226277328 2.021648405654525e-06 0.04596497870754415 \
2.021648667254947e-06 0.04493681260994405 2.021648944707071e-06 0.04387103439794762 2.021649220766506e-06 0.04283531238677037 2.021649529036243e-06 0.04170718945545093 \
2.021649751468864e-06 0.0409114719535993 2.021650039009947e-06 0.03990505631995635 2.02165027524288e-06 0.0390969788355163 2.021650593704555e-06 0.03803800466874574 \
2.021650844115589e-06 0.03722710566490722 2.021651167100391e-06 0.03620720400565681 2.021651425436406e-06 0.03541203096995557 2.021651715410285e-06 0.03454066075983582 \
2.021651945205102e-06 0.0338658635512188 2.021652230100444e-06 0.03304787219836024 2.021652469846563e-06 0.03237513696606491 2.021652710481132e-06 0.03171392889024889 \
2.021652949599619e-06 0.03107212555077287 2.02165318553853e-06 0.03045460689686571 2.021653416367391e-06 0.02986254663395104 2.021653631393919e-06 0.02932175456294728 \
2.02165403355976e-06 0.0283374222946415 2.02165423211788e-06 0.02786401170979088 2.021654605819066e-06 0.02699470773596776 2.021654792632261e-06 0.02657042318767052 \
2.021655138633508e-06 0.02580176906824739 2.021655260576947e-06 0.02553595448027303 2.021655643429963e-06 0.02472011952872977 2.021655803864149e-06 0.02438657631284594 \
2.021656246865303e-06 0.02348572425118655 2.021656417479345e-06 0.02314627247835563 2.021656738055941e-06 0.02251902970747987 2.021656938340868e-06 0.0221336684630111 \
2.021657385278801e-06 0.02128811173678137 2.021657513222917e-06 0.02104854104185888 2.021658001100276e-06 0.02014826272243131 2.021658136077553e-06 0.01990454278080647 \
2.021658618329072e-06 0.0190640092473091 2.021658780655186e-06 0.01879235028057063 2.021659267049527e-06 0.01801148170254873 2.021659430077186e-06 0.01776103207540622 \
2.021660110298876e-06 0.01676849304257711 2.021660249382615e-06 0.01657541006259178 2.021660981877148e-06 0.01560782569993242 2.02166114077078e-06 0.01540693214221847 \
2.021661923851867e-06 0.01445869962397344 2.021662069644422e-06 0.01428952172302696 2.021662920425781e-06 0.01334248985256295 2.021663031529053e-06 0.01322388191882306 \
2.021663964823417e-06 0.0122699293983148 2.021664098661466e-06 0.01213902814618388 2.021665057199482e-06 0.01123495036716388 2.021665178316551e-06 0.01112486091825863 \
2.021666300400349e-06 0.01017270671243764 2.021666405901602e-06 0.01008921053061839 2.021667734976014e-06 0.009112307258623473 2.021667855180288e-06 0.009029744095492466 \
2.021669403542048e-06 0.008036808760534916 2.021669484329818e-06 0.007986285493236449 2.021671055209352e-06 0.007024564730313319 2.021671122625551e-06 0.006986095570813155 \
2.021673043392229e-06 0.006001386377072119 2.021673230194113e-06 0.005914747648762168 2.021675545608061e-06 0.0049318160947762 2.021675945134908e-06 0.004777795182599986 \
2.021678508944408e-06 0.003889929704329555 2.021679007815328e-06 0.003736330440833864 2.021682637539317e-06 0.002784984367379526 2.021683188233292e-06 0.002663729254427667 \
2.021688586673672e-06 0.001711392372544448 2.021688899941243e-06 0.001662511220227468 2.021693892233792e-06 0.0006970413096974805 2.021694076252826e-06 0.0006571176749162138 \
2.024342555395609e-06 -0.0002691198397987355 2.024342711454572e-06 -0.0004551674219448388 2.024343259438427e-06 -0.001322174727784445 2.02434337237642e-06 -0.001539785040943742 \
2.02434380163135e-06 -0.002474302920374066 2.024343907888515e-06 -0.002730173903076456 2.024344190690667e-06 -0.003454402452283872 2.02434430428521e-06 -0.003760966378165151 \
2.024344642839789e-06 -0.004705104513819927 2.02434475526375e-06 -0.005021586953003071 2.024345083541651e-06 -0.005887841248467669 2.024345191080172e-06 -0.006130875888161453 \
2.024346071006203e-06 -0.005789627805322099 2.02434624621225e-06 -0.004910736584223327 2.024346363043014e-06 -0.004127745010746014 2.024346489910138e-06 -0.00309221842859156 \
2.024346591442863e-06 -0.002125750314016509 2.024346712864133e-06 -0.0008095618968406578 2.024346803029046e-06 0.0002767910803854594 2.024346900212696e-06 0.001550247908954045 \
2.02434699828696e-06 0.002938803805678211 2.024347165508045e-06 0.005530627736217106 2.024347387813323e-06 0.009378371294171852 2.024347573551714e-06 0.01290572951649239 \
2.024347797633049e-06 0.01747895571448658 2.024347957277782e-06 0.02091945933227325 2.024348121767111e-06 0.02459614091902196 2.024348271591569e-06 0.0280452875125503 \
2.024348420991462e-06 0.03156498790849799 2.024348570522767e-06 0.03515592969144176 2.024348724602661e-06 0.03891669635189081 2.024348886786809e-06 0.0429309674228065 \
2.024349053210035e-06 0.0470989728378523 2.024349229143508e-06 0.05154884981278444 2.024349410271779e-06 0.05616867911875007 2.024349602402705e-06 0.06110225049351239 \
2.024349810098117e-06 0.0664648391313285 2.024350032018198e-06 0.07222051812179281 2.02435026721968e-06 0.07834079218654426 2.024350519405989e-06 0.08491829088081257 \
2.024350795545224e-06 0.09213111703448683 2.024351096666701e-06 0.1000001933597138 2.024351428586562e-06 0.1086702418150647 2.02435180590533e-06 0.1185147411083515 \
2.024352204195387e-06 0.1288888856248832 2.024352673503707e-06 0.1410822143415975 2.024353219529231e-06 0.1552200475789812 2.024353854489538e-06 0.1715918832733369 \
2.024354553890129e-06 0.1895291194622146 2.024355372129055e-06 0.2103807608661494 2.024356277823022e-06 0.2332840710921665 2.024357067334088e-06 0.253091928008631 \
2.024357771092906e-06 0.2706124241987875 2.02435838894372e-06 0.2858796548825839 2.024358954567131e-06 0.2997575097153312 2.024359476302405e-06 0.3124620269501652 \
2.024359974086121e-06 0.3244932238414255 2.024360457724081e-06 0.3360954048923613 2.024360914598215e-06 0.3469667650518959 2.024361387439109e-06 0.3581213589834248 \
2.024361827052466e-06 0.3684065070151987 2.024362314929562e-06 0.379719432411247 2.024362845729985e-06 0.3919028193132517 2.02436334362536e-06 0.4032143644097119 \
2.024363775002613e-06 0.41292177789323 2.024364261889801e-06 0.4237731225600331 2.024364761989243e-06 0.4348012155672935 2.024365106609934e-06 0.4423321287141763 \
2.024365460003778e-06 0.4500000647748709 2.024365887773617e-06 0.4592134948422093 2.024366279634688e-06 0.4675816212925634 2.024366579929044e-06 0.4739471552041949 \
2.024366921860125e-06 0.4811428413521782 2.02436726519457e-06 0.4883132334011818 2.024367525955058e-06 0.4937215836208605 2.024367768011587e-06 0.4987106167174703 \
2.024368034010056e-06 0.5041617362307154 2.02436829349824e-06 0.5094435946950286 2.02436848341454e-06 0.5132872703533161 2.024368698649141e-06 0.5176241792560061 \
2.0243688371999e-06 0.5204025546691405 2.024368982080679e-06 0.5232962183003332 2.024369195494746e-06 0.5275364624051522 2.024369397519361e-06 0.5315382148201082 \
2.024369590248024e-06 0.5353370730264509 2.024369775503404e-06 0.5389735557287745 2.024369952500928e-06 0.5424323215059959 2.024370261764263e-06 0.5484573594957171 \
2.02437052291231e-06 0.5535233414883098 2.024370824731481e-06 0.5593562770234363 2.024371080160122e-06 0.5642781701956761 2.024371372515619e-06 0.5698968483756405 \
2.024371631969813e-06 0.5748654731717864 2.02437190208979e-06 0.5800301911327002 2.024372144100348e-06 0.5846380733684551 2.024372401610146e-06 0.5895273573494454 \
2.024372628054484e-06 0.5938057549890672 2.024372864942966e-06 0.5982619499065401 2.024373074987873e-06 0.6021962733001386 2.024373287918585e-06 0.6061670177072124 \
2.024373541397282e-06 0.6108668889270118 2.024373744692931e-06 0.6146150465592417 2.024373936381114e-06 0.6181346807088086 2.024374125007479e-06 0.6215812235468744 \
2.024374312325417e-06 0.6249823889551316 2.024374517937406e-06 0.6286953279350977 2.024374767760625e-06 0.6331759959753138 2.024374971572404e-06 0.6368063379741715 \
2.024375179211121e-06 0.6404826298163093 2.024375371862737e-06 0.6438748386876914 2.02437561647481e-06 0.6481531432733096 2.024375864373314e-06 0.6524620620600715 \
2.024376044208219e-06 0.6555644139995785 2.024376234982255e-06 0.6588391718544121 2.024376388158437e-06 0.6614554104590837 2.024376559827147e-06 0.6643705886591137 \
2.024376710293968e-06 0.6669108747194671 2.024376846897972e-06 0.6692010654183506 2.024376996338373e-06 0.6716954191563786 2.024377124072523e-06 0.6738189269502312 \
2.02437726394477e-06 0.6761323074508511 2.024377388021905e-06 0.6781756764962316 2.02437751938327e-06 0.6803315871556701 2.024377643554731e-06 0.6823627547057004 \
2.024377781331592e-06 0.6846081866267727 2.024377901575812e-06 0.6865586181592046 2.024378043628418e-06 0.6888545186016138 2.024378143856123e-06 0.6904668682779994 \
2.024378265160113e-06 0.6924123325129877 2.024378356135388e-06 0.6938641504265992 2.024378453518671e-06 0.695411869780077 2.024378550601538e-06 0.6969507228893711 \
2.024378639884159e-06 0.6983595753378042 2.024378737855943e-06 0.699898781449533 2.024378868131031e-06 0.7019319515314388 2.024379021543255e-06 0.7043083163565919 \
2.024379157109067e-06 0.7063909659299702 2.024379301449562e-06 0.708591461371511 2.024379427320445e-06 0.710496752775434 2.024379552347831e-06 0.712376488910674 \
2.024379666630191e-06 0.7140841686551523 2.024379777613336e-06 0.7157331888171029 2.024379877308404e-06 0.7172065512867005 2.024380014352623e-06 0.7192196995505324 \
2.024380133379835e-06 0.7209572005600779 2.024380253677943e-06 0.7227029412191364 2.024380380176863e-06 0.7245276185835638 2.024380504108467e-06 0.7263044524160376 \
2.0243806283948e-06 0.7280754330070212 2.024380754759953e-06 0.7298652243312684 2.024380884571694e-06 0.7316925631262517 2.024381008410214e-06 0.7334254795816325 \
2.024381141191101e-06 0.735272086289578 2.024381242042306e-06 0.7366670415914529 2.024381355233975e-06 0.738224777043618 2.024381442019956e-06 0.7394137384482823 \
2.024381558645253e-06 0.7410021813026957 2.02438164793451e-06 0.7422110784210975 2.024381759111394e-06 0.7437075443329063 2.024381888370158e-06 0.7454347509364776 \
2.024382002229194e-06 0.7469455276109591 2.024382106633406e-06 0.74832188588007 2.024382231000437e-06 0.7499498655229884 2.024382378240616e-06 0.7518616907275563 \
2.024382498520907e-06 0.753411006437983 2.024382614425446e-06 0.7548933175676444 2.02438275450129e-06 0.7566706674475765 2.02438289711296e-06 0.7584645678799224 \
2.024383015067203e-06 0.7599365027959469 2.024383141883712e-06 0.7615071445339606 2.024383282766856e-06 0.7632375905494565 2.024383402560354e-06 0.7646969139886852 \
2.024383547519211e-06 0.7664484133613445 2.024383669077996e-06 0.7679052725436226 2.02438378811749e-06 0.7693214142140735 2.024383909748853e-06 0.7707575700077021 \
2.024384037717832e-06 0.772256936813787 2.024384146933014e-06 0.7735272422640712 2.024384271823892e-06 0.774969549136603 2.024384378939953e-06 0.7761978171588899 \
2.024384512193147e-06 0.7777146071439789 2.024384639296593e-06 0.7791497354387434 2.024384761047568e-06 0.7805132846941326 2.024384877632151e-06 0.7818078758210534 \
2.024384983459753e-06 0.7829735233300771 2.024385122825895e-06 0.7844949153190801 2.024385271897694e-06 0.786105286864636 2.024385419626362e-06 0.7876841235632186 \
2.02438553893224e-06 0.7889471147195867 2.024385672939052e-06 0.7903527806482344 2.024385793365227e-06 0.791604423795974 2.024385934910404e-06 0.7930616786923709 \
2.024386082336417e-06 0.7945638089648995 2.024386206810925e-06 0.7958198087139573 2.024386325854918e-06 0.7970105506108808 2.024386437445202e-06 0.7981174590942314 \
2.02438654267449e-06 0.7991530841216606 2.024386638185594e-06 0.8000862307887144 2.024386774247548e-06 0.8014036057482816 2.024386891123682e-06 0.8025237700417888 \
2.024387010277354e-06 0.8036549841722296 2.024387132589548e-06 0.8048050501807249 2.024387255861622e-06 0.8059526272620129 2.024387382358399e-06 0.8071184350969989 \
2.024387507861063e-06 0.8082633544790385 2.024387638586967e-06 0.8094437311890262 2.024387764154939e-06 0.8105658358439867 2.024387893209804e-06 0.8117072367686948 \
2.024387999065961e-06 0.8126345588578442 2.024388100234837e-06 0.8135133322873783 2.024388194854656e-06 0.8143286754242188 2.02438831913574e-06 0.8153900871385379 \
2.024388408847426e-06 0.816149614585347 2.02438850788495e-06 0.8169816577628611 2.024388645662827e-06 0.8181280288377792 2.024388780198678e-06 0.81923501721715 \
2.024388888604944e-06 0.8201180631035904 2.024389038518448e-06 0.8213254631869725 2.024389189097026e-06 0.8225223201378843 2.02438931459218e-06 0.8235077122548546 \
2.024389458438707e-06 0.8246238332260477 2.024389583021971e-06 0.8255790649890803 2.024389731875191e-06 0.8267066458678887 2.024389868023775e-06 0.827725029289517 \
2.024389993047602e-06 0.8286494160599757 2.024390110754582e-06 0.8295103773055483 2.02439025639358e-06 0.8305630309532103 2.024390422774875e-06 0.8317484146982921 \
2.024390553358565e-06 0.8326660250626342 2.024390726880675e-06 0.8338683097812621 2.024390895002578e-06 0.8350147136930499 2.02439106486518e-06 0.8361549927788252 \
2.024391245766883e-06 0.8373497079260466 2.024391388876165e-06 0.8382806519784776 2.024391502965127e-06 0.839013953006387 2.024391633127603e-06 0.8398410866028793 \
2.024391734972734e-06 0.8404811280669765 2.02439185179894e-06 0.8412075886390841 2.02439198869038e-06 0.8420483852080155 2.024392186497604e-06 0.843243620449199 \
2.02439237812275e-06 0.8443797466267589 2.024392587554618e-06 0.8455974227529048 2.0243927695013e-06 0.8466352798309468 2.024392966630154e-06 0.8477391449715804 \
2.024393139971014e-06 0.8486924050423899 2.024393322979321e-06 0.8496814535024207 2.024393494142356e-06 0.8505903669473519 2.024393668779451e-06 0.851501688465695 \
2.024393844039281e-06 0.8524001683007644 2.02439402018973e-06 0.8532872510191711 2.02439421047003e-06 0.8542278331088334 2.02439440106916e-06 0.8551519386507073 \
2.024394601692395e-06 0.8561055033533737 2.02439479430095e-06 0.8570028516027762 2.024395004981641e-06 0.8579644845832216 2.024395233083109e-06 0.8589827023971403 \
2.024395498871092e-06 0.860139640227508 2.024395797483852e-06 0.8614018215255795 2.024396073772491e-06 0.8625348754565382 2.02439635800901e-06 0.8636666213345715 \
2.02439663221378e-06 0.8647267940813509 2.024396904448638e-06 0.8657495569722869 2.02439717465278e-06 0.8667361702337206 2.024397431808391e-06 0.867649441901348 \
2.024397704388604e-06 0.8685908808535525 2.02439798037489e-06 0.8695169452638583 2.024398250477721e-06 0.870397355937691 2.024398550334798e-06 0.8713451925332844 \
2.024398921362456e-06 0.8724761722512941 2.024399216299767e-06 0.8733433185969293 2.024399470589207e-06 0.8740690226522811 2.024399768845991e-06 0.874895168896023 \
2.024400042455427e-06 0.8756299040683481 2.024400278583914e-06 0.8762466977562872 2.024400518929827e-06 0.8768585021646264 2.024400741263492e-06 0.8774104263690854 \
2.024400935269169e-06 0.8778812671168952 2.024401264991886e-06 0.8786590883967833 2.024401420165319e-06 0.8790156160651978 2.024401737941389e-06 0.8797272612331356 \
2.024401916803032e-06 0.8801171459162566 2.024402259264861e-06 0.8808425821290963 2.024402443393021e-06 0.881221400612852 2.024402918270754e-06 0.8821634994206867 \
2.024403085666965e-06 0.8824839765989225 2.024403551508906e-06 0.8833452998114757 2.024403732330958e-06 0.8836679564577563 2.024404226369383e-06 0.8845176198113115 \
2.024404367718007e-06 0.8847523712107549 2.024404974052073e-06 0.8857188576377059 2.024405126121396e-06 0.8859512996759633 2.024405772809558e-06 0.8868983431897121 \
2.02440590110417e-06 0.8870786909355212 2.024406549221232e-06 0.8879538337624689 2.024406679020295e-06 0.8881220828502663 2.024407457223772e-06 0.8890807033877333 \
2.024407572278734e-06 0.8892148977954012 2.024408427940206e-06 0.8901543051721961 2.024408573301076e-06 0.8903040038307473 2.024409559057127e-06 0.8912446482480114 \
2.024409780162496e-06 0.8914382978987679 2.024410925289423e-06 0.8923659558950503 2.024411056506439e-06 0.8924678262926897 2.024412397715013e-06 0.8934599079028542 \
2.024412549114272e-06 0.8935646301988298 2.024414030551995e-06 0.8944937559627255 2.024414269431373e-06 0.8946275407274444 2.024416038746979e-06 0.8955013787854181 \
2.024416427898191e-06 0.8956696032899972 2.024418821561142e-06 0.8965547188539188 2.02441929727014e-06 0.8967039926079825 2.02442336043021e-06 0.8977020505850396 \
2.024423851854269e-06 0.8977948037134476 2.024432168453822e-06 0.898787348739254 2.02443308835295e-06 0.8988506593152591 2.02457657358348e-06 0.8998476076348748 \
2.024577692016456e-06 0.8998537475785264 2.024782783635956e-06 0.898985773748599 2.024783010725457e-06 0.8988224379910277 2.024784620332256e-06 0.8978282360369357 \
2.024784797740799e-06 0.8977338482811539 2.024801704889099e-06 0.8987315468430059 2.024801814328198e-06 0.8987460089186867 2.024817595049444e-06 0.8997418097871094 \
2.02481789137534e-06 0.8997476966799167 2.025301325027745e-06 0.9007060148833608 2.025301454078085e-06 0.9008313386292994 2.025302104227931e-06 0.9016292186224167 \
2.025302293723661e-06 0.9019133038041363 2.02530279694564e-06 0.9027675859898705 2.0253029324183e-06 0.9030208676018907 2.025303332877016e-06 0.9038195223753869 \
2.025303464814953e-06 0.9040958310886574 2.025303866030017e-06 0.9049509627747726 2.025303964290194e-06 0.9051582028152527 2.025304430164004e-06 0.9060587574877488 \
2.025304591662727e-06 0.9063060456044927 2.02530573567525e-06 0.9055153668657776 2.025305880654596e-06 0.9049059606760256 2.025306059207354e-06 0.9039396653125833 \
2.025306239402631e-06 0.9027054491383806 2.025306382093561e-06 0.9015369228101149 2.025306499253164e-06 0.9004524619440171 2.025306588234525e-06 0.8995505656965809 \
2.025306679878178e-06 0.8985529714258781 2.02530681299011e-06 0.8969831049011855 2.025306906711193e-06 0.8957895978311226 2.025306997850002e-06 0.8945634483845346 \
2.025307111142313e-06 0.8929516940777753 2.025307214251226e-06 0.8913998138690341 2.025307310518407e-06 0.8898830246517148 2.025307429655523e-06 0.8879200664089764 \
2.025307598240772e-06 0.8849885378698126 2.025307760012273e-06 0.8820195265790133 2.025307953231332e-06 0.8782956415026882 2.025308138794443e-06 0.8745571577041361 \
2.025308349060748e-06 0.8701566079887386 2.025308531309789e-06 0.8662213066841463 2.025308716173183e-06 0.8621339172744639 2.02530888885833e-06 0.8582419637438897 \
2.025309074966404e-06 0.8539816046497358 2.025309252782492e-06 0.849858603441091 2.025309433499072e-06 0.8456251963850057 2.025309598637332e-06 0.8417258760277182 \
2.025309763911433e-06 0.837798995916667 2.025309927159096e-06 0.8339004324287677 2.02531008574937e-06 0.8300982805770993 2.025310262673772e-06 0.8258418712800655 \
2.025310459187584e-06 0.8211009660847696 2.025310626744125e-06 0.8170498602679914 2.025310793484544e-06 0.8130123908857781 2.025310967908062e-06 0.8087844286215062 \
2.025311137277684e-06 0.8046757316210446 2.025311305476778e-06 0.8005936994537799 2.025311494325046e-06 0.7960093488074458 2.025311685140882e-06 0.7913773844868103 \
2.025311893523092e-06 0.7863203192056716 2.025312119942597e-06 0.7808277108969495 2.025312309142794e-06 0.7762391340290878 2.025312519289483e-06 0.7711455503222944 \
2.025312668057988e-06 0.7675418410361046 2.025312799050976e-06 0.7643705172588006 2.025312936616212e-06 0.7610417440783073 2.025313042367442e-06 0.7584842184275663 \
2.025313177141075e-06 0.7552262509102785 2.025313288973801e-06 0.7525244432456109 2.025313418408965e-06 0.7493992292091655 2.025313573597688e-06 0.7456545577979357 \
2.025313685233441e-06 0.7429626190147979 2.025313844808055e-06 0.7391166470929011 2.025314020129688e-06 0.7348935218456193 2.025314232505151e-06 0.7297828120356423 \
2.025314425387679e-06 0.7251458607116523 2.025314582088971e-06 0.7213823872711312 2.025314768763662e-06 0.716903961299824 2.025314957650011e-06 0.7123775767926828 \
2.025315148534203e-06 0.70780884692282 2.025315335282138e-06 0.7033444557767304 2.025315518366954e-06 0.698972331957095 2.025315655685935e-06 0.6956951921588121 \
2.025315808928892e-06 0.6920418367118417 2.025316004057543e-06 0.6873949992893974 2.025316161351872e-06 0.6836535194673684 2.025316320746467e-06 0.6798660670227984 \
2.02531651649026e-06 0.6752219404489795 2.025316708689394e-06 0.6706682621108646 2.025316943641022e-06 0.6651105611269369 2.02531713111727e-06 0.6606839627962382 \
2.025317368354404e-06 0.6550894036851447 2.025317557534366e-06 0.6506361170423679 2.025317738150179e-06 0.6463915264929231 2.025317901844742e-06 0.6425504277539856 \
2.02531804639615e-06 0.6391628119244788 2.02531818686792e-06 0.6358764726647652 2.025318313968708e-06 0.6329064225879303 2.025318446276184e-06 0.6298198307262635 \
2.02531857286323e-06 0.626870110582017 2.025318703443498e-06 0.62383130535404 2.025318832712896e-06 0.6208285625908692 2.025318971819793e-06 0.6176004736356133 \
2.025319120330103e-06 0.6141606483517721 2.025319309878658e-06 0.6097777958748198 2.025319455581914e-06 0.6064170107178907 2.025319690632478e-06 0.601007464699683 \
2.025319873631749e-06 0.5968099615921 2.025320097973422e-06 0.5916778694808832 2.025320269146672e-06 0.5877753019413697 2.025320401480491e-06 0.5847634284691802 \
2.02532053327703e-06 0.5817721407249107 2.025320639820934e-06 0.5793579518205488 2.025320735711292e-06 0.5771868999037388 2.025320828211542e-06 0.5750974572268882 \
2.025320920638905e-06 0.5730134868920421 2.025320993067212e-06 0.5713818265150021 2.025321048796317e-06 0.5701269325864891 2.025321109905405e-06 0.5687522410723198 \
2.02532120667008e-06 0.5665806864277688 2.025321268161595e-06 0.5652027770813386 2.025321327214216e-06 0.5638802801505602 2.025321402840882e-06 0.5621878686488651 \
2.02532146986366e-06 0.5606896577364279 2.02532154346077e-06 0.5590483558003441 2.025321611066773e-06 0.5575429304381756 2.025321727135829e-06 0.5549610936632026 \
2.025321827342234e-06 0.5527359403974305 2.025321939349424e-06 0.5502565947066531 2.025322033841475e-06 0.5481686943853854 2.025322154996173e-06 0.5454955387196141 \
2.025322255183939e-06 0.5432910220514219 2.025322371174451e-06 0.5407443765731218 2.025322478878288e-06 0.5383833065966291 2.025322588456977e-06 0.5359861028148916 \
2.025322700578421e-06 0.5335400310751951 2.025322827515605e-06 0.5307765704644959 2.025322949665123e-06 0.5281221248815906 2.025323089426038e-06 0.525095489155881 \
2.025323226564154e-06 0.522132778766487 2.025323376529244e-06 0.5189020692106626 2.025323535302247e-06 0.5154923220538846 2.025323709327904e-06 0.511765695450105 \
2.025323896158028e-06 0.5077823379664483 2.025324101125994e-06 0.5034264211640872 2.025324323834942e-06 0.4987133299464507 2.025324576739139e-06 0.4933874474923696 \
2.025324811693046e-06 0.4884604410272814 2.025325107961308e-06 0.4822828691822955 2.025325397751266e-06 0.4762763831984252 2.025325704087085e-06 0.4699660956099861 \
2.025326016405612e-06 0.4635767846525711 2.025326354971068e-06 0.4566963260653934 2.025326678082485e-06 0.4501741115777416 2.025327016477788e-06 0.4433881855507311 \
2.025327340309054e-06 0.4369378830387565 2.025327664703474e-06 0.4305204627449936 2.02532800763776e-06 0.4237851826852676 2.025328346918578e-06 0.4171698123421442 \
2.025328686393213e-06 0.4105997181257849 2.025329129505058e-06 0.4020958655332711 2.025329491573227e-06 0.3952155038183801 2.025329812124965e-06 0.3891775711374149 \
2.025330199059534e-06 0.3819561902961204 2.025330526929795e-06 0.3758957719299574 2.025330812088852e-06 0.3706704968427373 2.025331130457646e-06 0.3648820026298218 \
2.025331413288573e-06 0.3597820188690578 2.025331641977337e-06 0.3556924369094372 2.025331859870142e-06 0.3518226517641353 2.025332055119486e-06 0.3483769517668343 \
2.025332262027586e-06 0.344751588202948 2.025332476824342e-06 0.3410137651016431 2.025332729050892e-06 0.3366564674340092 2.025332971046205e-06 0.3325077909124976 \
2.025333201898484e-06 0.3285822460490526 2.025333416746675e-06 0.3249550452085373 2.025333637103364e-06 0.3212604562488142 2.025333838674264e-06 0.3179050685021769 \
2.025334041758211e-06 0.3145531374773136 2.025334239655597e-06 0.3113121771742085 2.025334426754836e-06 0.3082694484595072 2.02533462065518e-06 0.3051385396431291 \
2.025334825703514e-06 0.3018527636900292 2.025335005938266e-06 0.2989872106339772 2.025335241836277e-06 0.2952669081535775 2.025335443123828e-06 0.2921198200609627 \
2.025335644514631e-06 0.2889965001417216 2.025335869163794e-06 0.2855437159941698 2.025336034543768e-06 0.2830223598911593 2.025336212348106e-06 0.280330186126118 \
2.025336396004319e-06 0.277570343839212 2.025336581246077e-06 0.2748090658167894 2.025336759391454e-06 0.2721781298892599 2.025336932983518e-06 0.2696316866093095 \
2.02533709334837e-06 0.267306655456324 2.025337214459553e-06 0.2655585721882695 2.025337367654341e-06 0.2633570345323199 2.025337494985789e-06 0.2615475749425888 \
2.025337598313628e-06 0.2600830587034867 2.025337715638424e-06 0.2584225376281647 2.025337833445381e-06 0.2567591557214636 2.025337957409147e-06 0.2550199666844239 \
2.025338074393314e-06 0.2533821414201824 2.025338205189442e-06 0.2515535495016885 2.025338322399552e-06 0.2499173892700276 2.025338475652677e-06 0.2477853623028658 \
2.025338611183197e-06 0.2459029165157107 2.025338742864406e-06 0.244074199323236 2.025338899457317e-06 0.2419017673596028 2.025339024653875e-06 0.2401755227310949 \
2.025339160371502e-06 0.2383060149301216 2.025339292798663e-06 0.2364844144139329 2.025339412772324e-06 0.2348355337769661 2.025339575820161e-06 0.232606585912384 \
2.025339714627253e-06 0.230713852557009 2.025339853100972e-06 0.2288300961780371 2.025339958645721e-06 0.2273962817971701 2.025340087007401e-06 0.2256537837490921 \
2.025340191135024e-06 0.2242444877898851 2.025340291651026e-06 0.222886569499566 2.025340366695402e-06 0.2218745444235658 2.025340444028457e-06 0.2208349692306942 \
2.025340518791637e-06 0.2198305887827458 2.025340596755314e-06 0.218785487158918 2.025340651621824e-06 0.2180503923904892 2.0253407081186e-06 0.2172938400168352 \
2.025340751572119e-06 0.2167123195211523 2.025340791613166e-06 0.2161767335077376 2.025340830852113e-06 0.2156521099473339 2.02534087172635e-06 0.2151058606261434 \
2.02534092587884e-06 0.2143825797409383 2.025340964295972e-06 0.2138698309421548 2.025341003584679e-06 0.2133480458229882 2.025341065121387e-06 0.2125332203444249 \
2.025341127098915e-06 0.2117131287842428 2.025341183575664e-06 0.2109664019951111 2.025341248207255e-06 0.2101124842966758 2.025341343715876e-06 0.2088522205996687 \
2.025341431031607e-06 0.207701294711168 2.025341527641208e-06 0.2064291756790013 2.025341624870762e-06 0.2051510266126755 2.025341725717823e-06 0.2038307158897115 \
2.025341826317594e-06 0.2025192706911573 2.025341922808891e-06 0.2012627769767186 2.025342024991065e-06 0.1999338657614989 2.025342128630721e-06 0.1985898465970496 \
2.025342238404734e-06 0.1971698847140261 2.02534234757976e-06 0.1957617939809042 2.025342467677852e-06 0.1942174441246506 2.025342577697376e-06 0.1928086337505992 \
2.025342685809285e-06 0.1914295694688549 2.025342808837984e-06 0.1898652723262108 2.025342898948554e-06 0.1887234630454603 2.025343006314045e-06 0.1873671680421656 \
2.025343083125352e-06 0.1864004060894758 2.025343166570621e-06 0.1853535952511875 2.025343256102432e-06 0.1842338297700716 2.025343340667899e-06 0.1831790839553313 \
2.025343420384039e-06 0.1821880912968773 2.025343521709242e-06 0.1809331989518758 2.025343630056471e-06 0.1795959386230563 2.02534372653217e-06 0.1784102562612937 \
2.025343851909986e-06 0.1768766438339704 2.025343984693456e-06 0.1752616821119887 2.02534410246428e-06 0.1738362801839788 2.025344248115856e-06 0.1720835746408261 \
2.025344358713008e-06 0.1707596463148658 2.025344500843447e-06 0.1690680578777541 2.02534461655307e-06 0.1676985735146403 2.025344722027083e-06 0.166456424915798 \
2.025344816543742e-06 0.1653485352650968 2.025344912181114e-06 0.1642320043563913 2.025345009252958e-06 0.1631032360400927 2.025345108304212e-06 0.161956192050434 \
2.025345202227769e-06 0.1608730077890209 2.025345287503444e-06 0.1598934595213354 2.025345387883236e-06 0.1587475631033795 2.025345472186073e-06 0.1577906478848196 \
2.025345574585582e-06 0.1566342854655733 2.025345651979844e-06 0.1557646215197878 2.025345744324758e-06 0.154731814591042 2.02534581457623e-06 0.1539498814072817 \
2.025345910750659e-06 0.1528844393027091 2.025345987575323e-06 0.152038051282755 2.025346066345474e-06 0.1511758489440315 2.025346140238394e-06 0.150370438825067 \
2.025346207936138e-06 0.1496353997608715 2.025346304000026e-06 0.1485973848112393 2.025346373572453e-06 0.1478489919002561 2.025346457461626e-06 0.1469503328160803 \
2.025346518593462e-06 0.146298213254472 2.025346590861543e-06 0.1455309799806117 2.025346663300106e-06 0.1447677488542132 2.025346744281147e-06 0.1439178685120187 \
2.025346810355616e-06 0.1432275520600639 2.025346887756114e-06 0.1424219220725307 2.02534697713157e-06 0.1414956876531561 2.025347047992217e-06 0.1407644282175171 \
2.025347146879283e-06 0.1397487730030469 2.025347224198192e-06 0.1389620820751095 2.025347306243418e-06 0.1381330876879582 2.02534739435453e-06 0.1372467208126059 \
2.025347461981677e-06 0.1365690714953818 2.025347542278859e-06 0.1357674830239305 2.025347617062888e-06 0.1350239185327315 2.025347685064065e-06 0.1343502586094245 \
2.025347731746974e-06 0.1338891847862563 2.025347820998567e-06 0.1330118383700247 2.025347859221617e-06 0.1326395291833771 2.025347928213527e-06 0.1319690872918072 \
2.025347980961596e-06 0.1314578750898332 2.025348063954379e-06 0.1306559489775353 2.025348104132829e-06 0.1302688434457458 2.025348196650203e-06 0.1293805059784019 \
2.02534823536857e-06 0.1290098403727171 2.025348309129285e-06 0.1283055160094505 2.025348370757287e-06 0.1277188748199021 2.025348442784976e-06 0.1270353589407805 \
2.025348510952008e-06 0.1263909833196726 2.025348585574169e-06 0.1256908956540175 2.025348667426635e-06 0.1249253613889138 2.025348750880797e-06 0.124147338931438 \
2.025348823832511e-06 0.1234692772477456 2.025348896559441e-06 0.122795332839617 2.025348956549436e-06 0.1222410931008323 2.025349042917447e-06 0.121445549533078 \
2.025349103886164e-06 0.1208856452315438 2.025349162271955e-06 0.1203507897957366 2.02534922790662e-06 0.119751336354628 2.025349287260861e-06 0.1192111367930785 \
2.025349355292642e-06 0.1185941868697126 2.025349452587012e-06 0.11771710490035 2.025349531078992e-06 0.1170124163111649 2.025349621315123e-06 0.1162055395685231 \
2.025349717161808e-06 0.1153523005684616 2.025349792119505e-06 0.1146878351828532 2.025349896478921e-06 0.1137670532163148 2.025349983267518e-06 0.1130053589403202 \
2.025350092924934e-06 0.1120476726212376 2.025350174478997e-06 0.1113387926087848 2.025350270092629e-06 0.1105114393564785 2.025350346804823e-06 0.10985058581598 \
2.025350441723287e-06 0.1090364400125625 2.025350517546392e-06 0.1083889268999046 2.025350595246049e-06 0.1077282965354292 2.0253506775775e-06 0.1070311517075373 \
2.025350737142764e-06 0.1065286079538068 2.025350800900501e-06 0.1059924133642201 2.025350861995109e-06 0.1054803128126646 2.025350957858847e-06 0.1046801683739134 \
2.025351002721941e-06 0.1043071445723913 2.025351085962687e-06 0.1036173314376927 2.025351135082509e-06 0.1032117000904133 2.025351244131271e-06 0.1023149933518279 \
2.025351288967354e-06 0.1019479364619093 2.025351379228585e-06 0.1012117400678687 2.025351420105203e-06 0.1008795969612472 2.025351490563617e-06 0.1003088525914566 \
2.025351576851038e-06 0.09961307626065434 2.025351668628597e-06 0.09887705578174606 2.02535173815669e-06 0.09832225024344161 2.025351816683849e-06 0.09769854072774181 \
2.025351907412526e-06 0.09698178745350861 2.025351983228664e-06 0.09638605854785212 2.025352065241407e-06 0.09574500473888557 2.025352146994443e-06 0.09510943278387665 \
2.025352237502267e-06 0.09440967388330095 2.025352327061565e-06 0.09372126988887708 2.025352412671398e-06 0.09306698857649189 2.025352505450896e-06 0.09236212353634379 \
2.025352586338857e-06 0.0917510971760913 2.025352687467827e-06 0.09099177263830999 2.025352767961352e-06 0.09039108594384238 2.025352852204218e-06 0.08976589684797046 \
2.025352926049265e-06 0.08922077348043934 2.025353002898744e-06 0.08865632925481931 2.025353091039112e-06 0.08801255002475737 2.025353171103482e-06 0.08743108261130086 \
2.025353264139672e-06 0.08675939571108145 2.025353382140385e-06 0.08591369538214398 2.025353524513612e-06 0.08490278100234279 2.025353668761962e-06 0.08388867104764453 \
2.025353811089671e-06 0.08289807427203813 2.025353960667415e-06 0.08186746790234835 2.025354096981161e-06 0.08093761126893445 2.025354239101592e-06 0.0799778356000513 \
2.02535437365502e-06 0.07907840240745091 2.02535451400773e-06 0.07814980287393705 2.025354661689802e-06 0.0771833418413561 2.025354811805299e-06 0.07621180464723754 \
2.025354976525776e-06 0.07515824360926991 2.025355140155128e-06 0.07412455432658185 2.025355314933688e-06 0.07303438636984133 2.025355502186304e-06 0.07188220095900363 \
2.025355712231308e-06 0.07060976590783831 2.025355930441531e-06 0.06930979572898451 2.025356163898619e-06 0.06794333957253913 2.025356418744638e-06 0.06648001693367038 \
2.025356711839195e-06 0.06483321328442151 2.025357014178957e-06 0.06317411115207273 2.025357328765832e-06 0.06148945259513613 2.025357725026527e-06 0.05942677493938087 \
2.025358058743672e-06 0.05774249301432461 2.025358466054501e-06 0.05574994498853819 2.02535879393926e-06 0.05419380357502902 2.025359150629899e-06 0.05254809000207299 \
2.02535946386806e-06 0.05114243792209583 2.025359766835193e-06 0.04981740498512215 2.025360064375719e-06 0.04854875663330436 2.025360343155274e-06 0.04739109061078805 \
2.025360626155169e-06 0.04624570307560639 2.025360887895477e-06 0.04521055793698023 2.02536116713437e-06 0.04413130357485813 2.02536143924029e-06 0.0431040186124033 \
2.025361746607047e-06 0.04197194005652995 2.025361968409948e-06 0.04117329707315532 2.025362274870428e-06 0.04009446155587663 2.025362501059881e-06 0.03931650950691581 \
2.025362739977206e-06 0.03851359500741255 2.025362964401039e-06 0.03777663690506906 2.025363166663321e-06 0.03712468825868943 2.025363367705949e-06 0.03648814235703791 \
2.025363719479983e-06 0.03540095449820539 2.025363969725821e-06 0.03464776841732944 2.025364216044101e-06 0.03392252499723709 2.025364497376965e-06 0.03311308780599518 \
2.02536474046795e-06 0.03242954897046491 2.025364975941701e-06 0.03178112583711486 2.025365217601206e-06 0.03113119522156456 2.025365454483483e-06 0.03050988948014832 \
2.025365685016041e-06 0.02991733361391674 2.025365898984569e-06 0.02937801894285819 2.025366104927116e-06 0.02886851641492237 2.025366497651603e-06 0.02792196059063811 \
2.025366685729283e-06 0.02747992420741849 2.025367061168249e-06 0.02661861215736662 2.025367236042478e-06 0.02622659266649364 2.025367659365492e-06 0.02530049759795254 \
2.025367780614876e-06 0.02504150687334681 2.025368221176528e-06 0.02412433837770948 2.025368363674648e-06 0.02383402682615681 2.025368695728158e-06 0.02316883068419595 \
2.025368878693682e-06 0.02280879143785283 2.025369267997886e-06 0.02205689891561978 2.025369436343594e-06 0.02173705378531499 2.025369908457993e-06 0.02085107653961301 \
2.025370048202727e-06 0.0205916297664938 2.025370543782805e-06 0.01969297428531048 2.025370671008238e-06 0.01946923320191776 2.025371238917342e-06 0.01851512288677271 \
2.02537140317129e-06 0.0182513999453204 2.025372013043029e-06 0.0173209960017622 2.025372172728257e-06 0.01708922829277545 2.025372699639798e-06 0.01635462467776483 \
2.025372904157091e-06 0.01608193551804103 2.025373627634478e-06 0.01515939662837778 2.02537379307661e-06 0.01495683325581705 2.025374539636356e-06 0.01408081084911163 \
2.025374672939569e-06 0.01393008075245666 2.025375533124155e-06 0.01299799962960837 2.02537566920557e-06 0.01285670227674402 2.02537660979946e-06 0.01192267652923807 \
2.025376773572533e-06 0.01176632439256516 2.025377774751465e-06 0.01084959205883911 2.025377912229187e-06 0.01072929995296418 2.025379082926798e-06 0.009787962024485789 \
2.025379175323166e-06 0.009718668544398181 2.025380593399014e-06 0.008725931027897449 2.025380680375162e-06 0.00866912727384293 2.025382221370793e-06 0.00770199130002063 \
2.025382330686807e-06 0.007633428668288294 2.025383973934629e-06 0.006673746291950173 2.025384106791908e-06 0.006603544020797993 2.025386201172206e-06 0.005605323336654431 \
2.025386409576941e-06 0.00551468736035817 2.025388763913366e-06 0.004577307911602986 2.025389237472123e-06 0.004407121484391641 2.02539212290898e-06 0.003492041675788492 \
2.025392652573327e-06 0.00334538389506189 2.025396860800552e-06 0.00237996320858989 2.025397374234803e-06 0.002283557532494709 2.025403133485496e-06 0.001325291758975802 \
2.025403368066713e-06 0.001279502680325907 2.025418035894088e-06 0.0002809017338477542 2.02541814896418e-06 0.0002788534805396912 2.02805516904393e-06 -0.0006849217749926401 \
2.028055335205606e-06 -0.0009443270389602415 2.028055814074993e-06 -0.001850320037528519 2.02805590679462e-06 -0.002050462221988249 2.028056272019697e-06 -0.002913187630468476 \
2.028056363676814e-06 -0.00314709230904735 2.028056729783165e-06 -0.004133001189868674 2.028056839930291e-06 -0.004442309109773816 2.028057150668543e-06 -0.005311341427314526 \
2.028057252407188e-06 -0.005583925258601597 2.028057616111313e-06 -0.00638370916272213 2.028057780957637e-06 -0.006585924750287024 2.028058360754956e-06 -0.005792290386912202 \
2.028058535589415e-06 -0.004916934050781314 2.028058652279015e-06 -0.00413641027497409 2.028058778708708e-06 -0.00310656561120747 2.028058880730911e-06 -0.002137079422087956 \
2.028059000577393e-06 -0.0008406209844352954 2.028059091214629e-06 0.0002489246187367611 2.028059189634679e-06 0.001536790859923857 2.028059289358323e-06 0.002948496343048522 \
2.028059456842332e-06 0.005545701385567424 2.028059675420934e-06 0.009327395936412004 2.028059861491256e-06 0.0128572688386996 2.028060082873864e-06 0.01737012273305725 \
2.028060243533998e-06 0.02082840415615294 2.028060406999647e-06 0.02447866954313523 2.028060557635164e-06 0.02794359528291388 2.028060706690917e-06 0.03145289236167962 \
2.028060856153671e-06 0.03504014479003619 2.028061010184684e-06 0.03879791952579481 2.028061172300943e-06 0.04280891157365373 2.028061338330408e-06 0.04696567134311741 \
2.028061514283228e-06 0.05141478668696391 2.028061694953866e-06 0.05602187592747932 2.028061886774812e-06 0.06094655248807559 2.028062093880316e-06 0.06629309753158302 \
2.028062315452046e-06 0.07203901748582854 2.028062550186216e-06 0.07814662931008168 2.028062801725783e-06 0.08470684589377442 2.028063077167849e-06 0.09190125212984442 \
2.028063377363668e-06 0.09974607960254324 2.028063708295878e-06 0.108390578238945 2.028064083962612e-06 0.1181923833971668 2.02806448154548e-06 0.1285487285136021 \
2.028064948370082e-06 0.1406786766767902 2.028065491362617e-06 0.1547396794802719 2.02806612478764e-06 0.1710742296429572 2.028066820727691e-06 0.1889259607126788 \
2.0280676362848e-06 0.2097135943149445 2.028068546312904e-06 0.2327316641523666 2.028069339569124e-06 0.2526372689279454 2.0280700450442e-06 0.2702038474981599 \
2.028070663988468e-06 0.2855008995781749 2.028071231094408e-06 0.2994177966724069 2.028071754174414e-06 0.3121574438576628 2.028072253153207e-06 0.3242197130846058 \
2.028072737193214e-06 0.3358335658028451 2.028073192420047e-06 0.3466679577370423 2.028073666932009e-06 0.3578644504627745 2.028074106840717e-06 0.368158604789619 \
2.028074592685345e-06 0.3794271463718566 2.028075124288118e-06 0.3916316501999784 2.028075626951417e-06 0.4030538969706937 2.02807605602367e-06 0.4127111343288326 \
2.028076547040338e-06 0.4236561147984291 2.028077048470419e-06 0.434714731975362 2.028077395015009e-06 0.442288187401736 2.028077750424386e-06 0.4500000616404133 \
2.028078177652115e-06 0.4592019891792938 2.028078569851637e-06 0.4675774400278049 2.028078870233395e-06 0.4739448723400065 2.028079212045155e-06 0.4811381049525967 \
2.028079555484969e-06 0.4883107756756314 2.028079816220095e-06 0.4937186470393492 2.028080058250049e-06 0.4987071765458648 2.028080324195291e-06 0.5041573145298286 \
2.028080581464587e-06 0.509394255416739 2.02808077158369e-06 0.5132422368582924 2.028080985109851e-06 0.5175451019736222 2.028081124800157e-06 0.5203466115392713 \
2.028081271000449e-06 0.5232668091041763 2.02808148498835e-06 0.5275186200231483 2.02808169300461e-06 0.5316389396023125 2.028081885465879e-06 0.5354321131715788 \
2.02808207058211e-06 0.5390651926504321 2.028082244955557e-06 0.5424725330931349 2.028082549497633e-06 0.5484058192982523 2.028082810056515e-06 0.5534602958276967 \
2.028083111487544e-06 0.5592859190791987 2.028083365805138e-06 0.5641865993769294 2.028083658661328e-06 0.5698153316805189 2.02808391787448e-06 0.5747800306938655 \
2.028084188950812e-06 0.579963273174682 2.028084430794571e-06 0.5845680738798381 2.028084688299729e-06 0.5894577538325241 2.028084915043605e-06 0.5937419314630586 \
2.028085152044424e-06 0.5982006324572362 2.028085362230986e-06 0.6021379329905048 2.02808557499152e-06 0.6061060319396779 2.028085827870286e-06 0.6107954169450593 \
2.028086031533554e-06 0.6145509252949414 2.028086222250936e-06 0.6180531102377972 2.028086409587374e-06 0.6214768531423983 2.028086598465652e-06 0.6249070011644339 \
2.028086806665448e-06 0.6286671070650327 2.028087050997562e-06 0.6330499453121026 2.028087250564095e-06 0.6366057789565548 2.028087454709836e-06 0.6402215701419991 \
2.02808763934909e-06 0.643474671963314 2.028087908884781e-06 0.6481901084955864 2.028088136591638e-06 0.652149230294136 2.028088324263375e-06 0.6553888277830079 \
2.02808850516352e-06 0.6584949378977958 2.028088664704602e-06 0.661221510907812 2.028088835167002e-06 0.6641177016088209 2.028088986918443e-06 0.6666817235716488 \
2.028089124561455e-06 0.6689905419339194 2.028089273556319e-06 0.6714784915997724 2.028089401298182e-06 0.6736028790357499 2.028089544284695e-06 0.675968899142866 \
2.028089666067751e-06 0.6779749688503388 2.028089802351161e-06 0.6802121872853304 2.028089922180062e-06 0.682172759947357 2.028090068775623e-06 0.6845626218370968 \
2.028090187248565e-06 0.6864845934661837 2.028090283181927e-06 0.6880368302455475 2.028090375701511e-06 0.6895284278106264 2.028090480762022e-06 0.6912169000724893 \
2.028090578843908e-06 0.6927871490736753 2.028090715959225e-06 0.6949707622226827 2.028090835157868e-06 0.6968607547931925 2.028090945097838e-06 0.6985951241089645 \
2.028091082597082e-06 0.7007503743809057 2.028091214026983e-06 0.7027960765825516 2.028091346256499e-06 0.7048392108129343 2.028091459433897e-06 0.7065756917706891 \
2.028091613866752e-06 0.708927873976708 2.028091744646745e-06 0.7109048231498766 2.028091867315455e-06 0.7127465601965561 2.028091973583711e-06 0.7143329262278221 \
2.028092095963735e-06 0.7161490373358268 2.028092197817232e-06 0.7176517022913665 2.028092331955132e-06 0.7196190116794019 2.028092452648172e-06 0.7213783352064487 \
2.02809257178997e-06 0.7231049829175343 2.028092696807985e-06 0.7249059312823601 2.028092826647791e-06 0.7267645120560844 2.028092946459962e-06 0.7284691779696002 \
2.028093075453213e-06 0.730293808329565 2.028093207560277e-06 0.7321507998840678 2.028093325866095e-06 0.7338038328985433 2.028093469126786e-06 0.7357927618453034 \
2.028093571581473e-06 0.7372070005703254 2.028093667788359e-06 0.7385290937783453 2.028093772805981e-06 0.7399656334130889 2.028093883577511e-06 0.7414708009413548 \
2.028093985256052e-06 0.7428439364018735 2.028094088217506e-06 0.7442258341871242 2.028094205143661e-06 0.7457850038572696 2.028094333903936e-06 0.747489965072781 \
2.028094435062908e-06 0.7488201182152049 2.028094583931952e-06 0.7507626302114226 2.028094731611489e-06 0.75267249971878 2.028094850976855e-06 0.7542038164026367 \
2.0280949974607e-06 0.7560679527984652 2.02809512063619e-06 0.7576223900169708 2.028095261439865e-06 0.7593848990234215 2.028095398032531e-06 0.7610800595258669 \
2.028095520190381e-06 0.7625841275516777 2.028095632846779e-06 0.7639610711610054 2.02809577457292e-06 0.7656796138775311 2.02809590073942e-06 0.767196844592689 \
2.028096016156724e-06 0.768574452686535 2.028096146464904e-06 0.7701179991486644 2.028096262177572e-06 0.7714782821591826 2.02809638500186e-06 0.7729116492687436 \
2.028096502846129e-06 0.7742769236963016 2.028096608476119e-06 0.7754922619072108 2.028096723849553e-06 0.7768108638983861 2.028096829112716e-06 0.7780056027231214 \
2.028096940062529e-06 0.7792565499870431 2.028097026467031e-06 0.7802246528436213 2.028097130500851e-06 0.7813823422463088 2.028097244396594e-06 0.7826398494046257 \
2.028097347430014e-06 0.7837684443710583 2.028097455512714e-06 0.7849432998269023 2.02809756376437e-06 0.7861107422109641 2.028097699181616e-06 0.7875582910536544 \
2.028097811855724e-06 0.7887521292973186 2.028097936279784e-06 0.7900592323105087 2.028098054252648e-06 0.7912877959129118 2.028098198720603e-06 0.7927781272271259 \
2.028098316389742e-06 0.7939806363584788 2.028098452269581e-06 0.7953567374150946 2.028098587013954e-06 0.7967081403609936 2.028098698084933e-06 0.7978123285366109 \
2.028098797974273e-06 0.7987978371087655 2.02809889965423e-06 0.7997937268659365 2.028099032867897e-06 0.8010867894381996 2.028099151240716e-06 0.8022243628210853 \
2.028099272781791e-06 0.8033812848148773 2.028099392145442e-06 0.8045065422543012 2.028099513276819e-06 0.80563739819571 2.028099644976236e-06 0.8068544426691319 \
2.028099767984513e-06 0.8079795872959963 2.02809989582812e-06 0.8091371804586788 2.02810002673464e-06 0.8103101881504271 2.028100150327798e-06 0.8114062915203997 \
2.028100257500303e-06 0.8123479140825919 2.028100364929502e-06 0.8132835730547656 2.028100447598621e-06 0.8139979974227743 2.028100565310381e-06 0.8150069815425507 \
2.028100655915986e-06 0.8157770472204025 2.028100786569431e-06 0.8168774959419571 2.028100930959301e-06 0.8180800468042847 2.028101064133715e-06 0.8191766687328477 \
2.028101174025106e-06 0.8200725423139092 2.028101317623992e-06 0.8212302325252553 2.028101471014683e-06 0.8224508494407716 2.028101599092908e-06 0.8234574467428303 \
2.028101738880276e-06 0.8245431382086058 2.028101865129839e-06 0.8255122018650548 2.028102019728392e-06 0.8266841987320058 2.028102151939368e-06 0.8276738265999063 \
2.028102278166151e-06 0.8286078934539939 2.028102395913874e-06 0.8294698388787296 2.028102544986668e-06 0.8305480062617677 2.028102712318221e-06 0.8317406852496945 \
2.028102845539497e-06 0.8326770812274722 2.028103018320819e-06 0.8338744310092966 2.028103186826193e-06 0.8350236380668206 2.028103356205492e-06 0.8361608866600232 \
2.028103537840761e-06 0.8373606451951652 2.028103680174083e-06 0.8382866867625347 2.028103794011069e-06 0.8390185116470331 2.028103925192579e-06 0.8398522525089582 \
2.028104026724794e-06 0.8404903982372576 2.028104143009054e-06 0.8412135669902132 2.028104277643808e-06 0.8420406924792603 2.028104474666644e-06 0.8432316292878405 \
2.028104664772186e-06 0.8443592803112207 2.028104874895499e-06 0.8455816023960827 2.028105055213604e-06 0.8466107566581813 2.028105252676705e-06 0.8477171937062282 \
2.02810542674582e-06 0.8486750118570332 2.02810560906524e-06 0.8496608982186138 2.028105780480376e-06 0.8505716849290491 2.028105954593653e-06 0.8514808063694008 \
2.028106130324621e-06 0.8523822271368225 2.028106306436321e-06 0.8532696099472232 2.028106496054173e-06 0.8542074684498208 2.02810668683567e-06 0.8551330189126392 \
2.028106888431747e-06 0.8560917259710515 2.028107081166005e-06 0.856990088884472 2.028107290037826e-06 0.8579439907476532 2.028107520740263e-06 0.8589743400177088 \
2.028107785183227e-06 0.8601259267840322 2.028108084005915e-06 0.8613896125360476 2.028108363960216e-06 0.8625380186322354 2.028108648086082e-06 0.8636694076724545 \
2.028108922855057e-06 0.8647317823994775 2.028109194712217e-06 0.8657531067718063 2.028109465089334e-06 0.8667403371654003 2.028109722167856e-06 0.8676533221001362 \
2.028109994792687e-06 0.868594905839151 2.028110270759835e-06 0.8695208838709013 2.028110540864093e-06 0.8704012674911344 2.028110840740104e-06 0.8713491368600049 \
2.028111211801163e-06 0.8724801680184872 2.02811150674079e-06 0.8733472453740196 2.028111761036548e-06 0.8740729094291386 2.028112059297474e-06 0.8748989982677786 \
2.028112332904015e-06 0.8756336613858092 2.028112569029958e-06 0.876250392688866 2.028112809374056e-06 0.8768621356511911 2.028113031706182e-06 0.8774140071409635 \
2.028113225712247e-06 0.8778848105679672 2.028113555434997e-06 0.8786625669521169 2.028113710608525e-06 0.8790190643519731 2.028114028387606e-06 0.879730644938159 \
2.028114207248865e-06 0.8801204696806418 2.028114549710761e-06 0.8808457867651537 2.028114733837363e-06 0.8812245477320809 2.028115208711942e-06 0.8821665346129511 \
2.028115376108352e-06 0.8824869809105039 2.028115841951854e-06 0.883348261932613 2.028116022773548e-06 0.8836708855253055 2.02811651681265e-06 0.8845204537290557 \
2.028116658162059e-06 0.8847551796839913 2.028117264500122e-06 0.8857215808967022 2.028117416569336e-06 0.8859539944113424 2.028118063256356e-06 0.8869009218298172 \
2.028118191551239e-06 0.8870812460539503 2.028118839667745e-06 0.8879562712787433 2.028118969467641e-06 0.8881245027440973 2.02811974767834e-06 0.8890830197250962 \
2.028119862725472e-06 0.8892171882189283 2.028120718396314e-06 0.8901564861234483 2.028120863744077e-06 0.8903061494816453 2.028121849499649e-06 0.8912466483555094 \
2.028122070607711e-06 0.8914402669210102 2.028123215727715e-06 0.892367747196105 2.028123346939159e-06 0.8924695935232408 2.028124688211624e-06 0.8934615053489913 \
2.0281248396029e-06 0.8935661991834861 2.02812632105512e-06 0.8944951400107031 2.028126559934816e-06 0.8946288932334222 2.028128329356654e-06 0.895502508848118 \
2.028128718477945e-06 0.895670668133377 2.028131112210654e-06 0.8965556062201232 2.028131587750593e-06 0.8967047758494365 2.028135650819817e-06 0.8977025964496719 \
2.028136142295654e-06 0.8977953148389237 2.028144458892796e-06 0.8987880790885289 2.028145378794248e-06 0.8988514070442593 2.028299242370168e-06 0.8998485708192639 \
2.028302885496457e-06 0.8998628537402877 2.028529614276672e-06 0.8989664306490068 2.028529844616583e-06 0.8988008565867064 2.02853145953688e-06 0.897804750401333 \
2.028531637269166e-06 0.8977103535805105 2.028548403669272e-06 0.8986978311584225 2.028548539768403e-06 0.8987160394686986 2.028563710608672e-06 0.8997133888183054 \
2.028563987713508e-06 0.899719468756186 2.029048028906422e-06 0.9005852143835333 2.029048202241039e-06 0.9007408621809421 2.029048862730638e-06 0.9015135064485434 \
2.02904902879582e-06 0.9017527716291757 2.029049555130528e-06 0.9026184054967997 2.029049746244448e-06 0.9029704910143604 2.0290501104655e-06 0.9036902342402512 \
2.029050289664921e-06 0.9040628043424317 2.029050651551594e-06 0.9048333795345931 2.029050846661164e-06 0.9052442844328937 2.029051379059525e-06 0.9062266394381637 \
2.029051561413164e-06 0.9064623886473868 2.029052553393556e-06 0.905594670761786 2.029052714934123e-06 0.9049318860608667 2.029052882926575e-06 0.9040378649110347 \
2.029053042758061e-06 0.9029782421366458 2.029053180254799e-06 0.9018984154159868 2.029053313162112e-06 0.9007052793196499 2.029053439587579e-06 0.8994328447569792 \
2.029053546986819e-06 0.8982475863895881 2.029053651483477e-06 0.8970047013543965 2.029053765533147e-06 0.8955451342423859 2.029053855502734e-06 0.8943225684615312 \
2.029053960321373e-06 0.8928208677113324 2.029054049769612e-06 0.891473284704788 2.029054132145393e-06 0.8901820884368528 2.029054223238393e-06 0.8887006634027688 \
2.029054360574471e-06 0.8863657732814155 2.029054459067403e-06 0.8846195012157601 2.029054571141153e-06 0.8825649218508906 2.029054702024186e-06 0.880080778639088 \
2.029054838495216e-06 0.8774018563482072 2.029054991949379e-06 0.8742910281085086 2.029055151043747e-06 0.8709679977889497 2.029055315327649e-06 0.867445283300377 \
2.029055471995751e-06 0.8640104344288071 2.029055624086531e-06 0.860615744772629 2.029055777800207e-06 0.857132398554192 2.029055937362381e-06 0.853469801378647 \
2.029056092451083e-06 0.8498714074018293 2.029056266130402e-06 0.8458039138600054 2.02905642916127e-06 0.8419559450883216 2.029056590803684e-06 0.8381170660338335 \
2.029056753450421e-06 0.8342344554797501 2.029056914868927e-06 0.8303657475978833 2.029057083463406e-06 0.8263109424305363 2.029057266356504e-06 0.8219002364007665 \
2.029057434185218e-06 0.8178440888239877 2.029057602471033e-06 0.8137703061148112 2.029057773299085e-06 0.8096302849976138 2.029057945473642e-06 0.8054541271740473 \
2.029058113235561e-06 0.8013830614994394 2.029058296865019e-06 0.7969255463994016 2.029058468271496e-06 0.7927646873948894 2.029058653714802e-06 0.7882638003278283 \
2.029058820385454e-06 0.7842196820467244 2.029058989271585e-06 0.7801233737411432 2.029059173427882e-06 0.7756572567105651 2.02905936803791e-06 0.7709405333854473 \
2.029059515293242e-06 0.7673736106648734 2.029059641923832e-06 0.7643079795643375 2.029059783780644e-06 0.7608754495129878 2.029059888184422e-06 0.7583505812556488 \
2.029060020577074e-06 0.7551502542766809 2.029060130161271e-06 0.7525028097975122 2.029060263325923e-06 0.7492875979647342 2.029060419507685e-06 0.7455190770546114 \
2.029060532737112e-06 0.7427887939149777 2.029060695258476e-06 0.7388718945951063 2.029060867439291e-06 0.7347246296492568 2.029061063444044e-06 0.7300078517193382 \
2.029061227834023e-06 0.7260553905833119 2.029061380230704e-06 0.7223944885043934 2.029061543905858e-06 0.718466402706526 2.029061711831558e-06 0.7144406657912139 \
2.029061891671936e-06 0.7101336212543717 2.029062067965886e-06 0.7059164985576465 2.029062239040521e-06 0.7018286413152719 2.029062407358697e-06 0.6978099102718778 \
2.029062560624829e-06 0.6941537154717222 2.029062722508398e-06 0.6902960245155986 2.029062901459939e-06 0.6860364417190952 2.02906303567149e-06 0.6828448068431195 \
2.029063139177788e-06 0.6803854168085423 2.029063238462201e-06 0.6780286039046017 2.029063339916677e-06 0.6756220912380299 2.029063432373276e-06 0.6734303711245889 \
2.029063516962075e-06 0.6714267031582685 2.029063610539411e-06 0.6692114082407524 2.029063727081631e-06 0.6664546942583044 2.029063836559192e-06 0.6638675763958631 \
2.029063949672203e-06 0.6611971533414394 2.02906407279097e-06 0.6582923426231613 2.029064197017283e-06 0.6553636581362478 2.029064367777427e-06 0.6513432847262797 \
2.029064526226014e-06 0.6476181700514572 2.029064698513837e-06 0.6435738126612673 2.029064844491904e-06 0.6401512360303271 2.02906498628512e-06 0.6368325564797357 \
2.029065117883574e-06 0.6337564355289309 2.029065248046859e-06 0.630718219665797 2.0290653735718e-06 0.6277924818644975 2.029065505354707e-06 0.6247239543970449 \
2.029065635278203e-06 0.6217046839485236 2.029065771586778e-06 0.6185408917806742 2.029065916200346e-06 0.615188962872713 2.029066075692536e-06 0.611499189008522 \
2.029066249152652e-06 0.6074939486938447 2.029066420159954e-06 0.6035554342946753 2.029066651528523e-06 0.5982402936372396 2.029066894990529e-06 0.5926661367297537 \
2.029067069111016e-06 0.5886942528256315 2.029067215383093e-06 0.5853638081576373 2.029067349755312e-06 0.58231230528805 2.029067466850207e-06 0.5796585826255305 \
2.029067562614553e-06 0.5774900935424465 2.029067661461096e-06 0.5752566196463251 2.029067745438414e-06 0.5733628024369305 2.029067823052464e-06 0.571614165956722 \
2.029067884377937e-06 0.5702331258704825 2.029067949058576e-06 0.5687779664863769 2.029068030366712e-06 0.5669528575016536 2.029068080436707e-06 0.5658306078972934 \
2.029068129757269e-06 0.5647256890740617 2.029068191677069e-06 0.5633393552914843 2.029068239508894e-06 0.5622690492396486 2.02906829001368e-06 0.5611395143522533 \
2.029068350075717e-06 0.559799205480933 2.029068409358512e-06 0.5584782058326896 2.029068484415226e-06 0.5568072508052372 2.029068554097883e-06 0.5552574373576753 \
2.029068639686449e-06 0.5533559356568912 2.029068726753821e-06 0.5514265885063823 2.029068810416342e-06 0.5495763264044081 2.029068896561366e-06 0.5476734676082877 \
2.029068992265987e-06 0.5455621222678217 2.029069096550938e-06 0.5432673229847179 2.029069211218114e-06 0.5407497407899529 2.029069319936574e-06 0.5383664115638558 \
2.029069429508814e-06 0.5359693749054023 2.029069541813574e-06 0.5335193270114367 2.029069668589196e-06 0.530759392645703 2.029069790866427e-06 0.5281021910076299 \
2.029069930952405e-06 0.5250685463469849 2.029070067969763e-06 0.5221084647952599 2.029070218271135e-06 0.5188705764247719 2.029070377166376e-06 0.5154582091324615 \
2.029070551500259e-06 0.5117250894133971 2.029070738517481e-06 0.5077378180012799 2.029070943835486e-06 0.5033745272871338 2.029071155677679e-06 0.498891131759938 \
2.029071408479721e-06 0.4935662239713107 2.02907161056737e-06 0.4893264048484654 2.029071845160675e-06 0.4844277613141263 2.029072081275272e-06 0.4795194943790256 \
2.029072334451769e-06 0.474283574581623 2.029072644981732e-06 0.4679020429045382 2.02907286303971e-06 0.4634451779596257 2.029073036485345e-06 0.4599153839204358 \
2.029073212977781e-06 0.4563351808422506 2.029073492459577e-06 0.4506930409909046 2.029073724703484e-06 0.4460279192631412 2.029074011797073e-06 0.44029020239849 \
2.029074229643181e-06 0.435960758243863 2.029074439695769e-06 0.4318042429497612 2.029074640893605e-06 0.4278406951573778 2.029074823313766e-06 0.4242617300271556 \
2.029074997208751e-06 0.4208637793449936 2.029075162072867e-06 0.4176529694331993 2.02907532082684e-06 0.4145718140694327 2.029075487073787e-06 0.4113577680628809 \
2.029075635718993e-06 0.4084923702366076 2.029075788087249e-06 0.4055658186126443 2.029075930150432e-06 0.4028468403491589 2.02907609952631e-06 0.3996150665462138 \
2.02907621990823e-06 0.3973276483660343 2.029076329881494e-06 0.3952449223617059 2.029076444806895e-06 0.3930732253581283 2.029076597048475e-06 0.3902080468194818 \
2.02907670926954e-06 0.3881039677199808 2.029076816462041e-06 0.386098874836553 2.02907696899029e-06 0.383254723448244 2.029077097137419e-06 0.380874963946598 \
2.029077219985412e-06 0.3786015923730871 2.029077399083788e-06 0.375299968600122 2.02907754816842e-06 0.3725653942578417 2.029077715875808e-06 0.3695018296724824 \
2.029077871273443e-06 0.3666748141177644 2.029077995440288e-06 0.3644243980538668 2.029078109332155e-06 0.3623666676050148 2.029078230775526e-06 0.3601804966264144 \
2.029078410927294e-06 0.3569532670533712 2.029078577415114e-06 0.3539878629329621 2.029078767834223e-06 0.3506138544217919 2.029078959590819e-06 0.3472380408565978 \
2.029079142640212e-06 0.344035729794033 2.029079291612277e-06 0.3414435189591631 2.029079411552182e-06 0.3393660536257183 2.029079534213665e-06 0.3372483242714233 \
2.029079657244151e-06 0.3351324902755385 2.029079802148562e-06 0.3326515017845288 2.029079905461337e-06 0.3308907757076019 2.029079999190846e-06 0.3292979229163631 \
2.029080089851149e-06 0.3277620998585528 2.029080200972602e-06 0.3258853746017661 2.029080308145579e-06 0.3240820510456246 2.02908040642023e-06 0.3224338250618513 \
2.029080518824776e-06 0.3205545940512134 2.029080682764677e-06 0.3178277446588927 2.029080844402555e-06 0.3151576097143818 2.029080992189301e-06 0.3127316247504084 \
2.029081154434516e-06 0.3100832165115083 2.029081314465074e-06 0.3074868334344322 2.029081466728372e-06 0.3050304870660137 2.029081620100242e-06 0.3025703731928215 \
2.029081778808771e-06 0.3000411640344692 2.0290819432579e-06 0.297437246442505 2.029082110484977e-06 0.2948063590562646 2.029082263596514e-06 0.292412731930112 \
2.029082446694441e-06 0.2895700146919417 2.029082637002178e-06 0.2866380344427262 2.029082785905237e-06 0.2843603072871506 2.029082959842541e-06 0.2817165165722222 \
2.02908313671993e-06 0.2790484233348025 2.029083284317149e-06 0.2768363681311815 2.029083473948849e-06 0.2740172295061162 2.029083623950768e-06 0.2718052906662373 \
2.029083761060958e-06 0.2697943906627059 2.029083902591401e-06 0.2677397479842996 2.02908401605027e-06 0.2661005451260196 2.029084152340596e-06 0.2641384584581135 \
2.029084282417218e-06 0.2622807416655737 2.02908440067147e-06 0.2606037730704709 2.029084518527066e-06 0.2589348966568543 2.029084649420877e-06 0.2570853888657079 \
2.029084789659635e-06 0.2551145527343576 2.029084905154221e-06 0.2534976852533538 2.029085034005598e-06 0.2516957519945816 2.02908514915158e-06 0.2500885525459272 \
2.029085302462547e-06 0.2479513765689386 2.029085440316308e-06 0.2460367343642474 2.02908557977796e-06 0.2441002375748529 2.029085735245815e-06 0.2419427021952501 \
2.02908586002843e-06 0.2402176526454788 2.029085999893338e-06 0.2382916534360561 2.029086128595514e-06 0.2365220787132559 2.029086249554366e-06 0.234860341242685 \
2.029086366599666e-06 0.2332541163798121 2.02908649260073e-06 0.2315368940272461 2.029086589320323e-06 0.2302195772445239 2.029086681409196e-06 0.2289683907689286 \
2.029086795826668e-06 0.2274152998827935 2.029086894197314e-06 0.2260807986508055 2.029087011344108e-06 0.2244933520241092 2.029087114435226e-06 0.2231010305483718 \
2.029087219949952e-06 0.2216798666278746 2.029087300868012e-06 0.2205933880575098 2.029087374539197e-06 0.2196046443759679 2.029087417268434e-06 0.2190314036349237 \
2.029087460398579e-06 0.2184540235451489 2.029087511196061e-06 0.217774515685755 2.029087548370939e-06 0.217277430841393 2.029087589041954e-06 0.2167338127731004 \
2.029087631833756e-06 0.2161620985357572 2.029087668244897e-06 0.2156758299561118 2.029087710169888e-06 0.2151161507306283 2.029087764712098e-06 0.2143884526296278 \
2.029087803170856e-06 0.2138756926875936 2.029087842797626e-06 0.2133496230586122 2.029087904630128e-06 0.212531488259555 2.029087966356579e-06 0.2117156525305126 \
2.029088022493854e-06 0.210974237875411 2.029088086149084e-06 0.210134110843225 2.029088180240117e-06 0.2088936328424611 2.029088267048376e-06 0.2077505933124353 \
2.02908836100502e-06 0.2065146061917991 2.029088459047254e-06 0.2052266823513323 2.02908856063462e-06 0.2038976009052371 2.029088661543568e-06 0.2025832113009377 \
2.029088758279377e-06 0.2013244528083448 2.029088860404348e-06 0.1999972806373927 2.029088963735906e-06 0.1986583046056677 2.029089073618507e-06 0.1972379690671278 \
2.029089182560765e-06 0.1958337611883887 2.029089302395885e-06 0.1942937175364915 2.029089412679751e-06 0.1928822800638286 2.029089520558496e-06 0.191507108810815 \
2.029089646621254e-06 0.1899051957406391 2.029089736488961e-06 0.1887671190866151 2.0290898469673e-06 0.1873723090993208 2.029089924500249e-06 0.1863971337376019 \
2.029090008823992e-06 0.1853400660204312 2.02909009641205e-06 0.1842452710069853 2.029090184204644e-06 0.18315095174413 2.029090265924516e-06 0.1821357652581398 \
2.029090363486193e-06 0.1809282658474054 2.029090470197344e-06 0.1796118512064394 2.029090570679026e-06 0.178377576484793 2.029090694850238e-06 0.1768595317522179 \
2.029090828741761e-06 0.1752320886156309 2.029090947653953e-06 0.1737937102924047 2.029091098054147e-06 0.1719851742607024 2.02909120888924e-06 0.1706594030660365 \
2.029091348655982e-06 0.168997130456427 2.02909146718129e-06 0.1675953052211382 2.029091572608521e-06 0.1663548750207849 2.02909166731838e-06 0.1652455210322802 \
2.029091760628154e-06 0.1641568522804657 2.02909186153427e-06 0.1629842804551663 2.029091956952102e-06 0.1618800504313296 2.029092054143026e-06 0.1607598891027116 \
2.029092135704507e-06 0.1598237474547246 2.029092241020952e-06 0.1586229753023833 2.029092324500659e-06 0.1576763029943549 2.029092426029949e-06 0.1565306813704828 \
2.029092503260486e-06 0.1556635090415242 2.029092594132523e-06 0.154647919213242 2.029092663483834e-06 0.1538765336840219 2.029092748067885e-06 0.1529397840535594 \
2.029092822461091e-06 0.1521208717489242 2.029092901831293e-06 0.151251902275755 2.029092976418965e-06 0.1504388356812226 2.029093045640521e-06 0.1496871728711989 \
2.029093140321328e-06 0.1486640077242138 2.029093210087093e-06 0.1479134441579097 2.029093294531656e-06 0.147008717574758 2.029093356097002e-06 0.1463518850554192 \
2.029093430139493e-06 0.1455673550676988 2.029093503525017e-06 0.1447940960774066 2.029093584960259e-06 0.1439395015691976 2.029093654409405e-06 0.1432139999234875 \
2.029093729511102e-06 0.1424323701137583 2.029093819423173e-06 0.1415006120834361 2.029093896506793e-06 0.1407052977810757 2.029093995617377e-06 0.1396885207473417 \
2.02909406515744e-06 0.138983077430453 2.029094146475916e-06 0.1381612812129989 2.029094216644325e-06 0.1374549162714094 2.029094295612438e-06 0.1366629455350578 \
2.029094374590721e-06 0.1358740351737466 2.02909444691251e-06 0.1351544405911459 2.029094516277969e-06 0.1344667589602006 2.029094564981977e-06 0.1339854049281765 \
2.029094655744348e-06 0.1330945614011112 2.029094687765876e-06 0.1327823711724506 2.029094775869844e-06 0.131925672678654 2.029094808363887e-06 0.1316105445757083 \
2.029094907031544e-06 0.1306564447580443 2.029094950687519e-06 0.130235859061297 2.029095028669336e-06 0.1294866595045693 2.029095066000294e-06 0.1291289430202982 \
2.029095168151694e-06 0.128153223240932 2.029095235595654e-06 0.1275115375392494 2.029095300748612e-06 0.1268935577290946 2.029095366654626e-06 0.1262729746041904 \
2.029095437806609e-06 0.1256052797936485 2.02909552074397e-06 0.1248293808775363 2.029095606139451e-06 0.1240331657139879 2.029095682226845e-06 0.1233259817834828 \
2.029095762687521e-06 0.1225806238777534 2.029095820771462e-06 0.1220441728027253 2.029095892104936e-06 0.1213870835332726 2.029095976893369e-06 0.1206085709991845 \
2.029096038048402e-06 0.1200487744399507 2.029096108134853e-06 0.1194096117168642 2.029096170640142e-06 0.1188419501154776 2.02909623664509e-06 0.1182453094891599 \
2.029096305417857e-06 0.1176255789053269 2.029096374874481e-06 0.1170017375875525 2.029096458038731e-06 0.1162574953874909 2.029096531156255e-06 0.1156056107435251 \
2.029096601870241e-06 0.1149774116339468 2.029096661221924e-06 0.1144518657417393 2.029096766519136e-06 0.1135239342411639 2.02909681238663e-06 0.1131212254602471 \
2.029096899340683e-06 0.1123603821649216 2.029096942354464e-06 0.1119852310621949 2.029096987221211e-06 0.1115947726395539 2.029097076954706e-06 0.1108164664143028 \
2.029097147839057e-06 0.110204256460374 2.029097226692571e-06 0.109525796983828 2.029097289470346e-06 0.1089876103666232 2.029097349464702e-06 0.1084750215669379 \
2.029097460462474e-06 0.1075310013968523 2.02909754121676e-06 0.1068475792877216 2.029097653680086e-06 0.1059005796323111 2.029097704824629e-06 0.1054717782906781 \
2.029097787809798e-06 0.1047785948356612 2.029097845974503e-06 0.1042945647727652 2.029097960212503e-06 0.1033482075721767 2.02909801011597e-06 0.1029366076865433 \
2.029098095857569e-06 0.1022320954501846 2.02909814488902e-06 0.1018307629303728 2.029098227455441e-06 0.101157455862875 2.029098298387777e-06 0.1005815064560546 \
2.029098366538128e-06 0.1000302812267231 2.029098444148443e-06 0.0994053199805509 2.029098516491814e-06 0.09882546240595018 2.029098594067778e-06 0.09820656846618626 \
2.029098682738439e-06 0.09750287271560702 2.029098756553227e-06 0.09692010793638871 2.029098838144235e-06 0.09627924899616347 2.029098916282703e-06 0.09566870926115327 \
2.029099002032494e-06 0.09500229249765579 2.029099089729402e-06 0.09432453920671229 2.029099183638967e-06 0.09360304191323381 2.029099280098285e-06 0.09286661217778783 \
2.029099358728946e-06 0.09226977907248698 2.029099461452546e-06 0.09149473120661993 2.029099545280196e-06 0.09086620530027881 2.029099666032378e-06 0.08996702094116031 \
2.029099795302029e-06 0.08901247130467421 2.029099951190493e-06 0.08787237469953549 2.029100106290076e-06 0.08675000010972149 2.029100263305883e-06 0.08562614142917294 \
2.029100443326735e-06 0.08435280068725284 2.029100593847601e-06 0.08330035525696428 2.029100742221624e-06 0.08227363395463329 2.029100879838855e-06 0.08133079092382095 \
2.029101019758505e-06 0.08038162993974078 2.029101156365494e-06 0.07946425488810546 2.029101295092791e-06 0.07854214404995859 2.029101440403653e-06 0.07758663187171365 \
2.029101588151466e-06 0.07662571164688473 2.029101746748333e-06 0.07560598447141591 2.029101911000851e-06 0.07456266320243836 2.029102080017927e-06 0.07350246718885647 \
2.029102261906921e-06 0.07237646636762114 2.02910246252902e-06 0.07115268999588262 2.029102676406562e-06 0.0698691158856425 2.029102904040694e-06 0.0685263410462881 \
2.029103145626236e-06 0.06712722147996912 2.029103427215414e-06 0.06552977831071743 2.029103724369535e-06 0.06388229915275011 2.029104047802612e-06 0.06213267023812474 \
2.029104438962031e-06 0.0600758559534558 2.029104840456333e-06 0.05803293250078725 2.029105217397059e-06 0.05617754872181892 2.029105584510791e-06 0.05442503025024555 \
2.029105934627471e-06 0.05280240270907886 2.029106253933125e-06 0.05136309724710254 2.029106558257407e-06 0.05002640192327024 2.029106855163313e-06 0.04875503464657577 \
2.029107137163638e-06 0.04757867888787161 2.029107417596943e-06 0.04643900623749339 2.029107682320567e-06 0.04538777697325767 2.029107958218279e-06 0.04431704973151576 \
2.029108232683143e-06 0.04327654260273706 2.029108531102424e-06 0.04217254828989973 2.02910875761848e-06 0.04135316230013186 2.029109069531317e-06 0.04025053053625379 \
2.029109289786109e-06 0.03948972371590862 2.029109507050864e-06 0.03875470657060948 2.029109716773512e-06 0.03806113111453101 2.0291100269559e-06 0.03705828856757609 \
2.029110249553778e-06 0.03635538859683734 2.029110496919279e-06 0.03559019656168042 2.029110769325656e-06 0.03476651972027592 2.02911098995821e-06 0.03411384091885184 \
2.02911127423846e-06 0.03329124852897781 2.029111512151752e-06 0.0326183788879464 2.029111750241164e-06 0.03195887699386461 2.029111985496492e-06 0.03132132139405813 \
2.029112214275199e-06 0.03071728735992773 2.029112447005948e-06 0.03011490821398154 2.029112666308989e-06 0.02955843195412813 2.02911287025206e-06 0.02905055018162466 \
2.029113269161796e-06 0.02808303002558106 2.029113456316051e-06 0.02764052191221165 2.029113828521772e-06 0.0267814187683372 2.029114015473295e-06 0.02635997027055515 \
2.029114384827242e-06 0.02554620807076183 2.02911453848041e-06 0.02521471147941385 2.029114954694564e-06 0.02434161493068329 2.029115160182381e-06 0.02392065165079968 \
2.029115499190341e-06 0.02323955384462723 2.02911568188507e-06 0.02287916718068597 2.029116138978978e-06 0.02199597290476789 2.029116268719714e-06 0.02174967209293581 \
2.029116722140138e-06 0.02089828923199067 2.02911686451243e-06 0.0206336680476187 2.029117394079191e-06 0.01967289368906444 2.029117520286197e-06 0.01945139161001456 \
2.029118082520636e-06 0.01850749734048266 2.029118245259022e-06 0.01824627541187189 2.029118809439087e-06 0.01738327200207762 2.029118961183154e-06 0.01716165742474803 \
2.029119662862638e-06 0.01618760396393164 2.029119832951728e-06 0.01596324388168 2.029120488009604e-06 0.01513221026437959 2.029120654523916e-06 0.01492874613340729 \
2.029121387637676e-06 0.01406966818047924 2.029121520900854e-06 0.01391906482409888 2.029122372558029e-06 0.01299647369571925 2.029122510500477e-06 0.01285324185793544 \
2.029123450559967e-06 0.0119198170026788 2.029123614321604e-06 0.01176347583728811 2.029124601555039e-06 0.01085909507266535 2.029124736144115e-06 0.0107410715025141 \
2.029125877583545e-06 0.009819907073012045 2.029125985822443e-06 0.009738548299709823 2.029127309069827e-06 0.00880579379490502 2.029127441815526e-06 0.008718202093769473 \
2.02912896431665e-06 0.007760835273143199 2.029129076858719e-06 0.007690148685505111 2.029130769150306e-06 0.00669558715138598 2.029130909416891e-06 0.00662113250846694 \
2.029132982426194e-06 0.005629132576249021 2.029133174987711e-06 0.005545002188831318 2.029135385197559e-06 0.004656096148610405 2.029135791984232e-06 0.004507219767123045 \
2.029138613724208e-06 0.003590578528330178 2.029139135019959e-06 0.00344214578404881 2.029143347121009e-06 0.002447529662748036 2.029143899683877e-06 0.002340875287107731 \
2.029149782973417e-06 0.001359168649576994 2.029150032246415e-06 0.001311490127959886 2.029163182367465e-06 0.0003136950974005476 2.029163299150436e-06 0.0003112730584132499 \
2.058990000000011e-06 3.042397160644726e-06 2.102746667027013e-06 -0.0009024818035526668 2.102746739442629e-06 -0.001022682652537627 2.102747175467347e-06 -0.001858525046639076 \
2.10274726236173e-06 -0.002046124893065343 2.102747617065043e-06 -0.00288168582347465 2.102747716611644e-06 -0.003135075204051477 2.102747976881349e-06 -0.003828199033013717 \
2.10274811720375e-06 -0.004216406518003108 2.102748344689832e-06 -0.004856871791621592 2.102748481897271e-06 -0.005239031028659006 2.10274886679612e-06 -0.006187559915121 \
2.102748998893307e-06 -0.006423332025500122 2.102749687336335e-06 -0.005917035979538006 2.102749844265069e-06 -0.005202654566481615 2.102749971914231e-06 -0.004414133290428114 \
2.102750099456021e-06 -0.003433350487145549 2.102750217130234e-06 -0.002355902309038119 2.10275031626992e-06 -0.001320627313728655 2.10275042165263e-06 -9.507383675133965e-05 \
2.102750535559933e-06 0.001369964538583592 2.102750666615328e-06 0.003229572948258866 2.102750791978547e-06 0.005172303930030842 2.102750983820411e-06 0.008432154569684791 \
2.102751127490205e-06 0.01107975669588844 2.102751285472017e-06 0.01417105828876112 2.102751434071664e-06 0.01723098336859398 2.102751587122593e-06 0.02051714008521248 \
2.102751746187569e-06 0.02405720796424875 2.102751899257778e-06 0.02756764950178633 2.102752047604842e-06 0.03105219347129199 2.102752196711284e-06 0.03462388853332505 \
2.102752351275713e-06 0.03838854885099419 2.102752511961677e-06 0.04235886888523473 2.102752676640863e-06 0.04647718198980624 2.102752853163806e-06 0.05093664320808645 \
2.102753032175606e-06 0.05549818742091989 2.102753222948448e-06 0.0603932190016783 2.1027534277958e-06 0.06567927942044927 2.102753648293053e-06 0.07139554989571946 \
2.102753881211021e-06 0.07745499876455469 2.102754130458799e-06 0.08395499695136356 2.102754403380327e-06 0.09108394918256098 2.102754700173383e-06 0.09884095133633181 \
2.102755027609896e-06 0.1073964775374675 2.102755397423695e-06 0.1170487607486894 2.102755792369975e-06 0.1273407304921971 2.102756250458528e-06 0.1392499850125259 \
2.102756782558388e-06 0.1530377249371455 2.102757408110396e-06 0.169180864038255 2.102758094102462e-06 0.1867931863309214 2.102758896945878e-06 0.2072766958045763 \
2.102759796258209e-06 0.2300508264895909 2.102760696698322e-06 0.2526618731709107 2.102761498589855e-06 0.2726215666318766 2.102762194096996e-06 0.2897857674353052 \
2.102762826931282e-06 0.3052728323588638 2.102763422339773e-06 0.3197161646377594 2.102763969382815e-06 0.3328722959176427 2.102764503143162e-06 0.3455929446372428 \
2.102765022382586e-06 0.3578476146335662 2.102765529774049e-06 0.3697097539883151 2.102766033395218e-06 0.3813674725871593 2.102766545138114e-06 0.3930934709428262 \
2.102767052299123e-06 0.404595334768291 2.102767582595137e-06 0.4164962117964878 2.102768068708625e-06 0.4272847049163567 2.102768546816947e-06 0.437781779057129 \
2.102768986249071e-06 0.4473362978389137 2.102769109408535e-06 0.4500002106608159 2.102769355727463e-06 0.4553046876287923 2.102769698999458e-06 0.4626558934952216 \
2.102770010436459e-06 0.4692815017887791 2.102770261147724e-06 0.4745855323881177 2.102770531976868e-06 0.480281321066213 2.102770868458777e-06 0.4873122872019196 \
2.102771224467388e-06 0.4946959640027882 2.102771541737556e-06 0.5012322602315481 2.102771780618105e-06 0.506122906570856 2.102772021646287e-06 0.5110269393752048 \
2.102772273577991e-06 0.5161276795544476 2.102772513731834e-06 0.5209621749612534 2.102772736483296e-06 0.5254248476203834 2.102772925040943e-06 0.5291850880529715 \
2.102773139790987e-06 0.5334523706207774 2.102773354339378e-06 0.5376948565446859 2.10277361310367e-06 0.5427871977552768 2.102773863931242e-06 0.5477009885064807 \
2.102774119350104e-06 0.5526782776843104 2.102774470392629e-06 0.5594898819265107 2.102774735000954e-06 0.5645984056527484 2.10277500141751e-06 0.569709962982798 \
2.10277526193182e-06 0.5746801970751495 2.102775529021882e-06 0.5797469183389945 2.102775772159962e-06 0.5843213438768613 2.102776027852189e-06 0.5890994944692448 \
2.102776255671159e-06 0.5933243819692556 2.102776493215979e-06 0.5976999800355528 2.102776704606465e-06 0.6015679915939678 2.102776916747225e-06 0.6054277082074113 \
2.102777105936602e-06 0.6088479815213901 2.10277723709492e-06 0.6112112531841202 2.102777369391478e-06 0.6135871094428261 2.102777554614204e-06 0.6169015645304802 \
2.102777716636591e-06 0.6197943209800671 2.102777875055755e-06 0.6226100751126036 2.102778009167621e-06 0.6249846001944386 2.102778181488729e-06 0.6280247049765127 \
2.102778310427531e-06 0.6302937061188456 2.102778430805044e-06 0.6324061607157294 2.102778571333915e-06 0.634864734791624 2.102778764419407e-06 0.6382321981637986 \
2.102778914230185e-06 0.6408363654380513 2.102779081537779e-06 0.6437327988167145 2.102779262592003e-06 0.6468572757970242 2.102779465918433e-06 0.6503523798695617 \
2.102779648771588e-06 0.6534819287355287 2.102779819395834e-06 0.6563879501053153 2.102779996860074e-06 0.6594029650344411 2.102780162839025e-06 0.6622113135173925 \
2.102780320075814e-06 0.6648594636266301 2.102780460561866e-06 0.6672075432495704 2.102780604291994e-06 0.6695987751186935 2.102780737338985e-06 0.6718055529208897 \
2.102780879311128e-06 0.6741523780906628 2.102780999371661e-06 0.6761293215200647 2.102781144309748e-06 0.6785098354674278 2.102781260306798e-06 0.6804095298668216 \
2.102781379886685e-06 0.6823647593763783 2.10278147884666e-06 0.68397755359623 2.102781597355078e-06 0.6859039329668146 2.10278168439936e-06 0.6873150904607619 \
2.102781806410179e-06 0.6892866586554622 2.102781905332791e-06 0.6908817703737582 2.102781997228166e-06 0.6923536807698466 2.102782097196705e-06 0.6939486118486815 \
2.102782195442366e-06 0.6955126686751646 2.102782287156128e-06 0.6969676095571918 2.10278239128907e-06 0.698613189139943 2.102782527015812e-06 0.7007470979739818 \
2.102782681624274e-06 0.7031613517373301 2.102782816731986e-06 0.7052558942641604 2.102782963068532e-06 0.7075085519458914 2.102783091536073e-06 0.7094732734147607 \
2.102783215720207e-06 0.7113609898537658 2.102783325624507e-06 0.7130225953369277 2.102783442207576e-06 0.7147759898693785 2.102783542385407e-06 0.7162749667021007 \
2.102783679474215e-06 0.7183149847558421 2.102783799463242e-06 0.7200901405411056 2.10278391857669e-06 0.7218426783097279 2.102784045072077e-06 0.723693513465353 \
2.102784170939449e-06 0.7255245570057045 2.102784293560467e-06 0.7272980597885179 2.102784421177991e-06 0.7291334326655684 2.102784551426783e-06 0.7309957624152177 \
2.102784673019733e-06 0.73272442801297 2.102784811788425e-06 0.7346853525547948 2.102784912196869e-06 0.7360963845229137 2.102785015584257e-06 0.7375412410987998 \
2.102785109244699e-06 0.7388443755773992 2.102785220866297e-06 0.7403895158541485 2.1027853073349e-06 0.7415798421827293 2.10278540819801e-06 0.7429609798983192 \
2.102785540294732e-06 0.7447573558536402 2.102785649496033e-06 0.7462323422761349 2.102785754027664e-06 0.747635567415085 2.102785877674145e-06 0.7492836897664436 \
2.10278602637058e-06 0.7512497161812216 2.102786148251239e-06 0.7528480713857697 2.102786261855803e-06 0.7543274008692354 2.102786402375488e-06 0.7561429069656862 \
2.10278654356493e-06 0.7579511824827749 2.102786661311106e-06 0.7594470562859095 2.102786790000765e-06 0.7610693809796742 2.102786932555413e-06 0.7628512182523866 \
2.102787048411964e-06 0.7642872416835913 2.102787194175229e-06 0.7660789429779771 2.102787316007677e-06 0.7675637574673733 2.102787434476374e-06 0.7689965471136999 \
2.102787557264006e-06 0.7704700089613156 2.102787683416888e-06 0.7719718272910862 2.102787793785939e-06 0.7732757954107932 2.102787919217035e-06 0.7747465774777432 \
2.102788024698746e-06 0.775974259539018 2.102788157865176e-06 0.7775122819577122 2.102788280546631e-06 0.7789173428708996 2.102788415309674e-06 0.7804473432620218 \
2.102788525980963e-06 0.7816923373676121 2.102788635302591e-06 0.7829118427552927 2.102788770435026e-06 0.7844048889494442 2.10278892121405e-06 0.7860523747618094 \
2.102789061582958e-06 0.7875692293014268 2.102789181294483e-06 0.7888502570533434 2.102789319548823e-06 0.7903153082715967 2.102789442919159e-06 0.7916096503654788 \
2.102789588017784e-06 0.7931164937536124 2.102789727758043e-06 0.7945521172774316 2.102789854939467e-06 0.7958455533278409 2.10278997397922e-06 0.7970449251022731 \
2.102790086337411e-06 0.7981670522831598 2.10279019056619e-06 0.79919939674296 2.102790285905002e-06 0.8001364844871954 2.102790422193112e-06 0.8014634245741865 \
2.102790539085655e-06 0.8025894467082511 2.102790658725145e-06 0.8037305025474466 2.102790780606717e-06 0.8048811831579785 2.102790902985053e-06 0.8060245537852575 \
2.102791031013733e-06 0.8072081965553952 2.102791155658531e-06 0.8083483262222385 2.10279128615728e-06 0.8095291977395493 2.102791412617707e-06 0.8106611567088965 \
2.102791539743675e-06 0.8117869190804841 2.102791644861151e-06 0.8127087429624065 2.10279175011134e-06 0.8136235164943317 2.10279184125159e-06 0.8144090748259969 \
2.102791964669625e-06 0.8154632009865571 2.102792051748274e-06 0.8162003374872545 2.102792151070959e-06 0.8170344894488412 2.102792295992702e-06 0.8182390501293432 \
2.102792432261206e-06 0.8193582434421302 2.102792541723485e-06 0.8202477434185359 2.102792687843586e-06 0.8214214001843773 2.102792839202198e-06 0.8226208465286928 \
2.10279296500612e-06 0.8236052915965452 2.102793109416779e-06 0.824721541823094 2.102793234017729e-06 0.8256729463037898 2.102793384729791e-06 0.8268094083523665 \
2.10279352010105e-06 0.8278169867326588 2.102793645303979e-06 0.8287379047458127 2.102793762973362e-06 0.829593908450195 2.102793908801338e-06 0.8306418458276996 \
2.10279407529732e-06 0.8318207857986918 2.102794206154408e-06 0.8327345044534114 2.102794379603849e-06 0.833928356718921 2.102794547722322e-06 0.8350667646575466 \
2.102794717596125e-06 0.8361988603660855 2.102794898450754e-06 0.8373843006762304 2.102795041633135e-06 0.8383085120571983 2.102795155746479e-06 0.8390361588138326 \
2.10279528581247e-06 0.8398559950134801 2.102795387687706e-06 0.8404909448220066 2.102795504566998e-06 0.8412116130393378 2.102795641678928e-06 0.8420465258793415 \
2.102795839559572e-06 0.843231707656198 2.102796031345765e-06 0.8443585547012582 2.102796240708828e-06 0.8455646258450146 2.102796422822406e-06 0.846593677725298 \
2.102796619917178e-06 0.8476867969181797 2.102796793185875e-06 0.8486305714188691 2.102796976264561e-06 0.8496104335327738 2.102797147401587e-06 0.8505103231661706 \
2.102797322080438e-06 0.8514128411730317 2.102797497318728e-06 0.8523022053693007 2.102797673458368e-06 0.8531802340241421 2.102797863809624e-06 0.8541115036082744 \
2.10279805438677e-06 0.855025905954957 2.102798254818193e-06 0.8559685891497206 2.102798447410669e-06 0.8568563992305701 2.102798658273806e-06 0.8578086227668252 \
2.102798886187182e-06 0.8588150784816577 2.102799152217719e-06 0.8599606428795262 2.102799450738801e-06 0.8612090806949765 2.102799726692482e-06 0.8623286542354505 \
2.102800010954596e-06 0.8634483918036945 2.102800285103046e-06 0.8644969441068078 2.102800557392313e-06 0.8655088801415273 2.102800827558089e-06 0.8664846790737442 \
2.102801084736186e-06 0.8673881555543895 2.102801357299353e-06 0.868319368003445 2.102801633304697e-06 0.8692355072818493 2.102801903418628e-06 0.870106770567397 \
2.102802203245002e-06 0.8710447971670072 2.102802574222291e-06 0.8721640818024149 2.102802869154012e-06 0.8730224021943973 2.102803123432376e-06 0.873740732376842 \
2.102803421677207e-06 0.8745584461000401 2.102803695285219e-06 0.8752856917963749 2.102803931415444e-06 0.8758961959341748 2.102804171760979e-06 0.8765017794770257 \
2.102804394097167e-06 0.8770481951318053 2.10280458810245e-06 0.8775144010549708 2.102804917823794e-06 0.8782846129827527 2.102805072996819e-06 0.8786376896881318 \
2.102805390752407e-06 0.8793424631377607 2.102805569616983e-06 0.8797286397841958 2.102805912078462e-06 0.8804474051285093 2.102806096217817e-06 0.880822800830328 \
2.102806571118475e-06 0.881756283451624 2.102806738513154e-06 0.8820737784441692 2.1028072043462e-06 0.8829272622221894 2.102807385170493e-06 0.8832470363605239 \
2.102807879204793e-06 0.8840891816604841 2.102808020548668e-06 0.8843218944112644 2.102808626940586e-06 0.8852805359894154 2.102808779011766e-06 0.8855111592597558 \
2.102809425691436e-06 0.8864506941541785 2.102809553987642e-06 0.8866295550025313 2.102810202164815e-06 0.8874976172723908 2.102810331923675e-06 0.8876644392549727 \
2.102811100144498e-06 0.8886037370453904 2.102811229881009e-06 0.8887539063021698 2.102812083306654e-06 0.8896836309705964 2.102812226565088e-06 0.8898301468060963 \
2.102813212785821e-06 0.890764641901611 2.102813434267227e-06 0.8909571971396437 2.102814577308628e-06 0.8918770673440963 2.102814707298117e-06 0.8919774876506176 \
2.102816058923388e-06 0.8929731820841386 2.10281620928357e-06 0.89307657739048 2.102817689916169e-06 0.8939986636922405 2.102817928817934e-06 0.8941315911431026 \
2.102819693311633e-06 0.894999985510941 2.102820000994978e-06 0.8951330875684044 2.102822522266181e-06 0.8960612226716312 2.102822959317422e-06 0.8961978289811912 \
2.102826862729643e-06 0.8971619289239613 2.10282710951145e-06 0.8972094058147089 2.102834686001284e-06 0.8981998139535015 2.102834801913031e-06 0.8982099955090975 \
2.102853900445735e-06 0.8992062631372056 2.102854297888509e-06 0.8992194728667773 2.10300471332359e-06 0.9002121614362558 2.103004979381947e-06 0.9002436812458944 \
2.103010247532015e-06 0.8993470931706574 2.103010453902932e-06 0.899191170936528 2.103011932015742e-06 0.8982046351054961 2.103012112466398e-06 0.8981003355419954 \
2.103014334948061e-06 0.8971299612768925 2.103014541040576e-06 0.897079983173831 2.103024949306681e-06 0.8980580240048047 2.103025087164257e-06 0.8980839755683444 \
2.103031884513298e-06 0.8990685088718567 2.103032070084766e-06 0.8990874390200084 2.103528299258968e-06 0.9000706848616691 2.103528359054814e-06 0.9000975977971888 \
2.103529612605432e-06 0.9010828413531861 2.103529718298035e-06 0.9012097231395001 2.103530376428752e-06 0.9021613947651476 2.103530513611021e-06 0.9023918767045529 \
2.103531036637641e-06 0.9033649777562528 2.103531099501233e-06 0.9034908765919824 2.103531572096782e-06 0.904476514442582 2.103531623410595e-06 0.9045863669199017 \
2.103532089373931e-06 0.9055619780118375 2.103532121578392e-06 0.9056252631670594 2.103532838677129e-06 0.9066212416280413 2.103532923113402e-06 0.9066528951765993 \
2.103533523179781e-06 0.9059679814895146 2.103533643037393e-06 0.9055903401525059 2.103533774200172e-06 0.9050640446667092 2.103533909019925e-06 0.9043926011431642 \
2.103534057154984e-06 0.9034897747335404 2.103534194714336e-06 0.902493211317788 2.103534334926096e-06 0.9013135799985507 2.103534433588205e-06 0.9003872218501816 \
2.103534519272014e-06 0.8995148096066522 2.103534601836213e-06 0.8986166894493001 2.103534716618842e-06 0.8972773101170661 2.103534797717086e-06 0.8962642459447687 \
2.103534877134364e-06 0.8952218112132616 2.103534982588892e-06 0.8937633947192651 2.103535105230195e-06 0.8919606744930825 2.103535204954274e-06 0.890414036797163 \
2.103535375148685e-06 0.8876203405523397 2.103535521333777e-06 0.8850727273800474 2.103535689551925e-06 0.8819879035815887 2.103535861713021e-06 0.8786780617039783 \
2.103536046099114e-06 0.8749807502679057 2.103536230665458e-06 0.8711418063496947 2.103536414912944e-06 0.8671917613865908 2.103536600248607e-06 0.8631174608718694 \
2.103536774636335e-06 0.8592060069639053 2.103536957340272e-06 0.8550405244181323 2.103537132687366e-06 0.8509893565349284 2.103537315016877e-06 0.8467313026054767 \
2.103537505330306e-06 0.8422468264612591 2.103537675660435e-06 0.838204894125699 2.103537842184074e-06 0.8342320488410089 2.103538004754937e-06 0.830337741667393 \
2.10353815461616e-06 0.8267359097041467 2.103538305792179e-06 0.8230937075736249 2.103538494937653e-06 0.8185270080344306 2.103538640655708e-06 0.8150026134285653 \
2.103538815646674e-06 0.8107652770601156 2.103538964118218e-06 0.807166938184282 2.103539136005683e-06 0.8029987283123258 2.103539305073922e-06 0.7988973224349885 \
2.103539469252632e-06 0.7949140139776875 2.103539628580168e-06 0.7910485911592836 2.103539789029776e-06 0.7871568543472617 2.103539990849157e-06 0.7822630953020117 \
2.103540139296892e-06 0.7786646206504594 2.103540293464276e-06 0.77492821376164 2.103540430547636e-06 0.7716074476660475 2.103540539933082e-06 0.7689587163513494 \
2.103540645866538e-06 0.7663946531324515 2.103540772880885e-06 0.7633217481666642 2.103540887243854e-06 0.7605561828888391 2.103540990091676e-06 0.7580702160470256 \
2.103541111681992e-06 0.7551325442760125 2.103541222459267e-06 0.7524575925939972 2.103541339308092e-06 0.7496376180588871 2.103541450092818e-06 0.7469652567786068 \
2.103541568458919e-06 0.7441116745915923 2.103541693286014e-06 0.7411038668912771 2.10354184584781e-06 0.7374292753756717 2.103541979744798e-06 0.7342062928952946 \
2.103542100776237e-06 0.7312947572377408 2.103542264973752e-06 0.7273475399259534 2.103542442334699e-06 0.7230877912371642 2.103542624545108e-06 0.7187161681757385 \
2.103542805542373e-06 0.7143786395952922 2.103542986206316e-06 0.7100537072471783 2.103543176357883e-06 0.7055071781827296 2.103543364117777e-06 0.7010230964996226 \
2.103543564650882e-06 0.696237807975249 2.103543773336343e-06 0.6912646166759551 2.103543980979908e-06 0.6863227581165517 2.103544208547776e-06 0.6809140411171237 \
2.10354440082261e-06 0.6763521085712711 2.103544638087858e-06 0.6707310800019505 2.103544831366122e-06 0.6661595641347996 2.103545064098868e-06 0.6606646229758047 \
2.103545269656336e-06 0.6558174602470968 2.103545502009757e-06 0.6503484594495911 2.103545697011728e-06 0.6457674053103037 2.103545900240336e-06 0.6410004262200759 \
2.103546080092881e-06 0.6367906205544323 2.103546259199312e-06 0.6326052789263827 2.103546422576526e-06 0.628795088826817 2.10354659462593e-06 0.6247880828503264 \
2.103546758118769e-06 0.6209892715878097 2.103546933908587e-06 0.6169100951581823 2.103547115847573e-06 0.6126978430086294 2.103547304331305e-06 0.6083422542008314 \
2.103547510763727e-06 0.6035858951323969 2.10354769007839e-06 0.5994633272559844 2.103547887257257e-06 0.5949432360761027 2.103548096345397e-06 0.5901646611556908 \
2.10354830209466e-06 0.5854760387944159 2.103548542605348e-06 0.5800160304866983 2.10354871573345e-06 0.5760958285528379 2.103548880627452e-06 0.5723746772837877 \
2.103549061488027e-06 0.5683014035092815 2.103549218774123e-06 0.5647722902613652 2.103549387756918e-06 0.5609879409349005 2.103549567863379e-06 0.5569709657351898 \
2.103549720846506e-06 0.5535669615732179 2.103549852560951e-06 0.5506462283231492 2.103549999948651e-06 0.5473865746199473 2.103550087374242e-06 0.5454560063082221 \
2.103550172245481e-06 0.5435860258811447 2.103550270874694e-06 0.5414171943998213 2.103550342966855e-06 0.5398340751058975 2.103550440057874e-06 0.5377039800781129 \
2.103550525648258e-06 0.5358302678688993 2.103550590729134e-06 0.5344081412607664 2.103550714329502e-06 0.5317121235594142 2.103550808753772e-06 0.52965475734789 \
2.103550906276994e-06 0.5275349985745696 2.103551079137645e-06 0.5237893654184622 2.103551214133166e-06 0.5208709659121862 2.103551368316628e-06 0.5175498113398643 \
2.103551542781984e-06 0.5138002600288881 2.10355169458797e-06 0.510550000123414 2.103551840818953e-06 0.5074290310664136 2.103551984717826e-06 0.5043644611166801 \
2.10355212773967e-06 0.5013276181140283 2.103552223349517e-06 0.499301733014788 2.103552317793473e-06 0.4973032961550828 2.103552438849414e-06 0.4947494705229025 \
2.10355253372771e-06 0.4927525559781179 2.103552649558553e-06 0.4903172469328811 2.103552736822402e-06 0.4884854516151125 2.103552819252848e-06 0.4867593351188191 \
2.103552914660801e-06 0.484765406725184 2.103553015371081e-06 0.4826639978995959 2.103553112231473e-06 0.4806459052877932 2.103553250961225e-06 0.4777646955734051 \
2.103553386666086e-06 0.4749532752442271 2.10355358715081e-06 0.4708139964547478 2.103553802464962e-06 0.4663911383470885 2.103553984040267e-06 0.462674698484628 \
2.103554183012236e-06 0.4586189944293299 2.103554353577757e-06 0.455154096457448 2.103554527931444e-06 0.4516251957269069 2.103554696864699e-06 0.4482170126441485 \
2.10355486946186e-06 0.4447467276163349 2.10355505206819e-06 0.4410867902598327 2.103555240617055e-06 0.4373240875354826 2.103555434084593e-06 0.4334777823509549 \
2.103555642405232e-06 0.4293535036700135 2.103555856750462e-06 0.4251286740881063 2.103556082455792e-06 0.4207018662297695 2.10355630899916e-06 0.4162771402745992 \
2.103556571175911e-06 0.4111844468197049 2.103556820209735e-06 0.4063709766754009 2.103557121308432e-06 0.4005865607947761 2.10355741072925e-06 0.3950673729298416 \
2.103557718243529e-06 0.3892455819062323 2.103558040439924e-06 0.3831936848847286 2.103558368170407e-06 0.3770882112794804 2.103558700600163e-06 0.3709500980558715 \
2.10355903032917e-06 0.3649083177186754 2.103559351558758e-06 0.3590729273462687 2.103559682375082e-06 0.3531219177045733 2.103560024730645e-06 0.3470224718704957 \
2.103560324371677e-06 0.3417374346434491 2.103560654159242e-06 0.3359723367088904 2.103560981053185e-06 0.3303128110141857 2.103561319032532e-06 0.3245206193888226 \
2.103561628003695e-06 0.3192755432624759 2.103561952801669e-06 0.31382336954194 2.103562268431866e-06 0.3085864885517507 2.103562573419032e-06 0.3035810258414895 \
2.103562828757678e-06 0.2994330834535801 2.103563093620834e-06 0.295170851203172 2.103563380703519e-06 0.2905978071194348 2.103563603673297e-06 0.2870801635277143 \
2.103563803212566e-06 0.2839591363066187 2.10356401286858e-06 0.2807045410859125 2.103564193125121e-06 0.2779290029372279 2.103564355469842e-06 0.2754463208250681 \
2.103564505904815e-06 0.2731629026725527 2.103564656910124e-06 0.2708866524077067 2.103564853800715e-06 0.2679392949564011 2.103564984945479e-06 0.2659970646012914 \
2.103565109682017e-06 0.2641561221543183 2.10356526127406e-06 0.2619266655689588 2.103565357242231e-06 0.2605306204207966 2.1035654537936e-06 0.2591282589302421 \
2.103565578413388e-06 0.2573209601776467 2.103565720989923e-06 0.255257422470362 2.103565879923458e-06 0.25296979123958 2.103566012589525e-06 0.251062957019046 \
2.103566196158294e-06 0.2484301322588876 2.103566377393459e-06 0.2458327969660818 2.103566588907564e-06 0.2428051031600066 2.103566791497399e-06 0.2399069804317323 \
2.103566958053847e-06 0.2375282895552967 2.103567168273059e-06 0.2345337828133105 2.103567341690945e-06 0.2320692345528927 2.103567570533673e-06 0.2288260787734411 \
2.103567791168424e-06 0.2257162440502939 2.103567966830138e-06 0.2232503232699662 2.103568147290643e-06 0.2207258962977968 2.103568318047021e-06 0.2183528725291195 \
2.103568498243287e-06 0.2158619697278009 2.103568664973904e-06 0.2135675266585953 2.103568814095326e-06 0.2115251542210239 2.103568969905344e-06 0.2094125291275523 \
2.103569105085769e-06 0.2075875692769576 2.103569255167197e-06 0.2055694209972212 2.103569387612823e-06 0.2037957203154137 2.103569528157359e-06 0.2019220745191926 \
2.103569645226124e-06 0.2003748851744883 2.10356977493373e-06 0.1986681706274326 2.103569896991199e-06 0.1970700654731777 2.103570019534635e-06 0.1954731161836187 \
2.103570137553958e-06 0.1939418157697267 2.103570272576731e-06 0.1921981789937757 2.103570417201182e-06 0.1903420634523806 2.103570545551681e-06 0.1887049708672087 \
2.103570669186156e-06 0.1871351133418249 2.103570766736279e-06 0.1859021016257166 2.103570881809208e-06 0.1844539912642748 2.103570975507888e-06 0.1832809848801438 \
2.103571074292012e-06 0.1820493959460708 2.103571197226553e-06 0.1805230483556907 2.103571292980556e-06 0.1793400249325384 2.103571422068107e-06 0.177753298391591 \
2.103571524533477e-06 0.1764993061988986 2.103571622786974e-06 0.1753029542432101 2.103571742874187e-06 0.1738483570896001 2.103571845423405e-06 0.1726127298531683 \
2.103571955881064e-06 0.1712877101305652 2.103572084370928e-06 0.1697552709290656 2.103572175855769e-06 0.1686698090598139 2.103572280340358e-06 0.1674358120019214 \
2.103572355277094e-06 0.1665544493622226 2.103572444845591e-06 0.1655049734124585 2.1035724954106e-06 0.164914347906921 2.103572545388976e-06 0.1643318187475747 \
2.103572610358061e-06 0.163576534137217 2.103572645872029e-06 0.1631646263336159 2.103572718071202e-06 0.162329174921529 2.103572785200297e-06 0.1615546732967998 \
2.103572844430032e-06 0.160873195114598 2.103572888175631e-06 0.1603710314414745 2.103572935822459e-06 0.1598254649913795 2.103573006202993e-06 0.1590230739426561 \
2.103573088541159e-06 0.1580883269013631 2.10357316671276e-06 0.1572048664554128 2.103573248765708e-06 0.1562816770844126 2.103573341469331e-06 0.1552436243401225 \
2.103573464249494e-06 0.153877370231325 2.103573563395588e-06 0.1527810927807017 2.103573664895935e-06 0.1516651170047695 2.103573766171126e-06 0.1505582666538253 \
2.103573862662911e-06 0.1495093242781697 2.103573962080945e-06 0.1484346886615803 2.103574046381569e-06 0.1475281828465028 2.103574139320259e-06 0.1465342051547719 \
2.1035742219212e-06 0.1456551508734999 2.103574330687285e-06 0.1445034822456445 2.103574436330265e-06 0.1433917535370727 2.103574517989854e-06 0.1425365900703354 \
2.103574611735024e-06 0.1415598856352903 2.103574705302971e-06 0.1405903867550886 2.103574788187462e-06 0.139735765814107 2.103574876346636e-06 0.1388313836440244 \
2.103574956132722e-06 0.1380170907865772 2.103575049728121e-06 0.1370669869522621 2.103575139660646e-06 0.1361590166429519 2.103575210211042e-06 0.1354501541392388 \
2.103575279971219e-06 0.1347521119166949 2.103575394120126e-06 0.1336164586193709 2.10357547609874e-06 0.1328058651355588 2.103575563704042e-06 0.1319440719770354 \
2.103575663205239e-06 0.1309710196939938 2.103575772385241e-06 0.1299110174488692 2.103575874550573e-06 0.1289256009328031 2.103575982010779e-06 0.1278959836800649 \
2.103576102045057e-06 0.1267549558890445 2.103576196253091e-06 0.1258657925752028 2.103576327232195e-06 0.1246390638240933 2.103576426659897e-06 0.1237164070883829 \
2.103576535781582e-06 0.1227104370444639 2.10357664463475e-06 0.1217138859540913 2.103576736944154e-06 0.120874257454373 2.103576849784484e-06 0.1198547128626846 \
2.103576946796524e-06 0.118986084968971 2.103577051062872e-06 0.1180628196869088 2.103577160029803e-06 0.1171053395831002 2.103577259569368e-06 0.1162371554254778 \
2.103577376562078e-06 0.1152245300989246 2.103577463662869e-06 0.1144761644999183 2.10357757295452e-06 0.1135478691973115 2.103577654479583e-06 0.1128618460838699 \
2.103577754254576e-06 0.1120273350449922 2.103577871679726e-06 0.1110526766231405 2.103577973464844e-06 0.1102143708571793 2.103578061203792e-06 0.1094962336869811 \
2.1035781420033e-06 0.1088432886892514 2.103578228954319e-06 0.1081456845520918 2.103578309740945e-06 0.1075007757815706 2.103578399947511e-06 0.1067842832273628 \
2.103578490898266e-06 0.1060655611559195 2.10357857956879e-06 0.1053685613006139 2.103578678583611e-06 0.1045946508745568 2.103578772289787e-06 0.1038723470842792 \
2.103578866149062e-06 0.1031520741219857 2.103578966976511e-06 0.1023817709659086 2.103579071607409e-06 0.1015861061604995 2.103579195570165e-06 0.1006484085638475 \
2.103579292969478e-06 0.09991551135558702 2.103579413227425e-06 0.09901872452754552 2.1035795240953e-06 0.09819831936474602 2.103579628568336e-06 0.09742874659471555 \
2.103579745805045e-06 0.09656937225591002 2.103579847599366e-06 0.09582695326576983 2.103579945574917e-06 0.09511577589263259 2.103580086079406e-06 0.09410164141823299 \
2.103580191157202e-06 0.09334832721827611 2.103580289770019e-06 0.09264549593674179 2.103580382484827e-06 0.09198739948435641 2.103580468683212e-06 0.09137785861853052 \
2.103580562596188e-06 0.09071637432184691 2.103580659696934e-06 0.09003559055802626 2.103580769117988e-06 0.08927317549644689 2.103580870101537e-06 0.08857281843916648 \
2.103580963759483e-06 0.08792605868920525 2.103581037934155e-06 0.08741581771673042 2.103581175834007e-06 0.08647193599618339 2.103581248191011e-06 0.08597917321277694 \
2.103581383512214e-06 0.08506274029062395 2.103581469423819e-06 0.08448410751389913 2.103581614152054e-06 0.08351486081643937 2.103581710382619e-06 0.0828744112740944 \
2.103581798218398e-06 0.08229260392026354 2.103581914017306e-06 0.08152964121883956 2.103582029145757e-06 0.08077575264951149 2.10358214291219e-06 0.08003553900012179 \
2.103582283169683e-06 0.0791300282244784 2.103582424545716e-06 0.07822490276368012 2.103582574181758e-06 0.07727536491519127 2.103582718670613e-06 0.07636690312463701 \
2.103582869844724e-06 0.07542565384097814 2.103583019215544e-06 0.07450459906593411 2.103583168562251e-06 0.0735926433331697 2.103583328517767e-06 0.07262574717347114 \
2.103583484664678e-06 0.07169171823582712 2.103583659153112e-06 0.07065947636250877 2.103583828862219e-06 0.0696671357044583 2.103584014041303e-06 0.0685979885997255 \
2.10358421076238e-06 0.06747763456279594 2.1035844212802e-06 0.06629631776014881 2.103584643312255e-06 0.06507007089066431 2.103584873524276e-06 0.0638195278444372 \
2.103585116035382e-06 0.06252626147401 2.103585376689467e-06 0.06116236403900636 2.103585656588531e-06 0.05972739422233359 2.103585950172255e-06 0.05825544847408989 \
2.103586265108239e-06 0.05671370145268265 2.103586607914164e-06 0.05507846134953124 2.103586957380758e-06 0.0534565727116736 2.103587366284915e-06 0.05161746230842366 \
2.103587712949942e-06 0.05010669351290297 2.103588100364995e-06 0.04846839895323611 2.103588444582788e-06 0.04705645202362623 2.103588768009047e-06 0.04576625679949029 \
2.103589073054809e-06 0.04458093278443617 2.103589365916806e-06 0.04347099288378908 2.103589650057723e-06 0.04242242262004604 2.103589926078015e-06 0.04142902112907627 \
2.103590192930566e-06 0.04049015932812138 2.103590461822789e-06 0.03956531631184226 2.103590737883211e-06 0.03863769040165695 2.103591025478782e-06 0.03769451689421055 \
2.103591265044408e-06 0.03692662498323904 2.103591554211835e-06 0.03602084344675294 2.103591770003438e-06 0.03535960341037672 2.103591957720476e-06 0.03479599077274986 \
2.103592155849583e-06 0.03421285035004928 2.103592518724446e-06 0.03317032497347058 2.103592776866276e-06 0.03244834222605905 2.10359308657919e-06 0.0316030971185694 \
2.103593352049328e-06 0.03089664771451467 2.103593620168408e-06 0.03019941363307669 2.103593899042439e-06 0.02949128999862272 2.103594145228875e-06 0.02888043298519722 \
2.103594375860285e-06 0.02832033800396738 2.103594614150204e-06 0.02775711540944564 2.103594849157568e-06 0.02721270742060762 2.103595076940031e-06 0.02669509678424227 \
2.103595485552303e-06 0.02579039168486155 2.103595661854632e-06 0.02540904040268441 2.103596016332316e-06 0.02465798827491217 2.103596200203288e-06 0.02427641469830137 \
2.10359653515201e-06 0.02359448510613503 2.103596699060727e-06 0.02326678168937357 2.103597091331304e-06 0.02249905491676728 2.103597247322069e-06 0.02220010404946675 \
2.103597678925426e-06 0.02138321689778962 2.103597816314806e-06 0.0211255367654138 2.103598333123589e-06 0.02017559010600388 2.103598458659483e-06 0.01995091418019728 \
2.103598915901008e-06 0.01915998482559782 2.103599075046989e-06 0.01889493739859509 2.103599682285467e-06 0.01793263500095189 2.103599816822955e-06 0.01772934138481063 \
2.103600480086948e-06 0.01678091027541291 2.103600673410379e-06 0.01651856846389665 2.103601341067039e-06 0.01565087920017967 2.103601502655887e-06 0.01544858341705342 \
2.10360225789114e-06 0.01454101846553843 2.103602407452107e-06 0.01436800730673201 2.103603297789931e-06 0.01338293844200974 2.103603396447817e-06 0.01327873262558703 \
2.103604353121314e-06 0.01230993787860994 2.103604474231021e-06 0.01219243157195396 2.10360546572373e-06 0.01126376273051215 2.10360562925246e-06 0.01111855113153209 \
2.103606759174536e-06 0.01018247077230436 2.103606871621774e-06 0.01009565848301377 2.103608249445262e-06 0.009103273453806031 2.103608388390533e-06 0.009009747578659758 \
2.103609942788868e-06 0.008018073335410726 2.10361005485534e-06 0.00794673960805117 2.10361169983817e-06 0.006958154532207958 2.103611807090665e-06 0.006899512253112593 \
2.103613751584153e-06 0.005937533026687714 2.10361395848211e-06 0.005843834961138424 2.103616297369852e-06 0.00487227039639981 2.103616721356264e-06 0.004712306502041247 \
2.10361949358946e-06 0.003780857497341114 2.103619941898552e-06 0.003647790772321777 2.103623582397237e-06 0.00272553831825111 2.103624079053072e-06 0.002619503085887757 \
2.103629830173496e-06 0.001650572925599863 2.103630116955382e-06 0.001609446887446839 2.103635471944067e-06 0.0006353228983793809 2.103635677300692e-06 0.0005920420449145349 \
2.106282712074507e-06 -0.0002718533828215428 2.106282867950111e-06 -0.0004579010352009555 2.106283416265203e-06 -0.001326296959495401 2.106283529048879e-06 -0.001543805653187533 \
2.106283963541019e-06 -0.002491429791030493 2.106284039366175e-06 -0.002673591589873599 2.106284396016773e-06 -0.003590195133438418 2.106284523065853e-06 -0.003936807634339821 \
2.106284801566247e-06 -0.004716444651655622 2.10628490965073e-06 -0.005020876868076652 2.106285253249855e-06 -0.00592430224391268 2.10628536024372e-06 -0.006162325733041658 \
2.106286259614116e-06 -0.005653094509861465 2.106286438047545e-06 -0.004687598829536962 2.106286543770961e-06 -0.003940993102967527 2.106286668833738e-06 -0.002883597584075996 \
2.106286762417833e-06 -0.001971418478057775 2.106286840257396e-06 -0.001132968824455395 2.106286920329394e-06 -0.0001977429743171 2.106287042702205e-06 0.001370578777960296 \
2.106287160958077e-06 0.003041212838230153 2.106287279607187e-06 0.004860750887681821 2.106287393089626e-06 0.006730904986417607 2.106287496532764e-06 0.008536402178002854 \
2.106287611192018e-06 0.01064190690353853 2.106287801775811e-06 0.0143607330143792 2.106287935565949e-06 0.01711819191720031 2.106288085819515e-06 0.02033933849841947 \
2.106288240988762e-06 0.02378599874269359 2.106288396380812e-06 0.0273434151175349 2.106288544088042e-06 0.03080849965087477 2.106288693077668e-06 0.03437359286003162 \
2.106288848068751e-06 0.03814545786868043 2.106289007439365e-06 0.04208062121327779 2.106289172372776e-06 0.04620305710844342 2.106289347319104e-06 0.0506208066052034 \
2.106289526449176e-06 0.05518387280380205 2.106289716238431e-06 0.06005265756871143 2.1062899199354e-06 0.06530840376289772 2.106290139745932e-06 0.07100650943730057 \
2.106290371497376e-06 0.07703584544314998 2.106290619322673e-06 0.08349927754587044 2.106290890643603e-06 0.09058756662233436 2.106291185356381e-06 0.09829181712822582 \
2.106291510614029e-06 0.106792896697727 2.106291876859735e-06 0.1163551101154179 2.106292270156448e-06 0.1266079356677421 2.106292722809343e-06 0.1383809089651769 \
2.106293248524511e-06 0.1520098384503803 2.106293867738049e-06 0.1679979965193872 2.106294548482366e-06 0.1854865650013753 2.10629534215732e-06 0.2057488551561759 \
2.106296230922954e-06 0.2282732214494322 2.106297044312215e-06 0.2487218262351868 2.106297766061792e-06 0.2667261628598245 2.106298401725801e-06 0.282460740414376 \
2.106298973442562e-06 0.2965101025186013 2.106299508996846e-06 0.3095696210007924 2.106300012355259e-06 0.3217495654069301 2.106300488682701e-06 0.3331878525640654 \
2.106300962606306e-06 0.3444754071334732 2.106301420078025e-06 0.3552759747331513 2.106301886058294e-06 0.3661792384270033 2.106302335046104e-06 0.376592601923634 \
2.106302831152646e-06 0.3879857357798637 2.106303350914508e-06 0.3998002499051578 2.106303730319153e-06 0.4083447473225827 2.106304170327876e-06 0.4181679450526055 \
2.106304640096814e-06 0.4285466970600206 2.106305125617752e-06 0.4391589006481625 2.106305565065858e-06 0.4486701556983262 2.106305626818807e-06 0.4500002248264944 \
2.106305750324704e-06 0.4526540461147197 2.106305997336498e-06 0.4579447795386873 2.106306249931409e-06 0.463325462421476 2.106306447502524e-06 0.467511453725808 \
2.106306673074271e-06 0.4722681264242033 2.106306994642268e-06 0.4790073975813253 2.106307263421497e-06 0.4846013351959894 2.10630748207297e-06 0.4891262574467725 \
2.106307692176936e-06 0.4934547887280634 2.106307918582462e-06 0.4980921872304203 2.106308127687652e-06 0.5023516957637455 2.10630831708991e-06 0.5061927337048852 \
2.106308441251129e-06 0.5086969563931187 2.106308568006226e-06 0.5112441466129884 2.106308728004704e-06 0.5144514110933732 2.106308975647656e-06 0.5193914248715521 \
2.106309154234115e-06 0.5229351592435862 2.106309325187692e-06 0.5263079149198099 2.106309586537288e-06 0.5314455197962068 2.10630981260887e-06 0.5358634945234868 \
2.106310015740537e-06 0.5398188128751134 2.106310180971267e-06 0.5430252218652345 2.106310337758288e-06 0.5460612552756139 2.106310526914905e-06 0.5497137532216215 \
2.106310728782658e-06 0.5535976061995346 2.106310952933981e-06 0.5578986282275192 2.106311191316346e-06 0.5624617013850463 2.106311426077985e-06 0.566941985223824 \
2.10631165634869e-06 0.5713275351537204 2.106311862141324e-06 0.5752375533958141 2.106312067125538e-06 0.5791255875933676 2.10631230994078e-06 0.5837094709690289 \
2.106312564698362e-06 0.588493349632063 2.106312792926793e-06 0.5927514274590796 2.106313030765665e-06 0.5971656109489694 2.106313243043101e-06 0.6010807441713891 \
2.106313454836506e-06 0.6049674646600495 2.106313708720774e-06 0.6095919957414236 2.106313913314301e-06 0.6132953190650409 2.106314165037654e-06 0.6178178328453598 \
2.106314352827174e-06 0.6211736970442716 2.106314605700251e-06 0.6256587164710262 2.106314804109613e-06 0.6291560967673944 2.106314983842284e-06 0.6323071487074056 \
2.106315254113091e-06 0.6370161336915187 2.106315471396856e-06 0.6407803561788556 2.106315651923236e-06 0.6438916924996977 2.106315853084131e-06 0.6473460740030906 \
2.106316021667512e-06 0.650231451944099 2.10631622602572e-06 0.6537144072723954 2.106316371688778e-06 0.6561873372238678 2.106316536247377e-06 0.6589728476742622 \
2.106316705716593e-06 0.6618316558839334 2.106316859256675e-06 0.664412775690417 2.106317000490202e-06 0.6667750288922751 2.106317144066014e-06 0.6691685747430841 \
2.106317277296139e-06 0.6713840140331436 2.106317419196459e-06 0.6737368819239464 2.106317539430086e-06 0.6757233098298149 2.106317684081138e-06 0.6781085120392751 \
2.106317800299844e-06 0.6800197521569988 2.106317919382163e-06 0.6819757159594566 2.106318017960477e-06 0.6835903813535821 2.106318135558183e-06 0.6855122399681081 \
2.106318222994146e-06 0.6869376986921233 2.106318347740232e-06 0.6889650632873403 2.106318447547296e-06 0.6905825000046129 2.106318540037092e-06 0.6920753042469043 \
2.106318641321177e-06 0.6937043390836264 2.106318739114283e-06 0.695273833970533 2.106318830385075e-06 0.6967333967490603 2.106318932842905e-06 0.6983656370917724 \
2.106319065752136e-06 0.7004728611232253 2.106319220767541e-06 0.7029137789397926 2.106319355649227e-06 0.7050222373350452 2.106319501145018e-06 0.7072806469370021 \
2.106319628999685e-06 0.709252249158637 2.106319753457981e-06 0.7111597484283609 2.106319864783685e-06 0.7128563623504806 2.106319978813713e-06 0.7145852226468989 \
2.10632007932493e-06 0.7161013069709498 2.106320216526077e-06 0.7181590832501857 2.106320336471979e-06 0.7199473375636642 2.106320455641778e-06 0.7217141075019444 \
2.106320582586792e-06 0.7235855504531626 2.106320707354209e-06 0.7254141264975077 2.106320830849597e-06 0.7272133847865295 2.10632095763087e-06 0.7290498056238117 \
2.106321088220356e-06 0.730930225429108 2.106321210432258e-06 0.7326797786847141 2.106321347490272e-06 0.7346298644824388 2.106321448705626e-06 0.7360619656663578 \
2.106321553674562e-06 0.7375401619041119 2.106321645165995e-06 0.7388229997694907 2.106321758241356e-06 0.7404001534680551 2.10632184554224e-06 0.7416107338190071 \
2.10632195000557e-06 0.7430512000342341 2.106322080768703e-06 0.7448411286358657 2.1063221906822e-06 0.7463352048609909 2.106322295341958e-06 0.7477488743938407 \
2.10632241917362e-06 0.7494094725133206 2.106322567926971e-06 0.751387874302702 2.106322689842132e-06 0.7529958494242643 2.106322803696392e-06 0.7544867042370438 \
2.10632294419585e-06 0.7563117925204224 2.106323085519364e-06 0.7581313010100689 2.106323203298971e-06 0.7596352654099263 2.106323331697459e-06 0.7612620174900669 \
2.106323474021161e-06 0.7630496612437514 2.106323590410316e-06 0.7644991888858087 2.106323736133978e-06 0.7662987831554334 2.106323857913867e-06 0.7677897310961733 \
2.106323976478797e-06 0.7692300520321635 2.106324099092246e-06 0.7707078417740018 2.106324225543629e-06 0.77221964326554 2.106324335666584e-06 0.7735261258099556 \
2.106324461188726e-06 0.7750039859681491 2.106324566849672e-06 0.7762386743660952 2.106324702026829e-06 0.7778058706872942 2.106324825637346e-06 0.7792267957652825 \
2.106324955634725e-06 0.7807078764205345 2.106325068606223e-06 0.7819831642610904 2.106325176500111e-06 0.7831908181350914 2.106325313030793e-06 0.7847046126527283 \
2.106325463151702e-06 0.7863508260127218 2.106325605416005e-06 0.7878933964149381 2.106325724997519e-06 0.7891771019825847 2.106325861808649e-06 0.7906313890246753 \
2.106325984312413e-06 0.7919206245676671 2.106326128984341e-06 0.7934276941869095 2.106326269769414e-06 0.794878360380241 2.106326396585209e-06 0.796171745508174 \
2.106326515632602e-06 0.7973744708066829 2.106326627895563e-06 0.7984986270115709 2.106326732283333e-06 0.7995352562746869 2.106326827560395e-06 0.8004739840425704 \
2.106326963902891e-06 0.8018044219089175 2.106327080767959e-06 0.8029326473252685 2.106327200364489e-06 0.8040757482679398 2.106327322250299e-06 0.8052288531124292 \
2.106327444838559e-06 0.8063765489401953 2.106327572579618e-06 0.8075599074701925 2.106327697362526e-06 0.8087035441861687 2.1063278278629e-06 0.8098867241643505 \
2.106327954229597e-06 0.8110199871086299 2.106328081578389e-06 0.8121498004723215 2.106328186791179e-06 0.8130740322933268 2.106328291495184e-06 0.8139855427426806 \
2.10632838302539e-06 0.8147757515715357 2.10632850639836e-06 0.8158311616195392 2.106328593352408e-06 0.8165684017534872 2.106328692208245e-06 0.8173999442793862 \
2.106328836710884e-06 0.8186029267949408 2.106328973036572e-06 0.8197243345631372 2.106329082445009e-06 0.8206145128367788 2.106329228461948e-06 0.821788834531623 \
2.106329380203007e-06 0.8229927727264784 2.106329506119585e-06 0.8239792970156907 2.106329650568649e-06 0.8250971468990039 2.106329775264817e-06 0.8260503472050121 \
2.106329925878834e-06 0.8271873005969326 2.106330061249302e-06 0.8281959289694237 2.106330186472937e-06 0.8291179217777711 2.106330304128897e-06 0.8299746468143927 \
2.10633044991051e-06 0.8310230722388168 2.10633061639426e-06 0.8322027532553667 2.106330747215023e-06 0.8331167337813133 2.106330920675045e-06 0.834311196379941 \
2.106331088787841e-06 0.8354501125721271 2.106331258668969e-06 0.8365827385393307 2.106331439512628e-06 0.8377685497174457 2.106331582704692e-06 0.8386931238161603 \
2.106331696822189e-06 0.8394210074154138 2.106331826873799e-06 0.8402408682651782 2.106331928753516e-06 0.8408758513273116 2.106332045641139e-06 0.841596551294542 \
2.106332182786859e-06 0.8424315815669623 2.106332380696072e-06 0.8436167827761205 2.106332572515411e-06 0.8447436440637145 2.106332781866158e-06 0.8459494874145237 \
2.106332964017768e-06 0.8469786287449077 2.106333161103991e-06 0.8480715276019779 2.106333334356719e-06 0.8490148531186206 2.106333517450963e-06 0.8499943787178993 \
2.10633368858243e-06 0.8508936588199895 2.106333863270272e-06 0.8517955326875627 2.106334038504287e-06 0.8526841769874772 2.106334214641154e-06 0.8535614892404448 \
2.106334405008494e-06 0.8544920815553035 2.106334595580845e-06 0.8554057038167108 2.106334795976838e-06 0.8563474066245403 2.106334988566463e-06 0.8572344253714166 \
2.106335199466375e-06 0.858185963363946 2.106335427341862e-06 0.8591913103610016 2.106335693424718e-06 0.8603357477151101 2.106335991926854e-06 0.8615822374427254 \
2.106336267816323e-06 0.8627000332972231 2.106336552083493e-06 0.8638181192989086 2.106336826221443e-06 0.8648650323418529 2.106337098522366e-06 0.8658754039994767 \
2.106337368678562e-06 0.8668495780678541 2.106337625862699e-06 0.8677515347235455 2.106337898421613e-06 0.8686810999091764 2.106338174469331e-06 0.8695957110915412 \
2.106338444589598e-06 0.8704649939918846 2.106338744449489e-06 0.8714007440816277 2.106339115430114e-06 0.8725171209518352 2.106339410352536e-06 0.8733732402027278 \
2.106339664628271e-06 0.8740897163373675 2.106339962841735e-06 0.8749052413925265 2.106340236411347e-06 0.8756305047096297 2.106340472534748e-06 0.8762394088953867 \
2.106340712859886e-06 0.8768433401198644 2.106340935193821e-06 0.8773882060838187 2.106341129200254e-06 0.8778530214284207 2.106341458909681e-06 0.8786208714695904 \
2.10634161408109e-06 0.87897283049042 2.10634193172349e-06 0.8796750328643211 2.106342110604035e-06 0.8800599154915705 2.106342453064798e-06 0.8807759898408113 \
2.10634263726721e-06 0.8811501695110489 2.106343112296513e-06 0.8820806183873429 2.106343279683462e-06 0.8823969901232691 2.106343745459843e-06 0.8832471741583867 \
2.106343926299187e-06 0.8835657112976044 2.106344420308805e-06 0.8844044135654346 2.106344561623711e-06 0.8846360992458032 2.106345167867327e-06 0.8855901496945974 \
2.106345319942526e-06 0.8858196526512701 2.106345966662599e-06 0.8867549368993356 2.106346094949267e-06 0.8869330782847171 2.106346743158686e-06 0.8877977435561634 \
2.106346872882985e-06 0.8879638504720397 2.106347641302053e-06 0.8888993076310558 2.106347771073903e-06 0.8890488273083775 2.106348624736509e-06 0.8899738047157748 \
2.106348767761561e-06 0.8901192131187072 2.106349754067048e-06 0.8910487927319016 2.1063499755536e-06 0.8912403904783051 2.106351118378139e-06 0.8921548233216382 \
2.106351248258076e-06 0.8922544308366913 2.106352600758498e-06 0.8932425879319322 2.106352751041431e-06 0.8933452769452155 2.106354231575698e-06 0.8942627870546499 \
2.106354470485492e-06 0.8943950258099049 2.106356252518432e-06 0.8952625983306248 2.10635663826586e-06 0.895426813549116 2.106359040424079e-06 0.8963023915260389 \
2.106359515360049e-06 0.8964490046842035 2.106363433287165e-06 0.8974035634625627 2.106363903247409e-06 0.8974927205890085 2.106372272035387e-06 0.8984807567386782 \
2.106372492545714e-06 0.8984960697096243 2.106417072074293e-06 0.8994905034760702 2.106418273460192e-06 0.8995076493514624 2.106554083268694e-06 0.9004821828323031 \
2.106554262245419e-06 0.9005421539807538 2.106557707120337e-06 0.8996085030263692 2.106557879904192e-06 0.8994755022453073 2.1065592062239e-06 0.8985168769831137 \
2.106559392989208e-06 0.8983970610744239 2.106561177194233e-06 0.8974304740967198 2.106561389324515e-06 0.8973403978332656 2.106574730020299e-06 0.8983331062395279 \
2.106574843308144e-06 0.8983517458922662 2.106583546661241e-06 0.8993273409280406 2.10658409447182e-06 0.8993637478389299 2.107076621843715e-06 0.9003542216796759 \
2.107076717582567e-06 0.9004233209197793 2.107077660131942e-06 0.9014023545001312 2.107077822585254e-06 0.9016297223302431 2.1070783892915e-06 0.9025464066367429 \
2.107078496462212e-06 0.9027401250447874 2.107078889770564e-06 0.9035002370985188 2.107079022567928e-06 0.9037710185404622 2.107079402169034e-06 0.9045728679206633 \
2.10707953238378e-06 0.9048512534150681 2.107079993790073e-06 0.9057878278182891 2.107080113037131e-06 0.9060008176934132 2.107081542646165e-06 0.9050557440230738 \
2.107081626316292e-06 0.9046580283931719 2.107081751622122e-06 0.9039622140338933 2.107081859436291e-06 0.9032622438705011 2.107081978430637e-06 0.9023800387125585 \
2.107082093802854e-06 0.9014106868475621 2.107082183899751e-06 0.900578017289966 2.107082295347455e-06 0.8994526603282017 2.107082381426603e-06 0.8985125975436928 \
2.107082487392251e-06 0.8972736935213672 2.107082587160618e-06 0.8960214106762436 2.107082668156228e-06 0.8949470092681954 2.107082777804195e-06 0.8934133399212493 \
2.107082863391606e-06 0.8921520042367302 2.107082955514215e-06 0.8907345325087322 2.107083043733598e-06 0.8893220116766375 2.107083152508351e-06 0.8875100775672261 \
2.107083235401386e-06 0.8860780350921965 2.107083343975057e-06 0.8841400608632336 2.107083436201252e-06 0.8824412727986957 2.10708352082175e-06 0.8808423775446282 \
2.10708360666218e-06 0.8791839877465467 2.10708368587706e-06 0.8776224824828824 2.10708376196503e-06 0.8760960492665846 2.107083854301399e-06 0.874210837196514 \
2.107083914177735e-06 0.8729702140710593 2.107083971566019e-06 0.8717685933706794 2.107084033561192e-06 0.8704574090763495 2.107084096840043e-06 0.8691057216070059 \
2.107084146911381e-06 0.8680269866686803 2.107084196353533e-06 0.8669542389500936 2.10708426002324e-06 0.8655623656543436 2.107084335970659e-06 0.8638877358586781 \
2.107084384801671e-06 0.8628032002737418 2.107084433325624e-06 0.8617197496806845 2.107084509037347e-06 0.8600184098866027 2.107084576246125e-06 0.8584975010852487 \
2.107084618952631e-06 0.8575263577286506 2.107084662855204e-06 0.8565244243916033 2.107084750660351e-06 0.8545103166059256 2.10708481351352e-06 0.8530605771626394 \
2.107084872183177e-06 0.8517018597088126 2.107084908361778e-06 0.8508614974547222 2.107084943180258e-06 0.8500510151036469 2.107084978206243e-06 0.8492340038666518 \
2.107085048258213e-06 0.8475953578585981 2.107085096728698e-06 0.8464581214772323 2.107085140673499e-06 0.8454248116355969 2.107085186191255e-06 0.8443523575543517 \
2.107085250092166e-06 0.8428433081697474 2.107085316218539e-06 0.8412777165526386 2.107085421348608e-06 0.8387809254526315 2.107085509283283e-06 0.8366857089760468 \
2.107085588228565e-06 0.834800137446173 2.107085676393602e-06 0.8326899670047023 2.107085763209599e-06 0.8306078985741704 2.107085851101283e-06 0.8284959280419055 \
2.107085942350373e-06 0.8262996967350639 2.107086045112241e-06 0.8238226494465998 2.107086143615716e-06 0.8214450402687625 2.107086255948632e-06 0.8187302447322098 \
2.107086368922768e-06 0.8159967029774419 2.107086490210663e-06 0.8130591602364435 2.107086620717817e-06 0.8098958628758253 2.107086749763719e-06 0.8067658935936169 \
2.10708690323932e-06 0.8030416153605923 2.10708706852354e-06 0.799029304640783 2.107087236264745e-06 0.7949567682299736 2.107087432788334e-06 0.7901857478752816 \
2.107087637550659e-06 0.7852160332972318 2.107087850227715e-06 0.7800563994093253 2.107088050847662e-06 0.7751902022758907 2.107088251706389e-06 0.7703212856706637 \
2.107088401728407e-06 0.766686939713112 2.107088532263574e-06 0.7635264252913375 2.107088666681014e-06 0.7602735436595947 2.107088772876544e-06 0.7577048602246427 \
2.107088906182877e-06 0.754482067181252 2.107089013215803e-06 0.7518959494812111 2.107089156291704e-06 0.7484409822837247 2.107089320797846e-06 0.7444713482725677 \
2.107089441615092e-06 0.74155777711076 2.107089612721756e-06 0.7374334100931738 2.107089773612309e-06 0.733558046396253 2.107089990204929e-06 0.7283457217000903 \
2.107090183460631e-06 0.7236999380850822 2.107090362395765e-06 0.7194029726762079 2.107090529212387e-06 0.7154015770462002 2.107090715418352e-06 0.7109395231330657 \
2.107090903351593e-06 0.7064416825495208 2.107091069273699e-06 0.7024749886985119 2.107091261631787e-06 0.6978803202016938 2.107091402988682e-06 0.6945068232011449 \
2.107091559996444e-06 0.6907636199298515 2.107091755976089e-06 0.6860965106368763 2.107091918410194e-06 0.6822325558671515 2.107092079586376e-06 0.6784034260021697 \
2.107092271894574e-06 0.6738409413562468 2.107092489556454e-06 0.6686845685784016 2.107092737577756e-06 0.6628199086538362 2.107092915635219e-06 0.6586162961343578 \
2.107093164179028e-06 0.6527567611811057 2.107093366786271e-06 0.6479896840619462 2.107093536596938e-06 0.6440011601507294 2.107093695213124e-06 0.6402799599229552 \
2.107093833743559e-06 0.637035894415233 2.107093969951321e-06 0.6338503464729111 2.107094096262698e-06 0.6309003762865483 2.107094225721933e-06 0.6278810604265532 \
2.107094354053672e-06 0.6248911458464299 2.107094485383603e-06 0.6218374290191309 2.107094617410215e-06 0.6187713222160208 2.107094761570095e-06 0.6154276788919771 \
2.107094905778687e-06 0.6120888358645944 2.107095053433791e-06 0.6086753592300279 2.107095200490149e-06 0.6052842859263143 2.107095358304175e-06 0.6016504852589418 \
2.107095490909828e-06 0.5986039825107707 2.107095622374794e-06 0.5955897059985247 2.107095741804593e-06 0.5928552647156846 2.107095877873286e-06 0.5897484304797134 \
2.107095992801548e-06 0.5871283594046445 2.107096143912269e-06 0.5836892419704927 2.107096258561337e-06 0.5810871834776226 2.107096376499006e-06 0.5784138884735546 \
2.107096466280294e-06 0.576381560286313 2.107096556599689e-06 0.5743415774978985 2.107096623290559e-06 0.5728373329037385 2.107096688852372e-06 0.5713590910263378 \
2.107096739894495e-06 0.5702089751121119 2.107096801596215e-06 0.5688198806440578 2.107096864686071e-06 0.5674025889664359 2.107096929044425e-06 0.5659586381304559 \
2.107096982438223e-06 0.5647616504486359 2.107097075080806e-06 0.5626864159088959 2.107097151688078e-06 0.5609719030357503 2.10709720751314e-06 0.5597256439368602 \
2.107097276567266e-06 0.5581857825097393 2.107097383455392e-06 0.5558054549196561 2.107097461199018e-06 0.5540764009223496 2.107097562049117e-06 0.5518382286767042 \
2.107097687729972e-06 0.5490568313009737 2.107097787971657e-06 0.5468419758621708 2.10709789988934e-06 0.5443739014182352 2.107098003155247e-06 0.5421024366463116 \
2.107098122904589e-06 0.5394737463112931 2.107098224637469e-06 0.5372436950013484 2.107098340157213e-06 0.5347185748314579 2.107098455192299e-06 0.5322102907975605 \
2.107098581673211e-06 0.529456475824718 2.107098707047008e-06 0.5267350629320526 2.107098853862932e-06 0.5235577714138258 2.10709898942638e-06 0.5206304261698983 \
2.107099147124634e-06 0.5172373565578411 2.107099309443689e-06 0.5137528589513558 2.107099490267585e-06 0.5098871206809381 2.107099682715905e-06 0.5057874350093188 \
2.107099895621209e-06 0.5012700264709963 2.107100127802608e-06 0.4963634062180514 2.107100385093186e-06 0.4909555076455908 2.10710062471901e-06 0.4859407514401474 \
2.107100926434446e-06 0.479662588092526 2.1071012143538e-06 0.4737079198104491 2.107101527242619e-06 0.4672821326282255 2.107101846980824e-06 0.4607585360408045 \
2.107102186575985e-06 0.4538766993710576 2.107102513478483e-06 0.4472977926730654 2.107102849036864e-06 0.4405887635920606 2.107103166132787e-06 0.4342949501181722 \
2.107103500370541e-06 0.4277061431972559 2.107103851801664e-06 0.4208322784122511 2.107104166327818e-06 0.4147233751108969 2.107104489505308e-06 0.4084912998479469 \
2.107104930620065e-06 0.400057814108821 2.107105272736104e-06 0.3935812134363078 2.107105572680633e-06 0.3879522399691127 2.107105947811639e-06 0.3809760137481454 \
2.107106277555878e-06 0.3749002425561211 2.107106560798804e-06 0.3697269896098562 2.107106860945059e-06 0.3642865787664632 2.107107140547253e-06 0.3592589179584539 \
2.107107364323365e-06 0.3552676761685443 2.107107576103695e-06 0.3515151294490645 2.107107778537159e-06 0.3479514629380864 2.107107979628427e-06 0.3444362246481504 \
2.107108185342845e-06 0.3408632458568372 2.107108452965717e-06 0.3362478643926977 2.107108691897011e-06 0.3321601360780691 2.107108925403074e-06 0.3281974319442653 \
2.107109138868473e-06 0.3246000376975314 2.107109360246046e-06 0.3208952602338652 2.107109560209693e-06 0.3175728982722026 2.107109764482006e-06 0.3142073831356898 \
2.107109961828878e-06 0.3109812293225088 2.107110147201405e-06 0.3079732989686547 2.107110343307796e-06 0.3048147723336881 2.107110545584936e-06 0.3015820927993307 \
2.107110721243233e-06 0.2988007390096292 2.10711090711339e-06 0.295878328903569 2.107111114092782e-06 0.2926488196724605 2.107111299414374e-06 0.2897857719971084 \
2.107111494641182e-06 0.2867989994419413 2.107111650415531e-06 0.28443329608414 2.107111829172313e-06 0.2817356906084737 2.107112010203233e-06 0.2790344478478936 \
2.107112160100346e-06 0.2768142575519123 2.107112361143774e-06 0.273859574769726 2.107112510258904e-06 0.2716833853889438 2.107112648798333e-06 0.2696726034832688 \
2.107112800673409e-06 0.2674956304896134 2.107112915147538e-06 0.2658586287383957 2.107113046677468e-06 0.2639823142040156 2.107113172435956e-06 0.2622048582339201 \
2.107113276776362e-06 0.2607341604582348 2.107113389755722e-06 0.2591418073851619 2.107113506084246e-06 0.2575033437579446 2.107113649011667e-06 0.2554974228347739 \
2.107113762273172e-06 0.2539102348881249 2.107113896429905e-06 0.2520298733123076 2.10711400690271e-06 0.2504818583075984 2.107114162335284e-06 0.2483006006477398 \
2.107114303220384e-06 0.2463217957442577 2.107114454612954e-06 0.2441928603691365 2.107114609775034e-06 0.2420086586735095 2.107114739184283e-06 0.2401849910837116 \
2.107114873896377e-06 0.2382868210192302 2.107115011594201e-06 0.2363478190565156 2.107115129346217e-06 0.2346905900295477 2.10711528867041e-06 0.2324499447852502 \
2.107115425932636e-06 0.2305210708572645 2.107115566678993e-06 0.2285488733964877 2.107115672470167e-06 0.2270688194984586 2.107115802411564e-06 0.2252532503786337 \
2.107115902948028e-06 0.2238506847401111 2.107116005281735e-06 0.2224250970611539 2.107116079010317e-06 0.2214012665004395 2.10711615824426e-06 0.2203047212273054 \
2.107116229215507e-06 0.2193236206014474 2.107116280678535e-06 0.218612902325451 2.107116333626988e-06 0.2178825126218075 2.10711641278199e-06 0.2167921001391954 \
2.107116455054626e-06 0.2162104926182252 2.107116494899171e-06 0.2156628374086678 2.10711653812282e-06 0.2150692779925967 2.107116579029823e-06 0.2145080585354088 \
2.107116649152284e-06 0.2135474129702876 2.107116682837256e-06 0.2130867492099046 2.107116727666638e-06 0.212477723463 2.1071167865238e-06 0.2116792343136102 \
2.107116851309261e-06 0.2108017053965978 2.107116908790024e-06 0.2100241135398916 2.107116969219033e-06 0.209207737948094 2.107117066255463e-06 0.2078991976528634 \
2.107117150945123e-06 0.2067595417901527 2.107117259855885e-06 0.2052972881712416 2.107117356256692e-06 0.2040065614180294 2.107117451273329e-06 0.2027428333585779 \
2.107117554705127e-06 0.2013717100485363 2.107117649634473e-06 0.2001158751783069 2.107117752654899e-06 0.198757993281026 2.107117857737332e-06 0.1973779917312911 \
2.107117967046146e-06 0.1959482000350934 2.107118077489628e-06 0.1945091075764383 2.107118193779903e-06 0.1929996650696684 2.107118303709896e-06 0.1915811184357085 \
2.10711841337232e-06 0.1901717999899754 2.107118515088965e-06 0.1888694322720079 2.107118608043679e-06 0.1876837490531375 2.107118700772569e-06 0.1865049219968967 \
2.107118774458125e-06 0.1855719169757668 2.10711885729934e-06 0.1845269810791141 2.107118931885336e-06 0.1835895008849975 2.107119001608678e-06 0.1827150226754214 \
2.107119068327085e-06 0.1818808699270075 2.107119164170411e-06 0.1806871657728035 2.107119246877184e-06 0.1796611249561687 2.107119340441008e-06 0.1785035608809835 \
2.107119435337095e-06 0.1773351434884491 2.107119546707405e-06 0.1759704596301353 2.107119688349759e-06 0.1742450478777388 2.107119803596612e-06 0.1728486436789435 \
2.107119948144251e-06 0.1711076225712051 2.107120059739928e-06 0.1697708811114609 2.107120200958902e-06 0.1680898955975501 2.107120316696175e-06 0.1667201145354908 \
2.107120422656861e-06 0.1654722325850081 2.107120521416478e-06 0.164314417410061 2.10712061775965e-06 0.1631901152369615 2.107120706417402e-06 0.1621596955203892 \
2.107120831751673e-06 0.1607099933926625 2.107120926277088e-06 0.1596224416957933 2.10712102401604e-06 0.1585042187118262 2.107121132110917e-06 0.1572745454417887 \
2.107121226778605e-06 0.1562036643369483 2.107121334226452e-06 0.1549951394274829 2.107121425315495e-06 0.1539767092330788 2.107121532087207e-06 0.1527896463435911 \
2.107121635480473e-06 0.1516469620792683 2.107121746560958e-06 0.1504267727114754 2.10712183578694e-06 0.1494522115900035 2.107121921266868e-06 0.1485231035185812 \
2.107122005192055e-06 0.1476157397758405 2.107122074898619e-06 0.1468658175993407 2.107122153536697e-06 0.1460232248551682 2.107122231847954e-06 0.1451880611912267 \
2.107122302483827e-06 0.1444378248611795 2.107122387974695e-06 0.1435337156153706 2.107122475363672e-06 0.1426139614481139 2.107122556951186e-06 0.1417594571206545 \
2.107122654270137e-06 0.1407454482154784 2.107122734959659e-06 0.139910090776864 2.10712282574469e-06 0.1389752404035735 2.107122947088963e-06 0.1377336220260025 \
2.107123036138604e-06 0.13682812281983 2.107123134655454e-06 0.1358318692385875 2.107123221741723e-06 0.1349560640726983 2.107123332152611e-06 0.1338550874529322 \
2.107123420611433e-06 0.1329791517134813 2.107123521340026e-06 0.1319874611681985 2.10712362612958e-06 0.1309622419763913 2.107123720519813e-06 0.1300442429014473 \
2.107123817024605e-06 0.1291112112475518 2.107123916511258e-06 0.1281591654439075 2.107124002912429e-06 0.1273384721630967 2.10712409789256e-06 0.1264411177628728 \
2.107124202081388e-06 0.1254629331099751 2.107124311200139e-06 0.124445178694 2.107124405550594e-06 0.1235704029653004 2.107124517846343e-06 0.1225411084520107 \
2.107124613309697e-06 0.1216733466577494 2.107124717520587e-06 0.1207311846737792 2.107124806865944e-06 0.1199276649878674 2.107124877253218e-06 0.1192980345746366 \
2.107124952639251e-06 0.1186268760051257 2.107125028771421e-06 0.1179522201461119 2.107125097748918e-06 0.1173458504859956 2.107125180268091e-06 0.1166263596898966 \
2.107125252211578e-06 0.1160015972854393 2.107125334290304e-06 0.1152916772467617 2.10712541862478e-06 0.1145654108773922 2.107125496418619e-06 0.113898375935255 \
2.107125589183521e-06 0.1131065723182637 2.107125704787342e-06 0.1121254933399327 2.107125810692911e-06 0.1112341778178403 2.107125888349831e-06 0.1105854195321705 \
2.107125976646302e-06 0.1098504899494786 2.107126056703354e-06 0.1091866403929743 2.107126153629479e-06 0.1083861389179563 2.107126248864964e-06 0.1076031391441806 \
2.107126337436159e-06 0.1068780200140514 2.10712643874426e-06 0.1060523297458165 2.107126544289947e-06 0.1051963702337609 2.107126653484312e-06 0.1043160928234657 \
2.107126761601933e-06 0.1034503663302994 2.107126881519694e-06 0.1024949450012773 2.107126982881521e-06 0.1016914181115986 2.107127088891151e-06 0.100855068690839 \
2.10712721468278e-06 0.09986840123414902 2.107127344240086e-06 0.09885896724496235 2.107127479915441e-06 0.09780904711780367 2.107127655987303e-06 0.09645781830037269 \
2.107127819787824e-06 0.09521257997344186 2.107127982612565e-06 0.09398642071914091 2.1071280677512e-06 0.09334985726464029 2.107128137589223e-06 0.09282999162688726 \
2.107128207084828e-06 0.09231474740697931 2.107128281043488e-06 0.09176875214326782 2.107128377198376e-06 0.09106241641841166 2.107128451613741e-06 0.09051841344162129 \
2.10712852960331e-06 0.08995079828656057 2.107128606052139e-06 0.08939693755534793 2.107128693546224e-06 0.08876614459792892 2.107128795722934e-06 0.08803382885421264 \
2.107128884287322e-06 0.08740269463919083 2.10712899395281e-06 0.08662585268124241 2.107129110009217e-06 0.08580942306245626 2.107129251558034e-06 0.0848216759818637 \
2.107129384427018e-06 0.08390253510334872 2.107129525187328e-06 0.08293727564630923 2.107129674896948e-06 0.08192024575105315 2.107129810608835e-06 0.08100683753927941 \
2.107129952125717e-06 0.08006309454860433 2.107130087247591e-06 0.07917070961097784 2.107130228520028e-06 0.07824718349428782 2.10713037561292e-06 0.07729532867436953 \
2.107130527122786e-06 0.07632524417621221 2.1071306924985e-06 0.07527819040792309 2.10713085625969e-06 0.07425356708383206 2.107131032389632e-06 0.07316505371836476 \
2.10713122152861e-06 0.07201151367936541 2.107131432202234e-06 0.07074528708793332 2.107131651768855e-06 0.06944624562626683 2.107131886535262e-06 0.06808094281860989 \
2.1071321449277e-06 0.06660616301228137 2.10713243959236e-06 0.06496103773121734 2.107132743671683e-06 0.06330286177969326 2.107133104582163e-06 0.06138472526627536 \
2.107133440499035e-06 0.05964719353945821 2.107133880676406e-06 0.05743991201668189 2.107134259043809e-06 0.05560437501227136 2.107134701502771e-06 0.05352996728430704 \
2.107135055522917e-06 0.05192508193542229 2.107135442039672e-06 0.05022502935509546 2.107135786643729e-06 0.04875485597254389 2.107136108618665e-06 0.04741934964807833 \
2.107136412152492e-06 0.04619304551845941 2.107136707073488e-06 0.04503122626702559 2.107136989555767e-06 0.04394770877170886 2.107137266636177e-06 0.04291147062934708 \
2.107137532363668e-06 0.04194013461971725 2.107137803594355e-06 0.0409708748276704 2.107138079853372e-06 0.04000619535229137 2.107138369752594e-06 0.03901828782233653 \
2.107138598128988e-06 0.03825741181922668 2.107138903013054e-06 0.03726495139513845 2.10713911968491e-06 0.03657573971894532 2.107139311041637e-06 0.03597943984071691 \
2.107139509636156e-06 0.03537298232318693 2.107139839551497e-06 0.03438820140908775 2.10714008149717e-06 0.03368375433354889 2.107140396809222e-06 0.03278771666975258 \
2.107140666929207e-06 0.03203957074185158 2.107140923300881e-06 0.03134567005659093 2.107141203312881e-06 0.03060515313352298 2.107141448968656e-06 0.02997014710356035 \
2.107141681704302e-06 0.02938120249260199 2.107141924434299e-06 0.02878348292867495 2.107142161161564e-06 0.02821317433052753 2.107142389807974e-06 0.0276732289298247 \
2.107142807093634e-06 0.02671456010533928 2.107143002274328e-06 0.02627749693639509 2.107143383441411e-06 0.02544369227895442 2.107143560694233e-06 0.02506446942885681 \
2.107143903145688e-06 0.02434654114125227 2.10714405641412e-06 0.02403127656358269 2.107144431432584e-06 0.02327616399748992 2.107144569066725e-06 0.02300530455388665 \
2.107145053333359e-06 0.02207084195640928 2.10714517295276e-06 0.02184403312078184 2.107145589991564e-06 0.02106026682208277 2.107145733393791e-06 0.02079332360769017 \
2.107146254605172e-06 0.01984598817089831 2.107146382379043e-06 0.0196205814374062 2.107146966791417e-06 0.01863359713481367 2.107147139226823e-06 0.01835589372257288 \
2.107147743323573e-06 0.01743644241612937 2.107147904755214e-06 0.01720262545858322 2.107148544701434e-06 0.01631831686205014 2.1071487230176e-06 0.016083210242981 \
2.107149371001648e-06 0.01526127675881721 2.10714953625524e-06 0.01505930898173208 2.107150272557175e-06 0.01419381259610907 2.107150406833225e-06 0.01404154276213586 \
2.107151203932743e-06 0.01317592498067951 2.107151344530354e-06 0.01302934089458718 2.107152309873577e-06 0.0120661300044765 2.107152474212383e-06 0.01190857475316222 \
2.107153474943512e-06 0.01099048917119646 2.107153612213369e-06 0.01087009009405628 2.107154750907886e-06 0.009949273443646761 2.107154865085787e-06 0.009863136028526375 \
2.107156245730622e-06 0.008889755784408603 2.107156400087833e-06 0.00878832203975914 2.107157946582061e-06 0.00781340401000951 2.107158030943764e-06 0.007760176032106158 \
2.107159716371082e-06 0.006770348169342283 2.107159839899572e-06 0.00670487246831437 2.107161889714139e-06 0.005720970231232756 2.107162086114296e-06 0.005634691917282852 \
2.107164404793654e-06 0.004698942116576918 2.107164865407989e-06 0.004530544077955615 2.10716760550353e-06 0.003639937533647344 2.107168123648567e-06 0.00349159181499799 \
2.107172274289875e-06 0.002502201117031859 2.107172812139882e-06 0.002396807933581942 2.10717889437533e-06 0.001421603691354927 2.10717915335574e-06 0.001378272220758726 \
2.10718447611909e-06 0.0003814093765652445 2.107184589276134e-06 0.0003711807182531981 2.10983070639237e-06 -0.0004615907568095335 2.109830868831339e-06 -0.0006852153244161934 \
2.109831369832807e-06 -0.001554404032531494 2.109831454015369e-06 -0.001725199767551738 2.109831855538194e-06 -0.002626792336557519 2.10983194487316e-06 -0.002845673237760077 \
2.10983223146497e-06 -0.0035898660494722 2.109832359033499e-06 -0.003937855927128601 2.109832677745161e-06 -0.004830400105952924 2.109832791946313e-06 -0.00515011308870196 \
2.109833074346638e-06 -0.005887653497963378 2.109833204572857e-06 -0.006177415671381139 2.109834182925754e-06 -0.005220113099403402 2.109834370233287e-06 -0.004004368716724641 \
2.109834501677689e-06 -0.002901539130564616 2.109834607105243e-06 -0.001869327786897239 2.109834692822726e-06 -0.0009323217369615201 2.109834774749213e-06 4.151965372454519e-05 \
2.109834895786036e-06 0.001618129410352471 2.109834994714683e-06 0.003024565667809575 2.109835153111357e-06 0.005482561958548801 2.109835370558587e-06 0.00923691162542661 \
2.109835551780809e-06 0.0126653356758144 2.109835763874906e-06 0.01697021734206094 2.109835926898563e-06 0.02046388365739064 2.109836087520978e-06 0.02403759527126768 \
2.109836241061221e-06 0.02755862871109176 2.109836389117902e-06 0.031036270750196 2.109836538198811e-06 0.03460722192241437 2.109836692728723e-06 0.03837091703902212 \
2.109836853379538e-06 0.04234026030123839 2.109837018034218e-06 0.04645786783841532 2.109837194575117e-06 0.05091770581196236 2.109837373537969e-06 0.05547793877747508 \
2.109837564281134e-06 0.0603721650098247 2.109837769062163e-06 0.06565647483694508 2.109837989534449e-06 0.07137203566208646 2.109838222394174e-06 0.0774299331224613 \
2.10983847158165e-06 0.08392829098722057 2.109838744423777e-06 0.09105513637423955 2.109839041127578e-06 0.09880974921055499 2.109839368453968e-06 0.1073623706929605 \
2.109839738105355e-06 0.11701033799881 2.109840132977169e-06 0.1273002725707723 2.10984059081541e-06 0.1392030195235975 2.109841122622249e-06 0.1529832553757746 \
2.109841747860046e-06 0.1691182447448397 2.109842433607517e-06 0.1867241161332086 2.109843236003391e-06 0.2071957342970069 2.109844134802183e-06 0.2299563735557614 \
2.109844940415632e-06 0.2501946571168963 2.109845654166966e-06 0.2679877251922811 2.109846283728848e-06 0.2835633151515627 2.109846854092298e-06 0.2975737963344939 \
2.10984738504768e-06 0.3105173405876944 2.10984788683513e-06 0.3226580892822354 2.109848366129684e-06 0.3341673054699896 2.109848831685103e-06 0.3452566901045974 \
2.109849295481511e-06 0.3562094254686541 2.109849751229541e-06 0.3668794056881832 2.109850211449675e-06 0.3775613305945491 2.109850749733646e-06 0.3899285626759094 \
2.109851250584179e-06 0.4013172511919189 2.109851650806863e-06 0.4103337945930838 2.109852157667644e-06 0.421642452039157 2.109852643633856e-06 0.4323669409017459 \
2.109853043148568e-06 0.4410997362599856 2.109853453760627e-06 0.4500002277813482 2.10985388268706e-06 0.4592207708982954 2.109854284201442e-06 0.4677760623951868 \
2.109854591591888e-06 0.4742753916877908 2.109854941833647e-06 0.4816249679276425 2.10985529507385e-06 0.4889795533930016 2.10985554824443e-06 0.4942125642332652 \
2.10985578118832e-06 0.4989990073547648 2.109856022831611e-06 0.5039392821429431 2.109856247822229e-06 0.5085102868389438 2.109856439858337e-06 0.5123881070394828 \
2.109856624670034e-06 0.5161059569497825 2.10985684696035e-06 0.5205538992744256 2.109857013671757e-06 0.5238726938135662 2.109857230888352e-06 0.5281726418673847 \
2.109857433967244e-06 0.5321820613122353 2.1098576113787e-06 0.5356681922482178 2.109857799451086e-06 0.5393528234657015 2.109858035483266e-06 0.5439555888699217 \
2.109858301365289e-06 0.5491186112539347 2.109858523127178e-06 0.5534070305875756 2.109858803185033e-06 0.5588091140818973 2.109859046184818e-06 0.5634839438879177 \
2.109859321538161e-06 0.5687575845994758 2.109859566533502e-06 0.5734440561015828 2.109859806827721e-06 0.5780305526007354 2.109860047867023e-06 0.5826153106864888 \
2.109860305457841e-06 0.5874946531182738 2.109860540824618e-06 0.5919209497705462 2.109860772126727e-06 0.5962518282209535 2.109860994653448e-06 0.6003950532231523 \
2.109861203013056e-06 0.6042587207462122 2.10986144085487e-06 0.6086392006348278 2.109861651715085e-06 0.612499186772883 2.109861907322267e-06 0.617151767543529 \
2.109862106050032e-06 0.620751700070918 2.109862381682677e-06 0.6257066023742009 2.109862604438798e-06 0.6296824120643636 2.109862897809921e-06 0.6348814180513288 \
2.109863130579923e-06 0.6389753720667986 2.109863350781309e-06 0.6428252659334456 2.109863552051921e-06 0.6463216644290061 2.109863769340794e-06 0.6500784077528632 \
2.109863944056703e-06 0.6530842133917786 2.109864130321333e-06 0.6562672470877895 2.109864309060386e-06 0.6593113758161715 2.109864471764399e-06 0.6620700940033843 \
2.10986463703341e-06 0.6648583661366954 2.109864780301224e-06 0.6672607123132118 2.109864919531648e-06 0.669583864918244 2.109865059332215e-06 0.6719085596965743 \
2.109865194107422e-06 0.6741424479378803 2.109865321601663e-06 0.6762463034350935 2.109865454555774e-06 0.6784344250006583 2.109865576160125e-06 0.680430207161383 \
2.109865704573366e-06 0.6825336955632141 2.109865820340421e-06 0.6844241240890321 2.109865918381594e-06 0.686020684362688 2.1098660190777e-06 0.687656981754083 \
2.109866128831463e-06 0.689434454762776 2.109866245599418e-06 0.6913211166705923 2.109866336826191e-06 0.6927889453402305 2.109866446031605e-06 0.6945396927028351 \
2.109866547140326e-06 0.6961566646470493 2.109866642540618e-06 0.6976767415743361 2.109866752022642e-06 0.6994136821864276 2.109866886474277e-06 0.7015344809028976 \
2.109867035493214e-06 0.7038694457768003 2.109867164423233e-06 0.7058755144243859 2.109867311083691e-06 0.7081418729260142 2.109867437868072e-06 0.7100885084081828 \
2.109867562465961e-06 0.7119899232102255 2.109867674319728e-06 0.7136874821928206 2.109867787275692e-06 0.7153928249203609 2.109867887829089e-06 0.716903336497302 \
2.109868025110592e-06 0.7189542886859326 2.109868144979452e-06 0.7207346491296758 2.109868264162204e-06 0.7224952472954583 2.109868391164314e-06 0.7243608783177121 \
2.109868515712665e-06 0.726179956024653 2.109868639383676e-06 0.7279757435764195 2.109868765971953e-06 0.7298035010246171 2.109868896541188e-06 0.7316777339938921 \
2.109869019056222e-06 0.7334262671520465 2.109869155299713e-06 0.7353588786631546 2.109869256742486e-06 0.7367901064855561 2.109869362765969e-06 0.7382789144707947 \
2.109869453297152e-06 0.7395446819117977 2.109869567123378e-06 0.7411267287627761 2.10986965478496e-06 0.742338113895605 2.109869760680238e-06 0.7437932991468792 \
2.109869891033532e-06 0.7455718205320391 2.10987000160114e-06 0.7470699275523445 2.109870106271611e-06 0.7484790865773925 2.109870230233143e-06 0.7501360792234356 \
2.109870378790597e-06 0.752105598322839 2.109870500473193e-06 0.7537054667443914 2.109870614584882e-06 0.7551949470168074 2.109870755005483e-06 0.7570132059451244 \
2.109870896533544e-06 0.7588296197226846 2.109871014322813e-06 0.7603289862386273 2.109871142522635e-06 0.7619481626911874 2.109871284590468e-06 0.7637269294216019 \
2.109871401465576e-06 0.7651780119234867 2.109871547139362e-06 0.7669714049983392 2.10987166887781e-06 0.7684572223066155 2.109871787518301e-06 0.7698939375992205 \
2.109871909984594e-06 0.7713653733660819 2.109872036701684e-06 0.7728756341192486 2.109872146603679e-06 0.7741754302862822 2.109872272219022e-06 0.7756497674172792 \
2.10987237802943e-06 0.7768823528242577 2.109872514199553e-06 0.7784559787239111 2.109872638546601e-06 0.7798807766277074 2.109872765971877e-06 0.7813271999647126 \
2.109872880527956e-06 0.7826155184370988 2.109872987208226e-06 0.7838050786084815 2.109873125150823e-06 0.785328674235108 2.109873274600319e-06 0.7869612315653352 \
2.109873419452536e-06 0.7885256944569791 2.109873538888287e-06 0.7898026796320731 2.10987367431316e-06 0.7912364721526877 2.109873795807481e-06 0.7925100718437531 \
2.109873939166555e-06 0.7939977458315933 2.109874082600237e-06 0.7954699260458764 2.109874208411247e-06 0.7967479640295563 2.109874327457929e-06 0.7979459892863545 \
2.109874439471573e-06 0.7990632136113104 2.109874544263454e-06 0.8000996927221937 2.109874639456303e-06 0.8010335634530776 2.109874775866829e-06 0.8023587211299719 \
2.109874892679005e-06 0.8034813603122919 2.109875012140248e-06 0.8046180202255495 2.1098751341806e-06 0.8057672874017472 2.109875257080697e-06 0.8069126780167393 \
2.109875384200053e-06 0.8080849010520604 2.109875509341915e-06 0.8092265787736463 2.109875639893142e-06 0.8104047139317369 2.109875765969389e-06 0.811530109085512 \
2.109875893966049e-06 0.8126603425876329 2.109875999427297e-06 0.8135823118114501 2.109876102696598e-06 0.814477091043954 2.109876195349946e-06 0.8152732203909091 \
2.109876319044181e-06 0.8163262937528154 2.109876406664096e-06 0.8170655553659417 2.109876505330151e-06 0.8178914289762149 2.109876648877154e-06 0.819080619224994 \
2.109876784463307e-06 0.8201904093102529 2.109876893653288e-06 0.8210742465492874 2.109877041102747e-06 0.8222539401850584 2.109877191506449e-06 0.8234410273756358 \
2.109877316975412e-06 0.8244188977545531 2.109877461141395e-06 0.8255287290252299 2.10987758542996e-06 0.8264738611628292 2.109877735900256e-06 0.8276038147969816 \
2.109877871506614e-06 0.8286089145501508 2.109877996601616e-06 0.8295251220930787 2.109878114317453e-06 0.8303776282987162 2.109878260203052e-06 0.8314210189912619 \
2.109878426696148e-06 0.8325942517713072 2.109878557562851e-06 0.833503494447128 2.109878731007461e-06 0.8346911703335461 2.109878899140202e-06 0.8358239212093587 \
2.109879068993949e-06 0.8369500705213252 2.109879249886955e-06 0.838129582835239 2.109879393021216e-06 0.8390486258646698 2.109879507119162e-06 0.8397723391454259 \
2.109879637246322e-06 0.8405879656882547 2.109879739102179e-06 0.8412191375388212 2.109879855947599e-06 0.8419354178465567 2.109879992919396e-06 0.84276453896487 \
2.109880190759142e-06 0.843942473808897 2.10988038244463e-06 0.8450620046306492 2.109880591850993e-06 0.8462610422160779 2.109880773861877e-06 0.8472832413425977 \
2.109880970977333e-06 0.8483697584184032 2.109881144290447e-06 0.8493077402131245 2.109881327325656e-06 0.8502809338042043 2.109881498478783e-06 0.8511747489972419 \
2.109881673131736e-06 0.8520708361396651 2.109881848382891e-06 0.8529540285731302 2.109882024530391e-06 0.8538259128238825 2.109882214836779e-06 0.8547503816925358 \
2.109882405427748e-06 0.8556583881771193 2.109882605979791e-06 0.8565949481971697 2.109882798582588e-06 0.8574764650234362 2.109883009331288e-06 0.8584213553684483 \
2.109883237362186e-06 0.8594210644592908 2.109883503241952e-06 0.8605573106989262 2.109883801820094e-06 0.8617960322792503 2.109884077983729e-06 0.8629075153790151 \
2.109884362230229e-06 0.8640180616030438 2.109884636414231e-06 0.8650581816846495 2.10988490866944e-06 0.8660616517296992 2.109885178858914e-06 0.8670295451208139 \
2.109885436023238e-06 0.8679256252637404 2.109885708596972e-06 0.8688492356117473 2.109885984602435e-06 0.8697577927663542 2.109886254710518e-06 0.8706213441784563 \
2.109886554568938e-06 0.8715508809746347 2.109886925582816e-06 0.8726599440782473 2.109887220515529e-06 0.873510245983525 2.109887474800895e-06 0.8742218447789023 \
2.109887773044171e-06 0.8750318897722944 2.109888046640929e-06 0.8757523113099853 2.109888282767907e-06 0.8763571312809064 2.109888523107205e-06 0.876957042728428 \
2.109888745440861e-06 0.8774982514557473 2.109888939446793e-06 0.8779599514934209 2.109889269165228e-06 0.8787226653583874 2.109889424338019e-06 0.8790722725343518 \
2.109889742071409e-06 0.8797700114458387 2.10988992093906e-06 0.880152324917399 2.109890263400534e-06 0.8808637455080008 2.109890447552368e-06 0.8812353200296749 \
2.109890922478418e-06 0.8821594045029107 2.109891089871654e-06 0.8824737723885729 2.10989155569296e-06 0.8833186808430151 2.109891736520447e-06 0.883635209600208 \
2.109892230549786e-06 0.8844687288968743 2.109892371887773e-06 0.8846990198924604 2.109892978249103e-06 0.8856473543416146 2.109893130320955e-06 0.8858754372639542 \
2.109893777008948e-06 0.8868048391838264 2.109893905303109e-06 0.8869818633102416 2.109894553496582e-06 0.8878410756373726 2.109894683245133e-06 0.8880061989117775 \
2.109895451498601e-06 0.8889361126992519 2.109895581240625e-06 0.8890847997417872 2.109896434697557e-06 0.8900046759307325 2.109896577924673e-06 0.8901495209380393 \
2.109897564158077e-06 0.8910738355210844 2.109897785636141e-06 0.8912643084423501 2.109898928653689e-06 0.8921737958641509 2.109899058631989e-06 0.8922730011388891 \
2.109900410338988e-06 0.8932565980587214 2.109900560692342e-06 0.8933589605607284 2.109902041315768e-06 0.8942730372387374 2.10990228021907e-06 0.8944047337041336 \
2.109904061344228e-06 0.8952702388217941 2.109904447325594e-06 0.8954343910560414 2.109906848871634e-06 0.896309305076933 2.10990732380842e-06 0.8964562995603377 \
2.109911141970139e-06 0.8973944547681553 2.109911624459336e-06 0.897487269196476 2.109919510474849e-06 0.898471373493449 2.10992012663754e-06 0.8985180228791175 \
2.110015282612379e-06 0.899508178894561 2.110016773214557e-06 0.8995204306067698 2.110128061288741e-06 0.9005118233983579 2.110128237625743e-06 0.9005706457326812 \
2.110131860757067e-06 0.8996048713171836 2.110132041955094e-06 0.8994654179496379 2.11013335307657e-06 0.8985275682722235 2.110133534953976e-06 0.8984123497545736 \
2.11013535794417e-06 0.8974436520388238 2.110135517857424e-06 0.8973766233009967 2.110148668688723e-06 0.8983720910457982 2.110148779670277e-06 0.8983905835035384 \
2.110157601254383e-06 0.8993863063850064 2.110158148023846e-06 0.8994226481040219 2.11065071997668e-06 0.9003987622903815 2.110650789769166e-06 0.9004496773542636 \
2.110651622421929e-06 0.9012853800543292 2.110651748468094e-06 0.9014513953152168 2.110652328988957e-06 0.9023435091985418 2.110652469953212e-06 0.9025895326188698 \
2.110652869091291e-06 0.9033428289365844 2.110653019240832e-06 0.9036449200440446 2.110653462322153e-06 0.9045762589490434 2.110653619494256e-06 0.9049121924877023 \
2.110654065120987e-06 0.9058152254958243 2.110654163577326e-06 0.9059929146639856 2.11065558025872e-06 0.9052304871087643 2.110655711415865e-06 0.904616184869324 \
2.110655880423041e-06 0.9036290332250884 2.110656045714917e-06 0.9024406226812831 2.110656151980698e-06 0.9015554774641358 2.110656255417528e-06 0.9006052096506509 \
2.110656341184247e-06 0.8997486040545581 2.110656430678233e-06 0.8987887485205278 2.110656554922632e-06 0.8973492764100613 2.11065667300358e-06 0.8958624931586439 \
2.110656760219672e-06 0.8946938835082598 2.110656884526716e-06 0.8929289312882503 2.110656991510644e-06 0.8913158670103165 2.110657091342348e-06 0.8897378501708729 \
2.110657217633174e-06 0.8876466417139378 2.110657385821785e-06 0.884705368138502 2.110657541521538e-06 0.8818365157686672 2.110657738126367e-06 0.8780362649814708 \
2.110657921747617e-06 0.8743271923380105 2.11065813325501e-06 0.8698916163736473 2.11065831406481e-06 0.8659808238081558 2.110658498645858e-06 0.8618945354625286 \
2.110658671649853e-06 0.8579913311618118 2.110658857050504e-06 0.8537436868396935 2.110659036133651e-06 0.8495884889292737 2.110659219722713e-06 0.8452850234109005 \
2.110659386484418e-06 0.8413449312544377 2.110659554574996e-06 0.8373487193315756 2.110659717684167e-06 0.8334514816705533 2.110659872870403e-06 0.829729402178684 \
2.110660045969282e-06 0.8255639501984255 2.110660231959738e-06 0.8210763864673301 2.110660396580222e-06 0.8170961425007568 2.110660561450132e-06 0.8131038678717658 \
2.110660736782164e-06 0.8088537582860886 2.110660901208668e-06 0.8048648186953292 2.110661069844278e-06 0.8007719922541914 2.110661260647645e-06 0.7961398815555145 \
2.110661446171818e-06 0.7916360074082958 2.110661655100628e-06 0.7865651471012967 2.110661879917618e-06 0.7811107659751856 2.110662069732705e-06 0.77650678233121 \
2.110662271590188e-06 0.7716133355283564 2.110662415860827e-06 0.76811790639139 2.110662557504392e-06 0.7646880872338248 2.110662685202102e-06 0.7615975116975136 \
2.110662796247944e-06 0.7589113686396982 2.110662924810579e-06 0.7558028559024855 2.110663057376087e-06 0.7525995467138866 2.110663170697783e-06 0.7498629233610832 \
2.11066330703241e-06 0.7465723252212872 2.110663413431661e-06 0.7440058350410135 2.110663572650447e-06 0.7401674766516904 2.110663745028142e-06 0.7360137588823189 \
2.110663907275386e-06 0.7321074183421575 2.110664079624344e-06 0.7279612819449855 2.110664239010527e-06 0.7241302920521341 2.110664446815714e-06 0.7191408067115369 \
2.110664607355379e-06 0.7152908836069264 2.110664799844715e-06 0.7106793324906435 2.110664985361064e-06 0.7062404417184839 2.110665155237109e-06 0.7021802791355866 \
2.110665347106947e-06 0.6975984806629684 2.110665493330962e-06 0.6941099299715526 2.110665653617309e-06 0.6902897983225644 2.110665856006145e-06 0.6854719661536142 \
2.110666037294609e-06 0.681161582477689 2.110666206116035e-06 0.6771536053116509 2.110666391961911e-06 0.6727470762459599 2.110666597892751e-06 0.6678715161770782 \
2.110666765819558e-06 0.6639016226084196 2.110666926081261e-06 0.6601182542089066 2.110667164933735e-06 0.65448589698252 2.110667332694849e-06 0.6505369020837752 \
2.110667513768288e-06 0.6462813620835641 2.110667674923199e-06 0.642499550819208 2.11066782119046e-06 0.6390715923276049 2.110667959878569e-06 0.6358268652274862 \
2.110668089235615e-06 0.6328040340451749 2.11066821862017e-06 0.6297855584526113 2.11066834694149e-06 0.6267952385336898 2.11066847714363e-06 0.6237652412672913 \
2.110668606160073e-06 0.6207683673242944 2.110668744735633e-06 0.6175525629501428 2.11066889281122e-06 0.6141227553162802 2.110669079138505e-06 0.60981438109949 \
2.110669226822204e-06 0.6064079319686639 2.11066946198641e-06 0.600995965122186 2.110669654434141e-06 0.5965821560879089 2.110669895003955e-06 0.5910808370261941 \
2.110670064051325e-06 0.587228367631822 2.11067020171775e-06 0.5840969866928536 2.110670329822726e-06 0.581191110277254 2.110670443409422e-06 0.5786182870235701 \
2.110670534774225e-06 0.5765512826027382 2.110670624196113e-06 0.5745328691003393 2.110670691457846e-06 0.573016830490748 2.110670757478049e-06 0.5715297341779608 \
2.110670809531724e-06 0.5703577032508095 2.110670873770593e-06 0.5689124506700958 2.110670935307116e-06 0.5675311492520995 2.11067099958866e-06 0.5660899724818867 \
2.110671052779755e-06 0.5648985048860162 2.11067114512554e-06 0.5628316153148989 2.110671221701441e-06 0.5611191615154557 2.110671277545091e-06 0.5598732849310241 \
2.1106713468882e-06 0.5583285932816697 2.110671452739476e-06 0.5559733466166974 2.11067153043128e-06 0.5542469170533902 2.110671631029867e-06 0.5520159549745236 \
2.110671759063078e-06 0.5491849411292137 2.11067185856046e-06 0.5469885705929382 2.110671971125811e-06 0.544508366501287 2.110672074170131e-06 0.5422442603473754 \
2.110672194219017e-06 0.5396115972585003 2.110672295833426e-06 0.5373863339265779 2.110672411457693e-06 0.5348611538529422 2.110672526573874e-06 0.5323536236546169 \
2.110672653010918e-06 0.529604142030661 2.110672778525186e-06 0.5268822104345234 2.110672925204862e-06 0.5237112381511962 2.11067306087557e-06 0.5207845659358002 \
2.110673218641409e-06 0.5173942078023266 2.110673381063349e-06 0.5139116507621072 2.110673561971818e-06 0.5100482739823553 2.110673754563972e-06 0.5059503908118104 \
2.110673967555743e-06 0.5014368974673542 2.11067419998846e-06 0.4965308659362653 2.110674457509373e-06 0.49112491222925 2.110674697473551e-06 0.4861095397820235 \
2.110674998677906e-06 0.4798501326413723 2.110675286975534e-06 0.4738957353990632 2.110675600061861e-06 0.4674739717793394 2.110675919588141e-06 0.4609631488871989 \
2.110676259085406e-06 0.4540919149088484 2.110676585275518e-06 0.4475353831519197 2.11067692175678e-06 0.4408159131180407 2.110677238467587e-06 0.4345373385230166 \
2.11067757255266e-06 0.4279587671099637 2.110677924261529e-06 0.4210864038135054 2.110678238746378e-06 0.4149846225409808 2.110678562192835e-06 0.4087533091618546 \
2.110679003120948e-06 0.400331870031168 2.110679344916025e-06 0.3938679283557566 2.110679644350068e-06 0.3882534014213259 2.110680018872672e-06 0.3812944595528024 \
2.11068034825039e-06 0.375233915169682 2.110680631354694e-06 0.3700684563936956 2.110680931099705e-06 0.3646408765157301 2.110681210595549e-06 0.3596219010422631 \
2.110681434267487e-06 0.3556377385586224 2.110681645979194e-06 0.3518907610576284 2.110681848481927e-06 0.3483292724130969 2.110682049543475e-06 0.3448190020587957 \
2.110682255221384e-06 0.3412518188287665 2.11068247359686e-06 0.3374887625241871 2.110682717359257e-06 0.3333167726275162 2.110682944115829e-06 0.3294678078423895 \
2.1106831640268e-06 0.3257615367192951 2.110683382451408e-06 0.3221060038181086 2.110683586476418e-06 0.318715141566024 2.110683788334207e-06 0.3153870758963987 \
2.110683988657595e-06 0.3121102802474151 2.110684175271502e-06 0.309079115007194 2.110684372573108e-06 0.3058982938882217 2.110684581156335e-06 0.3025606704206737 \
2.110684786791057e-06 0.2992974534031506 2.110685011523137e-06 0.2957609785165763 2.11068522841898e-06 0.2923771984023277 2.11068543609833e-06 0.2891642611511841 \
2.110685667149177e-06 0.2856239464683982 2.110685841949429e-06 0.2829684481899911 2.110686021147604e-06 0.2802647299798244 2.11068619002212e-06 0.2777348429135014 \
2.110686418345393e-06 0.274348458173166 2.110686595082661e-06 0.2717528218126659 2.110686763365392e-06 0.2693020894036587 2.110686935832162e-06 0.2668230333489093 \
2.110687069934441e-06 0.264903804409765 2.110687215894446e-06 0.2628277003548514 2.110687354589946e-06 0.2608803500812688 2.110687476871551e-06 0.2591684246570544 \
2.110687610990381e-06 0.2572942758553639 2.110687740091486e-06 0.2554978336754472 2.11068785952522e-06 0.2538430842138498 2.11068798636042e-06 0.2520939183506197 \
2.110688106001441e-06 0.2504447954274527 2.110688255617635e-06 0.2483797066042054 2.110688390481146e-06 0.2465170278296022 2.11068852003856e-06 0.2447289494531232 \
2.110688677103379e-06 0.2425624627506451 2.110688801099014e-06 0.2408491463446025 2.110688941247149e-06 0.2389135279283614 2.11068907114005e-06 0.2371200701944942 \
2.11068919175767e-06 0.2354534357320198 2.110689354230601e-06 0.2332087289724075 2.1106895002847e-06 0.2311905595759856 2.110689638605484e-06 0.2292825126447264 \
2.110689746532702e-06 0.2277949627009887 2.110689877317609e-06 0.225993474229161 2.110689975823625e-06 0.22463752857886 2.110690079906972e-06 0.2232056532573264 \
2.110690152783836e-06 0.2222046546567725 2.110690234937313e-06 0.2210804129356655 2.110690302346398e-06 0.2201585377209549 2.110690349050661e-06 0.2195201149856669 \
2.11069039846802e-06 0.2188449488487562 2.110690489422163e-06 0.2176035744446363 2.110690555816576e-06 0.2166983392055156 2.110690602779869e-06 0.2160586379972232 \
2.110690653091075e-06 0.2153737902794619 2.110690712240425e-06 0.2145693142997165 2.110690755086328e-06 0.2139870779821451 2.110690798893629e-06 0.2133941263688522 \
2.110690868423894e-06 0.2124566309962414 2.110690955340708e-06 0.2112864027023158 2.110691036529563e-06 0.2101949018929156 2.110691122429026e-06 0.2090416531541652 \
2.110691216575207e-06 0.2077796428137634 2.110691308329081e-06 0.2065517647617813 2.110691403625517e-06 0.2052788208685862 2.110691500104208e-06 0.2039945431316728 \
2.11069160092949e-06 0.2026602783061639 2.110691696885502e-06 0.2013924147365721 2.110691799571213e-06 0.2000377255165624 2.110691902607567e-06 0.1986831378210229 \
2.110692012697906e-06 0.1972405340748948 2.110692121449794e-06 0.1958206085628783 2.110692241171749e-06 0.1942631948714586 2.110692351614651e-06 0.1928328887741874 \
2.110692459617459e-06 0.1914411844406488 2.110692584973803e-06 0.1898318066870429 2.110692677907979e-06 0.1886434908940876 2.110692756278755e-06 0.1876443873000938 \
2.110692832918829e-06 0.1866698667869858 2.110692915430143e-06 0.1856249297118943 2.110692984939759e-06 0.1847473639743596 2.110693050895387e-06 0.1839166514106665 \
2.110693115162722e-06 0.1831089953192083 2.110693227146207e-06 0.1817072258029639 2.110693321200174e-06 0.1805353135896268 2.110693428841935e-06 0.1791985758407087 \
2.110693535314993e-06 0.1778827552324552 2.11069365530692e-06 0.1764073736674057 2.110693793359545e-06 0.174720142305475 2.1106939095201e-06 0.1733081217455876 \
2.110694071616903e-06 0.1713503924599185 2.110694186705419e-06 0.1699688234017716 2.110694326691019e-06 0.1682987764548305 2.110694443897095e-06 0.1669083002780509 \
2.110694554816447e-06 0.1655990025649634 2.110694652444933e-06 0.1644521190704843 2.110694747295481e-06 0.1633427224865242 2.110694863349893e-06 0.161991523106341 \
2.110694954898444e-06 0.1609305136382055 2.11069505100742e-06 0.1598214181625073 2.110695145225553e-06 0.1587403933520305 2.110695238726156e-06 0.1576732160104884 \
2.110695332323478e-06 0.1566104070550305 2.110695428005016e-06 0.1555300824433628 2.110695518592921e-06 0.1545132165873678 2.110695609606078e-06 0.1534969984004868 \
2.110695705154556e-06 0.1524358767948732 2.110695795820268e-06 0.1514342506187442 2.110695898892631e-06 0.1503020548964867 2.110695971344079e-06 0.1495100717445464 \
2.110696050444873e-06 0.148649146151682 2.110696124993091e-06 0.1478424742503694 2.110696196024501e-06 0.1470770917224498 2.110696268788982e-06 0.1462962409077327 \
2.110696343406156e-06 0.1454990959398698 2.110696413389118e-06 0.1447543557055888 2.110696487550038e-06 0.143968261688537 2.110696541295377e-06 0.1434005634796054 \
2.110696594578932e-06 0.1428396203849428 2.11069665977469e-06 0.1421555039833398 2.110696731080731e-06 0.141411576573238 2.110696795450793e-06 0.1407432786314442 \
2.110696868802753e-06 0.1399847409254479 2.110696929420321e-06 0.1393607073002494 2.110697015453805e-06 0.1384787080092832 2.11069709140482e-06 0.1377037134581418 \
2.110697181372726e-06 0.1367902106004182 2.110697263099683e-06 0.1359645165492482 2.110697345789661e-06 0.1351360437760365 2.110697428345969e-06 0.1343145513298757 \
2.110697533908125e-06 0.1332698421778018 2.110697615775408e-06 0.1324642397250402 2.110697713142868e-06 0.1315110876582503 2.110697803143729e-06 0.130634908321232 \
2.110697891113987e-06 0.1297829978838479 2.110697974043842e-06 0.1289892226181523 2.110698048280934e-06 0.1282822873521282 2.110698147931993e-06 0.1273377645104763 \
2.110698243687052e-06 0.1264350619688987 2.110698330534457e-06 0.1256206895242312 2.110698420535994e-06 0.1247808744623497 2.110698500868674e-06 0.1240346855852102 \
2.110698587562703e-06 0.1232365419604467 2.110698686393032e-06 0.1223331159004786 2.11069877647517e-06 0.1215131568528167 2.110698886718427e-06 0.1205141992263624 \
2.110698973949866e-06 0.1197275966302077 2.110699042523e-06 0.1191120727131645 2.110699127185393e-06 0.1183553887582162 2.110699193692874e-06 0.1177634990399222 \
2.110699265148799e-06 0.1171309945267847 2.110699334822604e-06 0.1165184920865242 2.110699412159692e-06 0.1158409171037389 2.110699507902974e-06 0.1150054407698888 \
2.110699579157887e-06 0.1143861389207103 2.11069964652742e-06 0.1138025718558601 2.110699714964191e-06 0.113211685696446 2.110699790554542e-06 0.1125613765304429 \
2.110699881296389e-06 0.1117840233035959 2.110699964000116e-06 0.1110788257213999 2.110700077599187e-06 0.1101151050704521 2.110700187474899e-06 0.1091895325357105 \
2.110700279674213e-06 0.1084169374841771 2.110700403623544e-06 0.1073835127717347 2.110700491987867e-06 0.1066505015902263 2.110700631446837e-06 0.1055001025916527 \
2.110700730743538e-06 0.1046863788921388 2.11070082339359e-06 0.1039306459201802 2.110700933598102e-06 0.1030359883605075 2.110701018892542e-06 0.1023467905686673 \
2.110701103793345e-06 0.101663637589173 2.110701186744308e-06 0.1009989740617136 2.11070130925421e-06 0.1000225794851696 2.110701431196062e-06 0.09905761200121259 \
2.110701557818349e-06 0.09806258992746317 2.110701670630471e-06 0.09718220909187772 2.110701815205956e-06 0.09606278874246346 2.110701952919884e-06 0.09500564015228773 \
2.110702069610674e-06 0.09411672853020667 2.110702197354242e-06 0.0931507147971556 2.110702297018758e-06 0.09240236948627445 2.110702376452638e-06 0.09180921593916676 \
2.110702475187935e-06 0.09107599640376031 2.110702553063239e-06 0.09050081472416407 2.110702634529155e-06 0.08990210528957472 2.110702709246463e-06 0.0893557072655629 \
2.1107027897762e-06 0.08876971652456604 2.110702908608526e-06 0.08791061481419053 2.110702998269062e-06 0.08726673116015753 2.110703103183109e-06 0.08651800316437093 \
2.110703234657667e-06 0.08558693768262025 2.110703395765802e-06 0.08445695903909305 2.110703535947497e-06 0.08348350561263763 2.110703684450103e-06 0.08246223579158835 \
2.110703821170292e-06 0.08153124812726546 2.110703961182002e-06 0.08058696725890066 2.110704098179202e-06 0.07967195061625794 2.110704236789813e-06 0.07875532825288725 \
2.1107043812627e-06 0.07780967510081127 2.110704528808937e-06 0.07685421131041187 2.110704686312648e-06 0.07584560580436887 2.110704850707884e-06 0.07480523464991846 \
2.110705018799982e-06 0.07375451744755303 2.110705199799341e-06 0.07263751640721161 2.110705398512623e-06 0.07142823309373261 2.110705611921415e-06 0.07014922396308329 \
2.1107058380853e-06 0.06881630383186611 2.110706078645623e-06 0.06742468841361035 2.110706356206536e-06 0.06585179211508728 2.110706653410938e-06 0.06420523370201831 \
2.110706971711662e-06 0.06248365192299224 2.110707361695962e-06 0.06043183534616462 2.110707760522748e-06 0.05839861031494715 2.110708202994687e-06 0.05621846258761681 \
2.11070858797559e-06 0.05438828987170503 2.110709000022183e-06 0.05249218901100536 2.110709351759698e-06 0.05092353490091287 2.11070968726435e-06 0.04946969867921969 \
2.110709997763245e-06 0.04816021644386199 2.110710291700064e-06 0.04695194805701195 2.110710584430997e-06 0.04577883625507727 2.110710859274204e-06 0.04470700909733757 \
2.110711133117927e-06 0.04366353526031765 2.110711398807687e-06 0.04267398813878486 2.110711674116703e-06 0.04167180388267511 2.110711958673621e-06 0.04066026046469497 \
2.110712254971736e-06 0.03963283340811159 2.110712513847121e-06 0.03875659098599576 2.110712741803528e-06 0.03800131046948733 2.110712960528722e-06 0.03729095380188759 \
2.110713180383449e-06 0.03659437723507575 2.110713521249514e-06 0.03554043311314246 2.110713797290394e-06 0.03470953269536187 2.110714090721169e-06 0.03384790442147732 \
2.110714373289092e-06 0.03303898052111545 2.110714628198529e-06 0.03232625790162248 2.110714908882988e-06 0.03155947796597136 2.110715154716382e-06 0.03090318379665042 \
2.11071538687767e-06 0.03029616297556957 2.110715627215008e-06 0.02968398395812225 2.110715862851843e-06 0.02909722707395018 2.110716091063021e-06 0.0285403787496557 \
2.110716507835749e-06 0.02755138287878544 2.110716702361127e-06 0.02710176794309662 2.110717088601532e-06 0.02623051698020805 2.110717267770925e-06 0.0258356865503758 \
2.110717618998109e-06 0.02507792837274256 2.110717786904156e-06 0.0247229612172224 2.110718171166812e-06 0.02392944198669211 2.11071828644854e-06 0.02369675911063252 \
2.110718728496378e-06 0.02282172072611499 2.110718950311652e-06 0.02239223679446916 2.110719473931311e-06 0.02139838041889957 2.11071962929382e-06 0.02110714647916685 \
2.110720146999888e-06 0.02015295207761772 2.110720272033152e-06 0.01992792118872039 2.110720796234659e-06 0.01901759738223179 2.110720932454034e-06 0.01879045572456909 \
2.11072153873049e-06 0.01783210191617334 2.110721705739623e-06 0.01758082406519646 2.110722348947266e-06 0.01666064795441237 2.110722528091535e-06 0.0164167113061686 \
2.110723218250269e-06 0.01551958953683085 2.110723381870153e-06 0.01531511209162885 2.11072414235084e-06 0.01440332854054019 2.110724289392963e-06 0.01423371673427115 \
2.110725107264621e-06 0.01333087949608782 2.110725226813134e-06 0.01320411419549955 2.110726142674656e-06 0.01227329163592313 2.110726284027572e-06 0.01213544173166964 \
2.110727232503148e-06 0.01124488043697059 2.110727391142586e-06 0.01110230805801717 2.11072857354363e-06 0.01011356759191894 2.11072867164402e-06 0.01003725601038859 \
2.11072993325548e-06 0.009120360285939955 2.11073006766933e-06 0.009028655389366201 2.110731608240655e-06 0.008043892937307966 2.110731689273999e-06 0.007992925041580451 \
2.110733277867931e-06 0.007023242357651564 2.110733410759078e-06 0.006948518507451114 2.11073538746242e-06 0.005952856104192286 2.110735569200568e-06 0.005869662958407677 \
2.110737671554228e-06 0.004980929874643355 2.110738112345997e-06 0.004810448874467742 2.110740767560855e-06 0.003892108290451164 2.110741244140394e-06 0.003745909362026665 \
2.110744882222615e-06 0.00279447349697209 2.11074540774606e-06 0.002678838783887205 2.110751013810845e-06 0.001700248310874221 2.110751324898547e-06 0.001653333728976835 \
2.110756459226246e-06 0.0006858192122199529 2.110756653206019e-06 0.0006440832883579712 2.113404576914862e-06 -0.0002037173203380238 2.113404741115283e-06 -0.0003889174928863678 \
2.113405314458091e-06 -0.001270938904608877 2.113405389392278e-06 -0.001411855863724778 2.113405849976055e-06 -0.002393592696522268 2.113405961916807e-06 -0.002660411672198376 \
2.113406215188795e-06 -0.003300974950034667 2.113406381572099e-06 -0.003745951779090856 2.11340667656787e-06 -0.004566571567208835 2.113406788055443e-06 -0.00488071790655901 \
2.113407067428216e-06 -0.005641221413069743 2.113407188386555e-06 -0.005938820066262044 2.113408282339388e-06 -0.005180465225493313 2.113408406471631e-06 -0.004410796826645887 \
2.113408530879049e-06 -0.003456122327429311 2.113408650435429e-06 -0.002364170815481491 2.113408748579805e-06 -0.001341064316055312 2.113408855004127e-06 -0.0001052154991983786 \
2.113408967239972e-06 0.001336046702817826 2.113409102195821e-06 0.003249882807978809 2.113409224782331e-06 0.005149402351921401 2.113409413644246e-06 0.008353592055059769 \
2.113409554826578e-06 0.01094873860302964 2.113409708187922e-06 0.01393943619118621 2.113409851561427e-06 0.01687898420971235 2.113410005752867e-06 0.02017576688295359 \
2.113410161892825e-06 0.02363796584892512 2.113410317618878e-06 0.02719811802828209 2.113410465112557e-06 0.03065407560139007 2.113410613784323e-06 0.03420778369279751 \
2.113410769114407e-06 0.03798436241030867 2.113410927740287e-06 0.04189786275883118 2.113411092673448e-06 0.0460171220807938 2.113411267096336e-06 0.05041857973200652 \
2.113411446085736e-06 0.05497510627343041 2.113411635385597e-06 0.05982852266675163 2.113411838393603e-06 0.06506368941101938 2.113412057870669e-06 0.07075025585284363 \
2.11341228893533e-06 0.07675903373893865 2.113412535995649e-06 0.08319974270080552 2.113412806420637e-06 0.0902619122132732 2.113413099984324e-06 0.09793335781011638 \
2.113413424033306e-06 0.1064001814721126 2.113413788254856e-06 0.1159066558703892 2.113414180806326e-06 0.1261372395632307 2.113414630304251e-06 0.1378252442462487 \
2.113415153096484e-06 0.1513754922073403 2.113415766694219e-06 0.1672157090591849 2.113416444455093e-06 0.184625848284817 2.113417232720212e-06 0.2047487967247964 \
2.113418115553072e-06 0.22712469896725 2.113418933839029e-06 0.2476994923478653 2.113419661268608e-06 0.2658503723959502 2.113420301381636e-06 0.2817009601644404 \
2.11342087568535e-06 0.2958213763442377 2.113421413251317e-06 0.3089396094373287 2.113421917248776e-06 0.3211464104224903 2.11342239337143e-06 0.3325930942309646 \
2.113422871259445e-06 0.3439912352478621 2.113423324592551e-06 0.3547121966731367 2.113423795885259e-06 0.3657614311162562 2.113424238561085e-06 0.3760518588326446 \
2.113424757059872e-06 0.3879885572071845 2.113425284221992e-06 0.3999987293386327 2.113425663131623e-06 0.4085537955782026 2.113426193047166e-06 0.4204060347738258 \
2.113426622963746e-06 0.429919877745455 2.113427076664521e-06 0.4398653393542544 2.113427543378037e-06 0.4500002271552926 2.113427981059267e-06 0.4594210430579985 \
2.113428389021531e-06 0.468120704286539 2.113428708454564e-06 0.4748816926501604 2.113429080589836e-06 0.4826992142337162 2.113429315571977e-06 0.4876010339127531 \
2.113429549178225e-06 0.4924491904621348 2.113429797190648e-06 0.4975647713404599 2.113430095592078e-06 0.5036796627825791 2.11343035194848e-06 0.5088948470128004 \
2.11343056424179e-06 0.5131878547336713 2.113430758259862e-06 0.5170959594548015 2.113430905246394e-06 0.5200432695146362 2.113431059224405e-06 0.523118600542271 \
2.113431277106154e-06 0.5274469616807909 2.11343153021048e-06 0.5324525256580425 2.113431740049324e-06 0.5365797337241586 2.113431951502634e-06 0.5407247601751553 \
2.113432233709534e-06 0.5462280430697679 2.113432463254817e-06 0.5506821559930507 2.113432679151023e-06 0.5548604062613707 2.113432961372541e-06 0.560308769190463 \
2.113433212680268e-06 0.5651538146135803 2.11343351034116e-06 0.5708625224168123 2.113433760568061e-06 0.5756519166658941 2.113434016931556e-06 0.5805516059354519 \
2.11343425734157e-06 0.585116682128892 2.113434515521386e-06 0.5900038400537884 2.113434739113592e-06 0.5942175703762435 2.113434977623163e-06 0.5986919452581434 \
2.113435185207861e-06 0.6025689278491061 2.113435401730487e-06 0.6065904171332736 2.113435651033092e-06 0.6111939272561876 2.113435856106535e-06 0.6149609706257601 \
2.113436107378861e-06 0.6195555361399968 2.113436310600886e-06 0.6232455818254186 2.113436507472791e-06 0.6267987644955494 2.113436700764307e-06 0.630267737067843 \
2.113436955542762e-06 0.6348113783570861 2.113437185753374e-06 0.638887973644319 2.113437403107185e-06 0.6427143472883045 2.113437701512907e-06 0.6479268061885751 \
2.113437916915757e-06 0.6516657345437264 2.113438118139476e-06 0.6551344108237934 2.113438293060983e-06 0.6581323437428509 2.113438458126254e-06 0.6609495238976936 \
2.113438627594775e-06 0.6638251431769452 2.113438779731613e-06 0.666392827642013 2.113438917642298e-06 0.6687037209181631 2.113439066478412e-06 0.6711867545200138 \
2.113439194593014e-06 0.6733159837320549 2.113439337815828e-06 0.6756849429836936 2.113439459090077e-06 0.6776819274526149 2.113439596688761e-06 0.6799401191146522 \
2.113439716069216e-06 0.6818929034138137 2.113439863176962e-06 0.6842914131385206 2.113439980378628e-06 0.6861933934268433 2.113440073884205e-06 0.6877071857403232 \
2.113440164873897e-06 0.6891752279197846 2.113440267615961e-06 0.6908280855439021 2.113440369133525e-06 0.6924555900607121 2.113440487516631e-06 0.6943444167618776 \
2.113440599637217e-06 0.6961264383846065 2.113440717192718e-06 0.6979868779962457 2.113440902343005e-06 0.7008959348649784 2.113441033535213e-06 0.7029413755586562 \
2.113441169703753e-06 0.7050491462541959 2.113441291222456e-06 0.7069171228306749 2.113441431145468e-06 0.7090538254196674 2.113441535088117e-06 0.7106315721465845 \
2.113441646249101e-06 0.712309798010818 2.113441750508965e-06 0.7138759052437967 2.113441880147056e-06 0.7158124745844324 2.113441977077769e-06 0.7172526339884565 \
2.113442116000004e-06 0.7193052800722975 2.113442235549293e-06 0.7210612846995991 2.113442355121865e-06 0.7228080613301419 2.113442480897243e-06 0.7246353354365959 \
2.113442607615585e-06 0.7264656873164689 2.113442729655437e-06 0.728218443613998 2.11344285780388e-06 0.7300486655261287 2.113442987872205e-06 0.7318956587421809 \
2.113443108863227e-06 0.7336041830685722 2.113443249633811e-06 0.7355801168346318 2.11344335060338e-06 0.7369898206659778 2.113443452204237e-06 0.7384020079314992 \
2.113443548224548e-06 0.7397310783624924 2.113443659137403e-06 0.7412570822736337 2.11344374678503e-06 0.7424563811251772 2.113443846639401e-06 0.7438154404043728 \
2.113443981404538e-06 0.7456370856934184 2.113444097699018e-06 0.747198032089633 2.113444201190815e-06 0.7485782798032956 2.113444325446263e-06 0.7502239458264747 \
2.113444470359203e-06 0.7521280942578691 2.113444588339772e-06 0.753666143975803 2.113444707270879e-06 0.7552056331692281 2.113444846850418e-06 0.7569980918234445 \
2.113444991202808e-06 0.7588357421297242 2.113445109263616e-06 0.7603265096672839 2.113445234085336e-06 0.7618908200857619 2.113445373916531e-06 0.7636286950759973 \
2.113445498679428e-06 0.7651662633748356 2.113445642192899e-06 0.7669199865864609 2.113445762878376e-06 0.7683824344671055 2.113445883722124e-06 0.7698356273746885 \
2.113446003367048e-06 0.7712633747646481 2.113446133074687e-06 0.7727989859455529 2.11344624181849e-06 0.7740766298596218 2.113446364466226e-06 0.7755070372682662 \
2.113446474242911e-06 0.7767778749889983 2.113446603267025e-06 0.7782599816788072 2.113446735043344e-06 0.7797610257751375 2.11344684835592e-06 0.7810403609326458 \
2.113446969441861e-06 0.7823954393038701 2.113447073314495e-06 0.7835479431998941 2.113447215597517e-06 0.785111775748914 2.113447363800666e-06 0.7867227488076519 \
2.113447522694201e-06 0.7884297907063792 2.113447642887223e-06 0.7897074707829422 2.11344779245393e-06 0.7912811323018302 2.113447916569147e-06 0.7925734175081853 \
2.113448042273444e-06 0.7938699048627912 2.113448145219011e-06 0.7949224966762399 2.113448259590165e-06 0.7960823495211882 2.113448372064409e-06 0.7972131756542409 \
2.113448462336983e-06 0.7981137961420948 2.113448551677879e-06 0.7989989930139054 2.113448676903817e-06 0.800229513878344 2.11344878467518e-06 0.8012785338618679 \
2.113448914342978e-06 0.8025281307685926 2.113449035722257e-06 0.8036855380110038 2.113449152278057e-06 0.8047859282369955 2.113449273083453e-06 0.80591497746663 \
2.113449405708758e-06 0.8071413435168892 2.113449527502378e-06 0.8082555056211007 2.113449654106103e-06 0.8094015704683005 2.113449779719621e-06 0.8105266036187198 \
2.113449899211046e-06 0.8115857443778658 2.113450037409299e-06 0.8127973981963581 2.113450146908547e-06 0.8137473213416323 2.113450231056662e-06 0.8144713378799666 \
2.11345035186072e-06 0.8155017394983226 2.113450447369557e-06 0.8163089346032877 2.11345058366036e-06 0.8174496006492775 2.113450726424414e-06 0.8186303638797883 \
2.113450860857535e-06 0.8197292014569521 2.113450970729519e-06 0.8206175763825388 2.113451114629137e-06 0.8217677661037901 2.11345126795672e-06 0.8229768690765377 \
2.113451395805574e-06 0.8239722812379519 2.113451536202905e-06 0.8250521595273246 2.113451662107844e-06 0.8260088941474263 2.11345181672401e-06 0.8271688948348412 \
2.113451949079339e-06 0.8281489842609937 2.113452075346168e-06 0.8290730392392056 2.113452193006695e-06 0.8299245984162376 2.113452341409092e-06 0.8309852945996649 \
2.113452508603261e-06 0.8321626230293395 2.113452641380572e-06 0.8330844501529713 2.113452814281769e-06 0.8342675727345584 2.113452982699063e-06 0.8354015168591284 \
2.113453152193536e-06 0.8365246342267009 2.113453333630418e-06 0.8377070668209077 2.113453476186559e-06 0.8386219603417975 2.11345359009745e-06 0.8393441765511721 \
2.113453720973658e-06 0.8401643924869071 2.113453822596633e-06 0.8407940582489307 2.113453939036871e-06 0.8415078269750864 2.113454074330058e-06 0.8423269142909066 \
2.113454271595159e-06 0.8435017451489455 2.113454462114483e-06 0.844614933042255 2.113454672039296e-06 0.8458175693076773 2.113454852817827e-06 0.8468334846981137 \
2.113455050185846e-06 0.8479221976595614 2.11345522404434e-06 0.8488638701886076 2.113455406558583e-06 0.8498353939890455 2.113455577902693e-06 0.8507314120859523 \
2.113455752248258e-06 0.8516272398309612 2.113455927651258e-06 0.8525125793730954 2.113456103896448e-06 0.8533864315694911 2.113456293665327e-06 0.8543099749208749 \
2.113456484423344e-06 0.8552205033559714 2.11345668621255e-06 0.8561646193034282 2.113456878916116e-06 0.8570482883232282 2.113457088356793e-06 0.8579892478796384 \
2.113457318098559e-06 0.8589986827500428 2.113457583567511e-06 0.8601360945383778 2.113457882213856e-06 0.8613786760148464 2.113458160601222e-06 0.8625023989005415 \
2.113458444791177e-06 0.8636161469557806 2.113458719285784e-06 0.8646608622318305 2.113458991377281e-06 0.8656672252055042 2.113459261593727e-06 0.8666387059277968 \
2.113459518761915e-06 0.8675381145236246 2.113459791320979e-06 0.8684653318325959 2.11346006734232e-06 0.8693777905953765 2.113460337484171e-06 0.8702455402709716 \
2.113460637231954e-06 0.8711796653984102 2.113461008105812e-06 0.872294745819888 2.113461303028797e-06 0.8731503023941 2.113461557284845e-06 0.8738665406311316 \
2.113461855515577e-06 0.8746822274488602 2.113462129133901e-06 0.8754080260278182 2.113462365269549e-06 0.8760175227551726 2.113462605621406e-06 0.876622281264788 \
2.113462827963785e-06 0.8771680781109068 2.113463021968128e-06 0.8776338860468618 2.113463351691208e-06 0.8784037109613512 2.11346350686397e-06 0.8787567114621292 \
2.113463824616497e-06 0.879461652496718 2.113464003481858e-06 0.8798480920375044 2.113464345943324e-06 0.8805675499479563 2.113464530084847e-06 0.8809434933546246 \
2.113465004990284e-06 0.8818790560183651 2.113465172384703e-06 0.8821975058309585 2.113465638216128e-06 0.8830540251881659 2.113465819040967e-06 0.8833751042472839 \
2.113466313074347e-06 0.8842212008576973 2.113466454417056e-06 0.884455124402366 2.113467060806836e-06 0.8854193259359495 2.113467212878983e-06 0.8856514227360587 \
2.11346785955747e-06 0.8865980751852495 2.113467987853825e-06 0.8867785329419297 2.113468635979926e-06 0.8876550049536978 2.113468765772447e-06 0.8878236738033012 \
2.113469544034095e-06 0.8887860366092379 2.113469659025973e-06 0.8889208282599539 2.113470514758392e-06 0.8898661633196656 2.113470660021537e-06 0.8900169066926564 \
2.113471645777722e-06 0.8909664261264102 2.113471866882862e-06 0.8911622482549515 2.113473011997307e-06 0.8921020388386462 2.113473143207264e-06 0.8922053928944147 \
2.113474330865799e-06 0.8931033243919096 2.113474484486091e-06 0.8932130731307282 2.113475894522803e-06 0.8941348173026452 2.113476117329622e-06 0.8942660193790342 \
2.11347779802033e-06 0.8951452796684343 2.11347812564151e-06 0.8952966652167414 2.113480355582631e-06 0.8961896554712738 2.113480908496593e-06 0.8963788593752812 \
2.113484476711123e-06 0.8973573335043913 2.113484800223538e-06 0.8974284307984646 2.113491156631826e-06 0.8984120886469452 2.113491705534673e-06 0.8984686671268907 \
2.113544207609024e-06 0.8994658645395698 2.113544850637887e-06 0.8994692460188505 2.113736989308519e-06 0.9004073346715066 2.113737190722491e-06 0.9004708280105613 \
2.113741150500432e-06 0.8995366825576255 2.11374133452723e-06 0.8993953949813248 2.113742651124504e-06 0.8984641879157507 2.113742823168359e-06 0.8983566564859006 \
2.113744719544654e-06 0.8973720929359315 2.113744893250842e-06 0.897304621671452 2.113757467177875e-06 0.8982933655523699 2.113757552368112e-06 0.8983081509245614 \
2.113765819241151e-06 0.8993078551592517 2.113766293960572e-06 0.8993433667976791 2.114259794870012e-06 0.9002974142054325 2.114259914349736e-06 0.9003767372269074 \
2.114260807172786e-06 0.9012336455299185 2.114260953429422e-06 0.901423267690772 2.114261548322101e-06 0.9023325668564308 2.114261683292917e-06 0.9025673929107925 \
2.114262187968707e-06 0.9035294259428087 2.114262320579608e-06 0.9038000271808221 2.114262721206973e-06 0.9046475051114249 2.114262865572371e-06 0.9049556543240072 \
2.11426328869358e-06 0.9058123566484279 2.114263384150638e-06 0.9059850892484415 2.114264808709455e-06 0.9052205906349737 2.114264933747309e-06 0.9046352442223391 \
2.114265060157898e-06 0.9039223775493039 2.114265162806642e-06 0.9032486771507763 2.114265290021932e-06 0.9022944222362175 2.114265408867758e-06 0.9012801950564071 \
2.114265506520237e-06 0.9003603330664713 2.114265588522258e-06 0.8995243596151602 2.114265668185821e-06 0.8986589236008835 2.11426577896399e-06 0.8973708307079206 \
2.114265880140004e-06 0.8961049472956977 2.114265963084475e-06 0.8950067229086057 2.114266071529892e-06 0.8934921260891034 2.11426617999385e-06 0.8918872687155874 \
2.114266275049989e-06 0.8904106867557802 2.114266395922642e-06 0.8884444419111864 2.114266516699262e-06 0.8863849482818795 2.114266629744432e-06 0.8843763393508186 \
2.114266732915182e-06 0.8824794505619851 2.114266818515338e-06 0.8808620855018965 2.114266892989399e-06 0.8794251273161163 2.114266987312941e-06 0.8775673968166831 \
2.114267075773858e-06 0.8757888800524039 2.114267154846869e-06 0.8741711975775893 2.114267248834225e-06 0.872216793437976 2.114267330179529e-06 0.8704993514258973 \
2.114267425093555e-06 0.8684673705816817 2.114267518136275e-06 0.8664480751909672 2.114267614922069e-06 0.8643215060814092 2.114267738217441e-06 0.8615778533848952 \
2.114267851664452e-06 0.859022019682563 2.114267977516491e-06 0.8561558571929792 2.114268100844636e-06 0.8533196845306243 2.114268230022926e-06 0.850323637950593 \
2.114268370619783e-06 0.8470370034914 2.114268479399504e-06 0.8444782910716596 2.114268614459258e-06 0.8412850455921466 2.114268724119566e-06 0.8386804253780991 \
2.114268853299345e-06 0.8356002443501571 2.114268979483175e-06 0.8325812421138936 2.11426910657353e-06 0.8295317031556502 2.114269235595804e-06 0.826427745883674 \
2.114269344676045e-06 0.8237985689995477 2.114269484526701e-06 0.8204223029647078 2.114269623954893e-06 0.8170507778356514 2.114269756708524e-06 0.8138366863616762 \
2.114269886777199e-06 0.8106848159989707 2.114270010472646e-06 0.8076853837479523 2.114270147427036e-06 0.8043627031572629 2.114270261138882e-06 0.8016030849198694 \
2.114270388615923e-06 0.7985086235398901 2.114270499416994e-06 0.7958187897651571 2.114270618603452e-06 0.7929254985494992 2.114270731982508e-06 0.7901733724735396 \
2.114270866292901e-06 0.7869138859547327 2.114270973387168e-06 0.7843152933129034 2.114271089404312e-06 0.7815009627552112 2.114271218595276e-06 0.778367508739124 \
2.114271316207711e-06 0.7760002683782802 2.114271421787151e-06 0.773440790716327 2.11427153046932e-06 0.7708069008430674 2.114271632885583e-06 0.7683258101021144 \
2.114271726279241e-06 0.7660641808432364 2.114271845835017e-06 0.7631702213567544 2.114271938307379e-06 0.7609327305817616 2.114272030945494e-06 0.7586922094322426 \
2.11427212937031e-06 0.7563124992069843 2.114272237347962e-06 0.7537030947613649 2.114272333616474e-06 0.7513778334636231 2.114272419872877e-06 0.7492952979736797 \
2.114272522736666e-06 0.7468128004450286 2.114272601580994e-06 0.744910856519283 2.114272702387036e-06 0.7424801602439853 2.114272836915276e-06 0.7392377693660663 \
2.114272974140135e-06 0.7359316755186537 2.114273117619987e-06 0.7324773442723981 2.114273266044177e-06 0.7289066083419234 2.114273409305472e-06 0.7254625447335662 \
2.114273549382451e-06 0.7220977259655398 2.114273705808317e-06 0.7183435968963056 2.114273830210067e-06 0.715360858370426 2.114273951271848e-06 0.7124600029613375 \
2.11427410478411e-06 0.7087850045121084 2.114274239566055e-06 0.7055614325718365 2.114274365665088e-06 0.7025479112911024 2.114274508839371e-06 0.6991289103945657 \
2.114274628921163e-06 0.6962626602560111 2.114274758155491e-06 0.6931807499479741 2.114274864640539e-06 0.6906432840523983 2.114274976916361e-06 0.6879696524977363 \
2.114275073251647e-06 0.6856773754336868 2.11427517606134e-06 0.683232326200841 2.114275270865193e-06 0.6809792012818872 2.114275376187123e-06 0.6784784437814733 \
2.114275484625777e-06 0.6759058899658261 2.114275583635057e-06 0.673558569590366 2.11427570039165e-06 0.6707929011939652 2.114275808476928e-06 0.6682347329991606 \
2.114275918483136e-06 0.6656332609774134 2.114276004570979e-06 0.6635992664604092 2.114276134166118e-06 0.6605400273835189 2.114276226767366e-06 0.6583552307294462 \
2.114276322555092e-06 0.6560965362104854 2.114276407507078e-06 0.6540950852804182 2.114276526801602e-06 0.6512869789851043 2.11427661407154e-06 0.6492343850333612 \
2.114276704778561e-06 0.6471030993779646 2.114276805943536e-06 0.6447280068361273 2.114276885774359e-06 0.6428551652550211 2.114276974560194e-06 0.6407732405330839 \
2.11427705225042e-06 0.6389536101386547 2.114277114019368e-06 0.6375081226244841 2.114277177784013e-06 0.6360167668935747 2.114277241018233e-06 0.634538653569437 \
2.114277280258806e-06 0.6336218002627473 2.114277320897828e-06 0.6326726453797233 2.114277400982362e-06 0.6308039353694699 2.114277470886542e-06 0.6291742390428672 \
2.114277521523257e-06 0.6279942052995945 2.114277560272899e-06 0.6270914175114127 2.114277599267879e-06 0.6261832343283663 2.114277643882627e-06 0.6251445623164014 \
2.114277686739083e-06 0.6241478292286105 2.114277737053686e-06 0.6229782634938205 2.114277788990864e-06 0.6217719122409077 2.114277874058448e-06 0.6197972300178722 \
2.114277934038866e-06 0.6184052992407258 2.114278023826075e-06 0.61632338076978 2.114278100290156e-06 0.6145529519516876 2.114278179854447e-06 0.6127119801362371 \
2.114278260891059e-06 0.6108383709630588 2.114278350105382e-06 0.6087775861620425 2.114278440965394e-06 0.6066826282541496 2.114278528184102e-06 0.6046739453334793 \
2.114278621957293e-06 0.6025158549334848 2.114278723642756e-06 0.6001788642681311 2.114278823240848e-06 0.5978941858483342 2.114278935095889e-06 0.5953317151711254 \
2.114279051129026e-06 0.5926772450523136 2.114279172750132e-06 0.5899020947998995 2.114279277133946e-06 0.5875236635596754 2.114279421924166e-06 0.5842296531729801 \
2.114279534584127e-06 0.5816734289694181 2.114279643596094e-06 0.5792035939892568 2.114279736075537e-06 0.5771100174076607 2.114279829526177e-06 0.5749994714793375 \
2.11427992185204e-06 0.5729181236728181 2.114279994438741e-06 0.571283073141143 2.114280050392967e-06 0.5700232888304386 2.114280111461249e-06 0.5686498830286455 \
2.114280209950764e-06 0.5664400707212188 2.114280273162208e-06 0.5650238531380825 2.114280333588177e-06 0.5636708824310654 2.11428041053656e-06 0.5619492451093103 \
2.114280473695102e-06 0.5605380106414651 2.11428056200871e-06 0.558569506627369 2.114280633210033e-06 0.5569845302974165 2.114280719745787e-06 0.555060151797141 \
2.11428084109856e-06 0.5523665438352664 2.114280969027808e-06 0.5495364947125975 2.114281067158439e-06 0.5473694328713704 2.114281180282434e-06 0.5448752016832871 \
2.114281282350254e-06 0.5426314425864434 2.114281401299125e-06 0.5400217272291628 2.114281504386832e-06 0.5377630705755105 2.114281618593986e-06 0.5352670017334624 \
2.114281732009658e-06 0.532794946211756 2.114281859080713e-06 0.5300302694710822 2.114281982900802e-06 0.5273426867079006 2.114282127689607e-06 0.5242103332418484 \
2.11428226351311e-06 0.5212782585303676 2.114282418567968e-06 0.5179428401013338 2.114282579419853e-06 0.5144913885072363 2.1142827581493e-06 0.5106699876709851 \
2.11428294832834e-06 0.5066200804011861 2.114283158230362e-06 0.5021665212646098 2.114283386936347e-06 0.4973332357952056 2.114283640864285e-06 0.4919960258408594 \
2.114283881797751e-06 0.4869529241725989 2.114284177960236e-06 0.4807889695952298 2.114284467957623e-06 0.4747910561470179 2.114284774200956e-06 0.4684976697011882 \
2.114285094876887e-06 0.4619520863481486 2.114285422744054e-06 0.4553041925245184 2.114285762989109e-06 0.4484521981997251 2.114286088414655e-06 0.4419418052309769 \
2.114286410321802e-06 0.4355465312739703 2.114286740535907e-06 0.4290298934287748 2.114287096528499e-06 0.4220583188787752 2.114287415406929e-06 0.4158579595363656 \
2.114287752858691e-06 0.4093433989943853 2.114288180725408e-06 0.4011531841887147 2.114288529437355e-06 0.3945419525178304 2.114288837073319e-06 0.388759214407489 \
2.11428921689981e-06 0.3816861832573664 2.114289548089372e-06 0.3755780492082042 2.114289831697452e-06 0.370391509977049 2.114290142516396e-06 0.3647512908748707 \
2.114290421833005e-06 0.3597258263082204 2.114290648329153e-06 0.3556836811642302 2.114290864011538e-06 0.3518598964090484 2.114291061295543e-06 0.3483842179544538 \
2.114291266280002e-06 0.3447988491770444 2.114291478501966e-06 0.3411119200457455 2.114291733807154e-06 0.33670771290924 2.114291975329403e-06 0.3325734463267218 \
2.114292206706731e-06 0.3286464933807047 2.114292421559231e-06 0.3250253651850565 2.114292642118388e-06 0.3213332986541765 2.114292843544355e-06 0.3179852906236645 \
2.114293046612606e-06 0.3146379646143546 2.114293244508215e-06 0.3114011111455273 2.114293431469302e-06 0.3083651674074345 2.114293625269522e-06 0.3052406640298299 \
2.114293829186134e-06 0.3019773030815858 2.114294008255468e-06 0.2991336297844484 2.114294243846324e-06 0.2954229173226265 2.114294444650423e-06 0.2922868215109002 \
2.114294645829314e-06 0.2891696385850206 2.114294869639057e-06 0.2857334090862961 2.114295034201803e-06 0.2832271910241367 2.114295211129189e-06 0.2805503385691353 \
2.114295396922194e-06 0.2777610713150803 2.11429557873767e-06 0.2750538970423583 2.114295757762463e-06 0.2724132377985424 2.114295925107616e-06 0.2699606650006489 \
2.114296085536533e-06 0.2676371805838822 2.114296208110285e-06 0.2658719571410424 2.114296357874814e-06 0.2637236906090554 2.11429648557194e-06 0.2619099339733745 \
2.114296592880312e-06 0.2603957336038235 2.114296708880974e-06 0.2587625259947361 2.11429681918957e-06 0.2572125806747212 2.114296945068767e-06 0.2554509781935611 \
2.114297060550618e-06 0.2538402638894013 2.114297195131521e-06 0.2519757335310172 2.114297307194775e-06 0.2504255755821768 2.114297457534135e-06 0.2483447107137444 \
2.114297597159989e-06 0.2464124269747185 2.114297743051809e-06 0.2444035064209518 2.114297876012447e-06 0.2425734862730615 2.114297999574161e-06 0.2408709992523319 \
2.114298146783853e-06 0.2388417729476062 2.114298263370682e-06 0.2372355665500016 2.114298402825831e-06 0.23532008003217 2.114298537000301e-06 0.2334768281602104 \
2.114298662976758e-06 0.2317465561243653 2.11429878237616e-06 0.2301094434087779 2.114298877230585e-06 0.2288105340759602 2.114298990368184e-06 0.2272617792622066 \
2.114299070684642e-06 0.2261626001158484 2.114299158249698e-06 0.2249657246820506 2.114299283786835e-06 0.2232507767215072 2.114299389480543e-06 0.2218101326756785 \
2.114299479135054e-06 0.2205921574607158 2.114299549986253e-06 0.2196300825522397 2.114299593014783e-06 0.2190460135436258 2.114299635305326e-06 0.2184724035808872 \
2.114299677647042e-06 0.2178984240735344 2.114299749842462e-06 0.2169203674089526 2.114299792235817e-06 0.2163464205126744 2.114299827490656e-06 0.2158693585303403 \
2.11429987168224e-06 0.2152716287340076 2.114299941290467e-06 0.2143309212991285 2.114299975633796e-06 0.2138672544767182 2.114300020093325e-06 0.2132698436071631 \
2.114300087771806e-06 0.2123628126304402 2.114300174199065e-06 0.2112058698236149 2.114300248835667e-06 0.2102078598594563 2.114300330137675e-06 0.2091219706754807 \
2.114300427015059e-06 0.2078300362310651 2.114300552998548e-06 0.2061528795789772 2.114300655533384e-06 0.2047906894256944 2.114300757016901e-06 0.2034500128132261 \
2.114300858082597e-06 0.202119416354989 2.114300954696816e-06 0.2008491615811921 2.114301056661239e-06 0.1995112314821507 2.114301163383483e-06 0.1981153840927639 \
2.114301271788624e-06 0.1967018790395962 2.114301383782779e-06 0.1952465002768531 2.114301496249907e-06 0.1937897263683151 2.114301608323246e-06 0.1923454332378671 \
2.11430171621572e-06 0.1909603537828802 2.114301817598649e-06 0.1896629368444172 2.114301909236098e-06 0.1884941330679491 2.114302003211707e-06 0.1872990757663449 \
2.114302074478072e-06 0.1863957871745983 2.11430215115336e-06 0.1854271890400033 2.114302254812475e-06 0.184122202819407 2.114302328479595e-06 0.1831974022686171 \
2.114302401825495e-06 0.1822796569444652 2.114302515215845e-06 0.1808667181969195 2.114302603074485e-06 0.1797760932362061 2.114302686923162e-06 0.1787387947787487 \
2.114302815885589e-06 0.1771515524267008 2.114302917772084e-06 0.1759040172436072 2.114303023472791e-06 0.1746156056808686 2.114303125120866e-06 0.1733818993219825 \
2.114303255982584e-06 0.1718019019596718 2.114303363179221e-06 0.1705140034701537 2.114303492508118e-06 0.168969083715685 2.11430360420461e-06 0.167642098072289 \
2.114303704535189e-06 0.1664555496840579 2.114303800335743e-06 0.1653276075899142 2.114303911148015e-06 0.1640289617085985 2.114303998548296e-06 0.1630090521997956 \
2.114304109869413e-06 0.1617156184952586 2.114304202821272e-06 0.1606409001560029 2.11430429039415e-06 0.1596330843918451 2.114304392025023e-06 0.1584700928658864 \
2.114304476479078e-06 0.1575086241734052 2.114304551583457e-06 0.1566573095634876 2.1143046294057e-06 0.1557789554714152 2.114304709763569e-06 0.1548759612316424 \
2.114304810818399e-06 0.1537464547857493 2.114304893251962e-06 0.1528311848879565 2.114304985556514e-06 0.1518114053368895 2.114305062490987e-06 0.150965812476358 \
2.114305145413558e-06 0.1500585909391909 2.114305216944298e-06 0.1492793026301012 2.114305313327797e-06 0.1482344968214558 2.114305383556283e-06 0.1474766665551334 \
2.114305466536561e-06 0.1465853655470201 2.114305527978825e-06 0.1459298106834085 2.114305599661209e-06 0.1451677491870439 2.114305668289752e-06 0.1444408762699853 \
2.114305718558261e-06 0.1439102090153988 2.114305766138067e-06 0.143409423336876 2.114305820187418e-06 0.1428423132663369 2.114305879529516e-06 0.1422216078256897 \
2.114305947564923e-06 0.1415124633834424 2.114306023828345e-06 0.1407207186008814 2.114306092108144e-06 0.1400161356079559 2.114306186894323e-06 0.1390460813732662 \
2.114306276448135e-06 0.1381341561933974 2.114306348133609e-06 0.1374075731330657 2.114306432085017e-06 0.1365606113096345 2.114306497397473e-06 0.1359045398875483 \
2.114306558840598e-06 0.1352895588344758 2.114306633117096e-06 0.1345490408254265 2.114306695327357e-06 0.1339328028964004 2.114306763298366e-06 0.133265236037424 \
2.114306822505405e-06 0.1326856657519672 2.114306895177879e-06 0.1319767402814105 2.114306970197987e-06 0.1312477270463112 2.114307055651411e-06 0.1304208267333309 \
2.11430714175175e-06 0.1295914604616623 2.114307241877205e-06 0.1286317929389105 2.114307323166875e-06 0.127857435971709 2.114307424934223e-06 0.1268981149578782 \
2.114307509182182e-06 0.1261072369695883 2.114307607998911e-06 0.1251836587365037 2.114307680839456e-06 0.1245055382686853 2.114307760865543e-06 0.1237631876254407 \
2.114307831351338e-06 0.1231117958237987 2.114307903881761e-06 0.1224439308288319 2.114307981350756e-06 0.1217331219782777 2.114308088702104e-06 0.1207554316575004 \
2.114308189340119e-06 0.1198442997624752 2.114308261927673e-06 0.1191899427853172 2.114308330759514e-06 0.1185715582611356 2.114308396546334e-06 0.1179824683205609 \
2.114308466175132e-06 0.1173610347366148 2.114308536558877e-06 0.1167350538439435 2.11430861173725e-06 0.1160688810594495 2.114308715991484e-06 0.1151493019715505 \
2.114308791126138e-06 0.114489769343061 2.114308860041223e-06 0.1138870655592168 2.114308923246095e-06 0.1133369146236164 2.11430899278746e-06 0.1127339156958381 \
2.114309050088964e-06 0.1122385190692166 2.114309121730019e-06 0.1116210355509516 2.114309179565092e-06 0.1111240709857579 2.114309251686527e-06 0.1105063809580559 \
2.11430931410261e-06 0.1099736279351742 2.114309398424132e-06 0.1092565349771765 2.1143094660201e-06 0.1086842173446869 2.114309574816032e-06 0.1077671916889585 \
2.114309679126564e-06 0.1068924975608609 2.114309758614772e-06 0.1062289053282379 2.114309846183182e-06 0.1055008617114655 2.114309909639535e-06 0.1049752776433979 \
2.114309971350651e-06 0.10446579874651 2.114310075190416e-06 0.103612238268202 2.114310157871118e-06 0.1029362225408096 2.114310256339144e-06 0.1021348761715451 \
2.114310340785582e-06 0.101450818648051 2.114310457263062e-06 0.1005121841703865 2.114310591996508e-06 0.09943411943161744 2.114310728066044e-06 0.0983541971400249 \
2.114310842385451e-06 0.09745369041838402 2.114310927852596e-06 0.09678457778867394 2.114311038134269e-06 0.09592640631053104 2.114311118922622e-06 0.09530159220710262 \
2.114311218473493e-06 0.09453592511176086 2.114311308421543e-06 0.09384821103094763 2.114311380924943e-06 0.09329669945188329 2.114311462667009e-06 0.09267796846073476 \
2.114311590787244e-06 0.09171467366828615 2.114311672199308e-06 0.09110674702409056 2.114311746631215e-06 0.09055373306570065 2.114311821605099e-06 0.08999936228352182 \
2.114311901024074e-06 0.08941505746347288 2.114312009684932e-06 0.08862052380504259 2.114312104044903e-06 0.08793517800096999 2.114312193440026e-06 0.08728987318634121 \
2.114312300205743e-06 0.086524181682867 2.114312418708182e-06 0.08568073755029131 2.114312560233253e-06 0.08468224831562859 2.114312693371676e-06 0.08375174214918565 \
2.114312834217007e-06 0.08277682112810406 2.114312983268988e-06 0.08175525972387458 2.114313119066717e-06 0.08083369778093191 2.114313260523232e-06 0.0798830809748103 \
2.114313395783147e-06 0.07898330517332906 2.114313537164988e-06 0.07805242629322809 2.114313684232761e-06 0.07709434677344783 2.114313835960902e-06 0.07611680364043326 \
2.114314001309203e-06 0.07506403321855706 2.114314165176721e-06 0.07403332863189842 2.114314341490649e-06 0.07293832728335037 2.11431453092575e-06 0.07177777688466977 \
2.114314741692455e-06 0.07050569389938771 2.114314961464952e-06 0.06920150027616521 2.114315196433104e-06 0.06783224552442871 2.114315455333654e-06 0.06635227408830123 \
2.114315750264117e-06 0.06470266364809808 2.114316054610178e-06 0.06304001691994518 2.114316416556457e-06 0.06111393619706453 2.114316732684212e-06 0.05947639552636011 \
2.114317174006677e-06 0.0572596911373907 2.114317487572719e-06 0.05573556853365672 2.114317911072189e-06 0.0537382660685313 2.114318255024043e-06 0.05216649213267931 \
2.11431859526531e-06 0.05065508790922631 2.1143189061029e-06 0.04931137323461653 2.114319200574802e-06 0.04807062469528345 2.114319494274299e-06 0.04686392507224969 \
2.114319769145535e-06 0.04576537019482012 2.114320044685701e-06 0.04468949010490332 2.11432030977623e-06 0.04367785045825667 2.114320586533311e-06 0.04264571401740119 \
2.114320869801435e-06 0.04161414314527601 2.114321167794735e-06 0.04055545327485047 2.114321427280131e-06 0.03965542606183669 2.114321657303569e-06 0.03887446236327848 \
2.114321876995156e-06 0.03814321686473518 2.114322101935296e-06 0.0374128399305801 2.11432242218897e-06 0.0363978329183388 2.11432270998682e-06 0.03550963653148703 \
2.114322986382154e-06 0.03467738358988744 2.114323270201283e-06 0.03384352473043348 2.114323508310587e-06 0.03315996078327022 2.114323792621371e-06 0.03236211345273886 \
2.114324034533221e-06 0.03169864947531036 2.114324269673394e-06 0.03106710921041438 2.114324511380923e-06 0.03043352335444016 2.114324748333857e-06 0.02982731501219571 \
2.114324978676274e-06 0.02925002048968134 2.114325192426852e-06 0.02872465224286764 2.114325398273815e-06 0.02822791768061097 2.114325790610838e-06 0.02730524204782691 \
2.114325979002849e-06 0.02687312495148303 2.114326354614307e-06 0.02603163971789 2.114326529081082e-06 0.02564950258131362 2.114326953015541e-06 0.02474274850847508 \
2.114327073769958e-06 0.02449086781212801 2.114327544020722e-06 0.02353384026002922 2.114327693235786e-06 0.02323677291035493 2.114328086867998e-06 0.02246740853134286 \
2.114328257894342e-06 0.02213909006726131 2.114328745173274e-06 0.02121869533024997 2.114328887220983e-06 0.02095326544309953 2.114329420237252e-06 0.01997576278857772 \
2.114329542401289e-06 0.01975737097014436 2.114330064559033e-06 0.01885981776906158 2.114330235137336e-06 0.01857989792133653 2.114330722450399e-06 0.01781360777737795 \
2.114330893973323e-06 0.01755501440977742 2.11433151376008e-06 0.01666567753024489 2.114331684684406e-06 0.0164316648397145 2.114332390235396e-06 0.01551160061118263 \
2.114332552852409e-06 0.01530799450170666 2.114333309745899e-06 0.01439879525764199 2.114333450662544e-06 0.01423641007536438 2.114334350661384e-06 0.01324361033368418 \
2.114334438010635e-06 0.01315122959105692 2.114335342363989e-06 0.01223321097894121 2.114335479555938e-06 0.01209984223734439 2.114336450212214e-06 0.01118944790767422 \
2.114336578130092e-06 0.01107451071402888 2.114337728540038e-06 0.01011008206277823 2.114337822342075e-06 0.01003687265682024 2.114339078387887e-06 0.009120584045805383 \
2.114339215929201e-06 0.009026502753623255 2.114340774683602e-06 0.008029670037698805 2.114340858486287e-06 0.007977066150721189 2.114342463865106e-06 0.00699828665725172 \
2.11434257476345e-06 0.006935886594503895 2.114344507009824e-06 0.005959177461785255 2.114344686714759e-06 0.005876661013304485 2.114346798505876e-06 0.004981749118765498 \
2.114347141291011e-06 0.004848482978762325 2.114349654457045e-06 0.003966891390423618 2.114350124178715e-06 0.003819799497680527 2.11435376449499e-06 0.002847564273158896 \
2.114354280232175e-06 0.002731633924241866 2.114359622062014e-06 0.001773027297371861 2.114359907382299e-06 0.001729522787584184 2.114365136030129e-06 0.0007540451492352357 \
2.114365310176696e-06 0.0007162692714263865 2.117013698769002e-06 -0.0001123232525192561 2.11701387179429e-06 -0.0002901710972538241 2.117014491546044e-06 -0.001202022686018724 \
2.117014580115222e-06 -0.001365806793032466 2.117014941086355e-06 -0.002110727959526865 2.11701506578065e-06 -0.002395793696299351 2.117015429622531e-06 -0.003299857180474864 \
2.117015600898199e-06 -0.003758114451912169 2.117015894896038e-06 -0.004576312838821549 2.117016005104443e-06 -0.004886880824040592 2.117016283358441e-06 -0.005643955697619643 \
2.11701640463225e-06 -0.00594200199557267 2.117017498254348e-06 -0.00517389603226481 2.117017621358228e-06 -0.004409713243767066 2.117017744826303e-06 -0.003462788751204457 \
2.1170178649921e-06 -0.002366010162083454 2.117017962853768e-06 -0.001346276287748183 2.117018069556104e-06 -0.0001076498664581183 2.117018181397488e-06 0.001328007358939307 \
2.117018317371855e-06 0.003256083960376262 2.117018439401011e-06 0.00514709866632534 2.117018627817289e-06 0.008343062029134115 2.117018768805819e-06 0.01093380316938193 \
2.117018921577522e-06 0.01391176330477175 2.117019064280151e-06 0.01683596409946878 2.117019218632387e-06 0.02013443377634912 2.117019374426043e-06 0.02358734537610087 \
2.11701953048334e-06 0.02715365164079262 2.11701967788774e-06 0.03060642997674319 2.117019826504485e-06 0.03415780069914553 2.117019981925702e-06 0.03793559522944389 \
2.117020140311532e-06 0.04184227512730877 2.117020305251154e-06 0.04596085539464361 2.117020479500423e-06 0.05035714787605008 2.117020658443539e-06 0.05491177248689325 \
2.117020847583032e-06 0.0597604232635115 2.11702105036361e-06 0.06498910043066243 2.117021269735637e-06 0.07067233091134768 2.117021500572133e-06 0.07667464705993039 \
2.117021747383969e-06 0.0831083675499642 2.11702201751608e-06 0.09016243555275107 2.117022310704188e-06 0.0978236474935409 2.117022634359626e-06 0.1062798466079799 \
2.117022997926912e-06 0.1157689210849182 2.11702339022043e-06 0.1259925151671456 2.117023838699915e-06 0.1376538644086695 2.1170243603994e-06 0.1511757390224034 \
2.117024972772044e-06 0.1669844191341421 2.117025649417359e-06 0.1843663871188266 2.11702643632765e-06 0.2044554566749352 2.117027317548744e-06 0.2267919980918504 \
2.117028137292384e-06 0.2474048556006221 2.117028865745328e-06 0.2655829647002126 2.117029507221317e-06 0.2814688958417333 2.117030083144485e-06 0.2956305456066151 \
2.117030620401302e-06 0.3087428400511723 2.117031124292597e-06 0.3209487846516751 2.117031601896145e-06 0.3324328152479784 2.117032080019379e-06 0.343838772307344 \
2.117032532118229e-06 0.3545331600964184 2.117033003884519e-06 0.365596737404158 2.11703344758136e-06 0.3759140547845509 2.117033969549898e-06 0.3879344734281669 \
2.11703449708783e-06 0.399956933836353 2.117034876602574e-06 0.4085271910771138 2.117035405564175e-06 0.4203606102508351 2.117035874883255e-06 0.4307444005277802 \
2.117036310038791e-06 0.4402814026247405 2.117036757516117e-06 0.4500002273945978 2.117037197539592e-06 0.4594737646471725 2.117037600841335e-06 0.4680814138276727 \
2.117037919241101e-06 0.4748254127722248 2.117038289219015e-06 0.4826007100982719 2.117038525472097e-06 0.4875314737878706 2.117038760543493e-06 0.4924129045770672 \
2.117039011882831e-06 0.4975994385012801 2.117039318269865e-06 0.5038799449729535 2.117039575228319e-06 0.5091120301871851 2.117039783702615e-06 0.5133309170973237 \
2.117039984084905e-06 0.5173683849445317 2.117040126478606e-06 0.5202244049244739 2.117040275403072e-06 0.5231993726577677 2.117040486949329e-06 0.5274019882470222 \
2.117040713006952e-06 0.5318780389403845 2.117040907549334e-06 0.5357103559602913 2.117041096681229e-06 0.539423417888626 2.117041326128277e-06 0.5439012399750046 \
2.117041508634083e-06 0.5474563135343053 2.117041745996952e-06 0.5520623276458133 2.11704201499126e-06 0.5572695987004129 2.11704226390171e-06 0.5620706638085723 \
2.117042507918531e-06 0.5667633705755619 2.117042780273744e-06 0.5719926523718327 2.117043041669873e-06 0.5769928369418796 2.117043299301279e-06 0.5819084237686675 \
2.117043546144628e-06 0.586601202059797 2.117043791890354e-06 0.5912552023551558 2.117044018467874e-06 0.5955288021520931 2.117044249620064e-06 0.5998646534936181 \
2.117044455900444e-06 0.6037202012184053 2.117044684021204e-06 0.6079592993751251 2.117044906401185e-06 0.6120725203834017 2.117045133377667e-06 0.6162454422471376 \
2.117045348430617e-06 0.6201823359462864 2.11704557780019e-06 0.6243500782103125 2.117045846823065e-06 0.6292041961704016 2.117046069836712e-06 0.6331993632081415 \
2.117046282091289e-06 0.6369772451758789 2.117046493488879e-06 0.6407176358819484 2.117046693558109e-06 0.644236566349866 2.117046923151958e-06 0.6482486956559365 \
2.117047163988886e-06 0.6524328529570182 2.117047345738273e-06 0.6555667906748446 2.1170475342865e-06 0.6588018260593631 2.117047687366139e-06 0.6614154033769962 \
2.117047859374421e-06 0.6643352515471471 2.117048009547239e-06 0.6668697017322168 2.117048146064529e-06 0.6691578850264722 2.117048295693716e-06 0.6716547631652277 \
2.117048423434085e-06 0.673777752640997 2.117048563020222e-06 0.6760856948620949 2.11704868725891e-06 0.6781310478824312 2.117048818408749e-06 0.6802827752320969 \
2.117048942850093e-06 0.6823179209931315 2.117049080080916e-06 0.6845542421253382 2.117049200329086e-06 0.6865048414796368 2.117049341660529e-06 0.6887891282595083 \
2.11704944199164e-06 0.6904033553735033 2.117049563109343e-06 0.6923460943304175 2.117049653886878e-06 0.6937948943079848 2.117049751145344e-06 0.6953408241330762 \
2.117049847353224e-06 0.6968660703265798 2.117049935967068e-06 0.6982647859968389 2.117050033255091e-06 0.6997938110311075 2.117050165723729e-06 0.7018622871835729 \
2.117050320913928e-06 0.7042674555997347 2.117050458791879e-06 0.7063866855441746 2.117050603646153e-06 0.7085960165693863 2.11705073070791e-06 0.7105202221428537 \
2.11705085539347e-06 0.7123960184768648 2.117050968098846e-06 0.7140814553427599 2.117051079889191e-06 0.7157437310299281 2.11705118066784e-06 0.7172341607972841 \
2.117051317946295e-06 0.7192525454101454 2.117051437630367e-06 0.7210013704967912 2.117051557059838e-06 0.7227365757678518 2.11705168394306e-06 0.7245692610776365 \
2.117051808360712e-06 0.7263556789600311 2.117051932093536e-06 0.728121726658988 2.117052058689063e-06 0.7299181396522603 2.117052189074464e-06 0.7317573312219798 \
2.117052311884284e-06 0.7334798522758219 2.117052447320059e-06 0.7353678990088863 2.117052548609838e-06 0.7367723836293941 2.117052656232334e-06 0.7382576460517265 \
2.117052745760416e-06 0.7394878879617913 2.117052860308785e-06 0.7410528648863303 2.117052948337041e-06 0.7422487366778059 2.117053055415107e-06 0.7436953530868765 \
2.1170531854801e-06 0.7454403311053276 2.117053296759795e-06 0.7469230742113165 2.117053401378355e-06 0.7483084058091373 2.11705352546134e-06 0.7499400420429273 \
2.117053673762168e-06 0.7518749696944975 2.117053795162033e-06 0.7534462209622173 2.11705390960278e-06 0.7549170836379747 2.117054049940097e-06 0.7567069362027918 \
2.117054191702981e-06 0.7584995177563068 2.117054309503919e-06 0.759977341175643 2.117054437480785e-06 0.761570846386187 2.117054579183209e-06 0.7633205808366864 \
2.117054696694523e-06 0.7647599110190483 2.117054842299792e-06 0.7665289162262866 2.117054963994099e-06 0.7679951561698679 2.117055082724709e-06 0.7694149786178283 \
2.117055205011304e-06 0.7708662727382939 2.11705533205582e-06 0.77236234268503 2.117055441699792e-06 0.7736439866494906 2.117055567386705e-06 0.7751025186690397 \
2.117055673401805e-06 0.776323977486031 2.117055808987772e-06 0.7778743028704433 2.117055933950768e-06 0.7792913979962601 2.117056059856921e-06 0.7807070123991936 \
2.117056175124167e-06 0.7819915514687489 2.11705628142864e-06 0.7831664991275713 2.117056419833432e-06 0.7846822315516878 2.117056569129882e-06 0.7862997378875561 \
2.117056714637327e-06 0.7878588534534761 2.117056834041839e-06 0.7891257303126159 2.117056969134664e-06 0.7905455128963393 2.117057090387826e-06 0.7918076974797237 \
2.117057233381105e-06 0.7932816011184505 2.11705737758541e-06 0.7947523458802197 2.117057503122239e-06 0.7960199014141693 2.117057622168612e-06 0.7972110037065316 \
2.117057734104495e-06 0.7983213107123885 2.117057838976047e-06 0.7993531099923881 2.117057934226459e-06 0.8002831901653534 2.117058070569705e-06 0.8016020813281191 \
2.117058187393835e-06 0.8027203407102198 2.117058306798445e-06 0.803852171037294 2.117058428905249e-06 0.8049980820693966 2.117058551860251e-06 0.8061401395390313 \
2.117058678828951e-06 0.8073073595000361 2.11705880406856e-06 0.8084467645495962 2.117058934640955e-06 0.8096220968518901 2.117059060631473e-06 0.8107441738369082 \
2.117059188817386e-06 0.8118738099374113 2.117059294347114e-06 0.8127947795787664 2.117059397218887e-06 0.8136847278655364 2.117059490214057e-06 0.8144826950388273 \
2.117059614010659e-06 0.8155354283166244 2.117059701978918e-06 0.8162769513478326 2.117059800709988e-06 0.8171027376706747 2.117059943975142e-06 0.8182889948057973 \
2.117060079253827e-06 0.8193962136425846 2.11706018836845e-06 0.8202800249700468 2.117060336451758e-06 0.8214657808291811 2.117060486222685e-06 0.8226492530953341 \
2.117060611457286e-06 0.8236267526687548 2.117060755448703e-06 0.8247372275730155 2.117060879504774e-06 0.8256825756473101 2.117061029968032e-06 0.8268152483647575 \
2.117061165678884e-06 0.8278240064655301 2.117061290697392e-06 0.828742521381556 2.117061408452322e-06 0.8295983347934622 2.117061554429135e-06 0.8306466023667578 \
2.117061720938452e-06 0.8318251482734692 2.117061851861028e-06 0.8327390940956469 2.117062025288466e-06 0.8339327615268647 2.117062193435348e-06 0.8350717495747054 \
2.117062363270277e-06 0.8362042975620877 2.117062544195048e-06 0.8373912937861997 2.117062687293307e-06 0.8383160748488641 2.117062801379198e-06 0.8390446117604563 \
2.117062931553184e-06 0.8398665237782376 2.117063033394266e-06 0.8405024977857931 2.117063150213615e-06 0.8412243379523001 2.117063287078045e-06 0.8420597162999857 \
2.117063484876669e-06 0.8432475311273343 2.11706367648074e-06 0.8443767279905872 2.117063885921221e-06 0.8455874169714939 2.117064067846852e-06 0.8466193100105236 \
2.117064264979957e-06 0.8477171434207121 2.117064438329848e-06 0.8486653666163242 2.117064621329232e-06 0.8496493024239481 2.117064792495495e-06 0.8505537352954988 \
2.117064967127282e-06 0.8514606693963016 2.117065142389669e-06 0.8523550102558151 2.117065318541785e-06 0.8532381479010797 2.117065508812824e-06 0.8541746551565574 \
2.117065699414774e-06 0.85509499218684 2.117065900062401e-06 0.8560449689899254 2.117066092672966e-06 0.8569390259424264 2.117066303330652e-06 0.8578972157030333 \
2.117066531456051e-06 0.8589122247267402 2.117066797213369e-06 0.8600655879592763 2.117067095837813e-06 0.8613244245924475 2.117067372169332e-06 0.862454900702886 \
2.11706765640239e-06 0.8635842083919951 2.117067930614306e-06 0.8646423892283146 2.117068202842372e-06 0.8656634505877856 2.117068473051191e-06 0.8666487272755322 \
2.117068730204067e-06 0.8675609437488442 2.117069002786335e-06 0.868501515423508 2.117069278771335e-06 0.8694269133137555 2.117069548872912e-06 0.8703069289141475 \
2.117069848734863e-06 0.8712546000783432 2.117070219768993e-06 0.8723856543073821 2.117070514706754e-06 0.8732530157608677 2.117070768997536e-06 0.8739790309043101 \
2.117071067254951e-06 0.8748056771600844 2.117071340863485e-06 0.8755409825400007 2.117071576991549e-06 0.8761583495732972 2.11707181733693e-06 0.876770807053994 \
2.117072039670212e-06 0.8773233906735478 2.11707223367596e-06 0.8777948466981503 2.117072563398506e-06 0.8785737911727464 2.117072718571944e-06 0.8789308835864816 \
2.117073036347473e-06 0.8796437246174529 2.11707321520917e-06 0.8800342982281311 2.117073557671047e-06 0.8807611334253193 2.117073741799519e-06 0.8811407335605206 \
2.117074216677856e-06 0.8820849466541889 2.117074384074053e-06 0.8824061830950772 2.117074849915456e-06 0.8832696475595492 2.117075030737665e-06 0.8835931319180218 \
2.117075524775914e-06 0.8844450822729043 2.117075666124327e-06 0.8846804878101884 2.117076272457385e-06 0.8856498028150036 2.117076424526725e-06 0.8858829444029697 \
2.1170770712152e-06 0.8868329272509302 2.117077199509723e-06 0.8870138524519416 2.117077847626928e-06 0.8878919388991984 2.117077977425792e-06 0.8880607713689423 \
2.117078755627481e-06 0.8890227771434612 2.117078870684414e-06 0.8891574578072456 2.117079726342848e-06 0.8901003239091128 2.117079871707616e-06 0.8902505899439886 \
2.11708085746403e-06 0.8911948786459364 2.11708107856904e-06 0.8913892999646706 2.117082223696019e-06 0.8923206810037944 2.117082354912618e-06 0.892422953350996 \
2.117083696124267e-06 0.8934189515818408 2.117083847523211e-06 0.8935240845833778 2.117085328961459e-06 0.8944568913393511 2.117085567840892e-06 0.8945912088657246 \
2.117087337161074e-06 0.8954685138428928 2.117087726310841e-06 0.895637400736999 2.117090119976628e-06 0.896526474291006 2.11709059568945e-06 0.8966764365754722 \
2.117094011699057e-06 0.8975478548673914 2.117094658849072e-06 0.8976786076740833 2.117102137013678e-06 0.8986646932675814 2.117102809590797e-06 0.8987192862546014 \
2.117195253995366e-06 0.8997188196574962 2.117195917228051e-06 0.8997241906476866 2.117385126389945e-06 0.900686595210158 2.117385288462789e-06 0.9007292695325627 \
2.117387933983676e-06 0.8998161167154269 2.117388102533154e-06 0.8996881690130656 2.117389379285545e-06 0.8987393243250013 2.117389581451881e-06 0.8986030018074492 \
2.117391189561267e-06 0.8976721249252815 2.117391381667192e-06 0.8975774045828077 2.117406495049839e-06 0.8985726115129884 2.117406683108756e-06 0.8986004060702872 \
2.117417988037768e-06 0.8995874924221801 2.117418361423516e-06 0.8996034751727418 2.117907373786698e-06 0.9005892719715856 2.117907484554897e-06 0.9006868984798269 \
2.117908237227259e-06 0.9015617873136611 2.117908339021945e-06 0.9017086238768567 2.11790887442049e-06 0.9025814930725723 2.117908976929663e-06 0.9027670217776843 \
2.117909369148482e-06 0.9035254014384071 2.117909509991429e-06 0.9038129158713877 2.117909951028881e-06 0.9047472953155866 2.117910136514484e-06 0.9051402477015744 \
2.117910652827601e-06 0.9061269394579334 2.117910737502694e-06 0.9062564181617988 2.117911972174744e-06 0.9053011091537977 2.117912129388156e-06 0.9045688862145235 \
2.117912321204817e-06 0.9034162411061901 2.117912488045349e-06 0.9021712267446264 2.117912635003746e-06 0.9008824031243315 2.117912749119942e-06 0.8997575350477262 \
2.117912878992032e-06 0.8983446880789033 2.11791299010955e-06 0.8970273815442567 2.117913082914029e-06 0.8958483937359277 2.117913171236719e-06 0.8946639786015808 \
2.117913274417478e-06 0.8932058048613533 2.117913366625413e-06 0.8918333298588224 2.11791345419561e-06 0.8904732289418564 2.117913568189077e-06 0.8886245408236838 \
2.1179137299935e-06 0.8858564722885236 2.117913914992117e-06 0.8825005184224666 2.117914107151785e-06 0.8788219124347386 2.117914308599138e-06 0.874780227084481 \
2.117914515009728e-06 0.8704697801294994 2.117914700181681e-06 0.8664790122147591 2.117914884689405e-06 0.862405115500708 2.117915057841296e-06 0.8585071391690239 \
2.117915242887321e-06 0.8542751393552932 2.117915420261525e-06 0.8501657390392787 2.117915597007955e-06 0.8460284987362284 2.117915763166606e-06 0.8421077870518131 \
2.117915925211044e-06 0.8382599993991456 2.117916091783925e-06 0.8342839555277276 2.117916250437662e-06 0.8304816347052207 2.117916441313687e-06 0.8258903812682129 \
2.117916616297258e-06 0.8216694867670907 2.117916786243393e-06 0.8175615830390965 2.117916951419567e-06 0.8135626411663678 2.117917124611674e-06 0.8093650119631921 \
2.117917295673877e-06 0.8052155696745213 2.117917463774914e-06 0.801136095357175 2.117917654109863e-06 0.7965156511928794 2.117917837691806e-06 0.7920591698039 \
2.117918045682732e-06 0.7870113041480956 2.117918268259242e-06 0.7816114142545842 2.117918457674258e-06 0.7770174196885687 2.117918650984654e-06 0.7723312127316435 \
2.117918794430241e-06 0.7688556734481145 2.117918943853591e-06 0.7652374066097742 2.117919063006063e-06 0.7623536300085233 2.117919175722544e-06 0.7596269484184472 \
2.117919284997451e-06 0.7569846861296079 2.117919421027209e-06 0.753697254849378 2.117919533823024e-06 0.750972995067179 2.11791965602098e-06 0.7480232093637929 \
2.117919767605753e-06 0.7453311011793381 2.117919892312215e-06 0.7423241425761796 2.117920046694167e-06 0.7386034578119585 2.117920213478233e-06 0.7345862494782525 \
2.117920430642921e-06 0.7293605768817599 2.11792062520351e-06 0.7246835946359503 2.117920785534396e-06 0.7208333202545074 2.117920960959998e-06 0.7166251500492028 \
2.117921150723573e-06 0.7120779400724765 2.117921339451897e-06 0.7075610435995559 2.117921521273264e-06 0.7032145396962334 2.117921705870676e-06 0.6988062725207448 \
2.117921842953811e-06 0.6955348514212173 2.117921996242049e-06 0.6918805091472418 2.117922191613795e-06 0.6872279990818534 2.117922347770547e-06 0.6835136309588888 \
2.117922505722766e-06 0.6797605476340507 2.11792270397403e-06 0.6750570282453686 2.117922897319928e-06 0.6704763548785364 2.117923133825274e-06 0.6648822204491218 \
2.117923320030378e-06 0.6604858901039825 2.117923557652698e-06 0.6548824851665868 2.117923744451452e-06 0.6504854738275335 2.117923925009211e-06 0.6462424706993735 \
2.117924088085156e-06 0.6424159959781919 2.11792423269672e-06 0.6390271817202816 2.117924373299071e-06 0.6357379642635244 2.117924500108657e-06 0.632774906490579 \
2.117924632245193e-06 0.6296924762754078 2.117924758489144e-06 0.6267508340255646 2.117924889752774e-06 0.6236963630311418 2.117925018850514e-06 0.6206978048938425 \
2.117925158276179e-06 0.6174624210713571 2.117925306646171e-06 0.6140261568477932 2.11792550120306e-06 0.6095278574984737 2.117925644648937e-06 0.6062198040692683 \
2.117925879109183e-06 0.6008245134060309 2.117926051007495e-06 0.5968818013610552 2.117926263928033e-06 0.5920102583789468 2.117926436394651e-06 0.5880775912131976 \
2.117926566719198e-06 0.5851108450968721 2.117926698275517e-06 0.5821241897920357 2.117926808505599e-06 0.5796262478458715 2.117926904159846e-06 0.5774603558442819 \
2.117927003393806e-06 0.5752182923213994 2.117927086311907e-06 0.5733484809858778 2.117927165227534e-06 0.5715706040143225 2.117927228156309e-06 0.5701535626562365 \
2.117927293664786e-06 0.5686800671140783 2.117927374150838e-06 0.5668736364148982 2.117927424016846e-06 0.5657560592102344 2.117927473205615e-06 0.5646541775062763 \
2.117927534675401e-06 0.5632780399140616 2.11792758259693e-06 0.5622058085646952 2.117927633441648e-06 0.5610687758404553 2.117927692541903e-06 0.5597501790023616 \
2.11792775115623e-06 0.5584442118409422 2.117927826782323e-06 0.5567607189607793 2.117927897341035e-06 0.5551915720267918 2.117927986471042e-06 0.5532116467156011 \
2.11792807569462e-06 0.5512351177508077 2.117928160998231e-06 0.5493490637975145 2.117928248625197e-06 0.5474138635528197 2.11792834562712e-06 0.545274424894262 \
2.117928449972891e-06 0.5429792414815097 2.117928566264316e-06 0.5404269323775457 2.117928672601932e-06 0.5380963700835184 2.117928784310815e-06 0.5356536306660374 \
2.117928896605295e-06 0.5332047801427824 2.117929023802854e-06 0.5304364255197962 2.117929146572528e-06 0.5277698476303582 2.117929288796925e-06 0.5246912237717902 \
2.117929425160057e-06 0.5217463069543907 2.117929577381123e-06 0.5184691491721333 2.117929737017329e-06 0.5150420887864461 2.117929912992522e-06 0.5112761258030903 \
2.117930101501108e-06 0.5072591542828934 2.11793030856769e-06 0.5028616940969075 2.117930533509662e-06 0.4981043078903621 2.117930784905619e-06 0.4928144328841237 \
2.117931021331185e-06 0.4878598554762091 2.117931318494919e-06 0.4816683149127979 2.117931609172211e-06 0.4756487143466775 2.117931917027196e-06 0.469313240945046 \
2.117932230852953e-06 0.4628991126846517 2.117932559994313e-06 0.4562163541974347 2.11793289337242e-06 0.4494927613461197 2.117933224999028e-06 0.4428490490857003 \
2.117933546548425e-06 0.4364504708187015 2.117933874224238e-06 0.4299742838549845 2.11793422184386e-06 0.4231546934710667 2.117934555065174e-06 0.4166645133789623 \
2.117934900974402e-06 0.4099771621835854 2.117935346388222e-06 0.4014400148089548 2.117935704178092e-06 0.3946500490499754 2.117936018334911e-06 0.3887397205534429 \
2.117936402745391e-06 0.3815756289527631 2.117936732720036e-06 0.3754830843203271 2.117937017930125e-06 0.3702633801070484 2.117937326220382e-06 0.3646649204592909 \
2.117937606017443e-06 0.3596257204303125 2.117937832011793e-06 0.3555880084110294 2.117938046849748e-06 0.3517755993421203 2.11793824528482e-06 0.3482769933469286 \
2.117938449224337e-06 0.3447071465415313 2.117938659760396e-06 0.3410461989361561 2.117938916734521e-06 0.3366091000429626 2.117939157995129e-06 0.3324763702393667 \
2.117939389568845e-06 0.3285420159269506 2.117939604222291e-06 0.3249208057821749 2.117939825046275e-06 0.3212218866489027 2.117940026292867e-06 0.3178749657716667 \
2.11794022938212e-06 0.3145250552959265 2.117940427226992e-06 0.3112865758726304 2.117940614079936e-06 0.3082497660855442 2.117940808016662e-06 0.3051208532403978 \
2.117941011761317e-06 0.30185834615803 2.117941190488583e-06 0.2990186060348319 2.117941428134378e-06 0.2952727068736475 2.117941627896611e-06 0.2921508861588616 \
2.117941829525427e-06 0.2890253490052915 2.117942054991886e-06 0.285561995332 2.117942221086285e-06 0.2830312764183137 2.117942399705387e-06 0.2803277612349699 \
2.117942581409589e-06 0.2775983111934518 2.117942770043305e-06 0.2747882307029562 2.117942947466508e-06 0.2721695222189568 2.117943124659645e-06 0.2695724116247911 \
2.11794328473156e-06 0.2672552081803913 2.117943405132239e-06 0.2655193337608355 2.117943552958303e-06 0.2633957862580221 2.117943681588076e-06 0.2615692882062232 \
2.117943783793658e-06 0.2601227034409412 2.117943902028939e-06 0.2584516051170885 2.1179440224823e-06 0.2567534139348401 2.117944146190617e-06 0.2550183706610066 \
2.117944264442643e-06 0.2533694204037282 2.117944392295773e-06 0.2515887492000971 2.117944512581604e-06 0.249915736161692 2.11794466526121e-06 0.2477917697339537 \
2.117944800173988e-06 0.2459264316518071 2.11794492881341e-06 0.2441493177932957 2.117945086528788e-06 0.2419705448111171 2.117945213210091e-06 0.2402201997919771 \
2.117945348536159e-06 0.2383592392624043 2.117945487448727e-06 0.2364550510890953 2.117945605221031e-06 0.2348405558720491 2.11794576449185e-06 0.2326580599570062 \
2.117945901013704e-06 0.2307878375452989 2.11794604224565e-06 0.2288626996658652 2.117946148058693e-06 0.2274220928889542 2.11794627840164e-06 0.2256484734765637 \
2.117946378112453e-06 0.2242944442559471 2.117946480933888e-06 0.2228991027388591 2.117946554349542e-06 0.2219046249368765 2.117946634181104e-06 0.2208265149641777 \
2.117946704228335e-06 0.2198809561195558 2.117946754631426e-06 0.2192009305305119 2.117946806883225e-06 0.2184966408607167 2.117946886120743e-06 0.2174292050927151 \
2.117946927964696e-06 0.2168658036437602 2.117946967304648e-06 0.216336351877609 2.117947010340057e-06 0.2157575332679269 2.117947054507484e-06 0.2151638767852215 \
2.117947128273224e-06 0.2141731338947761 2.11794716378522e-06 0.2136967174286463 2.117947211500021e-06 0.2130606706933813 2.117947272229561e-06 0.2122518321687151 \
2.117947340486787e-06 0.2113438957752176 2.117947413008566e-06 0.2103801801047663 2.117947485683193e-06 0.2094152724966429 2.117947593999181e-06 0.2079788886429202 \
2.117947691670323e-06 0.20668564243436 2.117947803221819e-06 0.2052110974836689 2.117947901757253e-06 0.2039136008387587 2.117948005250393e-06 0.2025572972554956 \
2.117948101152128e-06 0.2013021587886929 2.117948203780057e-06 0.1999606878451601 2.11794830660317e-06 0.1986207062101238 2.117948416722797e-06 0.1971897063011611 \
2.117948525418353e-06 0.1957815523781236 2.117948645095582e-06 0.1942360962608612 2.11794875537326e-06 0.192818053470401 2.117948863436481e-06 0.1914343471929882 \
2.117948988535149e-06 0.1898375077741012 2.117949078504982e-06 0.1886931806549971 2.117949157191935e-06 0.1876950225942949 2.117949234476806e-06 0.1867173468865102 \
2.117949320985382e-06 0.1856271834369256 2.117949419934593e-06 0.1843848109964498 2.117949490443458e-06 0.1835017733581451 2.117949561894511e-06 0.1826096997732476 \
2.117949667039846e-06 0.1813018727451555 2.117949746279475e-06 0.1803200401832796 2.11794982736337e-06 0.1793174195483187 2.11794992085531e-06 0.1781663090788374 \
2.117950021631285e-06 0.1769308188703378 2.117950171343389e-06 0.175105380089017 2.117950287132703e-06 0.1737009932372819 2.117950438138081e-06 0.1718807311127691 \
2.1179505492465e-06 0.1705485445502526 2.117950691372958e-06 0.168854666407182 2.117950809031379e-06 0.167460358327668 2.117950913935975e-06 0.1662230887079887 \
2.117951008998573e-06 0.1651069099307241 2.117951102429828e-06 0.1640147999883682 2.11795120347649e-06 0.1628388413495604 2.117951299823398e-06 0.1617223204899406 \
2.117951396975644e-06 0.1606011553546776 2.117951480024216e-06 0.1596469772300165 2.11795159006187e-06 0.1583897228513109 2.117951672364432e-06 0.1574542248873526 \
2.117951777364141e-06 0.156267858580057 2.11795185506021e-06 0.1553950893374849 2.117951937879689e-06 0.1544690878994293 2.117952019541594e-06 0.1535604570452941 \
2.117952108890884e-06 0.152571060794856 2.11795218460332e-06 0.1517364980793458 2.117952267165934e-06 0.1508307726525361 2.117952343747367e-06 0.1499942554682341 \
2.117952412035254e-06 0.1492531084507001 2.117952505402266e-06 0.1482449401818621 2.117952574555677e-06 0.1475015570698688 2.117952650180008e-06 0.1466917482325688 \
2.117952711729128e-06 0.1460354497178591 2.117952778977892e-06 0.1453208357145237 2.117952850039892e-06 0.1445684785944268 2.11795292553732e-06 0.143772322008306 \
2.11795298444886e-06 0.1431546944759192 2.11795306112247e-06 0.1423563022825049 2.117953141443211e-06 0.1415233898163201 2.11795321459452e-06 0.1407682091691316 \
2.117953308750941e-06 0.139800669784813 2.117953380355125e-06 0.1390684367429364 2.117953453815901e-06 0.1383201464810226 2.117953537327651e-06 0.1374732033664194 \
2.117953626806796e-06 0.1365744208092838 2.1179536918717e-06 0.1359252211013016 2.117953803997723e-06 0.1348115665849295 2.117953869183863e-06 0.1341670699454539 \
2.117953939222108e-06 0.1334770515823289 2.117953999527163e-06 0.1328849371768329 2.117954054537987e-06 0.1323464455745446 2.117954142654965e-06 0.1314871014507438 \
2.11795418344126e-06 0.131090685705856 2.117954287144011e-06 0.1300923774523848 2.11795433045658e-06 0.1296773144713907 2.117954391675178e-06 0.1290920262082728 \
2.117954436511897e-06 0.1286643765206081 2.117954524107923e-06 0.127831527987147 2.117954565661879e-06 0.1274377589706847 2.117954625523389e-06 0.1268718307679372 \
2.117954697367115e-06 0.1261946708524367 2.117954753579841e-06 0.1256664967939027 2.11795481606734e-06 0.125081039250218 2.117954890295323e-06 0.1243877959456236 \
2.117954964976328e-06 0.1236954937854857 2.117955052159541e-06 0.1228905551604285 2.117955120558092e-06 0.1222610287411191 2.117955201128775e-06 0.1215216597888775 \
2.117955282424256e-06 0.120778012781285 2.117955349340781e-06 0.1201677797529914 2.117955432157726e-06 0.1194156054679852 2.117955491346448e-06 0.1188799972037829 \
2.117955557267448e-06 0.1182853617472536 2.117955637141492e-06 0.1175675408705869 2.11795571363729e-06 0.1168828806096336 2.1179557950994e-06 0.1161574242846086 \
2.117955893570281e-06 0.1152852106851665 2.11795596868063e-06 0.114622623867465 2.11795607166842e-06 0.1137180076826871 2.117956145852371e-06 0.1130691786503039 \
2.117956243471825e-06 0.1122190343868764 2.11795633928278e-06 0.1113890351962442 2.117956435131205e-06 0.110562946039519 2.117956516069412e-06 0.1098685209805978 \
2.117956604452683e-06 0.1091134439098378 2.117956703052661e-06 0.108274944429282 2.117956775836865e-06 0.1076586405352824 2.117956865109775e-06 0.1069058608836731 \
2.117956927091788e-06 0.1063852406583179 2.117956989684956e-06 0.1058613310701875 2.117957074907104e-06 0.105150777260444 2.117957180369478e-06 0.1042758147594986 \
2.117957260199961e-06 0.1036167065755082 2.117957340914214e-06 0.1029530974056021 2.117957423527949e-06 0.1022768941101355 2.117957493972562e-06 0.1017026162492672 \
2.117957597231928e-06 0.1008648142128753 2.117957670072054e-06 0.1002767039768694 2.117957755712335e-06 0.09958839426015198 2.117957874514073e-06 0.09863954321822334 \
2.117957942151898e-06 0.09810250133474645 2.11795801190202e-06 0.09755100310752296 2.117958089237e-06 0.09694230106952094 2.117958181657254e-06 0.09621870517595056 \
2.117958253354782e-06 0.09566033062548993 2.117958339171941e-06 0.09499542738017568 2.117958441597192e-06 0.09420660575030523 2.117958534892083e-06 0.09349264652734962 \
2.117958631208556e-06 0.09276005482712441 2.117958708110817e-06 0.09217843893134048 2.117958801590805e-06 0.09147541043939374 2.117958880833232e-06 0.09088281005358793 \
2.117958995455426e-06 0.0900310686188453 2.117959125063686e-06 0.08907580221142102 2.117959258320877e-06 0.08810234090122065 2.117959402350765e-06 0.08705990691030199 \
2.11795955951891e-06 0.08593388720602639 2.117959709295387e-06 0.08487214151476249 2.117959871762979e-06 0.08373303262435308 2.117960014942984e-06 0.08273971668837025 \
2.117960167622107e-06 0.0816913199659166 2.117960301891878e-06 0.08077856892457436 2.117960443644155e-06 0.07982444400446118 2.117960578643816e-06 0.07892500874648442 \
2.117960720601214e-06 0.07798882638923543 2.117960867448644e-06 0.07703088995320664 2.117961019894053e-06 0.07604750978240994 2.117961185112776e-06 0.07499422991502351 \
2.117961349250621e-06 0.07396067809208305 2.117961526112024e-06 0.07286119333145537 2.11796171645358e-06 0.07169407515132428 2.117961927410093e-06 0.07042030845332216 \
2.117962147819232e-06 0.0691121699798517 2.117962383344393e-06 0.06773900533435212 2.117962643793767e-06 0.0662496528900723 2.117962939459177e-06 0.06459579389282195 \
2.117963244581463e-06 0.06292902455725519 2.117963609576024e-06 0.06098725515092194 2.117964004456839e-06 0.05894944116461652 2.117964410847493e-06 0.05692211719668253 \
2.117964826573035e-06 0.05491854459141238 2.117965189379358e-06 0.0532251207245777 2.117965533980647e-06 0.05166301626031383 2.11796584916051e-06 0.05027284652491828 \
2.117966144689875e-06 0.04900240867073854 2.117966442670382e-06 0.04775344010203557 2.117966718469172e-06 0.04662857640242725 2.117966997243768e-06 0.04551884372531381 \
2.117967261178638e-06 0.04449205559535935 2.117967537201376e-06 0.04344260531795661 2.11796781615763e-06 0.04240676967887352 2.117968129850963e-06 0.04127097799875453 \
2.11796836585125e-06 0.04043636567030678 2.117968621645987e-06 0.03955075129286261 2.117968881769487e-06 0.03867033103466553 2.117969151904759e-06 0.03778142289416799 \
2.117969431124746e-06 0.03688501536902895 2.117969712963396e-06 0.03600226561751176 2.117969989839066e-06 0.03515600409566183 2.117970268932665e-06 0.03432349610146775 \
2.117970501810272e-06 0.03364444121149882 2.117970785646989e-06 0.03283527291840588 2.117971025751924e-06 0.03216626441466421 2.117971265550746e-06 0.0315119836023277 \
2.11797150482792e-06 0.03087436846876356 2.117971740084942e-06 0.03026290129608995 2.117971971011964e-06 0.02967475842909434 2.117972186001007e-06 0.02913788335257221 \
2.117972588155459e-06 0.02816043724496065 2.117972786878278e-06 0.02768988489927659 2.117973160561294e-06 0.0268265706552881 2.117973347359617e-06 0.02640514011949098 \
2.117973694919304e-06 0.02563810810034544 2.117973816848767e-06 0.0253740445387235 2.117974199320207e-06 0.02456430406701914 2.117974370028237e-06 0.02421180751242828 \
2.117974827125621e-06 0.02328894863848502 2.117975012758007e-06 0.0229225623309489 2.11797537621526e-06 0.02221803970155307 2.117975596582612e-06 0.02179832126591805 \
2.117976054308969e-06 0.02093867417890744 2.117976189728599e-06 0.02068687731869814 2.117976719624047e-06 0.01972418011126781 2.117976838945017e-06 0.01951377505543128 \
2.117977404730696e-06 0.01856069823426573 2.117977569110437e-06 0.0182962226476828 2.117978187655734e-06 0.01735107502432094 2.117978357709933e-06 0.01710418363667701 \
2.117978889842166e-06 0.01636278834442301 2.117979086926142e-06 0.01610013864443424 2.117979810045215e-06 0.01517806887136661 2.117979974675381e-06 0.01497647803580381 \
2.117980723800768e-06 0.01409711804523418 2.11798085710012e-06 0.01394643716836554 2.117981717353759e-06 0.01301449210748497 2.117981852457379e-06 0.01287422877142914 \
2.11798279503482e-06 0.01193816285908547 2.117982958630574e-06 0.01178202925388569 2.117983959987201e-06 0.0108653384673985 2.117984097529988e-06 0.01074500730514941 \
2.117985319636371e-06 0.009765086624518643 2.117985426589084e-06 0.00968516078425012 2.117986830780577e-06 0.008707372520026449 2.117986935611284e-06 0.008639312158696611 \
2.117988470448246e-06 0.00767719340797631 2.117988565731547e-06 0.007617466071856052 2.117990174528868e-06 0.006680264535635283 2.117990308605608e-06 0.006609506832171614 \
2.117992405618559e-06 0.005610918814474722 2.117992636163191e-06 0.005510783990371394 2.117994959158434e-06 0.004586584533412417 2.117995440488638e-06 0.004413562233393853 \
2.117998278050269e-06 0.003511943147855551 2.117998822969955e-06 0.003360532104877318 2.118002947178351e-06 0.002408309874554541 2.118003490902011e-06 0.002305347543005144 \
2.118009362191237e-06 0.001333291345955189 2.118009605056421e-06 0.001286469439319215 2.118023932948772e-06 0.0002880570268237783 2.118024077507414e-06 0.0002853642807229123 \
2.120661356428513e-06 -0.0006859155495331031 2.12066149598365e-06 -0.000901903561740745 2.120662005077582e-06 -0.001859438188174024 2.120662094565085e-06 -0.002052812934985279 \
2.120662457959945e-06 -0.00291126965001638 2.120662548982015e-06 -0.003143482006111167 2.120662914420052e-06 -0.004127275145644371 2.120663024680619e-06 -0.004436819103926468 \
2.120663336727774e-06 -0.005309594399865315 2.120663439442621e-06 -0.005584800160857357 2.120663803290477e-06 -0.006384516484886619 2.120663968081208e-06 -0.006586298968823262 \
2.120664547677408e-06 -0.005791490933239759 2.120664722787551e-06 -0.004914057272375438 2.120664839479485e-06 -0.004132845175365214 2.12066496606409e-06 -0.003100877896798674 \
2.120665067873013e-06 -0.002132773363901063 2.120665188361723e-06 -0.0008283127610571584 2.120665278808799e-06 0.0002599396317828252 2.120665376698931e-06 0.001541559978017447 \
2.120665475763239e-06 0.002943971508909197 2.120665646570516e-06 0.005594911825788154 2.120665868338539e-06 0.00944046646559993 2.120666064242384e-06 0.01317281463966807 \
2.120666223123766e-06 0.01639870563256729 2.120666387552263e-06 0.01989779506365397 2.120666541918293e-06 0.02331070396473752 2.120666700690818e-06 0.02693200463312963 \
2.120666847428777e-06 0.03036422445567413 2.120666996052748e-06 0.0339113704936035 2.120667151667245e-06 0.03768995713197771 2.120667308909259e-06 0.04156499463828727 \
2.120667473802058e-06 0.04567927910670353 2.120667647221578e-06 0.05005184210758699 2.120667825915293e-06 0.05459761989277153 2.12066801453113e-06 0.05943075613080645 \
2.120668215431273e-06 0.06460909294799391 2.120668434888064e-06 0.0702927970720964 2.120668664434351e-06 0.07626037976612585 2.120668910133291e-06 0.08266408948881369 \
2.12066917869823e-06 0.08967663153997742 2.120669470040145e-06 0.09728936802005522 2.120669791708172e-06 0.1056939239977524 2.120670152022263e-06 0.1150987971742611 \
2.120670543001701e-06 0.1252892839303718 2.120670986416517e-06 0.1368209045172546 2.120671502729605e-06 0.1502062239570841 2.120672108934821e-06 0.16586000516691 \
2.120672780191848e-06 0.1831102247110778 2.120673559691505e-06 0.20301830483439 2.120674432001389e-06 0.2251413938832897 2.120675262336714e-06 0.2460320778586349 \
2.120675993667063e-06 0.264292249712138 2.120676641612843e-06 0.280346965484095 2.120677224923317e-06 0.29469740877147 2.120677760655584e-06 0.3077798509628869 \
2.120678263914169e-06 0.3199778888071559 2.12067874911767e-06 0.3316516836183861 2.120679228040375e-06 0.3430829066939081 2.120679674471008e-06 0.3536501814456421 \
2.120680148800718e-06 0.3647819492304352 2.120680597991712e-06 0.3752331958288908 2.120681088463969e-06 0.3865396207984229 2.120681617036723e-06 0.3985997842463301 \
2.120681988181062e-06 0.4069920784971888 2.120682515935418e-06 0.4188173133762567 2.120682978292178e-06 0.4290642331729484 2.120683450624318e-06 0.4394285229343968 \
2.120683932409041e-06 0.4498981261869666 2.120683965448159e-06 0.4506126593745911 2.120684003207152e-06 0.45142837879914 2.120684078725137e-06 0.4530572051633331 \
2.120684229761107e-06 0.4563088938659436 2.120684437280373e-06 0.460764549126051 2.120684625319184e-06 0.4647825567212808 2.120684844328398e-06 0.469441659996985 \
2.120685087159409e-06 0.4745824626509371 2.120685386935038e-06 0.4808894567257585 2.120685624728187e-06 0.4858624696070272 2.120685887949588e-06 0.4913374535260851 \
2.120686148847132e-06 0.4967277906005185 2.120686378401219e-06 0.5014431429135263 2.120686601461413e-06 0.506003872007333 2.120686803037404e-06 0.5100983586086808 \
2.120686951867463e-06 0.51310967141356 2.120687196178516e-06 0.5180317772556589 2.120687328783749e-06 0.5206893064287169 2.120687468140331e-06 0.5234717264876519 \
2.120687679105724e-06 0.5276623644271943 2.120687853979606e-06 0.5311266030493931 2.120688122027852e-06 0.5364094032095129 2.12068831705351e-06 0.5402319029111832 \
2.120688496615017e-06 0.5437361368949839 2.120688747571146e-06 0.5486228351952749 2.120689024979257e-06 0.5540035987981641 2.120689308928559e-06 0.5594901708581531 \
2.12068956456585e-06 0.5644152233389156 2.120689855548069e-06 0.570006772487656 2.120690115853754e-06 0.5749917787111524 2.120690384297874e-06 0.5801232573974072 \
2.120690627063004e-06 0.5847450403362237 2.120690883594205e-06 0.5896146675871002 2.120691109757648e-06 0.59388771440121 2.120691347099143e-06 0.5983512154742827 \
2.12069155648786e-06 0.6022720321566808 2.120691770260628e-06 0.6062574570422776 2.120692023713469e-06 0.6109557890491497 2.120692226567816e-06 0.6146943332140289 \
2.120692419372338e-06 0.6182333111593361 2.120692609677365e-06 0.6217090173923294 2.120692800335854e-06 0.6251694921350958 2.12069300291378e-06 0.6288260100903066 \
2.120693265662542e-06 0.6335359534764116 2.120693494630232e-06 0.6376100987349322 2.120693714577867e-06 0.6414991146358265 2.12069394026254e-06 0.6454625140719233 \
2.120694149149966e-06 0.6491091855837361 2.120694370803585e-06 0.652957810138281 2.120694555693011e-06 0.6561429680377227 2.120694745707564e-06 0.6594017273991298 \
2.120694895862686e-06 0.6619630641908443 2.120695070740593e-06 0.6649292185271485 2.120695216461309e-06 0.6673855496832628 2.120695352493842e-06 0.6696641287411549 \
2.120695500856121e-06 0.672138295335571 2.120695630303834e-06 0.6742883907026684 2.12069576416953e-06 0.6764996355878535 2.12069589251393e-06 0.6786115243545502 \
2.120696017902058e-06 0.6806677490053815 2.120696147367755e-06 0.6827843190971332 2.12069627834897e-06 0.6849171426143115 2.120696426722072e-06 0.6873221141612875 \
2.120696534784827e-06 0.6890667486235877 2.1206966633165e-06 0.6911333958680312 2.120696798756283e-06 0.6933004139195943 2.120696923690607e-06 0.6952876996714908 \
2.120697049447875e-06 0.6972799977491608 2.120697155963766e-06 0.6989584331773744 2.120697273081655e-06 0.7007929859467624 2.120697391621401e-06 0.7026383448210159 \
2.120697514924797e-06 0.704545102273978 2.120697618097695e-06 0.7061304255463237 2.120697769068859e-06 0.7084341141567283 2.120697885323065e-06 0.7101955266062138 \
2.120698015883454e-06 0.7121605601685687 2.120698134445982e-06 0.7139335830373704 2.120698240519851e-06 0.7155108922888329 2.120698340544791e-06 0.716990346352101 \
2.120698477870006e-06 0.719009255813789 2.120698596531362e-06 0.7207429633399333 2.120698718230586e-06 0.7225107522614664 2.120698843413151e-06 0.7243181860083944 \
2.120698965432965e-06 0.7260693242762759 2.120699093464719e-06 0.7278954552757622 2.120699217946458e-06 0.7296603419865877 2.12069934624578e-06 0.7314685590147565 \
2.120699473339584e-06 0.7332489547570846 2.120699599364423e-06 0.7350034830462163 2.12069970210311e-06 0.7364262918236342 2.120699816775856e-06 0.7380063527755659 \
2.120699898181918e-06 0.7391232259175492 2.120700017381438e-06 0.7407496908814458 2.120700110023778e-06 0.7420059782745783 2.120700248182835e-06 0.7438668850244906 \
2.120700379238334e-06 0.7456179978167152 2.120700509370502e-06 0.7473439783685625 2.120700614344577e-06 0.7487266533969134 2.120700753484419e-06 0.7505456565005918 \
2.120700907428719e-06 0.7525407731682957 2.120701029372999e-06 0.7541080835708853 2.120701176919359e-06 0.7559892974429111 2.120701298924537e-06 0.7575320275232224 \
2.120701447624466e-06 0.7593968175435225 2.120701581671092e-06 0.7610632318338031 2.120701703924347e-06 0.7625711443351471 2.120701816790256e-06 0.763953046884334 \
2.120701959641225e-06 0.7656882893306027 2.120702086364119e-06 0.7672149413549471 2.120702202168995e-06 0.7685995877768005 2.120702331910823e-06 0.7701390587657672 \
2.12070244764921e-06 0.7715019052061673 2.120702570601637e-06 0.7729391548276606 2.120702688317297e-06 0.7743051053122872 2.120702794287273e-06 0.7755262985206828 \
2.120702910698467e-06 0.7768586864857919 2.1207030173164e-06 0.7780703956921795 2.120703129515121e-06 0.7793369495935717 2.12070321618369e-06 0.7803089322889447 \
2.120703319569181e-06 0.7814603789665585 2.120703432733432e-06 0.7827108149434853 2.120703538380716e-06 0.783868819044773 2.120703647720273e-06 0.7850578567336689 \
2.120703754897288e-06 0.786214126597127 2.120703884303365e-06 0.7875981444497275 2.12070399672075e-06 0.7887899291890393 2.12070412010849e-06 0.7900869036018625 \
2.120704237558825e-06 0.7913106402786101 2.120704381085743e-06 0.7927918312347375 2.120704496005322e-06 0.7939667362870242 2.120704634727735e-06 0.7953719780830618 \
2.120704772759876e-06 0.7967562205547866 2.120704882253029e-06 0.7978444364842524 2.12070498327146e-06 0.7988406866985471 2.12070508435942e-06 0.7998302780396641 \
2.120705216746616e-06 0.8011146558616069 2.120705335472037e-06 0.8022550163876687 2.120705457256542e-06 0.8034134048507504 2.120705576346336e-06 0.8045351524060473 \
2.120705697550853e-06 0.8056657048884367 2.120705829194664e-06 0.8068811249615274 2.120705952212703e-06 0.8080052413861453 2.120706079823023e-06 0.8091594649786741 \
2.120706210891683e-06 0.8103325925767672 2.120706334212046e-06 0.8114249716726942 2.120706442136311e-06 0.8123719892944993 2.120706549931703e-06 0.8133095350680949 \
2.120706631652631e-06 0.8140147772069938 2.120706748520247e-06 0.815015186305849 2.120706839581256e-06 0.8157880755829442 2.120706973749888e-06 0.8169164295805346 \
2.12070711832076e-06 0.8181184617099191 2.120707251823126e-06 0.8192158725965917 2.120707361789038e-06 0.8201107352847025 2.120707505654697e-06 0.8212684563313245 \
2.120707658960262e-06 0.8224861772268215 2.120707786698555e-06 0.8234883060891934 2.120707927340891e-06 0.8245786478120171 2.120708053124456e-06 0.8255423809867173 \
2.120708207742427e-06 0.8267124309768116 2.120708340154194e-06 0.8277017767197102 2.120708466433798e-06 0.8286345641820314 2.120708584064113e-06 0.8294941055817234 \
2.120708732230976e-06 0.8305638349826423 2.12070889937522e-06 0.8317531470681401 2.120709031993881e-06 0.832683775428688 2.120709204938569e-06 0.8338803479528284 \
2.120709373325224e-06 0.8350269493631071 2.120709542859754e-06 0.8361634673386688 2.120709724228909e-06 0.8373596561587384 2.120709866861491e-06 0.8382862741713709 \
2.120709980797339e-06 0.8390176620397163 2.120710111571134e-06 0.8398476357987267 2.120710213225074e-06 0.8404856735008092 2.120710329718803e-06 0.8412091703399448 \
2.120710465236349e-06 0.8420405885319162 2.120710662580143e-06 0.8432318270427018 2.120710853245141e-06 0.8443612543037786 2.12071106310198e-06 0.8455804035625291 \
2.120711244039104e-06 0.8466117334714958 2.120711441374591e-06 0.8477160230260256 2.120711615161427e-06 0.8486711109012058 2.120711797742881e-06 0.8496572451898022 \
2.120711969062461e-06 0.850566499179887 2.120712143447507e-06 0.8514760798656241 2.120712318831052e-06 0.8523748177975867 2.120712495063209e-06 0.8532619682996843 \
2.120712684901452e-06 0.8542000584728613 2.120712875637666e-06 0.8551245802328369 2.120713077434399e-06 0.856083442102113 2.120713270127775e-06 0.8569809170305027 \
2.120713479756077e-06 0.857937542729613 2.12071370919384e-06 0.8589615588718806 2.12071397499048e-06 0.8601183337444025 2.120714273565707e-06 0.8613802063570262 \
2.120714551467221e-06 0.8625196921548358 2.120714835677695e-06 0.8636511027355716 2.120715110089482e-06 0.8647118800460076 2.120715382252364e-06 0.8657341977214618 \
2.120715652421456e-06 0.8667205537246333 2.120715909616139e-06 0.8676338760342862 2.12071618215581e-06 0.868575115807136 2.120716458190291e-06 0.8695013130444248 \
2.120716728342986e-06 0.8703818891200001 2.120717028049788e-06 0.8713292845176382 2.120717398867258e-06 0.8724597217497643 2.120717693785921e-06 0.8733269024855727 \
2.120717948030199e-06 0.8740525764960509 2.120718246254199e-06 0.8748787854419284 2.120718519878969e-06 0.8756137195941651 2.120718756017959e-06 0.8762307200963571 \
2.120718996373686e-06 0.8768427579093606 2.120719218719338e-06 0.8773949085683344 2.120719412723072e-06 0.877865919014753 2.120719742447196e-06 0.878644045115768 \
2.120719897619855e-06 0.8790007149587372 2.120720215373248e-06 0.879712598742095 2.120720394238605e-06 0.8801026384247937 2.120720736700094e-06 0.8808283583858193 \
2.120720920841293e-06 0.8812073588304842 2.120721395746114e-06 0.8821499412898334 2.120721563140601e-06 0.8824705695712217 2.120722028971889e-06 0.8833323038036038 \
2.120722209796771e-06 0.8836551183393088 2.120722703830028e-06 0.8845051821644966 2.120722845172603e-06 0.8847400410050358 2.120723451563118e-06 0.8857071861637142 \
2.120723603635685e-06 0.8859397703602404 2.120724250313757e-06 0.8868873789663725 2.120724378610247e-06 0.8870678433440622 2.120725026723245e-06 0.8879435266410994 \
2.120725156528523e-06 0.8881118897635528 2.120725934785608e-06 0.8890711781604964 2.120726049780423e-06 0.8892053868933587 2.120726905511062e-06 0.8901454611437621 \
2.120727050777629e-06 0.8902951528450479 2.120728036533732e-06 0.8912364417375994 2.120728257640946e-06 0.8914302300078862 2.120729402752027e-06 0.892358484239638 \
2.120729533960174e-06 0.8924604119362172 2.120730875263369e-06 0.8934531785430913 2.12073102665103e-06 0.8935579568409697 2.120732508109867e-06 0.8944876667405802 \
2.120732746990229e-06 0.894621531696939 2.120734516461986e-06 0.8954958910368339 2.120734905568823e-06 0.8956641700186337 2.120737299334232e-06 0.8965498195158238 \
2.120737774894223e-06 0.8966991754584082 2.120741837950387e-06 0.8976977719002629 2.120742329424408e-06 0.8977905759376156 2.120750645951487e-06 0.8987839664765119 \
2.120751565805377e-06 0.8988472044554419 2.120877770945903e-06 0.8998441026240215 2.120878784754255e-06 0.8998514601858095 2.121070497347411e-06 0.8990059056521554 \
2.121070727348974e-06 0.8988405173838494 2.121072342221535e-06 0.8978439928078279 2.121072519935388e-06 0.8977495532019018 2.121089285710428e-06 0.8987316330193963 \
2.121089421698825e-06 0.8987497732072308 2.121104884427938e-06 0.8997471920221268 2.12110515229253e-06 0.8997526389354535 2.121588977619798e-06 0.9006560548284696 \
2.121589098408999e-06 0.9007687033315858 2.121589886180037e-06 0.9017381658104292 2.121590020318756e-06 0.901943163319478 2.12159051393353e-06 0.9027850367016239 \
2.121590658833145e-06 0.9030569221572713 2.12159105464053e-06 0.9038490360455199 2.121591174436184e-06 0.9041001886668685 2.121591558609717e-06 0.9049189780371781 \
2.121591670731364e-06 0.9051556495331843 2.121592178052336e-06 0.9061253139956988 2.121592272051191e-06 0.90626859229291 2.121593430700898e-06 0.9055667778886739 \
2.121593533663831e-06 0.9051589876696525 2.121593617506701e-06 0.9047707260375384 2.121593751246752e-06 0.9040404158978201 2.121593851964134e-06 0.9033957423200318 \
2.121593959579919e-06 0.9026166239542108 2.121594077153173e-06 0.9016533104038295 2.121594165418223e-06 0.90085556431878 2.121594285051691e-06 0.8996698288011099 \
2.121594382373389e-06 0.8986166602050341 2.121594493390828e-06 0.8973222354192386 2.121594595500415e-06 0.8960407982554908 2.121594678931815e-06 0.8949326975987755 \
2.121594783112883e-06 0.8934749428758865 2.121594874199646e-06 0.8921321265381427 2.121594966740432e-06 0.8907058396397178 2.12159506189443e-06 0.8891776325191247 \
2.121595176449407e-06 0.88725933118288 2.121595265292509e-06 0.8857137884271823 2.121595363531691e-06 0.8839502506198179 2.121595448901865e-06 0.8823735982707064 \
2.121595529802107e-06 0.8808434949738935 2.1215956027634e-06 0.8794355441897157 2.121595669782045e-06 0.8781198554636557 2.121595738393124e-06 0.8767515715160701 \
2.121595821888035e-06 0.8750591081124355 2.121595884015366e-06 0.8737811510706814 2.121595946997964e-06 0.8724704924326797 2.121596042153715e-06 0.8704632161180945 \
2.121596142764354e-06 0.8683077530860182 2.121596222643545e-06 0.8665738309361769 2.121596306905814e-06 0.8647250601592834 2.121596386016074e-06 0.8629723295901451 \
2.121596448831519e-06 0.8615696597604833 2.121596536288553e-06 0.8596016864744445 2.121596602182084e-06 0.8581079708060287 2.121596670243626e-06 0.856556281928966 \
2.121596719556134e-06 0.8554267461646872 2.121596774792923e-06 0.85415654045335 2.121596815532529e-06 0.8532164928603474 2.121596861834283e-06 0.8521450198670055 \
2.121596892048343e-06 0.8514441160591502 2.121596921089625e-06 0.8507691938976955 2.12159695172822e-06 0.8500558939662993 2.12159701300541e-06 0.8486254874746039 \
2.121597066077972e-06 0.8473828229799116 2.121597119733165e-06 0.8461232012188223 2.121597182390447e-06 0.8446482873934593 2.121597245673395e-06 0.8431545995644786 \
2.121597336171269e-06 0.8410121009440262 2.12159743316905e-06 0.8387078554355326 2.12159751614655e-06 0.8367307351423475 2.121597598150905e-06 0.8347721678896715 \
2.121597687219306e-06 0.8326403548070889 2.121597771732643e-06 0.8306135893189693 2.121597862591523e-06 0.8284303722590877 2.121597954526378e-06 0.8262176456275642 \
2.121598056957308e-06 0.8237486178045141 2.12159815707534e-06 0.8213320995840899 2.121598271896223e-06 0.8185572053828121 2.12159838410276e-06 0.8158423448209959 \
2.121598509096305e-06 0.8128151787794674 2.121598640356713e-06 0.8096337870015397 2.121598785627755e-06 0.8061104108175116 2.121598940135368e-06 0.8023613213197434 \
2.121599111575989e-06 0.7981999722344618 2.121599275625781e-06 0.794217661721315 2.121599460041203e-06 0.7897413884478564 2.121599666533577e-06 0.7847307375046715 \
2.12159985602742e-06 0.7801344622909899 2.121600049421183e-06 0.775444374634302 2.121600249988037e-06 0.7705834242206392 2.121600397552439e-06 0.7670092004965298 \
2.121600527563889e-06 0.7638619034739171 2.121600662428303e-06 0.7605987503374771 2.121600768918754e-06 0.7580234999254772 2.121600900608547e-06 0.7548403390839162 \
2.121601007032976e-06 0.7522693550468039 2.121601150211605e-06 0.7488125398635642 2.121601311338716e-06 0.7449250928176189 2.121601429565533e-06 0.7420746008290786 \
2.121601599798354e-06 0.7379721584775248 2.121601765724623e-06 0.7339761998059781 2.121601985266953e-06 0.7286940862104242 2.121602178454078e-06 0.724050920820232 \
2.121602353368041e-06 0.719851304223293 2.121602520315139e-06 0.7158476177432674 2.1216027078061e-06 0.711355754450834 2.121602895234537e-06 0.7068709122373377 \
2.121603063571096e-06 0.7028473835914892 2.12160325640163e-06 0.6982428782038785 2.121603396451377e-06 0.694901318858167 2.121603552708666e-06 0.6911769338170629 \
2.121603746878113e-06 0.6865540563080536 2.121603905984601e-06 0.6827702245679255 2.121604064344632e-06 0.679008548037742 2.12160425966174e-06 0.6743756772263459 \
2.12160447009052e-06 0.6693917663527935 2.121604722792665e-06 0.6634173774538097 2.121604902460616e-06 0.6591769455535931 2.121605154037489e-06 0.6532475027332399 \
2.121605354410306e-06 0.6485340174553987 2.121605526064158e-06 0.6445032789616798 2.121605684756275e-06 0.6407814961122935 2.121605823964202e-06 0.637522316374186 \
2.121605960288252e-06 0.6343349641335875 2.121606087501276e-06 0.6313646237382058 2.121606216993833e-06 0.6283457899522861 2.121606344985121e-06 0.6253646753452949 \
2.12160647605963e-06 0.6223174651643489 2.121606606771705e-06 0.6192830747181834 2.121606749379757e-06 0.6159760732208495 2.121606892103236e-06 0.612672916206165 \
2.121607044651037e-06 0.6091471600588 2.121607189155024e-06 0.6058158037532523 2.121607353173272e-06 0.6020406322262999 2.121607490637933e-06 0.5988837056407329 \
2.121607625454949e-06 0.5957940466067043 2.121607746953592e-06 0.5930134750293682 2.121607885803896e-06 0.5898448108574432 2.121607999450713e-06 0.5872554148224447 \
2.121608150860885e-06 0.5838116422847746 2.12160826457956e-06 0.5812320812748947 2.121608383992651e-06 0.5785269636915771 2.121608472673178e-06 0.5765205397309219 \
2.121608563818269e-06 0.5744630259469776 2.121608629157145e-06 0.5729901393713442 2.121608693626847e-06 0.5715377831648228 2.121608744447459e-06 0.5703933076453638 \
2.121608803422398e-06 0.569066051987989 2.121608870867106e-06 0.5675516747474645 2.121608937959298e-06 0.5660472084764079 2.121608990879742e-06 0.5648615894615425 \
2.121609086527225e-06 0.5627204246953637 2.121609143708361e-06 0.5614413394337 2.121609197510977e-06 0.5602399192081799 2.121609259253082e-06 0.5588634520375642 \
2.121609345086214e-06 0.5569525037715509 2.121609427781862e-06 0.5551133137453282 2.121609553910589e-06 0.552313430559463 2.121609689009665e-06 0.5493247407981657 \
2.121609787329828e-06 0.5471534914294828 2.12160989990789e-06 0.5446716589975775 2.121610002452305e-06 0.5424173856211837 2.121610122561131e-06 0.5397821662853191 \
2.121610224248782e-06 0.5375541863492928 2.121610339752746e-06 0.5350300289250629 2.121610454643861e-06 0.5325260225312031 2.121610581121134e-06 0.5297740207092871 \
2.12161070633833e-06 0.5270565158317848 2.121610853184312e-06 0.5238798967507053 2.121610988642446e-06 0.5209557060405445 2.121611146203055e-06 0.5175672114705414 \
2.121611308357229e-06 0.5140875588169389 2.121611489068307e-06 0.5102248342695275 2.12161168131606e-06 0.5061308236654174 2.121611894038323e-06 0.5016182665703952 \
2.121612125943484e-06 0.4967183500883584 2.121612383137187e-06 0.4913135654247419 2.121612622690498e-06 0.4863004534671564 2.121612924620373e-06 0.4800178499336004 \
2.121613212386814e-06 0.4740665530855001 2.121613525189057e-06 0.4676409412178996 2.121613845020806e-06 0.4611139840073785 2.121614184657409e-06 0.4542292677834274 \
2.121614511873228e-06 0.4476411633207955 2.121614847034797e-06 0.4409363684817221 2.121615164291457e-06 0.4346351592989786 2.121615498111436e-06 0.4280489847791872 \
2.12161584979678e-06 0.4211625252737479 2.121616163864498e-06 0.4150547397555842 2.121616486893702e-06 0.4088175946446666 2.121616927873099e-06 0.4003732788922496 \
2.121617270275942e-06 0.3938810608698495 2.12161757072383e-06 0.3882325136127223 2.121617946053401e-06 0.3812375944419973 2.12161827612863e-06 0.3751439175705365 \
2.121618559406411e-06 0.3699597784791666 2.121618859913772e-06 0.3645020109013299 2.121619139561233e-06 0.3594637112692664 2.121619363423523e-06 0.3554634414471464 \
2.121619575274513e-06 0.35170280677964 2.121619777623113e-06 0.3481338771034005 2.121619978758139e-06 0.3446120049995081 2.121620184535657e-06 0.3410324794262659 \
2.121620445514371e-06 0.3365252478245505 2.121620685004553e-06 0.3324209773202946 2.121620917679624e-06 0.3284665339262754 2.121621131761216e-06 0.3248537323113044 \
2.121621352906983e-06 0.3211475567840967 2.121621553789873e-06 0.3178053707831449 2.121621757181075e-06 0.3144500223650613 2.121621954849488e-06 0.3112139453100684 \
2.121622141093175e-06 0.3081862077816076 2.121622336074257e-06 0.3050391973134606 2.121622539536502e-06 0.3017803754370622 2.121622717477408e-06 0.2989521325826759 \
2.121622953201112e-06 0.2952356640875101 2.121623151333966e-06 0.2921385263640672 2.121623352678033e-06 0.2890160050544278 2.12162357696723e-06 0.2855690750291008 \
2.121623741897129e-06 0.2830551950838826 2.121623919525814e-06 0.2803657404651576 2.121624103924961e-06 0.2775946687427531 2.121624287746306e-06 0.2748547260732712 \
2.121624466202978e-06 0.2722194282383935 2.121624638103246e-06 0.2696976713509589 2.121624798643653e-06 0.2673699088296289 2.121624920125711e-06 0.265617282026588 \
2.121625073047239e-06 0.2634201198254058 2.121625200480934e-06 0.2616085083773952 2.121625304654604e-06 0.2601317890528609 2.121625421559081e-06 0.2584775571399547 \
2.121625536570573e-06 0.2568557450124987 2.121625660932803e-06 0.2551103168403305 2.121625776507086e-06 0.2534925198640895 2.121625910614607e-06 0.2516172680784447 \
2.121626025601848e-06 0.2500177396912131 2.121626179351445e-06 0.2478798443778067 2.121626316154646e-06 0.2459790966208961 2.121626450740453e-06 0.2441094379339017 \
2.121626606604589e-06 0.2419575875351012 2.121626731253411e-06 0.2402378086535915 2.121626870468935e-06 0.2383186229544463 2.12162700069296e-06 0.236525770455347 \
2.121627121045801e-06 0.2348769158236033 2.121627256439084e-06 0.233027137746051 2.121627407644063e-06 0.2309620730808924 2.121627542400533e-06 0.2291249940296414 \
2.12162764708672e-06 0.2277003186426776 2.121627769622861e-06 0.2260366668203369 2.12162790456742e-06 0.2242086518061946 2.121627999683167e-06 0.2229209267876512 \
2.121628114943222e-06 0.2213657311907907 2.121628197476202e-06 0.2202562617028589 2.121628268681533e-06 0.2192992955643472 2.121628317389017e-06 0.2186449771734718 \
2.121628364583973e-06 0.2180112263680214 2.121628411132791e-06 0.2173864029843717 2.121628464521355e-06 0.2166701476649976 2.121628501898025e-06 0.2161690444847812 \
2.121628539283138e-06 0.2156680710113931 2.121628579604508e-06 0.2151283464800275 2.121628650854647e-06 0.2141753141901174 2.121628685068904e-06 0.2137180869447317 \
2.121628731463534e-06 0.2131018213873352 2.121628791907201e-06 0.2122998083652294 2.12162886091012e-06 0.2113853596849882 2.121628926205072e-06 0.210520730631805 \
2.121628994183196e-06 0.2096212333552783 2.121629110629525e-06 0.2080823984153433 2.121629200551713e-06 0.2068957989735914 2.121629308217619e-06 0.2054771097790837 \
2.121629404278935e-06 0.2042146625011118 2.121629507657509e-06 0.2028641889872041 2.121629604342543e-06 0.2016026287683381 2.121629707152396e-06 0.2002625524503448 \
2.121629807912368e-06 0.1989526210414513 2.121629919058034e-06 0.1975116692735505 2.121630026097529e-06 0.1961279675313261 2.121630144004064e-06 0.1946083430154048 \
2.121630252114387e-06 0.1932197128021231 2.121630361412987e-06 0.1918224631760269 2.121630482044739e-06 0.1902849927564414 2.121630576945331e-06 0.1890796997295432 \
2.12163070550625e-06 0.18745262875399 2.121630798541038e-06 0.1862801166370808 2.121630900937594e-06 0.1849947785893032 2.121630988904886e-06 0.1838942174288659 \
2.121631087175557e-06 0.182668828510528 2.121631183776179e-06 0.1814691026470878 2.121631270414692e-06 0.1803971466393716 2.121631356823704e-06 0.1793305247657973 \
2.121631452660814e-06 0.1781527189679156 2.121631557387688e-06 0.1768710765218302 2.121631703199975e-06 0.1750963017969037 2.121631819167907e-06 0.1736923427161618 \
2.121631975631711e-06 0.1718092975148396 2.12163208681163e-06 0.1704786474822015 2.12163222706163e-06 0.1688098560703619 2.121632350073035e-06 0.1673544160765056 \
2.121632456564033e-06 0.1661007559767333 2.121632552889491e-06 0.1649724583647661 2.121632650322959e-06 0.1638357962207703 2.121632754176237e-06 0.1626293386330815 \
2.12163284597681e-06 0.1615673458739011 2.121632944364525e-06 0.1604337426303964 2.12163302728317e-06 0.1594828374885931 2.121633122651503e-06 0.1583950132920943 \
2.121633205213851e-06 0.1574587876231885 2.121633307798537e-06 0.1563016192679324 2.121633384076854e-06 0.1554454316211293 2.121633472662479e-06 0.1544557264474612 \
2.121633544831984e-06 0.1536532700165102 2.121633626541473e-06 0.1527486200895024 2.121633700220281e-06 0.1519363404455653 2.12163378044041e-06 0.1510573496788611 \
2.121633852168484e-06 0.1502755532525617 2.121633920425463e-06 0.149534520573691 2.121634018141422e-06 0.1484788062294206 2.121634087591606e-06 0.147731872792437 \
2.121634170343085e-06 0.1468455801890639 2.121634230379995e-06 0.1462052652532956 2.121634300618659e-06 0.1454587420502366 2.121634372046193e-06 0.1447037411390827 \
2.121634452559695e-06 0.1438588888651768 2.121634515822599e-06 0.1431977449412327 2.121634593496578e-06 0.1423892845091393 2.121634682806343e-06 0.141463758692191 \
2.121634752169929e-06 0.1407479403162204 2.121634850118149e-06 0.1397418416088305 2.121634940462669e-06 0.1388188591118084 2.121635026242994e-06 0.1379520826379384 \
2.121635093896779e-06 0.1372719511642241 2.121635160204629e-06 0.1366075914250998 2.121635238824321e-06 0.1358227655030745 2.12163531951923e-06 0.135020537018139 \
2.121635377921894e-06 0.1344419857224206 2.121635438674417e-06 0.1338420332148588 2.121635532580729e-06 0.1329184183639811 2.121635574978232e-06 0.1325029080242558 \
2.121635654222426e-06 0.1317336600863391 2.121635694592584e-06 0.1313430593815061 2.121635784293463e-06 0.130477658168832 2.12163582324155e-06 0.1301029732927899 \
2.121635918857236e-06 0.1291862249441596 2.121635957741065e-06 0.1288146335111444 2.121636050975841e-06 0.1279263274670414 2.12163611931843e-06 0.1272775968534341 \
2.121636171639285e-06 0.1267823325594629 2.121636253739999e-06 0.1260075984242486 2.121636324903378e-06 0.1253406747583812 2.121636402856366e-06 0.1246136378429537 \
2.121636481976102e-06 0.1238779526756392 2.121636560619333e-06 0.1231489004754178 2.121636640654242e-06 0.122409328367501 2.121636702388658e-06 0.1218405706457005 \
2.121636775983641e-06 0.1211645344030958 2.121636859363458e-06 0.120401093559758 2.121636923460189e-06 0.1198161795466899 2.121636992898777e-06 0.119184869057559 \
2.121637065921716e-06 0.1185234239195788 2.121637150796627e-06 0.1177582144838446 2.121637230159478e-06 0.117046673033812 2.121637314893136e-06 0.1162898833629492 \
2.121637405604426e-06 0.1154830714735263 2.121637481187504e-06 0.1148135241260771 2.121637546915429e-06 0.1142333070693714 2.121637606975201e-06 0.1137047561823949 \
2.121637676580917e-06 0.1130943456353956 2.121637742999968e-06 0.1125141752866663 2.121637822411231e-06 0.1118230150855203 2.121637912674161e-06 0.1110406875128299 \
2.121637981718461e-06 0.1104447270551955 2.12163805627358e-06 0.1098035355921305 2.121638144757501e-06 0.1090456469739195 2.121638223865648e-06 0.1083709350695736 \
2.121638293734029e-06 0.1077773127978274 2.121638374743399e-06 0.1070920034756896 2.121638430948213e-06 0.106618206733547 2.121638493607492e-06 0.1060916009495399 \
2.121638558754097e-06 0.105545887371837 2.121638630089726e-06 0.1049504956797945 2.121638750386101e-06 0.1039516085561449 2.121638801939674e-06 0.103525508500865 \
2.121638857088741e-06 0.1030709598036589 2.121638947785926e-06 0.1023262935955709 2.121639030175778e-06 0.1016530765296615 2.121639125755586e-06 0.1008759670630478 \
2.121639232965152e-06 0.1000092507657299 2.121639336624559e-06 0.09917656019160864 2.121639422832161e-06 0.09848810438956324 2.121639509074386e-06 0.09780303991321163 \
2.12163958861546e-06 0.09717448010577609 2.121639668628333e-06 0.09654538840876434 2.121639759916661e-06 0.09583163072761708 2.12163984166208e-06 0.09519620281310773 \
2.121639930588917e-06 0.09450872319168514 2.121640020366224e-06 0.09381864801001834 2.121640097328872e-06 0.09323024625953365 2.121640187653689e-06 0.0925435244861572 \
2.121640251462415e-06 0.09206084550525626 2.121640323925983e-06 0.09151514907748673 2.121640388054635e-06 0.09103438864950099 2.121640466302011e-06 0.09045054736970405 \
2.121640566003292e-06 0.08971110930136832 2.121640640056443e-06 0.08916512281998501 2.121640726664979e-06 0.08852997392441805 2.121640872964685e-06 0.08746544055362569 \
2.121640983676948e-06 0.08666684197409438 2.121641093986626e-06 0.08587717033461532 2.121641236182269e-06 0.08486839672072237 2.12164137623472e-06 0.08388450488753585 \
2.121641518880534e-06 0.08289222299161547 2.121641667651249e-06 0.08186778387581196 2.121641804363935e-06 0.08093569403044946 2.121641946484565e-06 0.07997640434545976 \
2.121642081061545e-06 0.07907728405019222 2.121642221281423e-06 0.07814997945867638 2.121642369028229e-06 0.07718353387841098 2.121642518982415e-06 0.07621348085094087 \
2.121642683698247e-06 0.07516037195605636 2.121642847284363e-06 0.07412732798506308 2.121643021932716e-06 0.07303837372665309 2.121643208986408e-06 0.07188781219077654 \
2.121643418972926e-06 0.0706159374129187 2.121643637046174e-06 0.06931715807027321 2.121643870366328e-06 0.06795188046253516 2.121644124845882e-06 0.0664909822812602 \
2.12164441780254e-06 0.06484528303377844 2.121644719953089e-06 0.06318745987130532 2.121645057674791e-06 0.06138078634948794 2.121645452783393e-06 0.05932807220464856 \
2.121645820234636e-06 0.05747953410674719 2.121646237842402e-06 0.05544691527644593 2.121646582838376e-06 0.0538196438399016 2.121646933380666e-06 0.05221302159193914 \
2.121647248341029e-06 0.0508087490907442 2.121647547582396e-06 0.049508488261462 2.121647846948248e-06 0.04824029756235761 2.121648122190958e-06 0.04710512226277328 \
2.121648405654525e-06 0.04596497870754415 2.121648667254947e-06 0.04493681260994405 2.121648944707071e-06 0.04387103439794762 2.121649220766506e-06 0.04283531238677037 \
2.121649529036243e-06 0.04170718945545093 2.121649751468864e-06 0.0409114719535993 2.121650039009947e-06 0.03990505631995635 2.12165027524288e-06 0.0390969788355163 \
2.121650593704555e-06 0.03803800466874574 2.121650844115589e-06 0.03722710566490722 2.121651167100391e-06 0.03620720400565681 2.121651425436406e-06 0.03541203096995557 \
2.121651715410285e-06 0.03454066075983582 2.121651945205102e-06 0.0338658635512188 2.121652230100444e-06 0.03304787219836024 2.121652469846563e-06 0.03237513696606491 \
2.121652710481132e-06 0.03171392889024889 2.121652949599619e-06 0.03107212555077287 2.12165318553853e-06 0.03045460689686571 2.121653416367391e-06 0.02986254663395104 \
2.121653631393919e-06 0.02932175456294728 2.12165403355976e-06 0.0283374222946415 2.12165423211788e-06 0.02786401170979088 2.121654605819066e-06 0.02699470773596776 \
2.121654792632261e-06 0.02657042318767052 2.121655138633508e-06 0.02580176906824739 2.121655260576947e-06 0.02553595448027303 2.121655643429963e-06 0.02472011952872977 \
2.121655803864149e-06 0.02438657631284594 2.121656246865303e-06 0.02348572425118655 2.121656417479345e-06 0.02314627247835563 2.121656738055941e-06 0.02251902970747987 \
2.121656938340868e-06 0.0221336684630111 2.121657385278801e-06 0.02128811173678137 2.121657513222917e-06 0.02104854104185888 2.121658001100276e-06 0.02014826272243131 \
2.121658136077553e-06 0.01990454278080647 2.121658618329071e-06 0.0190640092473091 2.121658780655186e-06 0.01879235028057063 2.121659267049527e-06 0.01801148170254873 \
2.121659430077186e-06 0.01776103207540622 2.121660110298876e-06 0.01676849304257711 2.121660249382615e-06 0.01657541006259178 2.121660981877148e-06 0.01560782569993242 \
2.12166114077078e-06 0.01540693214221847 2.121661923851867e-06 0.01445869962397344 2.121662069644422e-06 0.01428952172302696 2.121662920425781e-06 0.01334248985256295 \
2.121663031529053e-06 0.01322388191882306 2.121663964823416e-06 0.0122699293983148 2.121664098661466e-06 0.01213902814618388 2.121665057199482e-06 0.01123495036716388 \
2.121665178316551e-06 0.01112486091825863 2.121666300400349e-06 0.01017270671243764 2.121666405901602e-06 0.01008921053061839 2.121667734976014e-06 0.009112307258623473 \
2.121667855180288e-06 0.009029744095492466 2.121669403542048e-06 0.008036808760534916 2.121669484329818e-06 0.007986285493236449 2.121671055209352e-06 0.007024564730313319 \
2.121671122625551e-06 0.006986095570813155 2.121673043392229e-06 0.006001386377072119 2.121673230194113e-06 0.005914747648762168 2.12167554560806e-06 0.0049318160947762 \
2.121675945134908e-06 0.004777795182599986 2.121678508944408e-06 0.003889929704329555 2.121679007815328e-06 0.003736330440833864 2.121682637539317e-06 0.002784984367379526 \
2.121683188233292e-06 0.002663729254427667 2.121688586673671e-06 0.001711392372544448 2.121688899941243e-06 0.001662511220227468 2.121693892233791e-06 0.0006970413096974805 \
2.121694076252826e-06 0.0006571176749162138 2.124342555395609e-06 -0.0002691198397987355 2.124342711454572e-06 -0.0004551674219448388 2.124343259438427e-06 -0.001322174727784445 \
2.12434337237642e-06 -0.001539785040943742 2.12434380163135e-06 -0.002474302920374066 2.124343907888515e-06 -0.002730173903076456 2.124344190690667e-06 -0.003454402452283872 \
2.12434430428521e-06 -0.003760966378165151 2.124344642839789e-06 -0.004705104513819927 2.12434475526375e-06 -0.005021586953003071 2.124345083541651e-06 -0.005887841248467669 \
2.124345191080172e-06 -0.006130875888161453 2.124346071006203e-06 -0.005789627805322099 2.12434624621225e-06 -0.004910736584223327 2.124346363043013e-06 -0.004127745010746014 \
2.124346489910137e-06 -0.00309221842859156 2.124346591442863e-06 -0.002125750314016509 2.124346712864133e-06 -0.0008095618968406578 2.124346803029046e-06 0.0002767910803854594 \
2.124346900212695e-06 0.001550247908954045 2.12434699828696e-06 0.002938803805678211 2.124347165508045e-06 0.005530627736217106 2.124347387813323e-06 0.009378371294171852 \
2.124347573551714e-06 0.01290572951649239 2.124347797633049e-06 0.01747895571448658 2.124347957277781e-06 0.02091945933227325 2.124348121767111e-06 0.02459614091902196 \
2.124348271591569e-06 0.0280452875125503 2.124348420991461e-06 0.03156498790849799 2.124348570522767e-06 0.03515592969144176 2.124348724602661e-06 0.03891669635189081 \
2.124348886786809e-06 0.0429309674228065 2.124349053210035e-06 0.0470989728378523 2.124349229143508e-06 0.05154884981278444 2.124349410271779e-06 0.05616867911875007 \
2.124349602402705e-06 0.06110225049351239 2.124349810098117e-06 0.0664648391313285 2.124350032018198e-06 0.07222051812179281 2.12435026721968e-06 0.07834079218654426 \
2.124350519405989e-06 0.08491829088081257 2.124350795545224e-06 0.09213111703448683 2.124351096666701e-06 0.1000001933597138 2.124351428586562e-06 0.1086702418150647 \
2.12435180590533e-06 0.1185147411083515 2.124352204195387e-06 0.1288888856248832 2.124352673503706e-06 0.1410822143415975 2.124353219529231e-06 0.1552200475789812 \
2.124353854489538e-06 0.1715918832733369 2.124354553890129e-06 0.1895291194622146 2.124355372129055e-06 0.2103807608661494 2.124356277823022e-06 0.2332840710921665 \
2.124357067334088e-06 0.253091928008631 2.124357771092906e-06 0.2706124241987875 2.124358388943719e-06 0.2858796548825839 2.124358954567131e-06 0.2997575097153312 \
2.124359476302405e-06 0.3124620269501652 2.124359974086121e-06 0.3244932238414255 2.124360457724081e-06 0.3360954048923613 2.124360914598215e-06 0.3469667650518959 \
2.124361387439109e-06 0.3581213589834248 2.124361827052466e-06 0.3684065070151987 2.124362314929562e-06 0.379719432411247 2.124362845729985e-06 0.3919028193132517 \
2.124363343625359e-06 0.4032143644097119 2.124363775002613e-06 0.41292177789323 2.124364261889801e-06 0.4237731225600331 2.124364761989243e-06 0.4348012155672935 \
2.124365106609934e-06 0.4423321287141763 2.124365460003778e-06 0.4500000647748709 2.124365887773617e-06 0.4592134948422093 2.124366279634688e-06 0.4675816212925634 \
2.124366579929044e-06 0.4739471552041949 2.124366921860125e-06 0.4811428413521782 2.12436726519457e-06 0.4883132334011818 2.124367525955058e-06 0.4937215836208605 \
2.124367768011587e-06 0.4987106167174703 2.124368034010056e-06 0.5041617362307154 2.12436829349824e-06 0.5094435946950286 2.12436848341454e-06 0.5132872703533161 \
2.124368698649141e-06 0.5176241792560061 2.1243688371999e-06 0.5204025546691405 2.124368982080679e-06 0.5232962183003332 2.124369195494746e-06 0.5275364624051522 \
2.124369397519361e-06 0.5315382148201082 2.124369590248024e-06 0.5353370730264509 2.124369775503404e-06 0.5389735557287745 2.124369952500927e-06 0.5424323215059959 \
2.124370261764263e-06 0.5484573594957171 2.12437052291231e-06 0.5535233414883098 2.124370824731481e-06 0.5593562770234363 2.124371080160122e-06 0.5642781701956761 \
2.124371372515619e-06 0.5698968483756405 2.124371631969813e-06 0.5748654731717864 2.12437190208979e-06 0.5800301911327002 2.124372144100348e-06 0.5846380733684551 \
2.124372401610146e-06 0.5895273573494454 2.124372628054483e-06 0.5938057549890672 2.124372864942966e-06 0.5982619499065401 2.124373074987873e-06 0.6021962733001386 \
2.124373287918584e-06 0.6061670177072124 2.124373541397282e-06 0.6108668889270118 2.124373744692931e-06 0.6146150465592417 2.124373936381114e-06 0.6181346807088086 \
2.124374125007478e-06 0.6215812235468744 2.124374312325416e-06 0.6249823889551316 2.124374517937406e-06 0.6286953279350977 2.124374767760625e-06 0.6331759959753138 \
2.124374971572404e-06 0.6368063379741715 2.124375179211121e-06 0.6404826298163093 2.124375371862737e-06 0.6438748386876914 2.12437561647481e-06 0.6481531432733096 \
2.124375864373314e-06 0.6524620620600715 2.124376044208219e-06 0.6555644139995785 2.124376234982255e-06 0.6588391718544121 2.124376388158437e-06 0.6614554104590837 \
2.124376559827147e-06 0.6643705886591137 2.124376710293968e-06 0.6669108747194671 2.124376846897971e-06 0.6692010654183506 2.124376996338373e-06 0.6716954191563786 \
2.124377124072523e-06 0.6738189269502312 2.12437726394477e-06 0.6761323074508511 2.124377388021905e-06 0.6781756764962316 2.12437751938327e-06 0.6803315871556701 \
2.124377643554731e-06 0.6823627547057004 2.124377781331592e-06 0.6846081866267727 2.124377901575812e-06 0.6865586181592046 2.124378043628418e-06 0.6888545186016138 \
2.124378143856122e-06 0.6904668682779994 2.124378265160113e-06 0.6924123325129877 2.124378356135388e-06 0.6938641504265992 2.124378453518671e-06 0.695411869780077 \
2.124378550601538e-06 0.6969507228893711 2.124378639884158e-06 0.6983595753378042 2.124378737855943e-06 0.699898781449533 2.12437886813103e-06 0.7019319515314388 \
2.124379021543255e-06 0.7043083163565919 2.124379157109067e-06 0.7063909659299702 2.124379301449562e-06 0.708591461371511 2.124379427320445e-06 0.710496752775434 \
2.124379552347831e-06 0.712376488910674 2.124379666630191e-06 0.7140841686551523 2.124379777613335e-06 0.7157331888171029 2.124379877308404e-06 0.7172065512867005 \
2.124380014352622e-06 0.7192196995505324 2.124380133379835e-06 0.7209572005600779 2.124380253677943e-06 0.7227029412191364 2.124380380176863e-06 0.7245276185835638 \
2.124380504108467e-06 0.7263044524160376 2.1243806283948e-06 0.7280754330070212 2.124380754759953e-06 0.7298652243312684 2.124380884571694e-06 0.7316925631262517 \
2.124381008410214e-06 0.7334254795816325 2.1243811411911e-06 0.735272086289578 2.124381242042306e-06 0.7366670415914529 2.124381355233975e-06 0.738224777043618 \
2.124381442019956e-06 0.7394137384482823 2.124381558645253e-06 0.7410021813026957 2.12438164793451e-06 0.7422110784210975 2.124381759111394e-06 0.7437075443329063 \
2.124381888370158e-06 0.7454347509364776 2.124382002229194e-06 0.7469455276109591 2.124382106633406e-06 0.74832188588007 2.124382231000437e-06 0.7499498655229884 \
2.124382378240616e-06 0.7518616907275563 2.124382498520907e-06 0.753411006437983 2.124382614425446e-06 0.7548933175676444 2.12438275450129e-06 0.7566706674475765 \
2.12438289711296e-06 0.7584645678799224 2.124383015067203e-06 0.7599365027959469 2.124383141883712e-06 0.7615071445339606 2.124383282766856e-06 0.7632375905494565 \
2.124383402560353e-06 0.7646969139886852 2.124383547519211e-06 0.7664484133613445 2.124383669077996e-06 0.7679052725436226 2.12438378811749e-06 0.7693214142140735 \
2.124383909748853e-06 0.7707575700077021 2.124384037717832e-06 0.772256936813787 2.124384146933014e-06 0.7735272422640712 2.124384271823892e-06 0.774969549136603 \
2.124384378939953e-06 0.7761978171588899 2.124384512193147e-06 0.7777146071439789 2.124384639296593e-06 0.7791497354387434 2.124384761047568e-06 0.7805132846941326 \
