1.825342024991065e-06 0.1999338657614989 1.825342128630721e-06 0.1985898465970496 1.825342238404734e-06 0.1971698847140261 1.825342347579759e-06 0.1957617939809042 \
1.825342467677852e-06 0.1942174441246506 1.825342577697376e-06 0.1928086337505992 1.825342685809285e-06 0.1914295694688549 1.825342808837984e-06 0.1898652723262108 \
1.825342898948554e-06 0.1887234630454603 1.825343006314044e-06 0.1873671680421656 1.825343083125352e-06 0.1864004060894758 1.82534316657062e-06 0.1853535952511875 \
1.825343256102432e-06 0.1842338297700716 1.825343340667898e-06 0.1831790839553313 1.825343420384038e-06 0.1821880912968773 1.825343521709242e-06 0.1809331989518758 \
1.825343630056471e-06 0.1795959386230563 1.825343726532169e-06 0.1784102562612937 1.825343851909986e-06 0.1768766438339704 1.825343984693456e-06 0.1752616821119887 \
1.825344102464279e-06 0.1738362801839788 1.825344248115856e-06 0.1720835746408261 1.825344358713008e-06 0.1707596463148658 1.825344500843447e-06 0.1690680578777541 \
1.82534461655307e-06 0.1676985735146403 1.825344722027083e-06 0.166456424915798 1.825344816543742e-06 0.1653485352650968 1.825344912181114e-06 0.1642320043563913 \
1.825345009252958e-06 0.1631032360400927 1.825345108304212e-06 0.161956192050434 1.825345202227769e-06 0.1608730077890209 1.825345287503444e-06 0.1598934595213354 \
1.825345387883236e-06 0.1587475631033795 1.825345472186073e-06 0.1577906478848196 1.825345574585582e-06 0.1566342854655733 1.825345651979844e-06 0.1557646215197878 \
1.825345744324758e-06 0.154731814591042 1.82534581457623e-06 0.1539498814072817 1.825345910750659e-06 0.1528844393027091 1.825345987575322e-06 0.152038051282755 \
1.825346066345474e-06 0.1511758489440315 1.825346140238394e-06 0.150370438825067 1.825346207936138e-06 0.1496353997608715 1.825346304000026e-06 0.1485973848112393 \
1.825346373572453e-06 0.1478489919002561 1.825346457461625e-06 0.1469503328160803 1.825346518593461e-06 0.146298213254472 1.825346590861543e-06 0.1455309799806117 \
1.825346663300106e-06 0.1447677488542132 1.825346744281147e-06 0.1439178685120187 1.825346810355615e-06 0.1432275520600639 1.825346887756114e-06 0.1424219220725307 \
1.82534697713157e-06 0.1414956876531561 1.825347047992216e-06 0.1407644282175171 1.825347146879283e-06 0.1397487730030469 1.825347224198192e-06 0.1389620820751095 \
1.825347306243418e-06 0.1381330876879582 1.82534739435453e-06 0.1372467208126059 1.825347461981677e-06 0.1365690714953818 1.825347542278859e-06 0.1357674830239305 \
1.825347617062888e-06 0.1350239185327315 1.825347685064065e-06 0.1343502586094245 1.825347731746974e-06 0.1338891847862563 1.825347820998567e-06 0.1330118383700247 \
1.825347859221617e-06 0.1326395291833771 1.825347928213527e-06 0.1319690872918072 1.825347980961596e-06 0.1314578750898332 1.825348063954378e-06 0.1306559489775353 \
1.825348104132829e-06 0.1302688434457458 1.825348196650203e-06 0.1293805059784019 1.82534823536857e-06 0.1290098403727171 1.825348309129285e-06 0.1283055160094505 \
1.825348370757287e-06 0.1277188748199021 1.825348442784976e-06 0.1270353589407805 1.825348510952008e-06 0.1263909833196726 1.825348585574169e-06 0.1256908956540175 \
1.825348667426635e-06 0.1249253613889138 1.825348750880797e-06 0.124147338931438 1.825348823832511e-06 0.1234692772477456 1.825348896559441e-06 0.122795332839617 \
1.825348956549435e-06 0.1222410931008323 1.825349042917447e-06 0.121445549533078 1.825349103886164e-06 0.1208856452315438 1.825349162271955e-06 0.1203507897957366 \
1.825349227906619e-06 0.119751336354628 1.825349287260861e-06 0.1192111367930785 1.825349355292642e-06 0.1185941868697126 1.825349452587012e-06 0.11771710490035 \
1.825349531078992e-06 0.1170124163111649 1.825349621315123e-06 0.1162055395685231 1.825349717161808e-06 0.1153523005684616 1.825349792119505e-06 0.1146878351828532 \
1.825349896478921e-06 0.1137670532163148 1.825349983267518e-06 0.1130053589403202 1.825350092924934e-06 0.1120476726212376 1.825350174478997e-06 0.1113387926087848 \
1.825350270092629e-06 0.1105114393564785 1.825350346804822e-06 0.10985058581598 1.825350441723287e-06 0.1090364400125625 1.825350517546392e-06 0.1083889268999046 \
1.825350595246049e-06 0.1077282965354292 1.8253506775775e-06 0.1070311517075373 1.825350737142763e-06 0.1065286079538068 1.825350800900501e-06 0.1059924133642201 \
1.825350861995109e-06 0.1054803128126646 1.825350957858847e-06 0.1046801683739134 1.825351002721941e-06 0.1043071445723913 1.825351085962687e-06 0.1036173314376927 \
1.825351135082509e-06 0.1032117000904133 1.825351244131271e-06 0.1023149933518279 1.825351288967353e-06 0.1019479364619093 1.825351379228585e-06 0.1012117400678687 \
1.825351420105203e-06 0.1008795969612472 1.825351490563617e-06 0.1003088525914566 1.825351576851038e-06 0.09961307626065434 1.825351668628597e-06 0.09887705578174606 \
1.82535173815669e-06 0.09832225024344161 1.825351816683849e-06 0.09769854072774181 1.825351907412525e-06 0.09698178745350861 1.825351983228664e-06 0.09638605854785212 \
1.825352065241407e-06 0.09574500473888557 1.825352146994443e-06 0.09510943278387665 1.825352237502267e-06 0.09440967388330095 1.825352327061564e-06 0.09372126988887708 \
1.825352412671398e-06 0.09306698857649189 1.825352505450896e-06 0.09236212353634379 1.825352586338857e-06 0.0917510971760913 1.825352687467827e-06 0.09099177263830999 \
1.825352767961352e-06 0.09039108594384238 1.825352852204218e-06 0.08976589684797046 1.825352926049265e-06 0.08922077348043934 1.825353002898743e-06 0.08865632925481931 \
1.825353091039112e-06 0.08801255002475737 1.825353171103481e-06 0.08743108261130086 1.825353264139672e-06 0.08675939571108145 1.825353382140385e-06 0.08591369538214398 \
1.825353524513612e-06 0.08490278100234279 1.825353668761962e-06 0.08388867104764453 1.825353811089671e-06 0.08289807427203813 1.825353960667415e-06 0.08186746790234835 \
1.82535409698116e-06 0.08093761126893445 1.825354239101592e-06 0.0799778356000513 1.82535437365502e-06 0.07907840240745091 1.825354514007729e-06 0.07814980287393705 \
1.825354661689802e-06 0.0771833418413561 1.825354811805299e-06 0.07621180464723754 1.825354976525776e-06 0.07515824360926991 1.825355140155128e-06 0.07412455432658185 \
1.825355314933688e-06 0.07303438636984133 1.825355502186304e-06 0.07188220095900363 1.825355712231308e-06 0.07060976590783831 1.825355930441531e-06 0.06930979572898451 \
1.825356163898619e-06 0.06794333957253913 1.825356418744638e-06 0.06648001693367038 1.825356711839195e-06 0.06483321328442151 1.825357014178957e-06 0.06317411115207273 \
1.825357328765832e-06 0.06148945259513613 1.825357725026527e-06 0.05942677493938087 1.825358058743672e-06 0.05774249301432461 1.825358466054501e-06 0.05574994498853819 \
1.82535879393926e-06 0.05419380357502902 1.825359150629899e-06 0.05254809000207299 1.82535946386806e-06 0.05114243792209583 1.825359766835193e-06 0.04981740498512215 \
1.825360064375718e-06 0.04854875663330436 1.825360343155274e-06 0.04739109061078805 1.825360626155169e-06 0.04624570307560639 1.825360887895477e-06 0.04521055793698023 \
1.82536116713437e-06 0.04413130357485813 1.82536143924029e-06 0.0431040186124033 1.825361746607047e-06 0.04197194005652995 1.825361968409948e-06 0.04117329707315532 \
1.825362274870428e-06 0.04009446155587663 1.825362501059881e-06 0.03931650950691581 1.825362739977206e-06 0.03851359500741255 1.825362964401039e-06 0.03777663690506906 \
1.82536316666332e-06 0.03712468825868943 1.825363367705949e-06 0.03648814235703791 1.825363719479983e-06 0.03540095449820539 1.825363969725821e-06 0.03464776841732944 \
1.825364216044101e-06 0.03392252499723709 1.825364497376965e-06 0.03311308780599518 1.82536474046795e-06 0.03242954897046491 1.825364975941701e-06 0.03178112583711486 \
1.825365217601206e-06 0.03113119522156456 1.825365454483483e-06 0.03050988948014832 1.825365685016041e-06 0.02991733361391674 1.825365898984568e-06 0.02937801894285819 \
1.825366104927116e-06 0.02886851641492237 1.825366497651603e-06 0.02792196059063811 1.825366685729283e-06 0.02747992420741849 1.825367061168249e-06 0.02661861215736662 \
1.825367236042477e-06 0.02622659266649364 1.825367659365491e-06 0.02530049759795254 1.825367780614875e-06 0.02504150687334681 1.825368221176528e-06 0.02412433837770948 \
1.825368363674648e-06 0.02383402682615681 1.825368695728157e-06 0.02316883068419595 1.825368878693682e-06 0.02280879143785283 1.825369267997886e-06 0.02205689891561978 \
1.825369436343594e-06 0.02173705378531499 1.825369908457993e-06 0.02085107653961301 1.825370048202727e-06 0.0205916297664938 1.825370543782805e-06 0.01969297428531048 \
1.825370671008237e-06 0.01946923320191776 1.825371238917342e-06 0.01851512288677271 1.82537140317129e-06 0.0182513999453204 1.825372013043028e-06 0.0173209960017622 \
1.825372172728257e-06 0.01708922829277545 1.825372699639798e-06 0.01635462467776483 1.825372904157091e-06 0.01608193551804103 1.825373627634478e-06 0.01515939662837778 \
1.82537379307661e-06 0.01495683325581705 1.825374539636356e-06 0.01408081084911163 1.825374672939569e-06 0.01393008075245666 1.825375533124155e-06 0.01299799962960837 \
1.82537566920557e-06 0.01285670227674402 1.825376609799459e-06 0.01192267652923807 1.825376773572533e-06 0.01176632439256516 1.825377774751464e-06 0.01084959205883911 \
1.825377912229187e-06 0.01072929995296418 1.825379082926798e-06 0.009787962024485789 1.825379175323166e-06 0.009718668544398181 1.825380593399014e-06 0.008725931027897449 \
1.825380680375162e-06 0.00866912727384293 1.825382221370792e-06 0.00770199130002063 1.825382330686807e-06 0.007633428668288294 1.825383973934629e-06 0.006673746291950173 \
1.825384106791908e-06 0.006603544020797993 1.825386201172206e-06 0.005605323336654431 1.825386409576941e-06 0.00551468736035817 1.825388763913366e-06 0.004577307911602986 \
1.825389237472123e-06 0.004407121484391641 1.825392122908979e-06 0.003492041675788492 1.825392652573326e-06 0.00334538389506189 1.825396860800552e-06 0.00237996320858989 \
1.825397374234803e-06 0.002283557532494709 1.825403133485495e-06 0.001325291758975802 1.825403368066713e-06 0.001279502680325907 1.825418035894088e-06 0.0002809017338477542 \
1.82541814896418e-06 0.0002788534805396912 1.82805516904393e-06 -0.0006849217749926401 1.828055335205606e-06 -0.0009443270389602415 1.828055814074993e-06 -0.001850320037528519 \
1.828055906794619e-06 -0.002050462221988249 1.828056272019697e-06 -0.002913187630468476 1.828056363676814e-06 -0.00314709230904735 1.828056729783165e-06 -0.004133001189868674 \
1.828056839930291e-06 -0.004442309109773816 1.828057150668543e-06 -0.005311341427314526 1.828057252407188e-06 -0.005583925258601597 1.828057616111313e-06 -0.00638370916272213 \
1.828057780957636e-06 -0.006585924750287024 1.828058360754957e-06 -0.005792290386912202 1.828058535589415e-06 -0.004916934050781314 1.828058652279015e-06 -0.00413641027497409 \
1.828058778708707e-06 -0.00310656561120747 1.82805888073091e-06 -0.002137079422087956 1.828059000577393e-06 -0.0008406209844352954 1.828059091214629e-06 0.0002489246187367611 \
1.828059189634679e-06 0.001536790859923857 1.828059289358323e-06 0.002948496343048522 1.828059456842332e-06 0.005545701385567424 1.828059675420934e-06 0.009327395936412004 \
1.828059861491256e-06 0.0128572688386996 1.828060082873864e-06 0.01737012273305725 1.828060243533997e-06 0.02082840415615294 1.828060406999647e-06 0.02447866954313523 \
1.828060557635164e-06 0.02794359528291388 1.828060706690917e-06 0.03145289236167962 1.82806085615367e-06 0.03504014479003619 1.828061010184684e-06 0.03879791952579481 \
1.828061172300943e-06 0.04280891157365373 1.828061338330407e-06 0.04696567134311741 1.828061514283228e-06 0.05141478668696391 1.828061694953865e-06 0.05602187592747932 \
1.828061886774812e-06 0.06094655248807559 1.828062093880316e-06 0.06629309753158302 1.828062315452046e-06 0.07203901748582854 1.828062550186215e-06 0.07814662931008168 \
1.828062801725783e-06 0.08470684589377442 1.828063077167849e-06 0.09190125212984442 1.828063377363667e-06 0.09974607960254324 1.828063708295878e-06 0.108390578238945 \
1.828064083962612e-06 0.1181923833971668 1.82806448154548e-06 0.1285487285136021 1.828064948370082e-06 0.1406786766767902 1.828065491362617e-06 0.1547396794802719 \
1.82806612478764e-06 0.1710742296429572 1.82806682072769e-06 0.1889259607126788 1.8280676362848e-06 0.2097135943149445 1.828068546312903e-06 0.2327316641523666 \
1.828069339569124e-06 0.2526372689279454 1.8280700450442e-06 0.2702038474981599 1.828070663988468e-06 0.2855008995781749 1.828071231094408e-06 0.2994177966724069 \
1.828071754174414e-06 0.3121574438576628 1.828072253153207e-06 0.3242197130846058 1.828072737193214e-06 0.3358335658028451 1.828073192420047e-06 0.3466679577370423 \
1.828073666932009e-06 0.3578644504627745 1.828074106840717e-06 0.368158604789619 1.828074592685345e-06 0.3794271463718566 1.828075124288118e-06 0.3916316501999784 \
1.828075626951416e-06 0.4030538969706937 1.82807605602367e-06 0.4127111343288326 1.828076547040338e-06 0.4236561147984291 1.828077048470418e-06 0.434714731975362 \
1.828077395015009e-06 0.442288187401736 1.828077750424385e-06 0.4500000616404133 1.828078177652114e-06 0.4592019891792938 1.828078569851637e-06 0.4675774400278049 \
1.828078870233395e-06 0.4739448723400065 1.828079212045155e-06 0.4811381049525967 1.828079555484969e-06 0.4883107756756314 1.828079816220095e-06 0.4937186470393492 \
1.828080058250048e-06 0.4987071765458648 1.828080324195291e-06 0.5041573145298286 1.828080581464587e-06 0.509394255416739 1.82808077158369e-06 0.5132422368582924 \
1.828080985109851e-06 0.5175451019736222 1.828081124800157e-06 0.5203466115392713 1.828081271000449e-06 0.5232668091041763 1.82808148498835e-06 0.5275186200231483 \
1.828081693004609e-06 0.5316389396023125 1.828081885465879e-06 0.5354321131715788 1.82808207058211e-06 0.5390651926504321 1.828082244955557e-06 0.5424725330931349 \
1.828082549497633e-06 0.5484058192982523 1.828082810056515e-06 0.5534602958276967 1.828083111487544e-06 0.5592859190791987 1.828083365805138e-06 0.5641865993769294 \
1.828083658661328e-06 0.5698153316805189 1.82808391787448e-06 0.5747800306938655 1.828084188950812e-06 0.579963273174682 1.828084430794571e-06 0.5845680738798381 \
1.828084688299729e-06 0.5894577538325241 1.828084915043605e-06 0.5937419314630586 1.828085152044424e-06 0.5982006324572362 1.828085362230986e-06 0.6021379329905048 \
1.82808557499152e-06 0.6061060319396779 1.828085827870286e-06 0.6107954169450593 1.828086031533554e-06 0.6145509252949414 1.828086222250936e-06 0.6180531102377972 \
1.828086409587374e-06 0.6214768531423983 1.828086598465652e-06 0.6249070011644339 1.828086806665447e-06 0.6286671070650327 1.828087050997562e-06 0.6330499453121026 \
1.828087250564095e-06 0.6366057789565548 1.828087454709836e-06 0.6402215701419991 1.82808763934909e-06 0.643474671963314 1.828087908884781e-06 0.6481901084955864 \
1.828088136591637e-06 0.652149230294136 1.828088324263375e-06 0.6553888277830079 1.82808850516352e-06 0.6584949378977958 1.828088664704602e-06 0.661221510907812 \
1.828088835167002e-06 0.6641177016088209 1.828088986918443e-06 0.6666817235716488 1.828089124561455e-06 0.6689905419339194 1.828089273556318e-06 0.6714784915997724 \
1.828089401298182e-06 0.6736028790357499 1.828089544284695e-06 0.675968899142866 1.828089666067751e-06 0.6779749688503388 1.828089802351161e-06 0.6802121872853304 \
1.828089922180062e-06 0.682172759947357 1.828090068775623e-06 0.6845626218370968 1.828090187248565e-06 0.6864845934661837 1.828090283181927e-06 0.6880368302455475 \
1.828090375701511e-06 0.6895284278106264 1.828090480762022e-06 0.6912169000724893 1.828090578843908e-06 0.6927871490736753 1.828090715959225e-06 0.6949707622226827 \
1.828090835157868e-06 0.6968607547931925 1.828090945097838e-06 0.6985951241089645 1.828091082597081e-06 0.7007503743809057 1.828091214026983e-06 0.7027960765825516 \
1.828091346256499e-06 0.7048392108129343 1.828091459433897e-06 0.7065756917706891 1.828091613866752e-06 0.708927873976708 1.828091744646745e-06 0.7109048231498766 \
1.828091867315455e-06 0.7127465601965561 1.828091973583711e-06 0.7143329262278221 1.828092095963735e-06 0.7161490373358268 1.828092197817232e-06 0.7176517022913665 \
1.828092331955131e-06 0.7196190116794019 1.828092452648171e-06 0.7213783352064487 1.82809257178997e-06 0.7231049829175343 1.828092696807984e-06 0.7249059312823601 \
1.82809282664779e-06 0.7267645120560844 1.828092946459961e-06 0.7284691779696002 1.828093075453213e-06 0.730293808329565 1.828093207560277e-06 0.7321507998840678 \
1.828093325866095e-06 0.7338038328985433 1.828093469126786e-06 0.7357927618453034 1.828093571581473e-06 0.7372070005703254 1.828093667788358e-06 0.7385290937783453 \
1.82809377280598e-06 0.7399656334130889 1.828093883577511e-06 0.7414708009413548 1.828093985256052e-06 0.7428439364018735 1.828094088217506e-06 0.7442258341871242 \
1.82809420514366e-06 0.7457850038572696 1.828094333903936e-06 0.747489965072781 1.828094435062908e-06 0.7488201182152049 1.828094583931952e-06 0.7507626302114226 \
1.828094731611489e-06 0.75267249971878 1.828094850976855e-06 0.7542038164026367 1.828094997460699e-06 0.7560679527984652 1.82809512063619e-06 0.7576223900169708 \
1.828095261439864e-06 0.7593848990234215 1.828095398032531e-06 0.7610800595258669 1.828095520190381e-06 0.7625841275516777 1.828095632846779e-06 0.7639610711610054 \
1.82809577457292e-06 0.7656796138775311 1.82809590073942e-06 0.767196844592689 1.828096016156724e-06 0.768574452686535 1.828096146464904e-06 0.7701179991486644 \
1.828096262177572e-06 0.7714782821591826 1.82809638500186e-06 0.7729116492687436 1.828096502846128e-06 0.7742769236963016 1.828096608476118e-06 0.7754922619072108 \
1.828096723849553e-06 0.7768108638983861 1.828096829112716e-06 0.7780056027231214 1.828096940062529e-06 0.7792565499870431 1.82809702646703e-06 0.7802246528436213 \
1.82809713050085e-06 0.7813823422463088 1.828097244396594e-06 0.7826398494046257 1.828097347430013e-06 0.7837684443710583 1.828097455512714e-06 0.7849432998269023 \
1.82809756376437e-06 0.7861107422109641 1.828097699181616e-06 0.7875582910536544 1.828097811855724e-06 0.7887521292973186 1.828097936279784e-06 0.7900592323105087 \
1.828098054252648e-06 0.7912877959129118 1.828098198720602e-06 0.7927781272271259 1.828098316389742e-06 0.7939806363584788 1.828098452269581e-06 0.7953567374150946 \
1.828098587013954e-06 0.7967081403609936 1.828098698084933e-06 0.7978123285366109 1.828098797974273e-06 0.7987978371087655 1.828098899654231e-06 0.7997937268659365 \
1.828099032867897e-06 0.8010867894381996 1.828099151240716e-06 0.8022243628210853 1.82809927278179e-06 0.8033812848148773 1.828099392145442e-06 0.8045065422543012 \
1.828099513276819e-06 0.80563739819571 1.828099644976236e-06 0.8068544426691319 1.828099767984513e-06 0.8079795872959963 1.82809989582812e-06 0.8091371804586788 \
1.82810002673464e-06 0.8103101881504271 1.828100150327798e-06 0.8114062915203997 1.828100257500303e-06 0.8123479140825919 1.828100364929502e-06 0.8132835730547656 \
1.82810044759862e-06 0.8139979974227743 1.82810056531038e-06 0.8150069815425507 1.828100655915986e-06 0.8157770472204025 1.828100786569431e-06 0.8168774959419571 \
1.828100930959301e-06 0.8180800468042847 1.828101064133715e-06 0.8191766687328477 1.828101174025106e-06 0.8200725423139092 1.828101317623991e-06 0.8212302325252553 \
1.828101471014683e-06 0.8224508494407716 1.828101599092908e-06 0.8234574467428303 1.828101738880276e-06 0.8245431382086058 1.828101865129839e-06 0.8255122018650548 \
1.828102019728392e-06 0.8266841987320058 1.828102151939368e-06 0.8276738265999063 1.828102278166151e-06 0.8286078934539939 1.828102395913874e-06 0.8294698388787296 \
1.828102544986667e-06 0.8305480062617677 1.82810271231822e-06 0.8317406852496945 1.828102845539497e-06 0.8326770812274722 1.82810301832082e-06 0.8338744310092966 \
1.828103186826193e-06 0.8350236380668206 1.828103356205492e-06 0.8361608866600232 1.828103537840761e-06 0.8373606451951652 1.828103680174083e-06 0.8382866867625347 \
1.828103794011069e-06 0.8390185116470331 1.828103925192579e-06 0.8398522525089582 1.828104026724794e-06 0.8404903982372576 1.828104143009054e-06 0.8412135669902132 \
1.828104277643808e-06 0.8420406924792603 1.828104474666644e-06 0.8432316292878405 1.828104664772186e-06 0.8443592803112207 1.828104874895498e-06 0.8455816023960827 \
1.828105055213604e-06 0.8466107566581813 1.828105252676705e-06 0.8477171937062282 1.828105426745819e-06 0.8486750118570332 1.82810560906524e-06 0.8496608982186138 \
1.828105780480376e-06 0.8505716849290491 1.828105954593653e-06 0.8514808063694008 1.828106130324621e-06 0.8523822271368225 1.828106306436321e-06 0.8532696099472232 \
1.828106496054173e-06 0.8542074684498208 1.82810668683567e-06 0.8551330189126392 1.828106888431747e-06 0.8560917259710515 1.828107081166005e-06 0.856990088884472 \
1.828107290037825e-06 0.8579439907476532 1.828107520740263e-06 0.8589743400177088 1.828107785183227e-06 0.8601259267840322 1.828108084005915e-06 0.8613896125360476 \
1.828108363960216e-06 0.8625380186322354 1.828108648086082e-06 0.8636694076724545 1.828108922855057e-06 0.8647317823994775 1.828109194712216e-06 0.8657531067718063 \
1.828109465089334e-06 0.8667403371654003 1.828109722167855e-06 0.8676533221001362 1.828109994792686e-06 0.868594905839151 1.828110270759835e-06 0.8695208838709013 \
1.828110540864093e-06 0.8704012674911344 1.828110840740104e-06 0.8713491368600049 1.828111211801162e-06 0.8724801680184872 1.82811150674079e-06 0.8733472453740196 \
1.828111761036548e-06 0.8740729094291386 1.828112059297474e-06 0.8748989982677786 1.828112332904015e-06 0.8756336613858092 1.828112569029958e-06 0.876250392688866 \
1.828112809374056e-06 0.8768621356511911 1.828113031706182e-06 0.8774140071409635 1.828113225712247e-06 0.8778848105679672 1.828113555434997e-06 0.8786625669521169 \
1.828113710608526e-06 0.8790190643519731 1.828114028387606e-06 0.879730644938159 1.828114207248864e-06 0.8801204696806418 1.828114549710761e-06 0.8808457867651537 \
1.828114733837363e-06 0.8812245477320809 1.828115208711942e-06 0.8821665346129511 1.828115376108352e-06 0.8824869809105039 1.828115841951854e-06 0.883348261932613 \
1.828116022773548e-06 0.8836708855253055 1.828116516812651e-06 0.8845204537290557 1.828116658162059e-06 0.8847551796839913 1.828117264500122e-06 0.8857215808967022 \
1.828117416569336e-06 0.8859539944113424 1.828118063256356e-06 0.8869009218298172 1.828118191551239e-06 0.8870812460539503 1.828118839667745e-06 0.8879562712787433 \
1.828118969467641e-06 0.8881245027440973 1.82811974767834e-06 0.8890830197250962 1.828119862725472e-06 0.8892171882189283 1.828120718396314e-06 0.8901564861234483 \
1.828120863744077e-06 0.8903061494816453 1.828121849499649e-06 0.8912466483555094 1.828122070607711e-06 0.8914402669210102 1.828123215727714e-06 0.892367747196105 \
1.828123346939158e-06 0.8924695935232408 1.828124688211624e-06 0.8934615053489913 1.8281248396029e-06 0.8935661991834861 1.82812632105512e-06 0.8944951400107031 \
1.828126559934816e-06 0.8946288932334222 1.828128329356654e-06 0.895502508848118 1.828128718477945e-06 0.895670668133377 1.828131112210654e-06 0.8965556062201232 \
1.828131587750592e-06 0.8967047758494365 1.828135650819817e-06 0.8977025964496719 1.828136142295653e-06 0.8977953148389237 1.828144458892796e-06 0.8987880790885289 \
1.828145378794248e-06 0.8988514070442593 1.828299242370168e-06 0.8998485708192639 1.828302885496457e-06 0.8998628537402877 1.828529614276671e-06 0.8989664306490068 \
1.828529844616583e-06 0.8988008565867064 1.82853145953688e-06 0.897804750401333 1.828531637269166e-06 0.8977103535805105 1.828548403669271e-06 0.8986978311584225 \
1.828548539768402e-06 0.8987160394686986 1.828563710608672e-06 0.8997133888183054 1.828563987713508e-06 0.899719468756186 1.829048028906422e-06 0.9005852143835333 \
1.829048202241039e-06 0.9007408621809421 1.829048862730638e-06 0.9015135064485434 1.82904902879582e-06 0.9017527716291757 1.829049555130528e-06 0.9026184054967997 \
1.829049746244447e-06 0.9029704910143604 1.829050110465499e-06 0.9036902342402512 1.829050289664921e-06 0.9040628043424317 1.829050651551594e-06 0.9048333795345931 \
1.829050846661164e-06 0.9052442844328937 1.829051379059525e-06 0.9062266394381637 1.829051561413164e-06 0.9064623886473868 1.829052553393556e-06 0.905594670761786 \
1.829052714934123e-06 0.9049318860608667 1.829052882926575e-06 0.9040378649110347 1.829053042758061e-06 0.9029782421366458 1.829053180254799e-06 0.9018984154159868 \
1.829053313162111e-06 0.9007052793196499 1.829053439587579e-06 0.8994328447569792 1.829053546986819e-06 0.8982475863895881 1.829053651483477e-06 0.8970047013543965 \
1.829053765533147e-06 0.8955451342423859 1.829053855502734e-06 0.8943225684615312 1.829053960321372e-06 0.8928208677113324 1.829054049769612e-06 0.891473284704788 \
1.829054132145392e-06 0.8901820884368528 1.829054223238392e-06 0.8887006634027688 1.82905436057447e-06 0.8863657732814155 1.829054459067402e-06 0.8846195012157601 \
1.829054571141153e-06 0.8825649218508906 1.829054702024186e-06 0.880080778639088 1.829054838495216e-06 0.8774018563482072 1.829054991949379e-06 0.8742910281085086 \
1.829055151043747e-06 0.8709679977889497 1.829055315327649e-06 0.867445283300377 1.82905547199575e-06 0.8640104344288071 1.829055624086531e-06 0.860615744772629 \
1.829055777800206e-06 0.857132398554192 1.829055937362381e-06 0.853469801378647 1.829056092451083e-06 0.8498714074018293 1.829056266130402e-06 0.8458039138600054 \
1.829056429161269e-06 0.8419559450883216 1.829056590803684e-06 0.8381170660338335 1.82905675345042e-06 0.8342344554797501 1.829056914868927e-06 0.8303657475978833 \
1.829057083463406e-06 0.8263109424305363 1.829057266356504e-06 0.8219002364007665 1.829057434185218e-06 0.8178440888239877 1.829057602471033e-06 0.8137703061148112 \
1.829057773299085e-06 0.8096302849976138 1.829057945473642e-06 0.8054541271740473 1.829058113235561e-06 0.8013830614994394 1.829058296865018e-06 0.7969255463994016 \
1.829058468271496e-06 0.7927646873948894 1.829058653714802e-06 0.7882638003278283 1.829058820385453e-06 0.7842196820467244 1.829058989271585e-06 0.7801233737411432 \
1.829059173427882e-06 0.7756572567105651 1.82905936803791e-06 0.7709405333854473 1.829059515293241e-06 0.7673736106648734 1.829059641923832e-06 0.7643079795643375 \
1.829059783780644e-06 0.7608754495129878 1.829059888184422e-06 0.7583505812556488 1.829060020577074e-06 0.7551502542766809 1.82906013016127e-06 0.7525028097975122 \
1.829060263325923e-06 0.7492875979647342 1.829060419507685e-06 0.7455190770546114 1.829060532737112e-06 0.7427887939149777 1.829060695258476e-06 0.7388718945951063 \
1.829060867439291e-06 0.7347246296492568 1.829061063444044e-06 0.7300078517193382 1.829061227834023e-06 0.7260553905833119 1.829061380230703e-06 0.7223944885043934 \
1.829061543905858e-06 0.718466402706526 1.829061711831558e-06 0.7144406657912139 1.829061891671936e-06 0.7101336212543717 1.829062067965886e-06 0.7059164985576465 \
1.829062239040521e-06 0.7018286413152719 1.829062407358697e-06 0.6978099102718778 1.829062560624829e-06 0.6941537154717222 1.829062722508398e-06 0.6902960245155986 \
1.829062901459938e-06 0.6860364417190952 1.82906303567149e-06 0.6828448068431195 1.829063139177788e-06 0.6803854168085423 1.8290632384622e-06 0.6780286039046017 \
1.829063339916677e-06 0.6756220912380299 1.829063432373275e-06 0.6734303711245889 1.829063516962075e-06 0.6714267031582685 1.829063610539411e-06 0.6692114082407524 \
1.82906372708163e-06 0.6664546942583044 1.829063836559192e-06 0.6638675763958631 1.829063949672203e-06 0.6611971533414394 1.82906407279097e-06 0.6582923426231613 \
1.829064197017283e-06 0.6553636581362478 1.829064367777427e-06 0.6513432847262797 1.829064526226014e-06 0.6476181700514572 1.829064698513837e-06 0.6435738126612673 \
1.829064844491904e-06 0.6401512360303271 1.82906498628512e-06 0.6368325564797357 1.829065117883574e-06 0.6337564355289309 1.829065248046859e-06 0.630718219665797 \
1.829065373571799e-06 0.6277924818644975 1.829065505354707e-06 0.6247239543970449 1.829065635278202e-06 0.6217046839485236 1.829065771586778e-06 0.6185408917806742 \
1.829065916200345e-06 0.615188962872713 1.829066075692536e-06 0.611499189008522 1.829066249152652e-06 0.6074939486938447 1.829066420159954e-06 0.6035554342946753 \
1.829066651528522e-06 0.5982402936372396 1.829066894990528e-06 0.5926661367297537 1.829067069111016e-06 0.5886942528256315 1.829067215383093e-06 0.5853638081576373 \
1.829067349755311e-06 0.58231230528805 1.829067466850206e-06 0.5796585826255305 1.829067562614553e-06 0.5774900935424465 1.829067661461095e-06 0.5752566196463251 \
1.829067745438414e-06 0.5733628024369305 1.829067823052463e-06 0.571614165956722 1.829067884377937e-06 0.5702331258704825 1.829067949058575e-06 0.5687779664863769 \
1.829068030366711e-06 0.5669528575016536 1.829068080436707e-06 0.5658306078972934 1.829068129757269e-06 0.5647256890740617 1.829068191677069e-06 0.5633393552914843 \
1.829068239508894e-06 0.5622690492396486 1.82906829001368e-06 0.5611395143522533 1.829068350075717e-06 0.559799205480933 1.829068409358512e-06 0.5584782058326896 \
1.829068484415226e-06 0.5568072508052372 1.829068554097883e-06 0.5552574373576753 1.829068639686449e-06 0.5533559356568912 1.829068726753821e-06 0.5514265885063823 \
1.829068810416341e-06 0.5495763264044081 1.829068896561366e-06 0.5476734676082877 1.829068992265987e-06 0.5455621222678217 1.829069096550939e-06 0.5432673229847179 \
1.829069211218113e-06 0.5407497407899529 1.829069319936574e-06 0.5383664115638558 1.829069429508814e-06 0.5359693749054023 1.829069541813574e-06 0.5335193270114367 \
1.829069668589195e-06 0.530759392645703 1.829069790866427e-06 0.5281021910076299 1.829069930952405e-06 0.5250685463469849 1.829070067969762e-06 0.5221084647952599 \
1.829070218271135e-06 0.5188705764247719 1.829070377166376e-06 0.5154582091324615 1.829070551500259e-06 0.5117250894133971 1.829070738517481e-06 0.5077378180012799 \
1.829070943835486e-06 0.5033745272871338 1.829071155677679e-06 0.498891131759938 1.829071408479721e-06 0.4935662239713107 1.82907161056737e-06 0.4893264048484654 \
1.829071845160675e-06 0.4844277613141263 1.829072081275272e-06 0.4795194943790256 1.829072334451769e-06 0.474283574581623 1.829072644981732e-06 0.4679020429045382 \
1.82907286303971e-06 0.4634451779596257 1.829073036485344e-06 0.4599153839204358 1.829073212977781e-06 0.4563351808422506 1.829073492459577e-06 0.4506930409909046 \
1.829073724703484e-06 0.4460279192631412 1.829074011797073e-06 0.44029020239849 1.829074229643181e-06 0.435960758243863 1.829074439695768e-06 0.4318042429497612 \
1.829074640893604e-06 0.4278406951573778 1.829074823313765e-06 0.4242617300271556 1.82907499720875e-06 0.4208637793449936 1.829075162072867e-06 0.4176529694331993 \
1.82907532082684e-06 0.4145718140694327 1.829075487073786e-06 0.4113577680628809 1.829075635718993e-06 0.4084923702366076 1.829075788087249e-06 0.4055658186126443 \
1.829075930150432e-06 0.4028468403491589 1.82907609952631e-06 0.3996150665462138 1.82907621990823e-06 0.3973276483660343 1.829076329881494e-06 0.3952449223617059 \
1.829076444806895e-06 0.3930732253581283 1.829076597048475e-06 0.3902080468194818 1.82907670926954e-06 0.3881039677199808 1.829076816462041e-06 0.386098874836553 \
1.82907696899029e-06 0.383254723448244 1.829077097137419e-06 0.380874963946598 1.829077219985411e-06 0.3786015923730871 1.829077399083788e-06 0.375299968600122 \
1.82907754816842e-06 0.3725653942578417 1.829077715875807e-06 0.3695018296724824 1.829077871273442e-06 0.3666748141177644 1.829077995440288e-06 0.3644243980538668 \
1.829078109332155e-06 0.3623666676050148 1.829078230775526e-06 0.3601804966264144 1.829078410927293e-06 0.3569532670533712 1.829078577415113e-06 0.3539878629329621 \
1.829078767834223e-06 0.3506138544217919 1.829078959590818e-06 0.3472380408565978 1.829079142640212e-06 0.344035729794033 1.829079291612276e-06 0.3414435189591631 \
1.829079411552182e-06 0.3393660536257183 1.829079534213665e-06 0.3372483242714233 1.829079657244151e-06 0.3351324902755385 1.829079802148562e-06 0.3326515017845288 \
1.829079905461337e-06 0.3308907757076019 1.829079999190846e-06 0.3292979229163631 1.829080089851148e-06 0.3277620998585528 1.829080200972602e-06 0.3258853746017661 \
1.829080308145579e-06 0.3240820510456246 1.82908040642023e-06 0.3224338250618513 1.829080518824776e-06 0.3205545940512134 1.829080682764676e-06 0.3178277446588927 \
1.829080844402555e-06 0.3151576097143818 1.829080992189301e-06 0.3127316247504084 1.829081154434516e-06 0.3100832165115083 1.829081314465073e-06 0.3074868334344322 \
1.829081466728372e-06 0.3050304870660137 1.829081620100242e-06 0.3025703731928215 1.829081778808771e-06 0.3000411640344692 1.8290819432579e-06 0.297437246442505 \
1.829082110484976e-06 0.2948063590562646 1.829082263596513e-06 0.292412731930112 1.82908244669444e-06 0.2895700146919417 1.829082637002178e-06 0.2866380344427262 \
1.829082785905236e-06 0.2843603072871506 1.829082959842541e-06 0.2817165165722222 1.82908313671993e-06 0.2790484233348025 1.829083284317149e-06 0.2768363681311815 \
1.829083473948848e-06 0.2740172295061162 1.829083623950767e-06 0.2718052906662373 1.829083761060957e-06 0.2697943906627059 1.829083902591401e-06 0.2677397479842996 \
1.82908401605027e-06 0.2661005451260196 1.829084152340596e-06 0.2641384584581135 1.829084282417217e-06 0.2622807416655737 1.82908440067147e-06 0.2606037730704709 \
1.829084518527066e-06 0.2589348966568543 1.829084649420877e-06 0.2570853888657079 1.829084789659635e-06 0.2551145527343576 1.829084905154221e-06 0.2534976852533538 \
1.829085034005598e-06 0.2516957519945816 1.829085149151579e-06 0.2500885525459272 1.829085302462547e-06 0.2479513765689386 1.829085440316308e-06 0.2460367343642474 \
1.82908557977796e-06 0.2441002375748529 1.829085735245815e-06 0.2419427021952501 1.82908586002843e-06 0.2402176526454788 1.829085999893338e-06 0.2382916534360561 \
1.829086128595514e-06 0.2365220787132559 1.829086249554366e-06 0.234860341242685 1.829086366599666e-06 0.2332541163798121 1.82908649260073e-06 0.2315368940272461 \
1.829086589320323e-06 0.2302195772445239 1.829086681409196e-06 0.2289683907689286 1.829086795826667e-06 0.2274152998827935 1.829086894197314e-06 0.2260807986508055 \
1.829087011344108e-06 0.2244933520241092 1.829087114435225e-06 0.2231010305483718 1.829087219949952e-06 0.2216798666278746 1.829087300868011e-06 0.2205933880575098 \
1.829087374539197e-06 0.2196046443759679 1.829087417268434e-06 0.2190314036349237 1.829087460398579e-06 0.2184540235451489 1.82908751119606e-06 0.217774515685755 \
1.829087548370939e-06 0.217277430841393 1.829087589041954e-06 0.2167338127731004 1.829087631833755e-06 0.2161620985357572 1.829087668244897e-06 0.2156758299561118 \
1.829087710169888e-06 0.2151161507306283 1.829087764712098e-06 0.2143884526296278 1.829087803170856e-06 0.2138756926875936 1.829087842797625e-06 0.2133496230586122 \
1.829087904630127e-06 0.212531488259555 1.829087966356579e-06 0.2117156525305126 1.829088022493854e-06 0.210974237875411 1.829088086149083e-06 0.210134110843225 \
1.829088180240117e-06 0.2088936328424611 1.829088267048376e-06 0.2077505933124353 1.82908836100502e-06 0.2065146061917991 1.829088459047254e-06 0.2052266823513323 \
1.829088560634619e-06 0.2038976009052371 1.829088661543568e-06 0.2025832113009377 1.829088758279377e-06 0.2013244528083448 1.829088860404348e-06 0.1999972806373927 \
1.829088963735905e-06 0.1986583046056677 1.829089073618507e-06 0.1972379690671278 1.829089182560765e-06 0.1958337611883887 1.829089302395884e-06 0.1942937175364915 \
1.829089412679751e-06 0.1928822800638286 1.829089520558496e-06 0.191507108810815 1.829089646621254e-06 0.1899051957406391 1.829089736488961e-06 0.1887671190866151 \
1.8290898469673e-06 0.1873723090993208 1.829089924500249e-06 0.1863971337376019 1.829090008823992e-06 0.1853400660204312 1.82909009641205e-06 0.1842452710069853 \
1.829090184204644e-06 0.18315095174413 1.829090265924515e-06 0.1821357652581398 1.829090363486193e-06 0.1809282658474054 1.829090470197344e-06 0.1796118512064394 \
1.829090570679026e-06 0.178377576484793 1.829090694850237e-06 0.1768595317522179 1.829090828741761e-06 0.1752320886156309 1.829090947653953e-06 0.1737937102924047 \
1.829091098054147e-06 0.1719851742607024 1.82909120888924e-06 0.1706594030660365 1.829091348655982e-06 0.168997130456427 1.82909146718129e-06 0.1675953052211382 \
1.829091572608521e-06 0.1663548750207849 1.82909166731838e-06 0.1652455210322802 1.829091760628154e-06 0.1641568522804657 1.82909186153427e-06 0.1629842804551663 \
1.829091956952102e-06 0.1618800504313296 1.829092054143025e-06 0.1607598891027116 1.829092135704507e-06 0.1598237474547246 1.829092241020952e-06 0.1586229753023833 \
1.829092324500658e-06 0.1576763029943549 1.829092426029949e-06 0.1565306813704828 1.829092503260486e-06 0.1556635090415242 1.829092594132523e-06 0.154647919213242 \
1.829092663483833e-06 0.1538765336840219 1.829092748067884e-06 0.1529397840535594 1.829092822461091e-06 0.1521208717489242 1.829092901831293e-06 0.151251902275755 \
1.829092976418964e-06 0.1504388356812226 1.829093045640521e-06 0.1496871728711989 1.829093140321328e-06 0.1486640077242138 1.829093210087093e-06 0.1479134441579097 \
1.829093294531656e-06 0.147008717574758 1.829093356097001e-06 0.1463518850554192 1.829093430139493e-06 0.1455673550676988 1.829093503525017e-06 0.1447940960774066 \
1.829093584960258e-06 0.1439395015691976 1.829093654409405e-06 0.1432139999234875 1.829093729511102e-06 0.1424323701137583 1.829093819423173e-06 0.1415006120834361 \
1.829093896506793e-06 0.1407052977810757 1.829093995617377e-06 0.1396885207473417 1.82909406515744e-06 0.138983077430453 1.829094146475915e-06 0.1381612812129989 \
1.829094216644325e-06 0.1374549162714094 1.829094295612438e-06 0.1366629455350578 1.82909437459072e-06 0.1358740351737466 1.82909444691251e-06 0.1351544405911459 \
1.829094516277969e-06 0.1344667589602006 1.829094564981976e-06 0.1339854049281765 1.829094655744348e-06 0.1330945614011112 1.829094687765876e-06 0.1327823711724506 \
1.829094775869844e-06 0.131925672678654 1.829094808363886e-06 0.1316105445757083 1.829094907031543e-06 0.1306564447580443 1.829094950687519e-06 0.130235859061297 \
1.829095028669336e-06 0.1294866595045693 1.829095066000294e-06 0.1291289430202982 1.829095168151694e-06 0.128153223240932 1.829095235595654e-06 0.1275115375392494 \
1.829095300748611e-06 0.1268935577290946 1.829095366654626e-06 0.1262729746041904 1.829095437806609e-06 0.1256052797936485 1.82909552074397e-06 0.1248293808775363 \
1.829095606139451e-06 0.1240331657139879 1.829095682226844e-06 0.1233259817834828 1.829095762687521e-06 0.1225806238777534 1.829095820771462e-06 0.1220441728027253 \
1.829095892104936e-06 0.1213870835332726 1.829095976893369e-06 0.1206085709991845 1.829096038048402e-06 0.1200487744399507 1.829096108134853e-06 0.1194096117168642 \
1.829096170640142e-06 0.1188419501154776 1.82909623664509e-06 0.1182453094891599 1.829096305417857e-06 0.1176255789053269 1.829096374874481e-06 0.1170017375875525 \
1.829096458038731e-06 0.1162574953874909 1.829096531156255e-06 0.1156056107435251 1.829096601870241e-06 0.1149774116339468 1.829096661221924e-06 0.1144518657417393 \
1.829096766519136e-06 0.1135239342411639 1.82909681238663e-06 0.1131212254602471 1.829096899340683e-06 0.1123603821649216 1.829096942354464e-06 0.1119852310621949 \
1.829096987221211e-06 0.1115947726395539 1.829097076954706e-06 0.1108164664143028 1.829097147839057e-06 0.110204256460374 1.829097226692571e-06 0.109525796983828 \
1.829097289470346e-06 0.1089876103666232 1.829097349464702e-06 0.1084750215669379 1.829097460462474e-06 0.1075310013968523 1.82909754121676e-06 0.1068475792877216 \
1.829097653680086e-06 0.1059005796323111 1.829097704824629e-06 0.1054717782906781 1.829097787809798e-06 0.1047785948356612 1.829097845974503e-06 0.1042945647727652 \
1.829097960212503e-06 0.1033482075721767 1.82909801011597e-06 0.1029366076865433 1.829098095857569e-06 0.1022320954501846 1.829098144889019e-06 0.1018307629303728 \
1.829098227455441e-06 0.101157455862875 1.829098298387777e-06 0.1005815064560546 1.829098366538127e-06 0.1000302812267231 1.829098444148443e-06 0.0994053199805509 \
1.829098516491814e-06 0.09882546240595018 1.829098594067778e-06 0.09820656846618626 1.829098682738439e-06 0.09750287271560702 1.829098756553227e-06 0.09692010793638871 \
1.829098838144235e-06 0.09627924899616347 1.829098916282703e-06 0.09566870926115327 1.829099002032493e-06 0.09500229249765579 1.829099089729402e-06 0.09432453920671229 \
1.829099183638967e-06 0.09360304191323381 1.829099280098285e-06 0.09286661217778783 1.829099358728946e-06 0.09226977907248698 1.829099461452545e-06 0.09149473120661993 \
1.829099545280196e-06 0.09086620530027881 1.829099666032377e-06 0.08996702094116031 1.829099795302029e-06 0.08901247130467421 1.829099951190493e-06 0.08787237469953549 \
1.829100106290076e-06 0.08675000010972149 1.829100263305882e-06 0.08562614142917294 1.829100443326735e-06 0.08435280068725284 1.829100593847601e-06 0.08330035525696428 \
1.829100742221624e-06 0.08227363395463329 1.829100879838855e-06 0.08133079092382095 1.829101019758505e-06 0.08038162993974078 1.829101156365493e-06 0.07946425488810546 \
1.829101295092791e-06 0.07854214404995859 1.829101440403653e-06 0.07758663187171365 1.829101588151466e-06 0.07662571164688473 1.829101746748333e-06 0.07560598447141591 \
1.829101911000851e-06 0.07456266320243836 1.829102080017927e-06 0.07350246718885647 1.829102261906921e-06 0.07237646636762114 1.829102462529019e-06 0.07115268999588262 \
1.829102676406562e-06 0.0698691158856425 1.829102904040694e-06 0.0685263410462881 1.829103145626235e-06 0.06712722147996912 1.829103427215414e-06 0.06552977831071743 \
1.829103724369534e-06 0.06388229915275011 1.829104047802611e-06 0.06213267023812474 1.829104438962031e-06 0.0600758559534558 1.829104840456333e-06 0.05803293250078725 \
1.829105217397059e-06 0.05617754872181892 1.829105584510791e-06 0.05442503025024555 1.829105934627471e-06 0.05280240270907886 1.829106253933124e-06 0.05136309724710254 \
1.829106558257407e-06 0.05002640192327024 1.829106855163312e-06 0.04875503464657577 1.829107137163638e-06 0.04757867888787161 1.829107417596943e-06 0.04643900623749339 \
1.829107682320567e-06 0.04538777697325767 1.829107958218279e-06 0.04431704973151576 1.829108232683143e-06 0.04327654260273706 1.829108531102423e-06 0.04217254828989973 \
1.82910875761848e-06 0.04135316230013186 1.829109069531317e-06 0.04025053053625379 1.829109289786109e-06 0.03948972371590862 1.829109507050863e-06 0.03875470657060948 \
1.829109716773512e-06 0.03806113111453101 1.8291100269559e-06 0.03705828856757609 1.829110249553778e-06 0.03635538859683734 1.829110496919279e-06 0.03559019656168042 \
1.829110769325655e-06 0.03476651972027592 1.829110989958209e-06 0.03411384091885184 1.82911127423846e-06 0.03329124852897781 1.829111512151752e-06 0.0326183788879464 \
1.829111750241163e-06 0.03195887699386461 1.829111985496491e-06 0.03132132139405813 1.829112214275198e-06 0.03071728735992773 1.829112447005948e-06 0.03011490821398154 \
1.829112666308989e-06 0.02955843195412813 1.829112870252059e-06 0.02905055018162466 1.829113269161795e-06 0.02808303002558106 1.829113456316051e-06 0.02764052191221165 \
1.829113828521772e-06 0.0267814187683372 1.829114015473295e-06 0.02635997027055515 1.829114384827241e-06 0.02554620807076183 1.82911453848041e-06 0.02521471147941385 \
1.829114954694564e-06 0.02434161493068329 1.829115160182381e-06 0.02392065165079968 1.829115499190341e-06 0.02323955384462723 1.829115681885069e-06 0.02287916718068597 \
1.829116138978978e-06 0.02199597290476789 1.829116268719714e-06 0.02174967209293581 1.829116722140137e-06 0.02089828923199067 1.82911686451243e-06 0.0206336680476187 \
1.82911739407919e-06 0.01967289368906444 1.829117520286197e-06 0.01945139161001456 1.829118082520635e-06 0.01850749734048266 1.829118245259022e-06 0.01824627541187189 \
1.829118809439087e-06 0.01738327200207762 1.829118961183154e-06 0.01716165742474803 1.829119662862638e-06 0.01618760396393164 1.829119832951728e-06 0.01596324388168 \
1.829120488009604e-06 0.01513221026437959 1.829120654523916e-06 0.01492874613340729 1.829121387637676e-06 0.01406966818047924 1.829121520900854e-06 0.01391906482409888 \
1.829122372558029e-06 0.01299647369571925 1.829122510500477e-06 0.01285324185793544 1.829123450559967e-06 0.0119198170026788 1.829123614321604e-06 0.01176347583728811 \
1.829124601555038e-06 0.01085909507266535 1.829124736144114e-06 0.0107410715025141 1.829125877583544e-06 0.009819907073012045 1.829125985822443e-06 0.009738548299709823 \
1.829127309069827e-06 0.00880579379490502 1.829127441815525e-06 0.008718202093769473 1.82912896431665e-06 0.007760835273143199 1.829129076858719e-06 0.007690148685505111 \
1.829130769150306e-06 0.00669558715138598 1.829130909416891e-06 0.00662113250846694 1.829132982426194e-06 0.005629132576249021 1.82913317498771e-06 0.005545002188831318 \
1.829135385197559e-06 0.004656096148610405 1.829135791984232e-06 0.004507219767123045 1.829138613724208e-06 0.003590578528330178 1.829139135019959e-06 0.00344214578404881 \
1.829143347121009e-06 0.002447529662748036 1.829143899683877e-06 0.002340875287107731 1.829149782973417e-06 0.001359168649576994 1.829150032246415e-06 0.001311490127959886 \
1.829163182367465e-06 0.0003136950974005476 1.829163299150435e-06 0.0003112730584132499 1.858990000000011e-06 3.042397160644726e-06 1.902746667027013e-06 -0.0009024818035526668 \
1.902746739442629e-06 -0.001022682652537627 1.902747175467347e-06 -0.001858525046639076 1.90274726236173e-06 -0.002046124893065343 1.902747617065043e-06 -0.00288168582347465 \
1.902747716611644e-06 -0.003135075204051477 1.902747976881349e-06 -0.003828199033013717 1.90274811720375e-06 -0.004216406518003108 1.902748344689832e-06 -0.004856871791621592 \
1.902748481897271e-06 -0.005239031028659006 1.90274886679612e-06 -0.006187559915121 1.902748998893307e-06 -0.006423332025500122 1.902749687336335e-06 -0.005917035979538006 \
1.902749844265069e-06 -0.005202654566481615 1.902749971914231e-06 -0.004414133290428114 1.902750099456022e-06 -0.003433350487145549 1.902750217130233e-06 -0.002355902309038119 \
1.90275031626992e-06 -0.001320627313728655 1.90275042165263e-06 -9.507383675133965e-05 1.902750535559933e-06 0.001369964538583592 1.902750666615329e-06 0.003229572948258866 \
1.902750791978547e-06 0.005172303930030842 1.902750983820411e-06 0.008432154569684791 1.902751127490204e-06 0.01107975669588844 1.902751285472017e-06 0.01417105828876112 \
1.902751434071664e-06 0.01723098336859398 1.902751587122593e-06 0.02051714008521248 1.902751746187569e-06 0.02405720796424875 1.902751899257778e-06 0.02756764950178633 \
1.902752047604842e-06 0.03105219347129199 1.902752196711284e-06 0.03462388853332505 1.902752351275713e-06 0.03838854885099419 1.902752511961677e-06 0.04235886888523473 \
1.902752676640863e-06 0.04647718198980624 1.902752853163807e-06 0.05093664320808645 1.902753032175606e-06 0.05549818742091989 1.902753222948448e-06 0.0603932190016783 \
1.9027534277958e-06 0.06567927942044927 1.902753648293053e-06 0.07139554989571946 1.902753881211021e-06 0.07745499876455469 1.902754130458799e-06 0.08395499695136356 \
1.902754403380327e-06 0.09108394918256098 1.902754700173383e-06 0.09884095133633181 1.902755027609896e-06 0.1073964775374675 1.902755397423694e-06 0.1170487607486894 \
1.902755792369975e-06 0.1273407304921971 1.902756250458528e-06 0.1392499850125259 1.902756782558388e-06 0.1530377249371455 1.902757408110397e-06 0.169180864038255 \
1.902758094102463e-06 0.1867931863309214 1.902758896945878e-06 0.2072766958045763 1.90275979625821e-06 0.2300508264895909 1.902760696698323e-06 0.2526618731709107 \
1.902761498589855e-06 0.2726215666318766 1.902762194096996e-06 0.2897857674353052 1.902762826931282e-06 0.3052728323588638 1.902763422339773e-06 0.3197161646377594 \
1.902763969382815e-06 0.3328722959176427 1.902764503143162e-06 0.3455929446372428 1.902765022382586e-06 0.3578476146335662 1.902765529774049e-06 0.3697097539883151 \
1.902766033395218e-06 0.3813674725871593 1.902766545138114e-06 0.3930934709428262 1.902767052299123e-06 0.404595334768291 1.902767582595137e-06 0.4164962117964878 \
1.902768068708626e-06 0.4272847049163567 1.902768546816947e-06 0.437781779057129 1.902768986249071e-06 0.4473362978389137 1.902769109408535e-06 0.4500002106608159 \
1.902769355727463e-06 0.4553046876287923 1.902769698999458e-06 0.4626558934952216 1.902770010436459e-06 0.4692815017887791 1.902770261147724e-06 0.4745855323881177 \
1.902770531976868e-06 0.480281321066213 1.902770868458777e-06 0.4873122872019196 1.902771224467388e-06 0.4946959640027882 1.902771541737556e-06 0.5012322602315481 \
1.902771780618105e-06 0.506122906570856 1.902772021646287e-06 0.5110269393752048 1.902772273577991e-06 0.5161276795544476 1.902772513731835e-06 0.5209621749612534 \
1.902772736483296e-06 0.5254248476203834 1.902772925040943e-06 0.5291850880529715 1.902773139790987e-06 0.5334523706207774 1.902773354339378e-06 0.5376948565446859 \
1.90277361310367e-06 0.5427871977552768 1.902773863931242e-06 0.5477009885064807 1.902774119350104e-06 0.5526782776843104 1.902774470392629e-06 0.5594898819265107 \
1.902774735000954e-06 0.5645984056527484 1.90277500141751e-06 0.569709962982798 1.90277526193182e-06 0.5746801970751495 1.902775529021882e-06 0.5797469183389945 \
1.902775772159962e-06 0.5843213438768613 1.902776027852189e-06 0.5890994944692448 1.902776255671159e-06 0.5933243819692556 1.902776493215979e-06 0.5976999800355528 \
1.902776704606465e-06 0.6015679915939678 1.902776916747224e-06 0.6054277082074113 1.902777105936602e-06 0.6088479815213901 1.90277723709492e-06 0.6112112531841202 \
1.902777369391478e-06 0.6135871094428261 1.902777554614204e-06 0.6169015645304802 1.902777716636591e-06 0.6197943209800671 1.902777875055755e-06 0.6226100751126036 \
1.902778009167621e-06 0.6249846001944386 1.902778181488729e-06 0.6280247049765127 1.902778310427531e-06 0.6302937061188456 1.902778430805044e-06 0.6324061607157294 \
1.902778571333915e-06 0.634864734791624 1.902778764419407e-06 0.6382321981637986 1.902778914230185e-06 0.6408363654380513 1.90277908153778e-06 0.6437327988167145 \
1.902779262592003e-06 0.6468572757970242 1.902779465918433e-06 0.6503523798695617 1.902779648771588e-06 0.6534819287355287 1.902779819395834e-06 0.6563879501053153 \
1.902779996860074e-06 0.6594029650344411 1.902780162839025e-06 0.6622113135173925 1.902780320075814e-06 0.6648594636266301 1.902780460561866e-06 0.6672075432495704 \
1.902780604291994e-06 0.6695987751186935 1.902780737338985e-06 0.6718055529208897 1.902780879311128e-06 0.6741523780906628 1.902780999371661e-06 0.6761293215200647 \
1.902781144309748e-06 0.6785098354674278 1.902781260306798e-06 0.6804095298668216 1.902781379886685e-06 0.6823647593763783 1.90278147884666e-06 0.68397755359623 \
1.902781597355078e-06 0.6859039329668146 1.90278168439936e-06 0.6873150904607619 1.902781806410179e-06 0.6892866586554622 1.902781905332791e-06 0.6908817703737582 \
1.902781997228166e-06 0.6923536807698466 1.902782097196705e-06 0.6939486118486815 1.902782195442366e-06 0.6955126686751646 1.902782287156128e-06 0.6969676095571918 \
1.90278239128907e-06 0.698613189139943 1.902782527015812e-06 0.7007470979739818 1.902782681624274e-06 0.7031613517373301 1.902782816731986e-06 0.7052558942641604 \
1.902782963068532e-06 0.7075085519458914 1.902783091536073e-06 0.7094732734147607 1.902783215720207e-06 0.7113609898537658 1.902783325624507e-06 0.7130225953369277 \
1.902783442207576e-06 0.7147759898693785 1.902783542385407e-06 0.7162749667021007 1.902783679474215e-06 0.7183149847558421 1.902783799463242e-06 0.7200901405411056 \
1.90278391857669e-06 0.7218426783097279 1.902784045072077e-06 0.723693513465353 1.902784170939449e-06 0.7255245570057045 1.902784293560468e-06 0.7272980597885179 \
1.902784421177991e-06 0.7291334326655684 1.902784551426783e-06 0.7309957624152177 1.902784673019733e-06 0.73272442801297 1.902784811788425e-06 0.7346853525547948 \
1.902784912196869e-06 0.7360963845229137 1.902785015584257e-06 0.7375412410987998 1.9027851092447e-06 0.7388443755773992 1.902785220866297e-06 0.7403895158541485 \
1.902785307334899e-06 0.7415798421827293 1.90278540819801e-06 0.7429609798983192 1.902785540294732e-06 0.7447573558536402 1.902785649496034e-06 0.7462323422761349 \
1.902785754027664e-06 0.747635567415085 1.902785877674145e-06 0.7492836897664436 1.90278602637058e-06 0.7512497161812216 1.902786148251239e-06 0.7528480713857697 \
1.902786261855803e-06 0.7543274008692354 1.902786402375488e-06 0.7561429069656862 1.90278654356493e-06 0.7579511824827749 1.902786661311106e-06 0.7594470562859095 \
1.902786790000766e-06 0.7610693809796742 1.902786932555413e-06 0.7628512182523866 1.902787048411964e-06 0.7642872416835913 1.90278719417523e-06 0.7660789429779771 \
1.902787316007677e-06 0.7675637574673733 1.902787434476374e-06 0.7689965471136999 1.902787557264006e-06 0.7704700089613156 1.902787683416889e-06 0.7719718272910862 \
1.902787793785939e-06 0.7732757954107932 1.902787919217035e-06 0.7747465774777432 1.902788024698746e-06 0.775974259539018 1.902788157865176e-06 0.7775122819577122 \
1.902788280546631e-06 0.7789173428708996 1.902788415309674e-06 0.7804473432620218 1.902788525980962e-06 0.7816923373676121 1.902788635302591e-06 0.7829118427552927 \
1.902788770435025e-06 0.7844048889494442 1.90278892121405e-06 0.7860523747618094 1.902789061582958e-06 0.7875692293014268 1.902789181294483e-06 0.7888502570533434 \
1.902789319548823e-06 0.7903153082715967 1.902789442919159e-06 0.7916096503654788 1.902789588017784e-06 0.7931164937536124 1.902789727758043e-06 0.7945521172774316 \
1.902789854939467e-06 0.7958455533278409 1.90278997397922e-06 0.7970449251022731 1.902790086337411e-06 0.7981670522831598 1.90279019056619e-06 0.79919939674296 \
1.902790285905002e-06 0.8001364844871954 1.902790422193112e-06 0.8014634245741865 1.902790539085656e-06 0.8025894467082511 1.902790658725145e-06 0.8037305025474466 \
1.902790780606717e-06 0.8048811831579785 1.902790902985054e-06 0.8060245537852575 1.902791031013733e-06 0.8072081965553952 1.902791155658532e-06 0.8083483262222385 \
1.902791286157279e-06 0.8095291977395493 1.902791412617707e-06 0.8106611567088965 1.902791539743675e-06 0.8117869190804841 1.902791644861151e-06 0.8127087429624065 \
1.902791750111341e-06 0.8136235164943317 1.902791841251591e-06 0.8144090748259969 1.902791964669625e-06 0.8154632009865571 1.902792051748274e-06 0.8162003374872545 \
1.902792151070959e-06 0.8170344894488412 1.902792295992703e-06 0.8182390501293432 1.902792432261206e-06 0.8193582434421302 1.902792541723485e-06 0.8202477434185359 \
1.902792687843586e-06 0.8214214001843773 1.902792839202198e-06 0.8226208465286928 1.90279296500612e-06 0.8236052915965452 1.902793109416779e-06 0.824721541823094 \
1.902793234017729e-06 0.8256729463037898 1.902793384729791e-06 0.8268094083523665 1.90279352010105e-06 0.8278169867326588 1.902793645303979e-06 0.8287379047458127 \
1.902793762973362e-06 0.829593908450195 1.902793908801339e-06 0.8306418458276996 1.90279407529732e-06 0.8318207857986918 1.902794206154408e-06 0.8327345044534114 \
1.902794379603848e-06 0.833928356718921 1.902794547722322e-06 0.8350667646575466 1.902794717596124e-06 0.8361988603660855 1.902794898450754e-06 0.8373843006762304 \
1.902795041633135e-06 0.8383085120571983 1.902795155746479e-06 0.8390361588138326 1.90279528581247e-06 0.8398559950134801 1.902795387687706e-06 0.8404909448220066 \
1.902795504566998e-06 0.8412116130393378 1.902795641678929e-06 0.8420465258793415 1.902795839559572e-06 0.843231707656198 1.902796031345765e-06 0.8443585547012582 \
1.902796240708828e-06 0.8455646258450146 1.902796422822406e-06 0.846593677725298 1.902796619917178e-06 0.8476867969181797 1.902796793185875e-06 0.8486305714188691 \
1.902796976264561e-06 0.8496104335327738 1.902797147401587e-06 0.8505103231661706 1.902797322080438e-06 0.8514128411730317 1.902797497318728e-06 0.8523022053693007 \
1.902797673458367e-06 0.8531802340241421 1.902797863809624e-06 0.8541115036082744 1.90279805438677e-06 0.855025905954957 1.902798254818193e-06 0.8559685891497206 \
1.902798447410669e-06 0.8568563992305701 1.902798658273806e-06 0.8578086227668252 1.902798886187182e-06 0.8588150784816577 1.902799152217719e-06 0.8599606428795262 \
1.902799450738801e-06 0.8612090806949765 1.902799726692481e-06 0.8623286542354505 1.902800010954596e-06 0.8634483918036945 1.902800285103046e-06 0.8644969441068078 \
1.902800557392313e-06 0.8655088801415273 1.902800827558089e-06 0.8664846790737442 1.902801084736186e-06 0.8673881555543895 1.902801357299353e-06 0.868319368003445 \
1.902801633304697e-06 0.8692355072818493 1.902801903418629e-06 0.870106770567397 1.902802203245002e-06 0.8710447971670072 1.902802574222291e-06 0.8721640818024149 \
1.902802869154012e-06 0.8730224021943973 1.902803123432376e-06 0.873740732376842 1.902803421677207e-06 0.8745584461000401 1.902803695285219e-06 0.8752856917963749 \
1.902803931415444e-06 0.8758961959341748 1.902804171760979e-06 0.8765017794770257 1.902804394097168e-06 0.8770481951318053 1.90280458810245e-06 0.8775144010549708 \
1.902804917823794e-06 0.8782846129827527 1.902805072996819e-06 0.8786376896881318 1.902805390752408e-06 0.8793424631377607 1.902805569616983e-06 0.8797286397841958 \
1.902805912078462e-06 0.8804474051285093 1.902806096217817e-06 0.880822800830328 1.902806571118475e-06 0.881756283451624 1.902806738513154e-06 0.8820737784441692 \
1.9028072043462e-06 0.8829272622221894 1.902807385170493e-06 0.8832470363605239 1.902807879204793e-06 0.8840891816604841 1.902808020548669e-06 0.8843218944112644 \
1.902808626940586e-06 0.8852805359894154 1.902808779011766e-06 0.8855111592597558 1.902809425691436e-06 0.8864506941541785 1.902809553987642e-06 0.8866295550025313 \
1.902810202164815e-06 0.8874976172723908 1.902810331923675e-06 0.8876644392549727 1.902811100144497e-06 0.8886037370453904 1.902811229881009e-06 0.8887539063021698 \
1.902812083306654e-06 0.8896836309705964 1.902812226565088e-06 0.8898301468060963 1.902813212785821e-06 0.890764641901611 1.902813434267227e-06 0.8909571971396437 \
1.902814577308628e-06 0.8918770673440963 1.902814707298117e-06 0.8919774876506176 1.902816058923389e-06 0.8929731820841386 1.90281620928357e-06 0.89307657739048 \
1.902817689916169e-06 0.8939986636922405 1.902817928817934e-06 0.8941315911431026 1.902819693311633e-06 0.894999985510941 1.902820000994978e-06 0.8951330875684044 \
1.902822522266181e-06 0.8960612226716312 1.902822959317422e-06 0.8961978289811912 1.902826862729643e-06 0.8971619289239613 1.90282710951145e-06 0.8972094058147089 \
1.902834686001284e-06 0.8981998139535015 1.902834801913031e-06 0.8982099955090975 1.902853900445735e-06 0.8992062631372056 1.902854297888509e-06 0.8992194728667773 \
1.90300471332359e-06 0.9002121614362558 1.903004979381947e-06 0.9002436812458944 1.903010247532015e-06 0.8993470931706574 1.903010453902932e-06 0.899191170936528 \
1.903011932015742e-06 0.8982046351054961 1.903012112466398e-06 0.8981003355419954 1.903014334948061e-06 0.8971299612768925 1.903014541040576e-06 0.897079983173831 \
1.903024949306681e-06 0.8980580240048047 1.903025087164257e-06 0.8980839755683444 1.903031884513298e-06 0.8990685088718567 1.903032070084766e-06 0.8990874390200084 \
1.903528299258968e-06 0.9000706848616691 1.903528359054814e-06 0.9000975977971888 1.903529612605432e-06 0.9010828413531861 1.903529718298035e-06 0.9012097231395001 \
1.903530376428752e-06 0.9021613947651476 1.903530513611021e-06 0.9023918767045529 1.903531036637641e-06 0.9033649777562528 1.903531099501233e-06 0.9034908765919824 \
1.903531572096782e-06 0.904476514442582 1.903531623410596e-06 0.9045863669199017 1.903532089373931e-06 0.9055619780118375 1.903532121578392e-06 0.9056252631670594 \
1.903532838677129e-06 0.9066212416280413 1.903532923113402e-06 0.9066528951765993 1.903533523179781e-06 0.9059679814895146 1.903533643037393e-06 0.9055903401525059 \
1.903533774200172e-06 0.9050640446667092 1.903533909019925e-06 0.9043926011431642 1.903534057154984e-06 0.9034897747335404 1.903534194714335e-06 0.902493211317788 \
1.903534334926095e-06 0.9013135799985507 1.903534433588205e-06 0.9003872218501816 1.903534519272014e-06 0.8995148096066522 1.903534601836213e-06 0.8986166894493001 \
1.903534716618842e-06 0.8972773101170661 1.903534797717086e-06 0.8962642459447687 1.903534877134364e-06 0.8952218112132616 1.903534982588892e-06 0.8937633947192651 \
1.903535105230195e-06 0.8919606744930825 1.903535204954274e-06 0.890414036797163 1.903535375148685e-06 0.8876203405523397 1.903535521333777e-06 0.8850727273800474 \
1.903535689551925e-06 0.8819879035815887 1.903535861713021e-06 0.8786780617039783 1.903536046099114e-06 0.8749807502679057 1.903536230665458e-06 0.8711418063496947 \
1.903536414912944e-06 0.8671917613865908 1.903536600248607e-06 0.8631174608718694 1.903536774636335e-06 0.8592060069639053 1.903536957340272e-06 0.8550405244181323 \
1.903537132687366e-06 0.8509893565349284 1.903537315016877e-06 0.8467313026054767 1.903537505330306e-06 0.8422468264612591 1.903537675660435e-06 0.838204894125699 \
1.903537842184074e-06 0.8342320488410089 1.903538004754937e-06 0.830337741667393 1.90353815461616e-06 0.8267359097041467 1.903538305792179e-06 0.8230937075736249 \
1.903538494937653e-06 0.8185270080344306 1.903538640655707e-06 0.8150026134285653 1.903538815646674e-06 0.8107652770601156 1.903538964118217e-06 0.807166938184282 \
1.903539136005683e-06 0.8029987283123258 1.903539305073922e-06 0.7988973224349885 1.903539469252632e-06 0.7949140139776875 1.903539628580169e-06 0.7910485911592836 \
1.903539789029776e-06 0.7871568543472617 1.903539990849157e-06 0.7822630953020117 1.903540139296892e-06 0.7786646206504594 1.903540293464276e-06 0.77492821376164 \
1.903540430547636e-06 0.7716074476660475 1.903540539933082e-06 0.7689587163513494 1.903540645866538e-06 0.7663946531324515 1.903540772880885e-06 0.7633217481666642 \
1.903540887243854e-06 0.7605561828888391 1.903540990091676e-06 0.7580702160470256 1.903541111681993e-06 0.7551325442760125 1.903541222459267e-06 0.7524575925939972 \
1.903541339308092e-06 0.7496376180588871 1.903541450092818e-06 0.7469652567786068 1.903541568458919e-06 0.7441116745915923 1.903541693286014e-06 0.7411038668912771 \
1.90354184584781e-06 0.7374292753756717 1.903541979744798e-06 0.7342062928952946 1.903542100776237e-06 0.7312947572377408 1.903542264973752e-06 0.7273475399259534 \
1.903542442334699e-06 0.7230877912371642 1.903542624545107e-06 0.7187161681757385 1.903542805542373e-06 0.7143786395952922 1.903542986206316e-06 0.7100537072471783 \
1.903543176357883e-06 0.7055071781827296 1.903543364117777e-06 0.7010230964996226 1.903543564650881e-06 0.696237807975249 1.903543773336343e-06 0.6912646166759551 \
1.903543980979908e-06 0.6863227581165517 1.903544208547776e-06 0.6809140411171237 1.90354440082261e-06 0.6763521085712711 1.903544638087858e-06 0.6707310800019505 \
1.903544831366122e-06 0.6661595641347996 1.903545064098869e-06 0.6606646229758047 1.903545269656336e-06 0.6558174602470968 1.903545502009757e-06 0.6503484594495911 \
1.903545697011728e-06 0.6457674053103037 1.903545900240336e-06 0.6410004262200759 1.903546080092881e-06 0.6367906205544323 1.903546259199312e-06 0.6326052789263827 \
1.903546422576526e-06 0.628795088826817 1.90354659462593e-06 0.6247880828503264 1.903546758118769e-06 0.6209892715878097 1.903546933908587e-06 0.6169100951581823 \
1.903547115847573e-06 0.6126978430086294 1.903547304331305e-06 0.6083422542008314 1.903547510763727e-06 0.6035858951323969 1.90354769007839e-06 0.5994633272559844 \
1.903547887257256e-06 0.5949432360761027 1.903548096345397e-06 0.5901646611556908 1.90354830209466e-06 0.5854760387944159 1.903548542605348e-06 0.5800160304866983 \
1.90354871573345e-06 0.5760958285528379 1.903548880627452e-06 0.5723746772837877 1.903549061488027e-06 0.5683014035092815 1.903549218774123e-06 0.5647722902613652 \
1.903549387756918e-06 0.5609879409349005 1.903549567863379e-06 0.5569709657351898 1.903549720846506e-06 0.5535669615732179 1.903549852560951e-06 0.5506462283231492 \
1.903549999948651e-06 0.5473865746199473 1.903550087374242e-06 0.5454560063082221 1.903550172245482e-06 0.5435860258811447 1.903550270874694e-06 0.5414171943998213 \
1.903550342966855e-06 0.5398340751058975 1.903550440057874e-06 0.5377039800781129 1.903550525648258e-06 0.5358302678688993 1.903550590729134e-06 0.5344081412607664 \
1.903550714329502e-06 0.5317121235594142 1.903550808753772e-06 0.52965475734789 1.903550906276994e-06 0.5275349985745696 1.903551079137645e-06 0.5237893654184622 \
1.903551214133166e-06 0.5208709659121862 1.903551368316628e-06 0.5175498113398643 1.903551542781984e-06 0.5138002600288881 1.90355169458797e-06 0.510550000123414 \
1.903551840818953e-06 0.5074290310664136 1.903551984717826e-06 0.5043644611166801 1.903552127739669e-06 0.5013276181140283 1.903552223349517e-06 0.499301733014788 \
1.903552317793473e-06 0.4973032961550828 1.903552438849414e-06 0.4947494705229025 1.90355253372771e-06 0.4927525559781179 1.903552649558553e-06 0.4903172469328811 \
1.903552736822402e-06 0.4884854516151125 1.903552819252848e-06 0.4867593351188191 1.903552914660801e-06 0.484765406725184 1.903553015371081e-06 0.4826639978995959 \
1.903553112231473e-06 0.4806459052877932 1.903553250961225e-06 0.4777646955734051 1.903553386666086e-06 0.4749532752442271 1.903553587150809e-06 0.4708139964547478 \
1.903553802464962e-06 0.4663911383470885 1.903553984040267e-06 0.462674698484628 1.903554183012236e-06 0.4586189944293299 1.903554353577757e-06 0.455154096457448 \
1.903554527931445e-06 0.4516251957269069 1.903554696864699e-06 0.4482170126441485 1.90355486946186e-06 0.4447467276163349 1.90355505206819e-06 0.4410867902598327 \
1.903555240617055e-06 0.4373240875354826 1.903555434084593e-06 0.4334777823509549 1.903555642405232e-06 0.4293535036700135 1.903555856750462e-06 0.4251286740881063 \
1.903556082455792e-06 0.4207018662297695 1.90355630899916e-06 0.4162771402745992 1.903556571175911e-06 0.4111844468197049 1.903556820209735e-06 0.4063709766754009 \
1.903557121308433e-06 0.4005865607947761 1.90355741072925e-06 0.3950673729298416 1.903557718243529e-06 0.3892455819062323 1.903558040439924e-06 0.3831936848847286 \
1.903558368170407e-06 0.3770882112794804 1.903558700600163e-06 0.3709500980558715 1.90355903032917e-06 0.3649083177186754 1.903559351558758e-06 0.3590729273462687 \
1.903559682375082e-06 0.3531219177045733 1.903560024730645e-06 0.3470224718704957 1.903560324371677e-06 0.3417374346434491 1.903560654159242e-06 0.3359723367088904 \
1.903560981053185e-06 0.3303128110141857 1.903561319032532e-06 0.3245206193888226 1.903561628003696e-06 0.3192755432624759 1.903561952801669e-06 0.31382336954194 \
1.903562268431866e-06 0.3085864885517507 1.903562573419032e-06 0.3035810258414895 1.903562828757677e-06 0.2994330834535801 1.903563093620834e-06 0.295170851203172 \
1.903563380703519e-06 0.2905978071194348 1.903563603673297e-06 0.2870801635277143 1.903563803212566e-06 0.2839591363066187 1.90356401286858e-06 0.2807045410859125 \
1.903564193125121e-06 0.2779290029372279 1.903564355469842e-06 0.2754463208250681 1.903564505904816e-06 0.2731629026725527 1.903564656910124e-06 0.2708866524077067 \
1.903564853800715e-06 0.2679392949564011 1.903564984945479e-06 0.2659970646012914 1.903565109682017e-06 0.2641561221543183 1.90356526127406e-06 0.2619266655689588 \
1.903565357242231e-06 0.2605306204207966 1.9035654537936e-06 0.2591282589302421 1.903565578413389e-06 0.2573209601776467 1.903565720989923e-06 0.255257422470362 \
1.903565879923458e-06 0.25296979123958 1.903566012589525e-06 0.251062957019046 1.903566196158294e-06 0.2484301322588876 1.90356637739346e-06 0.2458327969660818 \
1.903566588907564e-06 0.2428051031600066 1.903566791497399e-06 0.2399069804317323 1.903566958053847e-06 0.2375282895552967 1.903567168273059e-06 0.2345337828133105 \
1.903567341690945e-06 0.2320692345528927 1.903567570533673e-06 0.2288260787734411 1.903567791168424e-06 0.2257162440502939 1.903567966830138e-06 0.2232503232699662 \
1.903568147290643e-06 0.2207258962977968 1.903568318047021e-06 0.2183528725291195 1.903568498243287e-06 0.2158619697278009 1.903568664973905e-06 0.2135675266585953 \
1.903568814095326e-06 0.2115251542210239 1.903568969905344e-06 0.2094125291275523 1.903569105085769e-06 0.2075875692769576 1.903569255167197e-06 0.2055694209972212 \
1.903569387612823e-06 0.2037957203154137 1.90356952815736e-06 0.2019220745191926 1.903569645226124e-06 0.2003748851744883 1.90356977493373e-06 0.1986681706274326 \
1.903569896991199e-06 0.1970700654731777 1.903570019534635e-06 0.1954731161836187 1.903570137553958e-06 0.1939418157697267 1.903570272576731e-06 0.1921981789937757 \
1.903570417201182e-06 0.1903420634523806 1.903570545551681e-06 0.1887049708672087 1.903570669186156e-06 0.1871351133418249 1.903570766736279e-06 0.1859021016257166 \
1.903570881809208e-06 0.1844539912642748 1.903570975507888e-06 0.1832809848801438 1.903571074292012e-06 0.1820493959460708 1.903571197226553e-06 0.1805230483556907 \
1.903571292980556e-06 0.1793400249325384 1.903571422068107e-06 0.177753298391591 1.903571524533477e-06 0.1764993061988986 1.903571622786974e-06 0.1753029542432101 \
1.903571742874187e-06 0.1738483570896001 1.903571845423405e-06 0.1726127298531683 1.903571955881064e-06 0.1712877101305652 1.903572084370928e-06 0.1697552709290656 \
1.903572175855769e-06 0.1686698090598139 1.903572280340358e-06 0.1674358120019214 1.903572355277094e-06 0.1665544493622226 1.903572444845591e-06 0.1655049734124585 \
1.9035724954106e-06 0.164914347906921 1.903572545388976e-06 0.1643318187475747 1.903572610358061e-06 0.163576534137217 1.903572645872029e-06 0.1631646263336159 \
1.903572718071202e-06 0.162329174921529 1.903572785200297e-06 0.1615546732967998 1.903572844430032e-06 0.160873195114598 1.90357288817563e-06 0.1603710314414745 \
1.903572935822458e-06 0.1598254649913795 1.903573006202993e-06 0.1590230739426561 1.903573088541159e-06 0.1580883269013631 1.903573166712759e-06 0.1572048664554128 \
1.903573248765708e-06 0.1562816770844126 1.903573341469331e-06 0.1552436243401225 1.903573464249495e-06 0.153877370231325 1.903573563395588e-06 0.1527810927807017 \
1.903573664895935e-06 0.1516651170047695 1.903573766171126e-06 0.1505582666538253 1.903573862662911e-06 0.1495093242781697 1.903573962080946e-06 0.1484346886615803 \
1.903574046381569e-06 0.1475281828465028 1.903574139320259e-06 0.1465342051547719 1.9035742219212e-06 0.1456551508734999 1.903574330687285e-06 0.1445034822456445 \
1.903574436330265e-06 0.1433917535370727 1.903574517989854e-06 0.1425365900703354 1.903574611735024e-06 0.1415598856352903 1.903574705302971e-06 0.1405903867550886 \
1.903574788187461e-06 0.139735765814107 1.903574876346636e-06 0.1388313836440244 1.903574956132722e-06 0.1380170907865772 1.903575049728122e-06 0.1370669869522621 \
1.903575139660646e-06 0.1361590166429519 1.903575210211042e-06 0.1354501541392388 1.903575279971219e-06 0.1347521119166949 1.903575394120126e-06 0.1336164586193709 \
1.90357547609874e-06 0.1328058651355588 1.903575563704042e-06 0.1319440719770354 1.903575663205238e-06 0.1309710196939938 1.903575772385241e-06 0.1299110174488692 \
1.903575874550573e-06 0.1289256009328031 1.903575982010779e-06 0.1278959836800649 1.903576102045057e-06 0.1267549558890445 1.903576196253091e-06 0.1258657925752028 \
1.903576327232195e-06 0.1246390638240933 1.903576426659896e-06 0.1237164070883829 1.903576535781582e-06 0.1227104370444639 1.90357664463475e-06 0.1217138859540913 \
1.903576736944154e-06 0.120874257454373 1.903576849784484e-06 0.1198547128626846 1.903576946796524e-06 0.118986084968971 1.903577051062872e-06 0.1180628196869088 \
1.903577160029802e-06 0.1171053395831002 1.903577259569368e-06 0.1162371554254778 1.903577376562078e-06 0.1152245300989246 1.903577463662868e-06 0.1144761644999183 \
1.90357757295452e-06 0.1135478691973115 1.903577654479583e-06 0.1128618460838699 1.903577754254576e-06 0.1120273350449922 1.903577871679726e-06 0.1110526766231405 \
1.903577973464844e-06 0.1102143708571793 1.903578061203792e-06 0.1094962336869811 1.9035781420033e-06 0.1088432886892514 1.903578228954319e-06 0.1081456845520918 \
1.903578309740945e-06 0.1075007757815706 1.903578399947511e-06 0.1067842832273628 1.903578490898266e-06 0.1060655611559195 1.90357857956879e-06 0.1053685613006139 \
1.903578678583611e-06 0.1045946508745568 1.903578772289787e-06 0.1038723470842792 1.903578866149063e-06 0.1031520741219857 1.903578966976511e-06 0.1023817709659086 \
1.903579071607409e-06 0.1015861061604995 1.903579195570165e-06 0.1006484085638475 1.903579292969478e-06 0.09991551135558702 1.903579413227425e-06 0.09901872452754552 \
1.9035795240953e-06 0.09819831936474602 1.903579628568336e-06 0.09742874659471555 1.903579745805045e-06 0.09656937225591002 1.903579847599366e-06 0.09582695326576983 \
1.903579945574917e-06 0.09511577589263259 1.903580086079406e-06 0.09410164141823299 1.903580191157202e-06 0.09334832721827611 1.903580289770019e-06 0.09264549593674179 \
1.903580382484827e-06 0.09198739948435641 1.903580468683212e-06 0.09137785861853052 1.903580562596188e-06 0.09071637432184691 1.903580659696934e-06 0.09003559055802626 \
1.903580769117988e-06 0.08927317549644689 1.903580870101537e-06 0.08857281843916648 1.903580963759483e-06 0.08792605868920525 1.903581037934155e-06 0.08741581771673042 \
1.903581175834007e-06 0.08647193599618339 1.903581248191011e-06 0.08597917321277694 1.903581383512214e-06 0.08506274029062395 1.903581469423819e-06 0.08448410751389913 \
1.903581614152054e-06 0.08351486081643937 1.903581710382619e-06 0.0828744112740944 1.903581798218398e-06 0.08229260392026354 1.903581914017306e-06 0.08152964121883956 \
1.903582029145757e-06 0.08077575264951149 1.90358214291219e-06 0.08003553900012179 1.903582283169683e-06 0.0791300282244784 1.903582424545716e-06 0.07822490276368012 \
1.903582574181758e-06 0.07727536491519127 1.903582718670613e-06 0.07636690312463701 1.903582869844724e-06 0.07542565384097814 1.903583019215543e-06 0.07450459906593411 \
1.903583168562251e-06 0.0735926433331697 1.903583328517767e-06 0.07262574717347114 1.903583484664678e-06 0.07169171823582712 1.903583659153112e-06 0.07065947636250877 \
1.903583828862219e-06 0.0696671357044583 1.903584014041303e-06 0.0685979885997255 1.90358421076238e-06 0.06747763456279594 1.9035844212802e-06 0.06629631776014881 \
1.903584643312255e-06 0.06507007089066431 1.903584873524276e-06 0.0638195278444372 1.903585116035382e-06 0.06252626147401 1.903585376689467e-06 0.06116236403900636 \
1.903585656588531e-06 0.05972739422233359 1.903585950172255e-06 0.05825544847408989 1.903586265108239e-06 0.05671370145268265 1.903586607914164e-06 0.05507846134953124 \
1.903586957380758e-06 0.0534565727116736 1.903587366284915e-06 0.05161746230842366 1.903587712949942e-06 0.05010669351290297 1.903588100364996e-06 0.04846839895323611 \
1.903588444582788e-06 0.04705645202362623 1.903588768009047e-06 0.04576625679949029 1.903589073054809e-06 0.04458093278443617 1.903589365916806e-06 0.04347099288378908 \
1.903589650057723e-06 0.04242242262004604 1.903589926078015e-06 0.04142902112907627 1.903590192930566e-06 0.04049015932812138 1.903590461822789e-06 0.03956531631184226 \
1.903590737883211e-06 0.03863769040165695 1.903591025478782e-06 0.03769451689421055 1.903591265044408e-06 0.03692662498323904 1.903591554211835e-06 0.03602084344675294 \
1.903591770003438e-06 0.03535960341037672 1.903591957720476e-06 0.03479599077274986 1.903592155849582e-06 0.03421285035004928 1.903592518724446e-06 0.03317032497347058 \
1.903592776866276e-06 0.03244834222605905 1.90359308657919e-06 0.0316030971185694 1.903593352049329e-06 0.03089664771451467 1.903593620168408e-06 0.03019941363307669 \
1.903593899042439e-06 0.02949128999862272 1.903594145228876e-06 0.02888043298519722 1.903594375860285e-06 0.02832033800396738 1.903594614150204e-06 0.02775711540944564 \
1.903594849157568e-06 0.02721270742060762 1.903595076940031e-06 0.02669509678424227 1.903595485552303e-06 0.02579039168486155 1.903595661854632e-06 0.02540904040268441 \
1.903596016332316e-06 0.02465798827491217 1.903596200203288e-06 0.02427641469830137 1.90359653515201e-06 0.02359448510613503 1.903596699060727e-06 0.02326678168937357 \
1.903597091331304e-06 0.02249905491676728 1.903597247322069e-06 0.02220010404946675 1.903597678925426e-06 0.02138321689778962 1.903597816314806e-06 0.0211255367654138 \
1.903598333123589e-06 0.02017559010600388 1.903598458659483e-06 0.01995091418019728 1.903598915901007e-06 0.01915998482559782 1.903599075046989e-06 0.01889493739859509 \
1.903599682285467e-06 0.01793263500095189 1.903599816822955e-06 0.01772934138481063 1.903600480086948e-06 0.01678091027541291 1.903600673410379e-06 0.01651856846389665 \
1.903601341067039e-06 0.01565087920017967 1.903601502655887e-06 0.01544858341705342 1.90360225789114e-06 0.01454101846553843 1.903602407452107e-06 0.01436800730673201 \
1.903603297789931e-06 0.01338293844200974 1.903603396447817e-06 0.01327873262558703 1.903604353121314e-06 0.01230993787860994 1.903604474231021e-06 0.01219243157195396 \
1.90360546572373e-06 0.01126376273051215 1.90360562925246e-06 0.01111855113153209 1.903606759174536e-06 0.01018247077230436 1.903606871621774e-06 0.01009565848301377 \
1.903608249445262e-06 0.009103273453806031 1.903608388390533e-06 0.009009747578659758 1.903609942788868e-06 0.008018073335410726 1.90361005485534e-06 0.00794673960805117 \
1.90361169983817e-06 0.006958154532207958 1.903611807090664e-06 0.006899512253112593 1.903613751584152e-06 0.005937533026687714 1.90361395848211e-06 0.005843834961138424 \
1.903616297369852e-06 0.00487227039639981 1.903616721356264e-06 0.004712306502041247 1.90361949358946e-06 0.003780857497341114 1.903619941898552e-06 0.003647790772321777 \
1.903623582397237e-06 0.00272553831825111 1.903624079053072e-06 0.002619503085887757 1.903629830173496e-06 0.001650572925599863 1.903630116955382e-06 0.001609446887446839 \
1.903635471944067e-06 0.0006353228983793809 1.903635677300692e-06 0.0005920420449145349 1.906282712074507e-06 -0.0002718533828215428 1.906282867950111e-06 -0.0004579010352009555 \
1.906283416265203e-06 -0.001326296959495401 1.906283529048879e-06 -0.001543805653187533 1.906283963541018e-06 -0.002491429791030493 1.906284039366175e-06 -0.002673591589873599 \
1.906284396016773e-06 -0.003590195133438418 1.906284523065853e-06 -0.003936807634339821 1.906284801566247e-06 -0.004716444651655622 1.90628490965073e-06 -0.005020876868076652 \
1.906285253249855e-06 -0.00592430224391268 1.90628536024372e-06 -0.006162325733041658 1.906286259614116e-06 -0.005653094509861465 1.906286438047545e-06 -0.004687598829536962 \
1.90628654377096e-06 -0.003940993102967527 1.906286668833738e-06 -0.002883597584075996 1.906286762417834e-06 -0.001971418478057775 1.906286840257396e-06 -0.001132968824455395 \
1.906286920329394e-06 -0.0001977429743171 1.906287042702205e-06 0.001370578777960296 1.906287160958077e-06 0.003041212838230153 1.906287279607187e-06 0.004860750887681821 \
1.906287393089626e-06 0.006730904986417607 1.906287496532764e-06 0.008536402178002854 1.906287611192018e-06 0.01064190690353853 1.906287801775811e-06 0.0143607330143792 \
1.906287935565949e-06 0.01711819191720031 1.906288085819515e-06 0.02033933849841947 1.906288240988762e-06 0.02378599874269359 1.906288396380811e-06 0.0273434151175349 \
1.906288544088043e-06 0.03080849965087477 1.906288693077668e-06 0.03437359286003162 1.906288848068751e-06 0.03814545786868043 1.906289007439365e-06 0.04208062121327779 \
1.906289172372776e-06 0.04620305710844342 1.906289347319104e-06 0.0506208066052034 1.906289526449176e-06 0.05518387280380205 1.906289716238432e-06 0.06005265756871143 \
1.9062899199354e-06 0.06530840376289772 1.906290139745932e-06 0.07100650943730057 1.906290371497376e-06 0.07703584544314998 1.906290619322674e-06 0.08349927754587044 \
1.906290890643603e-06 0.09058756662233436 1.906291185356381e-06 0.09829181712822582 1.906291510614029e-06 0.106792896697727 1.906291876859735e-06 0.1163551101154179 \
1.906292270156448e-06 0.1266079356677421 1.906292722809344e-06 0.1383809089651769 1.906293248524511e-06 0.1520098384503803 1.906293867738049e-06 0.1679979965193872 \
1.906294548482366e-06 0.1854865650013753 1.90629534215732e-06 0.2057488551561759 1.906296230922953e-06 0.2282732214494322 1.906297044312215e-06 0.2487218262351868 \
1.906297766061792e-06 0.2667261628598245 1.9062984017258e-06 0.282460740414376 1.906298973442562e-06 0.2965101025186013 1.906299508996846e-06 0.3095696210007924 \
1.906300012355259e-06 0.3217495654069301 1.906300488682702e-06 0.3331878525640654 1.906300962606306e-06 0.3444754071334732 1.906301420078024e-06 0.3552759747331513 \
1.906301886058294e-06 0.3661792384270033 1.906302335046104e-06 0.376592601923634 1.906302831152646e-06 0.3879857357798637 1.906303350914508e-06 0.3998002499051578 \
1.906303730319152e-06 0.4083447473225827 1.906304170327876e-06 0.4181679450526055 1.906304640096813e-06 0.4285466970600206 1.906305125617752e-06 0.4391589006481625 \
1.906305565065858e-06 0.4486701556983262 1.906305626818807e-06 0.4500002248264944 1.906305750324704e-06 0.4526540461147197 1.906305997336498e-06 0.4579447795386873 \
1.906306249931409e-06 0.463325462421476 1.906306447502524e-06 0.467511453725808 1.906306673074271e-06 0.4722681264242033 1.906306994642268e-06 0.4790073975813253 \
1.906307263421497e-06 0.4846013351959894 1.90630748207297e-06 0.4891262574467725 1.906307692176936e-06 0.4934547887280634 1.906307918582462e-06 0.4980921872304203 \
1.906308127687652e-06 0.5023516957637455 1.906308317089911e-06 0.5061927337048852 1.906308441251129e-06 0.5086969563931187 1.906308568006226e-06 0.5112441466129884 \
1.906308728004704e-06 0.5144514110933732 1.906308975647656e-06 0.5193914248715521 1.906309154234115e-06 0.5229351592435862 1.906309325187692e-06 0.5263079149198099 \
1.906309586537288e-06 0.5314455197962068 1.90630981260887e-06 0.5358634945234868 1.906310015740537e-06 0.5398188128751134 1.906310180971267e-06 0.5430252218652345 \
1.906310337758288e-06 0.5460612552756139 1.906310526914905e-06 0.5497137532216215 1.906310728782658e-06 0.5535976061995346 1.906310952933981e-06 0.5578986282275192 \
1.906311191316346e-06 0.5624617013850463 1.906311426077985e-06 0.566941985223824 1.90631165634869e-06 0.5713275351537204 1.906311862141324e-06 0.5752375533958141 \
1.906312067125538e-06 0.5791255875933676 1.90631230994078e-06 0.5837094709690289 1.906312564698362e-06 0.588493349632063 1.906312792926793e-06 0.5927514274590796 \
1.906313030765665e-06 0.5971656109489694 1.906313243043101e-06 0.6010807441713891 1.906313454836505e-06 0.6049674646600495 1.906313708720774e-06 0.6095919957414236 \
1.906313913314301e-06 0.6132953190650409 1.906314165037654e-06 0.6178178328453598 1.906314352827174e-06 0.6211736970442716 1.906314605700251e-06 0.6256587164710262 \
1.906314804109613e-06 0.6291560967673944 1.906314983842284e-06 0.6323071487074056 1.906315254113091e-06 0.6370161336915187 1.906315471396857e-06 0.6407803561788556 \
1.906315651923236e-06 0.6438916924996977 1.906315853084131e-06 0.6473460740030906 1.906316021667513e-06 0.650231451944099 1.90631622602572e-06 0.6537144072723954 \
1.906316371688778e-06 0.6561873372238678 1.906316536247377e-06 0.6589728476742622 1.906316705716593e-06 0.6618316558839334 1.906316859256675e-06 0.664412775690417 \
1.906317000490202e-06 0.6667750288922751 1.906317144066014e-06 0.6691685747430841 1.906317277296139e-06 0.6713840140331436 1.906317419196459e-06 0.6737368819239464 \
1.906317539430086e-06 0.6757233098298149 1.906317684081138e-06 0.6781085120392751 1.906317800299844e-06 0.6800197521569988 1.906317919382163e-06 0.6819757159594566 \
1.906318017960477e-06 0.6835903813535821 1.906318135558183e-06 0.6855122399681081 1.906318222994146e-06 0.6869376986921233 1.906318347740232e-06 0.6889650632873403 \
1.906318447547296e-06 0.6905825000046129 1.906318540037093e-06 0.6920753042469043 1.906318641321177e-06 0.6937043390836264 1.906318739114283e-06 0.695273833970533 \
1.906318830385074e-06 0.6967333967490603 1.906318932842905e-06 0.6983656370917724 1.906319065752135e-06 0.7004728611232253 1.906319220767541e-06 0.7029137789397926 \
1.906319355649227e-06 0.7050222373350452 1.906319501145018e-06 0.7072806469370021 1.906319628999685e-06 0.709252249158637 1.906319753457981e-06 0.7111597484283609 \
1.906319864783685e-06 0.7128563623504806 1.906319978813713e-06 0.7145852226468989 1.906320079324929e-06 0.7161013069709498 1.906320216526077e-06 0.7181590832501857 \
1.906320336471979e-06 0.7199473375636642 1.906320455641778e-06 0.7217141075019444 1.906320582586792e-06 0.7235855504531626 1.906320707354209e-06 0.7254141264975077 \
1.906320830849597e-06 0.7272133847865295 1.90632095763087e-06 0.7290498056238117 1.906321088220355e-06 0.730930225429108 1.906321210432258e-06 0.7326797786847141 \
1.906321347490271e-06 0.7346298644824388 1.906321448705626e-06 0.7360619656663578 1.906321553674562e-06 0.7375401619041119 1.906321645165995e-06 0.7388229997694907 \
1.906321758241356e-06 0.7404001534680551 1.90632184554224e-06 0.7416107338190071 1.906321950005571e-06 0.7430512000342341 1.906322080768703e-06 0.7448411286358657 \
1.9063221906822e-06 0.7463352048609909 1.906322295341958e-06 0.7477488743938407 1.90632241917362e-06 0.7494094725133206 1.906322567926971e-06 0.751387874302702 \
1.906322689842132e-06 0.7529958494242643 1.906322803696392e-06 0.7544867042370438 1.90632294419585e-06 0.7563117925204224 1.906323085519364e-06 0.7581313010100689 \
1.906323203298972e-06 0.7596352654099263 1.906323331697459e-06 0.7612620174900669 1.906323474021161e-06 0.7630496612437514 1.906323590410316e-06 0.7644991888858087 \
1.906323736133978e-06 0.7662987831554334 1.906323857913867e-06 0.7677897310961733 1.906323976478797e-06 0.7692300520321635 1.906324099092246e-06 0.7707078417740018 \
1.906324225543629e-06 0.77221964326554 1.906324335666584e-06 0.7735261258099556 1.906324461188726e-06 0.7750039859681491 1.906324566849672e-06 0.7762386743660952 \
1.906324702026829e-06 0.7778058706872942 1.906324825637346e-06 0.7792267957652825 1.906324955634725e-06 0.7807078764205345 1.906325068606223e-06 0.7819831642610904 \
1.906325176500111e-06 0.7831908181350914 1.906325313030793e-06 0.7847046126527283 1.906325463151702e-06 0.7863508260127218 1.906325605416006e-06 0.7878933964149381 \
1.906325724997519e-06 0.7891771019825847 1.906325861808649e-06 0.7906313890246753 1.906325984312413e-06 0.7919206245676671 1.906326128984341e-06 0.7934276941869095 \
1.906326269769414e-06 0.794878360380241 1.906326396585209e-06 0.796171745508174 1.906326515632602e-06 0.7973744708066829 1.906326627895563e-06 0.7984986270115709 \
1.906326732283333e-06 0.7995352562746869 1.906326827560395e-06 0.8004739840425704 1.906326963902891e-06 0.8018044219089175 1.90632708076796e-06 0.8029326473252685 \
1.906327200364489e-06 0.8040757482679398 1.906327322250299e-06 0.8052288531124292 1.906327444838559e-06 0.8063765489401953 1.906327572579618e-06 0.8075599074701925 \
1.906327697362526e-06 0.8087035441861687 1.906327827862901e-06 0.8098867241643505 1.906327954229597e-06 0.8110199871086299 1.906328081578389e-06 0.8121498004723215 \
1.906328186791179e-06 0.8130740322933268 1.906328291495184e-06 0.8139855427426806 1.90632838302539e-06 0.8147757515715357 1.90632850639836e-06 0.8158311616195392 \
1.906328593352408e-06 0.8165684017534872 1.906328692208245e-06 0.8173999442793862 1.906328836710884e-06 0.8186029267949408 1.906328973036573e-06 0.8197243345631372 \
1.906329082445008e-06 0.8206145128367788 1.906329228461948e-06 0.821788834531623 1.906329380203007e-06 0.8229927727264784 1.906329506119585e-06 0.8239792970156907 \
1.906329650568649e-06 0.8250971468990039 1.906329775264817e-06 0.8260503472050121 1.906329925878834e-06 0.8271873005969326 1.906330061249302e-06 0.8281959289694237 \
1.906330186472937e-06 0.8291179217777711 1.906330304128897e-06 0.8299746468143927 1.90633044991051e-06 0.8310230722388168 1.90633061639426e-06 0.8322027532553667 \
1.906330747215023e-06 0.8331167337813133 1.906330920675045e-06 0.834311196379941 1.906331088787841e-06 0.8354501125721271 1.906331258668969e-06 0.8365827385393307 \
1.906331439512628e-06 0.8377685497174457 1.906331582704692e-06 0.8386931238161603 1.906331696822189e-06 0.8394210074154138 1.9063318268738e-06 0.8402408682651782 \
1.906331928753516e-06 0.8408758513273116 1.906332045641139e-06 0.841596551294542 1.906332182786859e-06 0.8424315815669623 1.906332380696072e-06 0.8436167827761205 \
1.906332572515411e-06 0.8447436440637145 1.906332781866158e-06 0.8459494874145237 1.906332964017768e-06 0.8469786287449077 1.90633316110399e-06 0.8480715276019779 \
1.906333334356719e-06 0.8490148531186206 1.906333517450963e-06 0.8499943787178993 1.90633368858243e-06 0.8508936588199895 1.906333863270272e-06 0.8517955326875627 \
1.906334038504287e-06 0.8526841769874772 1.906334214641154e-06 0.8535614892404448 1.906334405008494e-06 0.8544920815553035 1.906334595580845e-06 0.8554057038167108 \
1.906334795976838e-06 0.8563474066245403 1.906334988566463e-06 0.8572344253714166 1.906335199466375e-06 0.858185963363946 1.906335427341862e-06 0.8591913103610016 \
1.906335693424718e-06 0.8603357477151101 1.906335991926854e-06 0.8615822374427254 1.906336267816323e-06 0.8627000332972231 1.906336552083493e-06 0.8638181192989086 \
1.906336826221443e-06 0.8648650323418529 1.906337098522366e-06 0.8658754039994767 1.906337368678562e-06 0.8668495780678541 1.906337625862699e-06 0.8677515347235455 \
1.906337898421613e-06 0.8686810999091764 1.906338174469331e-06 0.8695957110915412 1.906338444589598e-06 0.8704649939918846 1.906338744449489e-06 0.8714007440816277 \
1.906339115430114e-06 0.8725171209518352 1.906339410352536e-06 0.8733732402027278 1.906339664628271e-06 0.8740897163373675 1.906339962841735e-06 0.8749052413925265 \
1.906340236411346e-06 0.8756305047096297 1.906340472534749e-06 0.8762394088953867 1.906340712859886e-06 0.8768433401198644 1.906340935193821e-06 0.8773882060838187 \
1.906341129200254e-06 0.8778530214284207 1.906341458909681e-06 0.8786208714695904 1.90634161408109e-06 0.87897283049042 1.906341931723491e-06 0.8796750328643211 \
1.906342110604035e-06 0.8800599154915705 1.906342453064798e-06 0.8807759898408113 1.90634263726721e-06 0.8811501695110489 1.906343112296513e-06 0.8820806183873429 \
1.906343279683462e-06 0.8823969901232691 1.906343745459843e-06 0.8832471741583867 1.906343926299187e-06 0.8835657112976044 1.906344420308805e-06 0.8844044135654346 \
1.906344561623711e-06 0.8846360992458032 1.906345167867326e-06 0.8855901496945974 1.906345319942526e-06 0.8858196526512701 1.906345966662599e-06 0.8867549368993356 \
1.906346094949266e-06 0.8869330782847171 1.906346743158686e-06 0.8877977435561634 1.906346872882985e-06 0.8879638504720397 1.906347641302053e-06 0.8888993076310558 \
1.906347771073903e-06 0.8890488273083775 1.906348624736509e-06 0.8899738047157748 1.906348767761561e-06 0.8901192131187072 1.906349754067048e-06 0.8910487927319016 \
1.9063499755536e-06 0.8912403904783051 1.906351118378138e-06 0.8921548233216382 1.906351248258076e-06 0.8922544308366913 1.906352600758498e-06 0.8932425879319322 \
1.906352751041431e-06 0.8933452769452155 1.906354231575698e-06 0.8942627870546499 1.906354470485492e-06 0.8943950258099049 1.906356252518433e-06 0.8952625983306248 \
1.90635663826586e-06 0.895426813549116 1.906359040424079e-06 0.8963023915260389 1.906359515360049e-06 0.8964490046842035 1.906363433287165e-06 0.8974035634625627 \
1.906363903247409e-06 0.8974927205890085 1.906372272035387e-06 0.8984807567386782 1.906372492545714e-06 0.8984960697096243 1.906417072074293e-06 0.8994905034760702 \
1.906418273460191e-06 0.8995076493514624 1.906554083268694e-06 0.9004821828323031 1.906554262245419e-06 0.9005421539807538 1.906557707120337e-06 0.8996085030263692 \
1.906557879904192e-06 0.8994755022453073 1.9065592062239e-06 0.8985168769831137 1.906559392989208e-06 0.8983970610744239 1.906561177194233e-06 0.8974304740967198 \
1.906561389324515e-06 0.8973403978332656 1.906574730020299e-06 0.8983331062395279 1.906574843308144e-06 0.8983517458922662 1.906583546661241e-06 0.8993273409280406 \
1.90658409447182e-06 0.8993637478389299 1.907076621843715e-06 0.9003542216796759 1.907076717582566e-06 0.9004233209197793 1.907077660131942e-06 0.9014023545001312 \
1.907077822585254e-06 0.9016297223302431 1.9070783892915e-06 0.9025464066367429 1.907078496462212e-06 0.9027401250447874 1.907078889770564e-06 0.9035002370985188 \
1.907079022567928e-06 0.9037710185404622 1.907079402169034e-06 0.9045728679206633 1.90707953238378e-06 0.9048512534150681 1.907079993790073e-06 0.9057878278182891 \
1.907080113037131e-06 0.9060008176934132 1.907081542646166e-06 0.9050557440230738 1.907081626316292e-06 0.9046580283931719 1.907081751622122e-06 0.9039622140338933 \
1.90708185943629e-06 0.9032622438705011 1.907081978430637e-06 0.9023800387125585 1.907082093802854e-06 0.9014106868475621 1.907082183899751e-06 0.900578017289966 \
1.907082295347455e-06 0.8994526603282017 1.907082381426603e-06 0.8985125975436928 1.907082487392251e-06 0.8972736935213672 1.907082587160618e-06 0.8960214106762436 \
1.907082668156228e-06 0.8949470092681954 1.907082777804195e-06 0.8934133399212493 1.907082863391606e-06 0.8921520042367302 1.907082955514215e-06 0.8907345325087322 \
1.907083043733598e-06 0.8893220116766375 1.907083152508351e-06 0.8875100775672261 1.907083235401386e-06 0.8860780350921965 1.907083343975057e-06 0.8841400608632336 \
1.907083436201252e-06 0.8824412727986957 1.90708352082175e-06 0.8808423775446282 1.90708360666218e-06 0.8791839877465467 1.90708368587706e-06 0.8776224824828824 \
1.90708376196503e-06 0.8760960492665846 1.907083854301399e-06 0.874210837196514 1.907083914177735e-06 0.8729702140710593 1.907083971566019e-06 0.8717685933706794 \
1.907084033561192e-06 0.8704574090763495 1.907084096840043e-06 0.8691057216070059 1.907084146911381e-06 0.8680269866686803 1.907084196353534e-06 0.8669542389500936 \
1.90708426002324e-06 0.8655623656543436 1.907084335970659e-06 0.8638877358586781 1.907084384801671e-06 0.8628032002737418 1.907084433325624e-06 0.8617197496806845 \
1.907084509037347e-06 0.8600184098866027 1.907084576246125e-06 0.8584975010852487 1.907084618952631e-06 0.8575263577286506 1.907084662855204e-06 0.8565244243916033 \
1.907084750660351e-06 0.8545103166059256 1.907084813513519e-06 0.8530605771626394 1.907084872183177e-06 0.8517018597088126 1.907084908361778e-06 0.8508614974547222 \
1.907084943180258e-06 0.8500510151036469 1.907084978206243e-06 0.8492340038666518 1.907085048258213e-06 0.8475953578585981 1.907085096728698e-06 0.8464581214772323 \
1.907085140673499e-06 0.8454248116355969 1.907085186191255e-06 0.8443523575543517 1.907085250092166e-06 0.8428433081697474 1.90708531621854e-06 0.8412777165526386 \
1.907085421348608e-06 0.8387809254526315 1.907085509283283e-06 0.8366857089760468 1.907085588228565e-06 0.834800137446173 1.907085676393602e-06 0.8326899670047023 \
1.907085763209599e-06 0.8306078985741704 1.907085851101283e-06 0.8284959280419055 1.907085942350373e-06 0.8262996967350639 1.907086045112241e-06 0.8238226494465998 \
1.907086143615716e-06 0.8214450402687625 1.907086255948632e-06 0.8187302447322098 1.907086368922768e-06 0.8159967029774419 1.907086490210663e-06 0.8130591602364435 \
1.907086620717817e-06 0.8098958628758253 1.907086749763719e-06 0.8067658935936169 1.90708690323932e-06 0.8030416153605923 1.90708706852354e-06 0.799029304640783 \
1.907087236264745e-06 0.7949567682299736 1.907087432788334e-06 0.7901857478752816 1.907087637550659e-06 0.7852160332972318 1.907087850227715e-06 0.7800563994093253 \
1.907088050847662e-06 0.7751902022758907 1.907088251706389e-06 0.7703212856706637 1.907088401728407e-06 0.766686939713112 1.907088532263574e-06 0.7635264252913375 \
1.907088666681014e-06 0.7602735436595947 1.907088772876544e-06 0.7577048602246427 1.907088906182877e-06 0.754482067181252 1.907089013215803e-06 0.7518959494812111 \
1.907089156291704e-06 0.7484409822837247 1.907089320797846e-06 0.7444713482725677 1.907089441615093e-06 0.74155777711076 1.907089612721756e-06 0.7374334100931738 \
1.907089773612309e-06 0.733558046396253 1.90708999020493e-06 0.7283457217000903 1.907090183460631e-06 0.7236999380850822 1.907090362395765e-06 0.7194029726762079 \
1.907090529212387e-06 0.7154015770462002 1.907090715418352e-06 0.7109395231330657 1.907090903351593e-06 0.7064416825495208 1.907091069273699e-06 0.7024749886985119 \
1.907091261631787e-06 0.6978803202016938 1.907091402988682e-06 0.6945068232011449 1.907091559996444e-06 0.6907636199298515 1.907091755976089e-06 0.6860965106368763 \
1.907091918410194e-06 0.6822325558671515 1.907092079586376e-06 0.6784034260021697 1.907092271894574e-06 0.6738409413562468 1.907092489556454e-06 0.6686845685784016 \
1.907092737577756e-06 0.6628199086538362 1.907092915635219e-06 0.6586162961343578 1.907093164179028e-06 0.6527567611811057 1.907093366786271e-06 0.6479896840619462 \
1.907093536596938e-06 0.6440011601507294 1.907093695213124e-06 0.6402799599229552 1.907093833743559e-06 0.637035894415233 1.907093969951322e-06 0.6338503464729111 \
1.907094096262698e-06 0.6309003762865483 1.907094225721933e-06 0.6278810604265532 1.907094354053672e-06 0.6248911458464299 1.907094485383603e-06 0.6218374290191309 \
1.907094617410215e-06 0.6187713222160208 1.907094761570095e-06 0.6154276788919771 1.907094905778687e-06 0.6120888358645944 1.907095053433791e-06 0.6086753592300279 \
1.907095200490149e-06 0.6052842859263143 1.907095358304176e-06 0.6016504852589418 1.907095490909828e-06 0.5986039825107707 1.907095622374795e-06 0.5955897059985247 \
1.907095741804593e-06 0.5928552647156846 1.907095877873286e-06 0.5897484304797134 1.907095992801548e-06 0.5871283594046445 1.907096143912269e-06 0.5836892419704927 \
1.907096258561337e-06 0.5810871834776226 1.907096376499006e-06 0.5784138884735546 1.907096466280294e-06 0.576381560286313 1.907096556599689e-06 0.5743415774978985 \
1.907096623290559e-06 0.5728373329037385 1.907096688852372e-06 0.5713590910263378 1.907096739894496e-06 0.5702089751121119 1.907096801596215e-06 0.5688198806440578 \
1.907096864686071e-06 0.5674025889664359 1.907096929044424e-06 0.5659586381304559 1.907096982438223e-06 0.5647616504486359 1.907097075080806e-06 0.5626864159088959 \
1.907097151688078e-06 0.5609719030357503 1.90709720751314e-06 0.5597256439368602 1.907097276567267e-06 0.5581857825097393 1.907097383455393e-06 0.5558054549196561 \
1.907097461199018e-06 0.5540764009223496 1.907097562049117e-06 0.5518382286767042 1.907097687729972e-06 0.5490568313009737 1.907097787971657e-06 0.5468419758621708 \
1.90709789988934e-06 0.5443739014182352 1.907098003155247e-06 0.5421024366463116 1.907098122904589e-06 0.5394737463112931 1.907098224637469e-06 0.5372436950013484 \
1.907098340157213e-06 0.5347185748314579 1.907098455192299e-06 0.5322102907975605 1.907098581673211e-06 0.529456475824718 1.907098707047009e-06 0.5267350629320526 \
1.907098853862932e-06 0.5235577714138258 1.907098989426381e-06 0.5206304261698983 1.907099147124634e-06 0.5172373565578411 1.907099309443688e-06 0.5137528589513558 \
1.907099490267585e-06 0.5098871206809381 1.907099682715905e-06 0.5057874350093188 1.907099895621209e-06 0.5012700264709963 1.907100127802608e-06 0.4963634062180514 \
1.907100385093187e-06 0.4909555076455908 1.90710062471901e-06 0.4859407514401474 1.907100926434446e-06 0.479662588092526 1.9071012143538e-06 0.4737079198104491 \
1.907101527242619e-06 0.4672821326282255 1.907101846980824e-06 0.4607585360408045 1.907102186575985e-06 0.4538766993710576 1.907102513478483e-06 0.4472977926730654 \
1.907102849036864e-06 0.4405887635920606 1.907103166132787e-06 0.4342949501181722 1.907103500370541e-06 0.4277061431972559 1.907103851801663e-06 0.4208322784122511 \
1.907104166327817e-06 0.4147233751108969 1.907104489505308e-06 0.4084912998479469 1.907104930620066e-06 0.400057814108821 1.907105272736103e-06 0.3935812134363078 \
1.907105572680633e-06 0.3879522399691127 1.907105947811638e-06 0.3809760137481454 1.907106277555878e-06 0.3749002425561211 1.907106560798804e-06 0.3697269896098562 \
1.907106860945059e-06 0.3642865787664632 1.907107140547253e-06 0.3592589179584539 1.907107364323365e-06 0.3552676761685443 1.907107576103695e-06 0.3515151294490645 \
1.907107778537159e-06 0.3479514629380864 1.907107979628427e-06 0.3444362246481504 1.907108185342845e-06 0.3408632458568372 1.907108452965717e-06 0.3362478643926977 \
1.907108691897011e-06 0.3321601360780691 1.907108925403074e-06 0.3281974319442653 1.907109138868474e-06 0.3246000376975314 1.907109360246046e-06 0.3208952602338652 \
1.907109560209693e-06 0.3175728982722026 1.907109764482006e-06 0.3142073831356898 1.907109961828878e-06 0.3109812293225088 1.907110147201405e-06 0.3079732989686547 \
1.907110343307796e-06 0.3048147723336881 1.907110545584936e-06 0.3015820927993307 1.907110721243233e-06 0.2988007390096292 1.90711090711339e-06 0.295878328903569 \
1.907111114092783e-06 0.2926488196724605 1.907111299414374e-06 0.2897857719971084 1.907111494641182e-06 0.2867989994419413 1.907111650415531e-06 0.28443329608414 \
1.907111829172313e-06 0.2817356906084737 1.907112010203233e-06 0.2790344478478936 1.907112160100347e-06 0.2768142575519123 1.907112361143774e-06 0.273859574769726 \
1.907112510258904e-06 0.2716833853889438 1.907112648798333e-06 0.2696726034832688 1.907112800673409e-06 0.2674956304896134 1.907112915147538e-06 0.2658586287383957 \
1.907113046677468e-06 0.2639823142040156 1.907113172435956e-06 0.2622048582339201 1.907113276776362e-06 0.2607341604582348 1.907113389755722e-06 0.2591418073851619 \
1.907113506084246e-06 0.2575033437579446 1.907113649011667e-06 0.2554974228347739 1.907113762273172e-06 0.2539102348881249 1.907113896429905e-06 0.2520298733123076 \
1.90711400690271e-06 0.2504818583075984 1.907114162335285e-06 0.2483006006477398 1.907114303220383e-06 0.2463217957442577 1.907114454612954e-06 0.2441928603691365 \
1.907114609775035e-06 0.2420086586735095 1.907114739184283e-06 0.2401849910837116 1.907114873896376e-06 0.2382868210192302 1.907115011594202e-06 0.2363478190565156 \
1.907115129346217e-06 0.2346905900295477 1.90711528867041e-06 0.2324499447852502 1.907115425932636e-06 0.2305210708572645 1.907115566678993e-06 0.2285488733964877 \
1.907115672470167e-06 0.2270688194984586 1.907115802411564e-06 0.2252532503786337 1.907115902948028e-06 0.2238506847401111 1.907116005281736e-06 0.2224250970611539 \
1.907116079010317e-06 0.2214012665004395 1.90711615824426e-06 0.2203047212273054 1.907116229215507e-06 0.2193236206014474 1.907116280678535e-06 0.218612902325451 \
1.907116333626988e-06 0.2178825126218075 1.907116412781991e-06 0.2167921001391954 1.907116455054626e-06 0.2162104926182252 1.907116494899171e-06 0.2156628374086678 \
1.90711653812282e-06 0.2150692779925967 1.907116579029822e-06 0.2145080585354088 1.907116649152284e-06 0.2135474129702876 1.907116682837256e-06 0.2130867492099046 \
1.907116727666638e-06 0.212477723463 1.9071167865238e-06 0.2116792343136102 1.90711685130926e-06 0.2108017053965978 1.907116908790025e-06 0.2100241135398916 \
1.907116969219033e-06 0.209207737948094 1.907117066255463e-06 0.2078991976528634 1.907117150945123e-06 0.2067595417901527 1.907117259855885e-06 0.2052972881712416 \
1.907117356256692e-06 0.2040065614180294 1.907117451273329e-06 0.2027428333585779 1.907117554705127e-06 0.2013717100485363 1.907117649634473e-06 0.2001158751783069 \
1.907117752654899e-06 0.198757993281026 1.907117857737332e-06 0.1973779917312911 1.907117967046146e-06 0.1959482000350934 1.907118077489628e-06 0.1945091075764383 \
1.907118193779904e-06 0.1929996650696684 1.907118303709896e-06 0.1915811184357085 1.90711841337232e-06 0.1901717999899754 1.907118515088965e-06 0.1888694322720079 \
1.907118608043679e-06 0.1876837490531375 1.907118700772569e-06 0.1865049219968967 1.907118774458125e-06 0.1855719169757668 1.90711885729934e-06 0.1845269810791141 \
1.907118931885336e-06 0.1835895008849975 1.907119001608678e-06 0.1827150226754214 1.907119068327085e-06 0.1818808699270075 1.907119164170411e-06 0.1806871657728035 \
1.907119246877184e-06 0.1796611249561687 1.907119340441007e-06 0.1785035608809835 1.907119435337095e-06 0.1773351434884491 1.907119546707405e-06 0.1759704596301353 \
1.907119688349759e-06 0.1742450478777388 1.907119803596612e-06 0.1728486436789435 1.907119948144251e-06 0.1711076225712051 1.907120059739928e-06 0.1697708811114609 \
1.907120200958902e-06 0.1680898955975501 1.907120316696175e-06 0.1667201145354908 1.907120422656861e-06 0.1654722325850081 1.907120521416477e-06 0.164314417410061 \
1.90712061775965e-06 0.1631901152369615 1.907120706417402e-06 0.1621596955203892 1.907120831751673e-06 0.1607099933926625 1.907120926277088e-06 0.1596224416957933 \
1.90712102401604e-06 0.1585042187118262 1.907121132110917e-06 0.1572745454417887 1.907121226778605e-06 0.1562036643369483 1.907121334226451e-06 0.1549951394274829 \
1.907121425315495e-06 0.1539767092330788 1.907121532087207e-06 0.1527896463435911 1.907121635480473e-06 0.1516469620792683 1.907121746560958e-06 0.1504267727114754 \
1.907121835786939e-06 0.1494522115900035 1.907121921266868e-06 0.1485231035185812 1.907122005192055e-06 0.1476157397758405 1.907122074898619e-06 0.1468658175993407 \
1.907122153536697e-06 0.1460232248551682 1.907122231847954e-06 0.1451880611912267 1.907122302483827e-06 0.1444378248611795 1.907122387974695e-06 0.1435337156153706 \
1.907122475363672e-06 0.1426139614481139 1.907122556951186e-06 0.1417594571206545 1.907122654270137e-06 0.1407454482154784 1.90712273495966e-06 0.139910090776864 \
1.90712282574469e-06 0.1389752404035735 1.907122947088963e-06 0.1377336220260025 1.907123036138604e-06 0.13682812281983 1.907123134655454e-06 0.1358318692385875 \
1.907123221741723e-06 0.1349560640726983 1.907123332152611e-06 0.1338550874529322 1.907123420611433e-06 0.1329791517134813 1.907123521340027e-06 0.1319874611681985 \
1.90712362612958e-06 0.1309622419763913 1.907123720519813e-06 0.1300442429014473 1.907123817024605e-06 0.1291112112475518 1.907123916511258e-06 0.1281591654439075 \
1.907124002912429e-06 0.1273384721630967 1.90712409789256e-06 0.1264411177628728 1.907124202081388e-06 0.1254629331099751 1.907124311200139e-06 0.124445178694 \
1.907124405550594e-06 0.1235704029653004 1.907124517846343e-06 0.1225411084520107 1.907124613309697e-06 0.1216733466577494 1.907124717520587e-06 0.1207311846737792 \
1.907124806865944e-06 0.1199276649878674 1.907124877253217e-06 0.1192980345746366 1.907124952639251e-06 0.1186268760051257 1.907125028771421e-06 0.1179522201461119 \
1.907125097748918e-06 0.1173458504859956 1.907125180268091e-06 0.1166263596898966 1.907125252211578e-06 0.1160015972854393 1.907125334290304e-06 0.1152916772467617 \
1.90712541862478e-06 0.1145654108773922 1.907125496418619e-06 0.113898375935255 1.907125589183521e-06 0.1131065723182637 1.907125704787343e-06 0.1121254933399327 \
1.907125810692911e-06 0.1112341778178403 1.907125888349831e-06 0.1105854195321705 1.907125976646302e-06 0.1098504899494786 1.907126056703354e-06 0.1091866403929743 \
1.907126153629479e-06 0.1083861389179563 1.907126248864964e-06 0.1076031391441806 1.907126337436159e-06 0.1068780200140514 1.90712643874426e-06 0.1060523297458165 \
1.907126544289947e-06 0.1051963702337609 1.907126653484312e-06 0.1043160928234657 1.907126761601933e-06 0.1034503663302994 1.907126881519694e-06 0.1024949450012773 \
1.907126982881521e-06 0.1016914181115986 1.907127088891151e-06 0.100855068690839 1.90712721468278e-06 0.09986840123414902 1.907127344240086e-06 0.09885896724496235 \
1.90712747991544e-06 0.09780904711780367 1.907127655987304e-06 0.09645781830037269 1.907127819787824e-06 0.09521257997344186 1.907127982612565e-06 0.09398642071914091 \
1.9071280677512e-06 0.09334985726464029 1.907128137589223e-06 0.09282999162688726 1.907128207084828e-06 0.09231474740697931 1.907128281043488e-06 0.09176875214326782 \
1.907128377198375e-06 0.09106241641841166 1.907128451613741e-06 0.09051841344162129 1.90712852960331e-06 0.08995079828656057 1.907128606052139e-06 0.08939693755534793 \
1.907128693546224e-06 0.08876614459792892 1.907128795722934e-06 0.08803382885421264 1.907128884287322e-06 0.08740269463919083 1.90712899395281e-06 0.08662585268124241 \
1.907129110009217e-06 0.08580942306245626 1.907129251558034e-06 0.0848216759818637 1.907129384427017e-06 0.08390253510334872 1.907129525187328e-06 0.08293727564630923 \
1.907129674896948e-06 0.08192024575105315 1.907129810608835e-06 0.08100683753927941 1.907129952125717e-06 0.08006309454860433 1.907130087247591e-06 0.07917070961097784 \
1.907130228520028e-06 0.07824718349428782 1.90713037561292e-06 0.07729532867436953 1.907130527122786e-06 0.07632524417621221 1.9071306924985e-06 0.07527819040792309 \
1.90713085625969e-06 0.07425356708383206 1.907131032389632e-06 0.07316505371836476 1.90713122152861e-06 0.07201151367936541 1.907131432202234e-06 0.07074528708793332 \
1.907131651768855e-06 0.06944624562626683 1.907131886535262e-06 0.06808094281860989 1.9071321449277e-06 0.06660616301228137 1.90713243959236e-06 0.06496103773121734 \
1.907132743671683e-06 0.06330286177969326 1.907133104582163e-06 0.06138472526627536 1.907133440499035e-06 0.05964719353945821 1.907133880676406e-06 0.05743991201668189 \
1.907134259043809e-06 0.05560437501227136 1.907134701502772e-06 0.05352996728430704 1.907135055522916e-06 0.05192508193542229 1.907135442039672e-06 0.05022502935509546 \
1.907135786643729e-06 0.04875485597254389 1.907136108618665e-06 0.04741934964807833 1.907136412152492e-06 0.04619304551845941 1.907136707073488e-06 0.04503122626702559 \
1.907136989555767e-06 0.04394770877170886 1.907137266636177e-06 0.04291147062934708 1.907137532363668e-06 0.04194013461971725 1.907137803594355e-06 0.0409708748276704 \
1.907138079853372e-06 0.04000619535229137 1.907138369752594e-06 0.03901828782233653 1.907138598128987e-06 0.03825741181922668 1.907138903013054e-06 0.03726495139513845 \
1.90713911968491e-06 0.03657573971894532 1.907139311041637e-06 0.03597943984071691 1.907139509636156e-06 0.03537298232318693 1.907139839551497e-06 0.03438820140908775 \
1.90714008149717e-06 0.03368375433354889 1.907140396809222e-06 0.03278771666975258 1.907140666929207e-06 0.03203957074185158 1.907140923300881e-06 0.03134567005659093 \
1.907141203312881e-06 0.03060515313352298 1.907141448968657e-06 0.02997014710356035 1.907141681704302e-06 0.02938120249260199 1.907141924434299e-06 0.02878348292867495 \
1.907142161161563e-06 0.02821317433052753 1.907142389807974e-06 0.0276732289298247 1.907142807093634e-06 0.02671456010533928 1.907143002274328e-06 0.02627749693639509 \
1.907143383441411e-06 0.02544369227895442 1.907143560694233e-06 0.02506446942885681 1.907143903145688e-06 0.02434654114125227 1.90714405641412e-06 0.02403127656358269 \
1.907144431432584e-06 0.02327616399748992 1.907144569066725e-06 0.02300530455388665 1.907145053333359e-06 0.02207084195640928 1.90714517295276e-06 0.02184403312078184 \
1.907145589991563e-06 0.02106026682208277 1.907145733393791e-06 0.02079332360769017 1.907146254605172e-06 0.01984598817089831 1.907146382379043e-06 0.0196205814374062 \
1.907146966791417e-06 0.01863359713481367 1.907147139226823e-06 0.01835589372257288 1.907147743323573e-06 0.01743644241612937 1.907147904755214e-06 0.01720262545858322 \
1.907148544701434e-06 0.01631831686205014 1.9071487230176e-06 0.016083210242981 1.907149371001649e-06 0.01526127675881721 1.90714953625524e-06 0.01505930898173208 \
1.907150272557175e-06 0.01419381259610907 1.907150406833225e-06 0.01404154276213586 1.907151203932743e-06 0.01317592498067951 1.907151344530354e-06 0.01302934089458718 \
1.907152309873577e-06 0.0120661300044765 1.907152474212383e-06 0.01190857475316222 1.907153474943512e-06 0.01099048917119646 1.907153612213369e-06 0.01087009009405628 \
1.907154750907886e-06 0.009949273443646761 1.907154865085787e-06 0.009863136028526375 1.907156245730622e-06 0.008889755784408603 1.907156400087833e-06 0.00878832203975914 \
1.907157946582061e-06 0.00781340401000951 1.907158030943764e-06 0.007760176032106158 1.907159716371082e-06 0.006770348169342283 1.907159839899572e-06 0.00670487246831437 \
1.907161889714139e-06 0.005720970231232756 1.907162086114296e-06 0.005634691917282852 1.907164404793654e-06 0.004698942116576918 1.907164865407989e-06 0.004530544077955615 \
1.90716760550353e-06 0.003639937533647344 1.907168123648567e-06 0.00349159181499799 1.907172274289875e-06 0.002502201117031859 1.907172812139882e-06 0.002396807933581942 \
1.90717889437533e-06 0.001421603691354927 1.907179153355741e-06 0.001378272220758726 1.90718447611909e-06 0.0003814093765652445 1.907184589276134e-06 0.0003711807182531981 \
1.90983070639237e-06 -0.0004615907568095335 1.909830868831338e-06 -0.0006852153244161934 1.909831369832807e-06 -0.001554404032531494 1.90983145401537e-06 -0.001725199767551738 \
1.909831855538194e-06 -0.002626792336557519 1.909831944873161e-06 -0.002845673237760077 1.909832231464969e-06 -0.0035898660494722 1.909832359033499e-06 -0.003937855927128601 \
1.909832677745161e-06 -0.004830400105952924 1.909832791946314e-06 -0.00515011308870196 1.909833074346638e-06 -0.005887653497963378 1.909833204572857e-06 -0.006177415671381139 \
1.909834182925754e-06 -0.005220113099403402 1.909834370233287e-06 -0.004004368716724641 1.909834501677689e-06 -0.002901539130564616 1.909834607105242e-06 -0.001869327786897239 \
1.909834692822726e-06 -0.0009323217369615201 1.909834774749213e-06 4.151965372454519e-05 1.909834895786036e-06 0.001618129410352471 1.909834994714683e-06 0.003024565667809575 \
1.909835153111357e-06 0.005482561958548801 1.909835370558587e-06 0.00923691162542661 1.90983555178081e-06 0.0126653356758144 1.909835763874906e-06 0.01697021734206094 \
1.909835926898563e-06 0.02046388365739064 1.909836087520978e-06 0.02403759527126768 1.909836241061221e-06 0.02755862871109176 1.909836389117902e-06 0.031036270750196 \
1.909836538198811e-06 0.03460722192241437 1.909836692728722e-06 0.03837091703902212 1.909836853379538e-06 0.04234026030123839 1.909837018034219e-06 0.04645786783841532 \
1.909837194575117e-06 0.05091770581196236 1.909837373537969e-06 0.05547793877747508 1.909837564281134e-06 0.0603721650098247 1.909837769062163e-06 0.06565647483694508 \
1.909837989534449e-06 0.07137203566208646 1.909838222394174e-06 0.0774299331224613 1.909838471581651e-06 0.08392829098722057 1.909838744423778e-06 0.09105513637423955 \
1.909839041127578e-06 0.09880974921055499 1.909839368453968e-06 0.1073623706929605 1.909839738105355e-06 0.11701033799881 1.909840132977169e-06 0.1273002725707723 \
1.90984059081541e-06 0.1392030195235975 1.90984112262225e-06 0.1529832553757746 1.909841747860046e-06 0.1691182447448397 1.909842433607517e-06 0.1867241161332086 \
1.909843236003391e-06 0.2071957342970069 1.909844134802183e-06 0.2299563735557614 1.909844940415632e-06 0.2501946571168963 1.909845654166966e-06 0.2679877251922811 \
1.909846283728848e-06 0.2835633151515627 1.909846854092298e-06 0.2975737963344939 1.90984738504768e-06 0.3105173405876944 1.909847886835131e-06 0.3226580892822354 \
1.909848366129684e-06 0.3341673054699896 1.909848831685103e-06 0.3452566901045974 1.909849295481511e-06 0.3562094254686541 1.90984975122954e-06 0.3668794056881832 \
1.909850211449675e-06 0.3775613305945491 1.909850749733646e-06 0.3899285626759094 1.90985125058418e-06 0.4013172511919189 1.909851650806863e-06 0.4103337945930838 \
1.909852157667644e-06 0.421642452039157 1.909852643633856e-06 0.4323669409017459 1.909853043148568e-06 0.4410997362599856 1.909853453760627e-06 0.4500002277813482 \
1.90985388268706e-06 0.4592207708982954 1.909854284201442e-06 0.4677760623951868 1.909854591591889e-06 0.4742753916877908 1.909854941833647e-06 0.4816249679276425 \
1.909855295073851e-06 0.4889795533930016 1.90985554824443e-06 0.4942125642332652 1.90985578118832e-06 0.4989990073547648 1.909856022831611e-06 0.5039392821429431 \
1.90985624782223e-06 0.5085102868389438 1.909856439858337e-06 0.5123881070394828 1.909856624670034e-06 0.5161059569497825 1.90985684696035e-06 0.5205538992744256 \
1.909857013671757e-06 0.5238726938135662 1.909857230888352e-06 0.5281726418673847 1.909857433967244e-06 0.5321820613122353 1.909857611378699e-06 0.5356681922482178 \
1.909857799451086e-06 0.5393528234657015 1.909858035483265e-06 0.5439555888699217 1.90985830136529e-06 0.5491186112539347 1.909858523127178e-06 0.5534070305875756 \
1.909858803185033e-06 0.5588091140818973 1.909859046184818e-06 0.5634839438879177 1.909859321538161e-06 0.5687575845994758 1.909859566533501e-06 0.5734440561015828 \
1.90985980682772e-06 0.5780305526007354 1.909860047867023e-06 0.5826153106864888 1.909860305457841e-06 0.5874946531182738 1.909860540824618e-06 0.5919209497705462 \
1.909860772126727e-06 0.5962518282209535 1.909860994653448e-06 0.6003950532231523 1.909861203013056e-06 0.6042587207462122 1.909861440854871e-06 0.6086392006348278 \
1.909861651715085e-06 0.612499186772883 1.909861907322267e-06 0.617151767543529 1.909862106050033e-06 0.620751700070918 1.909862381682677e-06 0.6257066023742009 \
1.909862604438798e-06 0.6296824120643636 1.909862897809922e-06 0.6348814180513288 1.909863130579923e-06 0.6389753720667986 1.909863350781309e-06 0.6428252659334456 \
1.909863552051921e-06 0.6463216644290061 1.909863769340793e-06 0.6500784077528632 1.909863944056704e-06 0.6530842133917786 1.909864130321333e-06 0.6562672470877895 \
1.909864309060386e-06 0.6593113758161715 1.909864471764399e-06 0.6620700940033843 1.90986463703341e-06 0.6648583661366954 1.909864780301224e-06 0.6672607123132118 \
1.909864919531648e-06 0.669583864918244 1.909865059332214e-06 0.6719085596965743 1.909865194107422e-06 0.6741424479378803 1.909865321601663e-06 0.6762463034350935 \
1.909865454555775e-06 0.6784344250006583 1.909865576160125e-06 0.680430207161383 1.909865704573366e-06 0.6825336955632141 1.909865820340421e-06 0.6844241240890321 \
1.909865918381594e-06 0.686020684362688 1.9098660190777e-06 0.687656981754083 1.909866128831462e-06 0.689434454762776 1.909866245599418e-06 0.6913211166705923 \
1.909866336826192e-06 0.6927889453402305 1.909866446031605e-06 0.6945396927028351 1.909866547140326e-06 0.6961566646470493 1.909866642540618e-06 0.6976767415743361 \
1.909866752022643e-06 0.6994136821864276 1.909866886474277e-06 0.7015344809028976 1.909867035493214e-06 0.7038694457768003 1.909867164423232e-06 0.7058755144243859 \
1.909867311083691e-06 0.7081418729260142 1.909867437868072e-06 0.7100885084081828 1.909867562465961e-06 0.7119899232102255 1.909867674319728e-06 0.7136874821928206 \
1.909867787275692e-06 0.7153928249203609 1.909867887829089e-06 0.716903336497302 1.909868025110593e-06 0.7189542886859326 1.909868144979452e-06 0.7207346491296758 \
1.909868264162204e-06 0.7224952472954583 1.909868391164314e-06 0.7243608783177121 1.909868515712665e-06 0.726179956024653 1.909868639383676e-06 0.7279757435764195 \
1.909868765971953e-06 0.7298035010246171 1.909868896541188e-06 0.7316777339938921 1.909869019056222e-06 0.7334262671520465 1.909869155299713e-06 0.7353588786631546 \
1.909869256742486e-06 0.7367901064855561 1.909869362765969e-06 0.7382789144707947 1.909869453297152e-06 0.7395446819117977 1.909869567123378e-06 0.7411267287627761 \
1.90986965478496e-06 0.742338113895605 1.909869760680237e-06 0.7437932991468792 1.909869891033533e-06 0.7455718205320391 1.90987000160114e-06 0.7470699275523445 \
1.909870106271612e-06 0.7484790865773925 1.909870230233143e-06 0.7501360792234356 1.909870378790597e-06 0.752105598322839 1.909870500473193e-06 0.7537054667443914 \
1.909870614584882e-06 0.7551949470168074 1.909870755005483e-06 0.7570132059451244 1.909870896533544e-06 0.7588296197226846 1.909871014322813e-06 0.7603289862386273 \
1.909871142522635e-06 0.7619481626911874 1.909871284590468e-06 0.7637269294216019 1.909871401465576e-06 0.7651780119234867 1.909871547139362e-06 0.7669714049983392 \
1.909871668877809e-06 0.7684572223066155 1.909871787518302e-06 0.7698939375992205 1.909871909984595e-06 0.7713653733660819 1.909872036701685e-06 0.7728756341192486 \
1.909872146603679e-06 0.7741754302862822 1.909872272219022e-06 0.7756497674172792 1.909872378029431e-06 0.7768823528242577 1.909872514199554e-06 0.7784559787239111 \
1.909872638546602e-06 0.7798807766277074 1.909872765971877e-06 0.7813271999647126 1.909872880527956e-06 0.7826155184370988 1.909872987208226e-06 0.7838050786084815 \
1.909873125150823e-06 0.785328674235108 1.909873274600319e-06 0.7869612315653352 1.909873419452536e-06 0.7885256944569791 1.909873538888287e-06 0.7898026796320731 \
1.90987367431316e-06 0.7912364721526877 1.909873795807481e-06 0.7925100718437531 1.909873939166556e-06 0.7939977458315933 1.909874082600237e-06 0.7954699260458764 \
1.909874208411247e-06 0.7967479640295563 1.909874327457928e-06 0.7979459892863545 1.909874439471573e-06 0.7990632136113104 1.909874544263454e-06 0.8000996927221937 \
1.909874639456303e-06 0.8010335634530776 1.909874775866828e-06 0.8023587211299719 1.909874892679005e-06 0.8034813603122919 1.909875012140248e-06 0.8046180202255495 \
1.9098751341806e-06 0.8057672874017472 1.909875257080697e-06 0.8069126780167393 1.909875384200053e-06 0.8080849010520604 1.909875509341915e-06 0.8092265787736463 \
1.909875639893142e-06 0.8104047139317369 1.909875765969389e-06 0.811530109085512 1.909875893966049e-06 0.8126603425876329 1.909875999427297e-06 0.8135823118114501 \
1.909876102696597e-06 0.814477091043954 1.909876195349946e-06 0.8152732203909091 1.909876319044181e-06 0.8163262937528154 1.909876406664095e-06 0.8170655553659417 \
1.909876505330151e-06 0.8178914289762149 1.909876648877154e-06 0.819080619224994 1.909876784463306e-06 0.8201904093102529 1.909876893653288e-06 0.8210742465492874 \
1.909877041102747e-06 0.8222539401850584 1.909877191506449e-06 0.8234410273756358 1.909877316975412e-06 0.8244188977545531 1.909877461141395e-06 0.8255287290252299 \
1.90987758542996e-06 0.8264738611628292 1.909877735900256e-06 0.8276038147969816 1.909877871506614e-06 0.8286089145501508 1.909877996601616e-06 0.8295251220930787 \
1.909878114317453e-06 0.8303776282987162 1.909878260203052e-06 0.8314210189912619 1.909878426696148e-06 0.8325942517713072 1.909878557562851e-06 0.833503494447128 \
1.909878731007462e-06 0.8346911703335461 1.909878899140202e-06 0.8358239212093587 1.90987906899395e-06 0.8369500705213252 1.909879249886955e-06 0.838129582835239 \
1.909879393021216e-06 0.8390486258646698 1.909879507119162e-06 0.8397723391454259 1.909879637246322e-06 0.8405879656882547 1.909879739102178e-06 0.8412191375388212 \
1.909879855947599e-06 0.8419354178465567 1.909879992919396e-06 0.84276453896487 1.909880190759142e-06 0.843942473808897 1.90988038244463e-06 0.8450620046306492 \
1.909880591850993e-06 0.8462610422160779 1.909880773861877e-06 0.8472832413425977 1.909880970977333e-06 0.8483697584184032 1.909881144290447e-06 0.8493077402131245 \
1.909881327325656e-06 0.8502809338042043 1.909881498478783e-06 0.8511747489972419 1.909881673131736e-06 0.8520708361396651 1.909881848382891e-06 0.8529540285731302 \
1.909882024530391e-06 0.8538259128238825 1.909882214836779e-06 0.8547503816925358 1.909882405427748e-06 0.8556583881771193 1.909882605979791e-06 0.8565949481971697 \
1.909882798582589e-06 0.8574764650234362 1.909883009331288e-06 0.8584213553684483 1.909883237362186e-06 0.8594210644592908 1.909883503241952e-06 0.8605573106989262 \
1.909883801820094e-06 0.8617960322792503 1.909884077983729e-06 0.8629075153790151 1.909884362230229e-06 0.8640180616030438 1.909884636414231e-06 0.8650581816846495 \
1.90988490866944e-06 0.8660616517296992 1.909885178858915e-06 0.8670295451208139 1.909885436023238e-06 0.8679256252637404 1.909885708596972e-06 0.8688492356117473 \
1.909885984602435e-06 0.8697577927663542 1.909886254710518e-06 0.8706213441784563 1.909886554568938e-06 0.8715508809746347 1.909886925582816e-06 0.8726599440782473 \
1.909887220515529e-06 0.873510245983525 1.909887474800895e-06 0.8742218447789023 1.909887773044171e-06 0.8750318897722944 1.909888046640929e-06 0.8757523113099853 \
1.909888282767908e-06 0.8763571312809064 1.909888523107205e-06 0.876957042728428 1.909888745440861e-06 0.8774982514557473 1.909888939446794e-06 0.8779599514934209 \
1.909889269165229e-06 0.8787226653583874 1.909889424338019e-06 0.8790722725343518 1.90988974207141e-06 0.8797700114458387 1.909889920939061e-06 0.880152324917399 \
1.909890263400534e-06 0.8808637455080008 1.909890447552368e-06 0.8812353200296749 1.909890922478418e-06 0.8821594045029107 1.909891089871654e-06 0.8824737723885729 \
1.90989155569296e-06 0.8833186808430151 1.909891736520447e-06 0.883635209600208 1.909892230549785e-06 0.8844687288968743 1.909892371887773e-06 0.8846990198924604 \
1.909892978249103e-06 0.8856473543416146 1.909893130320955e-06 0.8858754372639542 1.909893777008948e-06 0.8868048391838264 1.909893905303109e-06 0.8869818633102416 \
1.909894553496582e-06 0.8878410756373726 1.909894683245133e-06 0.8880061989117775 1.909895451498601e-06 0.8889361126992519 1.909895581240625e-06 0.8890847997417872 \
1.909896434697558e-06 0.8900046759307325 1.909896577924673e-06 0.8901495209380393 1.909897564158077e-06 0.8910738355210844 1.909897785636141e-06 0.8912643084423501 \
1.909898928653688e-06 0.8921737958641509 1.909899058631989e-06 0.8922730011388891 1.909900410338988e-06 0.8932565980587214 1.909900560692342e-06 0.8933589605607284 \
1.909902041315768e-06 0.8942730372387374 1.90990228021907e-06 0.8944047337041336 1.909904061344228e-06 0.8952702388217941 1.909904447325595e-06 0.8954343910560414 \
1.909906848871635e-06 0.896309305076933 1.90990732380842e-06 0.8964562995603377 1.909911141970139e-06 0.8973944547681553 1.909911624459337e-06 0.897487269196476 \
1.909919510474849e-06 0.898471373493449 1.90992012663754e-06 0.8985180228791175 1.910015282612379e-06 0.899508178894561 1.910016773214557e-06 0.8995204306067698 \
1.910128061288741e-06 0.9005118233983579 1.910128237625743e-06 0.9005706457326812 1.910131860757067e-06 0.8996048713171836 1.910132041955093e-06 0.8994654179496379 \
1.91013335307657e-06 0.8985275682722235 1.910133534953976e-06 0.8984123497545736 1.91013535794417e-06 0.8974436520388238 1.910135517857424e-06 0.8973766233009967 \
1.910148668688723e-06 0.8983720910457982 1.910148779670276e-06 0.8983905835035384 1.910157601254383e-06 0.8993863063850064 1.910158148023847e-06 0.8994226481040219 \
1.91065071997668e-06 0.9003987622903815 1.910650789769166e-06 0.9004496773542636 1.910651622421929e-06 0.9012853800543292 1.910651748468094e-06 0.9014513953152168 \
1.910652328988958e-06 0.9023435091985418 1.910652469953212e-06 0.9025895326188698 1.910652869091291e-06 0.9033428289365844 1.910653019240831e-06 0.9036449200440446 \
1.910653462322153e-06 0.9045762589490434 1.910653619494256e-06 0.9049121924877023 1.910654065120987e-06 0.9058152254958243 1.910654163577326e-06 0.9059929146639856 \
1.91065558025872e-06 0.9052304871087643 1.910655711415865e-06 0.904616184869324 1.910655880423041e-06 0.9036290332250884 1.910656045714916e-06 0.9024406226812831 \
1.910656151980698e-06 0.9015554774641358 1.910656255417528e-06 0.9006052096506509 1.910656341184247e-06 0.8997486040545581 1.910656430678233e-06 0.8987887485205278 \
1.910656554922632e-06 0.8973492764100613 1.91065667300358e-06 0.8958624931586439 1.910656760219672e-06 0.8946938835082598 1.910656884526716e-06 0.8929289312882503 \
1.910656991510644e-06 0.8913158670103165 1.910657091342348e-06 0.8897378501708729 1.910657217633174e-06 0.8876466417139378 1.910657385821785e-06 0.884705368138502 \
1.910657541521538e-06 0.8818365157686672 1.910657738126367e-06 0.8780362649814708 1.910657921747617e-06 0.8743271923380105 1.910658133255011e-06 0.8698916163736473 \
1.910658314064811e-06 0.8659808238081558 1.910658498645858e-06 0.8618945354625286 1.910658671649854e-06 0.8579913311618118 1.910658857050504e-06 0.8537436868396935 \
1.910659036133651e-06 0.8495884889292737 1.910659219722713e-06 0.8452850234109005 1.910659386484418e-06 0.8413449312544377 1.910659554574996e-06 0.8373487193315756 \
1.910659717684167e-06 0.8334514816705533 1.910659872870402e-06 0.829729402178684 1.910660045969282e-06 0.8255639501984255 1.910660231959737e-06 0.8210763864673301 \
1.910660396580221e-06 0.8170961425007568 1.910660561450132e-06 0.8131038678717658 1.910660736782164e-06 0.8088537582860886 1.910660901208668e-06 0.8048648186953292 \
1.910661069844279e-06 0.8007719922541914 1.910661260647645e-06 0.7961398815555145 1.910661446171818e-06 0.7916360074082958 1.910661655100628e-06 0.7865651471012967 \
1.910661879917618e-06 0.7811107659751856 1.910662069732705e-06 0.77650678233121 1.910662271590188e-06 0.7716133355283564 1.910662415860827e-06 0.76811790639139 \
1.910662557504393e-06 0.7646880872338248 1.910662685202102e-06 0.7615975116975136 1.910662796247943e-06 0.7589113686396982 1.91066292481058e-06 0.7558028559024855 \
1.910663057376087e-06 0.7525995467138866 1.910663170697783e-06 0.7498629233610832 1.910663307032409e-06 0.7465723252212872 1.910663413431661e-06 0.7440058350410135 \
1.910663572650447e-06 0.7401674766516904 1.910663745028142e-06 0.7360137588823189 1.910663907275386e-06 0.7321074183421575 1.910664079624344e-06 0.7279612819449855 \
1.910664239010527e-06 0.7241302920521341 1.910664446815714e-06 0.7191408067115369 1.910664607355379e-06 0.7152908836069264 1.910664799844715e-06 0.7106793324906435 \
1.910664985361064e-06 0.7062404417184839 1.910665155237109e-06 0.7021802791355866 1.910665347106947e-06 0.6975984806629684 1.910665493330962e-06 0.6941099299715526 \
1.910665653617309e-06 0.6902897983225644 1.910665856006145e-06 0.6854719661536142 1.910666037294609e-06 0.681161582477689 1.910666206116036e-06 0.6771536053116509 \
1.910666391961911e-06 0.6727470762459599 1.910666597892751e-06 0.6678715161770782 1.910666765819558e-06 0.6639016226084196 1.910666926081261e-06 0.6601182542089066 \
1.910667164933735e-06 0.65448589698252 1.910667332694849e-06 0.6505369020837752 1.910667513768288e-06 0.6462813620835641 1.910667674923199e-06 0.642499550819208 \
1.910667821190459e-06 0.6390715923276049 1.910667959878569e-06 0.6358268652274862 1.910668089235615e-06 0.6328040340451749 1.91066821862017e-06 0.6297855584526113 \
1.91066834694149e-06 0.6267952385336898 1.910668477143629e-06 0.6237652412672913 1.910668606160074e-06 0.6207683673242944 1.910668744735633e-06 0.6175525629501428 \
1.91066889281122e-06 0.6141227553162802 1.910669079138505e-06 0.60981438109949 1.910669226822204e-06 0.6064079319686639 1.91066946198641e-06 0.600995965122186 \
1.91066965443414e-06 0.5965821560879089 1.910669895003955e-06 0.5910808370261941 1.910670064051326e-06 0.587228367631822 1.91067020171775e-06 0.5840969866928536 \
1.910670329822727e-06 0.581191110277254 1.910670443409422e-06 0.5786182870235701 1.910670534774226e-06 0.5765512826027382 1.910670624196113e-06 0.5745328691003393 \
1.910670691457846e-06 0.573016830490748 1.910670757478049e-06 0.5715297341779608 1.910670809531724e-06 0.5703577032508095 1.910670873770593e-06 0.5689124506700958 \
1.910670935307116e-06 0.5675311492520995 1.91067099958866e-06 0.5660899724818867 1.910671052779755e-06 0.5648985048860162 1.91067114512554e-06 0.5628316153148989 \
1.910671221701441e-06 0.5611191615154557 1.910671277545091e-06 0.5598732849310241 1.9106713468882e-06 0.5583285932816697 1.910671452739475e-06 0.5559733466166974 \
1.91067153043128e-06 0.5542469170533902 1.910671631029868e-06 0.5520159549745236 1.910671759063078e-06 0.5491849411292137 1.91067185856046e-06 0.5469885705929382 \
1.910671971125811e-06 0.544508366501287 1.910672074170132e-06 0.5422442603473754 1.910672194219017e-06 0.5396115972585003 1.910672295833426e-06 0.5373863339265779 \
1.910672411457693e-06 0.5348611538529422 1.910672526573874e-06 0.5323536236546169 1.910672653010918e-06 0.529604142030661 1.910672778525186e-06 0.5268822104345234 \
1.910672925204862e-06 0.5237112381511962 1.91067306087557e-06 0.5207845659358002 1.910673218641409e-06 0.5173942078023266 1.910673381063349e-06 0.5139116507621072 \
1.910673561971818e-06 0.5100482739823553 1.910673754563972e-06 0.5059503908118104 1.910673967555743e-06 0.5014368974673542 1.910674199988459e-06 0.4965308659362653 \
1.910674457509373e-06 0.49112491222925 1.910674697473551e-06 0.4861095397820235 1.910674998677906e-06 0.4798501326413723 1.910675286975534e-06 0.4738957353990632 \
1.910675600061861e-06 0.4674739717793394 1.91067591958814e-06 0.4609631488871989 1.910676259085406e-06 0.4540919149088484 1.910676585275518e-06 0.4475353831519197 \
1.91067692175678e-06 0.4408159131180407 1.910677238467587e-06 0.4345373385230166 1.91067757255266e-06 0.4279587671099637 1.910677924261529e-06 0.4210864038135054 \
1.910678238746378e-06 0.4149846225409808 1.910678562192836e-06 0.4087533091618546 1.910679003120949e-06 0.400331870031168 1.910679344916024e-06 0.3938679283557566 \
1.910679644350069e-06 0.3882534014213259 1.910680018872672e-06 0.3812944595528024 1.910680348250389e-06 0.375233915169682 1.910680631354694e-06 0.3700684563936956 \
1.910680931099705e-06 0.3646408765157301 1.910681210595549e-06 0.3596219010422631 1.910681434267487e-06 0.3556377385586224 1.910681645979195e-06 0.3518907610576284 \
1.910681848481927e-06 0.3483292724130969 1.910682049543475e-06 0.3448190020587957 1.910682255221384e-06 0.3412518188287665 1.91068247359686e-06 0.3374887625241871 \
1.910682717359256e-06 0.3333167726275162 1.910682944115829e-06 0.3294678078423895 1.910683164026801e-06 0.3257615367192951 1.910683382451408e-06 0.3221060038181086 \
1.910683586476418e-06 0.318715141566024 1.910683788334208e-06 0.3153870758963987 1.910683988657595e-06 0.3121102802474151 1.910684175271502e-06 0.309079115007194 \
1.910684372573109e-06 0.3058982938882217 1.910684581156335e-06 0.3025606704206737 1.910684786791057e-06 0.2992974534031506 1.910685011523137e-06 0.2957609785165763 \
1.910685228418979e-06 0.2923771984023277 1.910685436098331e-06 0.2891642611511841 1.910685667149178e-06 0.2856239464683982 1.910685841949429e-06 0.2829684481899911 \
1.910686021147604e-06 0.2802647299798244 1.91068619002212e-06 0.2777348429135014 1.910686418345393e-06 0.274348458173166 1.910686595082661e-06 0.2717528218126659 \
1.910686763365392e-06 0.2693020894036587 1.910686935832162e-06 0.2668230333489093 1.910687069934441e-06 0.264903804409765 1.910687215894446e-06 0.2628277003548514 \
1.910687354589946e-06 0.2608803500812688 1.910687476871551e-06 0.2591684246570544 1.910687610990381e-06 0.2572942758553639 1.910687740091486e-06 0.2554978336754472 \
1.91068785952522e-06 0.2538430842138498 1.910687986360419e-06 0.2520939183506197 1.910688106001441e-06 0.2504447954274527 1.910688255617635e-06 0.2483797066042054 \
1.910688390481146e-06 0.2465170278296022 1.91068852003856e-06 0.2447289494531232 1.910688677103379e-06 0.2425624627506451 1.910688801099014e-06 0.2408491463446025 \
1.910688941247149e-06 0.2389135279283614 1.91068907114005e-06 0.2371200701944942 1.910689191757671e-06 0.2354534357320198 1.910689354230601e-06 0.2332087289724075 \
1.910689500284699e-06 0.2311905595759856 1.910689638605484e-06 0.2292825126447264 1.910689746532702e-06 0.2277949627009887 1.910689877317609e-06 0.225993474229161 \
1.910689975823626e-06 0.22463752857886 1.910690079906971e-06 0.2232056532573264 1.910690152783836e-06 0.2222046546567725 1.910690234937313e-06 0.2210804129356655 \
1.910690302346398e-06 0.2201585377209549 1.91069034905066e-06 0.2195201149856669 1.91069039846802e-06 0.2188449488487562 1.910690489422163e-06 0.2176035744446363 \
1.910690555816576e-06 0.2166983392055156 1.910690602779869e-06 0.2160586379972232 1.910690653091075e-06 0.2153737902794619 1.910690712240425e-06 0.2145693142997165 \
1.910690755086328e-06 0.2139870779821451 1.910690798893629e-06 0.2133941263688522 1.910690868423894e-06 0.2124566309962414 1.910690955340708e-06 0.2112864027023158 \
1.910691036529563e-06 0.2101949018929156 1.910691122429026e-06 0.2090416531541652 1.910691216575207e-06 0.2077796428137634 1.910691308329081e-06 0.2065517647617813 \
1.910691403625517e-06 0.2052788208685862 1.910691500104208e-06 0.2039945431316728 1.91069160092949e-06 0.2026602783061639 1.910691696885502e-06 0.2013924147365721 \
1.910691799571213e-06 0.2000377255165624 1.910691902607566e-06 0.1986831378210229 1.910692012697906e-06 0.1972405340748948 1.910692121449794e-06 0.1958206085628783 \
1.910692241171749e-06 0.1942631948714586 1.910692351614651e-06 0.1928328887741874 1.910692459617459e-06 0.1914411844406488 1.910692584973803e-06 0.1898318066870429 \
1.910692677907979e-06 0.1886434908940876 1.910692756278755e-06 0.1876443873000938 1.910692832918829e-06 0.1866698667869858 1.910692915430143e-06 0.1856249297118943 \
1.910692984939759e-06 0.1847473639743596 1.910693050895387e-06 0.1839166514106665 1.910693115162722e-06 0.1831089953192083 1.910693227146207e-06 0.1817072258029639 \
1.910693321200174e-06 0.1805353135896268 1.910693428841935e-06 0.1791985758407087 1.910693535314993e-06 0.1778827552324552 1.91069365530692e-06 0.1764073736674057 \
1.910693793359546e-06 0.174720142305475 1.9106939095201e-06 0.1733081217455876 1.910694071616903e-06 0.1713503924599185 1.91069418670542e-06 0.1699688234017716 \
1.910694326691019e-06 0.1682987764548305 1.910694443897095e-06 0.1669083002780509 1.910694554816447e-06 0.1655990025649634 1.910694652444933e-06 0.1644521190704843 \
1.910694747295481e-06 0.1633427224865242 1.910694863349894e-06 0.161991523106341 1.910694954898444e-06 0.1609305136382055 1.91069505100742e-06 0.1598214181625073 \
1.910695145225553e-06 0.1587403933520305 1.910695238726156e-06 0.1576732160104884 1.910695332323478e-06 0.1566104070550305 1.910695428005016e-06 0.1555300824433628 \
1.910695518592921e-06 0.1545132165873678 1.910695609606078e-06 0.1534969984004868 1.910695705154556e-06 0.1524358767948732 1.910695795820268e-06 0.1514342506187442 \
1.910695898892631e-06 0.1503020548964867 1.91069597134408e-06 0.1495100717445464 1.910696050444872e-06 0.148649146151682 1.910696124993092e-06 0.1478424742503694 \
1.9106961960245e-06 0.1470770917224498 1.910696268788981e-06 0.1462962409077327 1.910696343406157e-06 0.1454990959398698 1.910696413389118e-06 0.1447543557055888 \
1.910696487550038e-06 0.143968261688537 1.910696541295377e-06 0.1434005634796054 1.910696594578932e-06 0.1428396203849428 1.91069665977469e-06 0.1421555039833398 \
1.910696731080731e-06 0.141411576573238 1.910696795450793e-06 0.1407432786314442 1.910696868802754e-06 0.1399847409254479 1.910696929420321e-06 0.1393607073002494 \
1.910697015453805e-06 0.1384787080092832 1.910697091404821e-06 0.1377037134581418 1.910697181372726e-06 0.1367902106004182 1.910697263099684e-06 0.1359645165492482 \
1.910697345789661e-06 0.1351360437760365 1.910697428345969e-06 0.1343145513298757 1.910697533908125e-06 0.1332698421778018 1.910697615775408e-06 0.1324642397250402 \
1.910697713142868e-06 0.1315110876582503 1.910697803143729e-06 0.130634908321232 1.910697891113988e-06 0.1297829978838479 1.910697974043843e-06 0.1289892226181523 \
1.910698048280934e-06 0.1282822873521282 1.910698147931993e-06 0.1273377645104763 1.910698243687052e-06 0.1264350619688987 1.910698330534456e-06 0.1256206895242312 \
1.910698420535994e-06 0.1247808744623497 1.910698500868674e-06 0.1240346855852102 1.910698587562703e-06 0.1232365419604467 1.910698686393032e-06 0.1223331159004786 \
1.91069877647517e-06 0.1215131568528167 1.910698886718427e-06 0.1205141992263624 1.910698973949866e-06 0.1197275966302077 1.910699042523e-06 0.1191120727131645 \
1.910699127185393e-06 0.1183553887582162 1.910699193692873e-06 0.1177634990399222 1.910699265148799e-06 0.1171309945267847 1.910699334822604e-06 0.1165184920865242 \
1.910699412159692e-06 0.1158409171037389 1.910699507902975e-06 0.1150054407698888 1.910699579157887e-06 0.1143861389207103 1.91069964652742e-06 0.1138025718558601 \
1.910699714964191e-06 0.113211685696446 1.910699790554542e-06 0.1125613765304429 1.910699881296388e-06 0.1117840233035959 1.910699964000116e-06 0.1110788257213999 \
1.910700077599187e-06 0.1101151050704521 1.910700187474899e-06 0.1091895325357105 1.910700279674213e-06 0.1084169374841771 1.910700403623544e-06 0.1073835127717347 \
1.910700491987867e-06 0.1066505015902263 1.910700631446837e-06 0.1055001025916527 1.910700730743538e-06 0.1046863788921388 1.910700823393589e-06 0.1039306459201802 \
1.910700933598102e-06 0.1030359883605075 1.910701018892542e-06 0.1023467905686673 1.910701103793345e-06 0.101663637589173 1.910701186744309e-06 0.1009989740617136 \
1.91070130925421e-06 0.1000225794851696 1.910701431196063e-06 0.09905761200121259 1.910701557818349e-06 0.09806258992746317 1.910701670630472e-06 0.09718220909187772 \
1.910701815205956e-06 0.09606278874246346 1.910701952919884e-06 0.09500564015228773 1.910702069610674e-06 0.09411672853020667 1.910702197354241e-06 0.0931507147971556 \
1.910702297018758e-06 0.09240236948627445 1.910702376452637e-06 0.09180921593916676 1.910702475187935e-06 0.09107599640376031 1.910702553063239e-06 0.09050081472416407 \
1.910702634529155e-06 0.08990210528957472 1.910702709246463e-06 0.0893557072655629 1.910702789776201e-06 0.08876971652456604 1.910702908608526e-06 0.08791061481419053 \
1.910702998269062e-06 0.08726673116015753 1.910703103183109e-06 0.08651800316437093 1.910703234657667e-06 0.08558693768262025 1.910703395765802e-06 0.08445695903909305 \
1.910703535947497e-06 0.08348350561263763 1.910703684450103e-06 0.08246223579158835 1.910703821170292e-06 0.08153124812726546 1.910703961182002e-06 0.08058696725890066 \
1.910704098179202e-06 0.07967195061625794 1.910704236789813e-06 0.07875532825288725 1.9107043812627e-06 0.07780967510081127 1.910704528808937e-06 0.07685421131041187 \
1.910704686312648e-06 0.07584560580436887 1.910704850707884e-06 0.07480523464991846 1.910705018799982e-06 0.07375451744755303 1.910705199799341e-06 0.07263751640721161 \
1.910705398512623e-06 0.07142823309373261 1.910705611921415e-06 0.07014922396308329 1.9107058380853e-06 0.06881630383186611 1.910706078645622e-06 0.06742468841361035 \
1.910706356206535e-06 0.06585179211508728 1.910706653410939e-06 0.06420523370201831 1.910706971711662e-06 0.06248365192299224 1.910707361695962e-06 0.06043183534616462 \
1.910707760522748e-06 0.05839861031494715 1.910708202994687e-06 0.05621846258761681 1.91070858797559e-06 0.05438828987170503 1.910709000022182e-06 0.05249218901100536 \
1.910709351759698e-06 0.05092353490091287 1.91070968726435e-06 0.04946969867921969 1.910709997763244e-06 0.04816021644386199 1.910710291700064e-06 0.04695194805701195 \
1.910710584430997e-06 0.04577883625507727 1.910710859274204e-06 0.04470700909733757 1.910711133117927e-06 0.04366353526031765 1.910711398807688e-06 0.04267398813878486 \
1.910711674116703e-06 0.04167180388267511 1.91071195867362e-06 0.04066026046469497 1.910712254971736e-06 0.03963283340811159 1.910712513847122e-06 0.03875659098599576 \
1.910712741803527e-06 0.03800131046948733 1.910712960528722e-06 0.03729095380188759 1.910713180383449e-06 0.03659437723507575 1.910713521249513e-06 0.03554043311314246 \
1.910713797290394e-06 0.03470953269536187 1.910714090721169e-06 0.03384790442147732 1.910714373289092e-06 0.03303898052111545 1.910714628198529e-06 0.03232625790162248 \
1.910714908882988e-06 0.03155947796597136 1.910715154716382e-06 0.03090318379665042 1.91071538687767e-06 0.03029616297556957 1.910715627215008e-06 0.02968398395812225 \
1.910715862851843e-06 0.02909722707395018 1.910716091063021e-06 0.0285403787496557 1.910716507835749e-06 0.02755138287878544 1.910716702361127e-06 0.02710176794309662 \
1.910717088601532e-06 0.02623051698020805 1.910717267770925e-06 0.0258356865503758 1.910717618998108e-06 0.02507792837274256 1.910717786904157e-06 0.0247229612172224 \
1.910718171166812e-06 0.02392944198669211 1.910718286448541e-06 0.02369675911063252 1.910718728496378e-06 0.02282172072611499 1.910718950311651e-06 0.02239223679446916 \
1.910719473931311e-06 0.02139838041889957 1.910719629293819e-06 0.02110714647916685 1.910720146999887e-06 0.02015295207761772 1.910720272033152e-06 0.01992792118872039 \
1.910720796234659e-06 0.01901759738223179 1.910720932454034e-06 0.01879045572456909 1.910721538730489e-06 0.01783210191617334 1.910721705739623e-06 0.01758082406519646 \
1.910722348947267e-06 0.01666064795441237 1.910722528091535e-06 0.0164167113061686 1.910723218250269e-06 0.01551958953683085 1.910723381870153e-06 0.01531511209162885 \
1.91072414235084e-06 0.01440332854054019 1.910724289392963e-06 0.01423371673427115 1.910725107264621e-06 0.01333087949608782 1.910725226813134e-06 0.01320411419549955 \
1.910726142674655e-06 0.01227329163592313 1.910726284027572e-06 0.01213544173166964 1.910727232503148e-06 0.01124488043697059 1.910727391142586e-06 0.01110230805801717 \
1.91072857354363e-06 0.01011356759191894 1.91072867164402e-06 0.01003725601038859 1.91072993325548e-06 0.009120360285939955 1.91073006766933e-06 0.009028655389366201 \
1.910731608240655e-06 0.008043892937307966 1.910731689273998e-06 0.007992925041580451 1.910733277867931e-06 0.007023242357651564 1.910733410759078e-06 0.006948518507451114 \
1.91073538746242e-06 0.005952856104192286 1.910735569200568e-06 0.005869662958407677 1.910737671554228e-06 0.004980929874643355 1.910738112345997e-06 0.004810448874467742 \
1.910740767560855e-06 0.003892108290451164 1.910741244140394e-06 0.003745909362026665 1.910744882222615e-06 0.00279447349697209 1.910745407746061e-06 0.002678838783887205 \
1.910751013810845e-06 0.001700248310874221 1.910751324898547e-06 0.001653333728976835 1.910756459226246e-06 0.0006858192122199529 1.910756653206019e-06 0.0006440832883579712 \
1.913404576914862e-06 -0.0002037173203380238 1.913404741115283e-06 -0.0003889174928863678 1.913405314458091e-06 -0.001270938904608877 1.913405389392278e-06 -0.001411855863724778 \
1.913405849976055e-06 -0.002393592696522268 1.913405961916807e-06 -0.002660411672198376 1.913406215188795e-06 -0.003300974950034667 1.9134063815721e-06 -0.003745951779090856 \
1.913406676567869e-06 -0.004566571567208835 1.913406788055442e-06 -0.00488071790655901 1.913407067428216e-06 -0.005641221413069743 1.913407188386555e-06 -0.005938820066262044 \
1.913408282339388e-06 -0.005180465225493313 1.913408406471631e-06 -0.004410796826645887 1.913408530879049e-06 -0.003456122327429311 1.913408650435428e-06 -0.002364170815481491 \
1.913408748579805e-06 -0.001341064316055312 1.913408855004127e-06 -0.0001052154991983786 1.913408967239972e-06 0.001336046702817826 1.913409102195821e-06 0.003249882807978809 \
1.91340922478233e-06 0.005149402351921401 1.913409413644246e-06 0.008353592055059769 1.913409554826578e-06 0.01094873860302964 1.913409708187922e-06 0.01393943619118621 \
1.913409851561427e-06 0.01687898420971235 1.913410005752867e-06 0.02017576688295359 1.913410161892825e-06 0.02363796584892512 1.913410317618878e-06 0.02719811802828209 \
1.913410465112557e-06 0.03065407560139007 1.913410613784323e-06 0.03420778369279751 1.913410769114408e-06 0.03798436241030867 1.913410927740287e-06 0.04189786275883118 \
1.913411092673448e-06 0.0460171220807938 1.913411267096337e-06 0.05041857973200652 1.913411446085736e-06 0.05497510627343041 1.913411635385597e-06 0.05982852266675163 \
1.913411838393603e-06 0.06506368941101938 1.913412057870669e-06 0.07075025585284363 1.91341228893533e-06 0.07675903373893865 1.913412535995649e-06 0.08319974270080552 \
1.913412806420637e-06 0.0902619122132732 1.913413099984324e-06 0.09793335781011638 1.913413424033306e-06 0.1064001814721126 1.913413788254856e-06 0.1159066558703892 \
1.913414180806326e-06 0.1261372395632307 1.913414630304251e-06 0.1378252442462487 1.913415153096484e-06 0.1513754922073403 1.913415766694219e-06 0.1672157090591849 \
1.913416444455093e-06 0.184625848284817 1.913417232720212e-06 0.2047487967247964 1.913418115553071e-06 0.22712469896725 1.913418933839029e-06 0.2476994923478653 \
1.913419661268608e-06 0.2658503723959502 1.913420301381636e-06 0.2817009601644404 1.91342087568535e-06 0.2958213763442377 1.913421413251317e-06 0.3089396094373287 \
1.913421917248776e-06 0.3211464104224903 1.91342239337143e-06 0.3325930942309646 1.913422871259445e-06 0.3439912352478621 1.91342332459255e-06 0.3547121966731367 \
1.913423795885258e-06 0.3657614311162562 1.913424238561085e-06 0.3760518588326446 1.913424757059872e-06 0.3879885572071845 1.913425284221992e-06 0.3999987293386327 \
1.913425663131623e-06 0.4085537955782026 1.913426193047166e-06 0.4204060347738258 1.913426622963746e-06 0.429919877745455 1.913427076664521e-06 0.4398653393542544 \
1.913427543378037e-06 0.4500002271552926 1.913427981059267e-06 0.4594210430579985 1.913428389021531e-06 0.468120704286539 1.913428708454565e-06 0.4748816926501604 \
1.913429080589837e-06 0.4826992142337162 1.913429315571978e-06 0.4876010339127531 1.913429549178225e-06 0.4924491904621348 1.913429797190648e-06 0.4975647713404599 \
1.913430095592078e-06 0.5036796627825791 1.91343035194848e-06 0.5088948470128004 1.913430564241789e-06 0.5131878547336713 1.913430758259861e-06 0.5170959594548015 \
1.913430905246394e-06 0.5200432695146362 1.913431059224405e-06 0.523118600542271 1.913431277106154e-06 0.5274469616807909 1.91343153021048e-06 0.5324525256580425 \
1.913431740049325e-06 0.5365797337241586 1.913431951502633e-06 0.5407247601751553 1.913432233709534e-06 0.5462280430697679 1.913432463254817e-06 0.5506821559930507 \
1.913432679151024e-06 0.5548604062613707 1.913432961372541e-06 0.560308769190463 1.913433212680268e-06 0.5651538146135803 1.91343351034116e-06 0.5708625224168123 \
1.913433760568061e-06 0.5756519166658941 1.913434016931556e-06 0.5805516059354519 1.91343425734157e-06 0.585116682128892 1.913434515521386e-06 0.5900038400537884 \
1.913434739113591e-06 0.5942175703762435 1.913434977623163e-06 0.5986919452581434 1.913435185207861e-06 0.6025689278491061 1.913435401730486e-06 0.6065904171332736 \
1.913435651033092e-06 0.6111939272561876 1.913435856106535e-06 0.6149609706257601 1.91343610737886e-06 0.6195555361399968 1.913436310600886e-06 0.6232455818254186 \
1.913436507472791e-06 0.6267987644955494 1.913436700764307e-06 0.630267737067843 1.913436955542762e-06 0.6348113783570861 1.913437185753374e-06 0.638887973644319 \
1.913437403107185e-06 0.6427143472883045 1.913437701512908e-06 0.6479268061885751 1.913437916915757e-06 0.6516657345437264 1.913438118139476e-06 0.6551344108237934 \
1.913438293060983e-06 0.6581323437428509 1.913438458126254e-06 0.6609495238976936 1.913438627594774e-06 0.6638251431769452 1.913438779731612e-06 0.666392827642013 \
1.913438917642299e-06 0.6687037209181631 1.913439066478412e-06 0.6711867545200138 1.913439194593014e-06 0.6733159837320549 1.913439337815827e-06 0.6756849429836936 \
1.913439459090078e-06 0.6776819274526149 1.913439596688762e-06 0.6799401191146522 1.913439716069216e-06 0.6818929034138137 1.913439863176962e-06 0.6842914131385206 \
1.913439980378628e-06 0.6861933934268433 1.913440073884205e-06 0.6877071857403232 1.913440164873897e-06 0.6891752279197846 1.913440267615961e-06 0.6908280855439021 \
1.913440369133525e-06 0.6924555900607121 1.913440487516631e-06 0.6943444167618776 1.913440599637217e-06 0.6961264383846065 1.913440717192718e-06 0.6979868779962457 \
1.913440902343005e-06 0.7008959348649784 1.913441033535213e-06 0.7029413755586562 1.913441169703753e-06 0.7050491462541959 1.913441291222456e-06 0.7069171228306749 \
1.913441431145468e-06 0.7090538254196674 1.913441535088117e-06 0.7106315721465845 1.913441646249101e-06 0.712309798010818 1.913441750508965e-06 0.7138759052437967 \
1.913441880147056e-06 0.7158124745844324 1.913441977077769e-06 0.7172526339884565 1.913442116000004e-06 0.7193052800722975 1.913442235549293e-06 0.7210612846995991 \
1.913442355121865e-06 0.7228080613301419 1.913442480897243e-06 0.7246353354365959 1.913442607615586e-06 0.7264656873164689 1.913442729655437e-06 0.728218443613998 \
1.913442857803881e-06 0.7300486655261287 1.913442987872205e-06 0.7318956587421809 1.913443108863227e-06 0.7336041830685722 1.91344324963381e-06 0.7355801168346318 \
1.91344335060338e-06 0.7369898206659778 1.913443452204236e-06 0.7384020079314992 1.913443548224548e-06 0.7397310783624924 1.913443659137403e-06 0.7412570822736337 \
1.91344374678503e-06 0.7424563811251772 1.913443846639401e-06 0.7438154404043728 1.913443981404538e-06 0.7456370856934184 1.913444097699018e-06 0.747198032089633 \
1.913444201190815e-06 0.7485782798032956 1.913444325446263e-06 0.7502239458264747 1.913444470359203e-06 0.7521280942578691 1.913444588339771e-06 0.753666143975803 \
1.913444707270878e-06 0.7552056331692281 1.913444846850418e-06 0.7569980918234445 1.913444991202808e-06 0.7588357421297242 1.913445109263616e-06 0.7603265096672839 \
1.913445234085335e-06 0.7618908200857619 1.913445373916531e-06 0.7636286950759973 1.913445498679428e-06 0.7651662633748356 1.913445642192899e-06 0.7669199865864609 \
1.913445762878377e-06 0.7683824344671055 1.913445883722124e-06 0.7698356273746885 1.913446003367048e-06 0.7712633747646481 1.913446133074687e-06 0.7727989859455529 \
1.91344624181849e-06 0.7740766298596218 1.913446364466227e-06 0.7755070372682662 1.913446474242911e-06 0.7767778749889983 1.913446603267025e-06 0.7782599816788072 \
1.913446735043344e-06 0.7797610257751375 1.91344684835592e-06 0.7810403609326458 1.913446969441862e-06 0.7823954393038701 1.913447073314495e-06 0.7835479431998941 \
1.913447215597517e-06 0.785111775748914 1.913447363800666e-06 0.7867227488076519 1.913447522694201e-06 0.7884297907063792 1.913447642887223e-06 0.7897074707829422 \
1.91344779245393e-06 0.7912811323018302 1.913447916569147e-06 0.7925734175081853 1.913448042273444e-06 0.7938699048627912 1.913448145219011e-06 0.7949224966762399 \
1.913448259590165e-06 0.7960823495211882 1.913448372064409e-06 0.7972131756542409 1.913448462336983e-06 0.7981137961420948 1.913448551677879e-06 0.7989989930139054 \
1.913448676903816e-06 0.800229513878344 1.91344878467518e-06 0.8012785338618679 1.913448914342978e-06 0.8025281307685926 1.913449035722257e-06 0.8036855380110038 \
1.913449152278057e-06 0.8047859282369955 1.913449273083453e-06 0.80591497746663 1.913449405708758e-06 0.8071413435168892 1.913449527502378e-06 0.8082555056211007 \
1.913449654106103e-06 0.8094015704683005 1.913449779719621e-06 0.8105266036187198 1.913449899211046e-06 0.8115857443778658 1.913450037409299e-06 0.8127973981963581 \
1.913450146908548e-06 0.8137473213416323 1.913450231056663e-06 0.8144713378799666 1.91345035186072e-06 0.8155017394983226 1.913450447369557e-06 0.8163089346032877 \
1.91345058366036e-06 0.8174496006492775 1.913450726424414e-06 0.8186303638797883 1.913450860857535e-06 0.8197292014569521 1.913450970729519e-06 0.8206175763825388 \
1.913451114629137e-06 0.8217677661037901 1.91345126795672e-06 0.8229768690765377 1.913451395805574e-06 0.8239722812379519 1.913451536202905e-06 0.8250521595273246 \
1.913451662107844e-06 0.8260088941474263 1.91345181672401e-06 0.8271688948348412 1.91345194907934e-06 0.8281489842609937 1.913452075346168e-06 0.8290730392392056 \
1.913452193006695e-06 0.8299245984162376 1.913452341409092e-06 0.8309852945996649 1.91345250860326e-06 0.8321626230293395 1.913452641380572e-06 0.8330844501529713 \
1.913452814281769e-06 0.8342675727345584 1.913452982699063e-06 0.8354015168591284 1.913453152193536e-06 0.8365246342267009 1.913453333630418e-06 0.8377070668209077 \
1.913453476186559e-06 0.8386219603417975 1.91345359009745e-06 0.8393441765511721 1.913453720973659e-06 0.8401643924869071 1.913453822596633e-06 0.8407940582489307 \
1.913453939036872e-06 0.8415078269750864 1.913454074330057e-06 0.8423269142909066 1.913454271595159e-06 0.8435017451489455 1.913454462114483e-06 0.844614933042255 \
1.913454672039296e-06 0.8458175693076773 1.913454852817827e-06 0.8468334846981137 1.913455050185846e-06 0.8479221976595614 1.91345522404434e-06 0.8488638701886076 \
1.913455406558583e-06 0.8498353939890455 1.913455577902694e-06 0.8507314120859523 1.913455752248258e-06 0.8516272398309612 1.913455927651258e-06 0.8525125793730954 \
1.913456103896448e-06 0.8533864315694911 1.913456293665326e-06 0.8543099749208749 1.913456484423344e-06 0.8552205033559714 1.91345668621255e-06 0.8561646193034282 \
1.913456878916116e-06 0.8570482883232282 1.913457088356792e-06 0.8579892478796384 1.913457318098559e-06 0.8589986827500428 1.913457583567511e-06 0.8601360945383778 \
1.913457882213855e-06 0.8613786760148464 1.913458160601222e-06 0.8625023989005415 1.913458444791177e-06 0.8636161469557806 1.913458719285784e-06 0.8646608622318305 \
1.913458991377281e-06 0.8656672252055042 1.913459261593727e-06 0.8666387059277968 1.913459518761914e-06 0.8675381145236246 1.913459791320979e-06 0.8684653318325959 \
1.91346006734232e-06 0.8693777905953765 1.913460337484171e-06 0.8702455402709716 1.913460637231955e-06 0.8711796653984102 1.913461008105812e-06 0.872294745819888 \
1.913461303028796e-06 0.8731503023941 1.913461557284845e-06 0.8738665406311316 1.913461855515577e-06 0.8746822274488602 1.913462129133902e-06 0.8754080260278182 \
1.913462365269549e-06 0.8760175227551726 1.913462605621406e-06 0.876622281264788 1.913462827963785e-06 0.8771680781109068 1.913463021968129e-06 0.8776338860468618 \
1.913463351691207e-06 0.8784037109613512 1.91346350686397e-06 0.8787567114621292 1.913463824616496e-06 0.879461652496718 1.913464003481858e-06 0.8798480920375044 \
1.913464345943324e-06 0.8805675499479563 1.913464530084847e-06 0.8809434933546246 1.913465004990284e-06 0.8818790560183651 1.913465172384703e-06 0.8821975058309585 \
1.913465638216129e-06 0.8830540251881659 1.913465819040967e-06 0.8833751042472839 1.913466313074347e-06 0.8842212008576973 1.913466454417056e-06 0.884455124402366 \
1.913467060806836e-06 0.8854193259359495 1.913467212878983e-06 0.8856514227360587 1.91346785955747e-06 0.8865980751852495 1.913467987853824e-06 0.8867785329419297 \
1.913468635979926e-06 0.8876550049536978 1.913468765772447e-06 0.8878236738033012 1.913469544034095e-06 0.8887860366092379 1.913469659025973e-06 0.8889208282599539 \
1.913470514758392e-06 0.8898661633196656 1.913470660021537e-06 0.8900169066926564 1.913471645777722e-06 0.8909664261264102 1.913471866882863e-06 0.8911622482549515 \
1.913473011997307e-06 0.8921020388386462 1.913473143207264e-06 0.8922053928944147 1.913474330865799e-06 0.8931033243919096 1.913474484486092e-06 0.8932130731307282 \
1.913475894522803e-06 0.8941348173026452 1.913476117329622e-06 0.8942660193790342 1.91347779802033e-06 0.8951452796684343 1.913478125641509e-06 0.8952966652167414 \
1.913480355582631e-06 0.8961896554712738 1.913480908496592e-06 0.8963788593752812 1.913484476711123e-06 0.8973573335043913 1.913484800223538e-06 0.8974284307984646 \
1.913491156631826e-06 0.8984120886469452 1.913491705534672e-06 0.8984686671268907 1.913544207609024e-06 0.8994658645395698 1.913544850637886e-06 0.8994692460188505 \
1.913736989308519e-06 0.9004073346715066 1.913737190722491e-06 0.9004708280105613 1.913741150500432e-06 0.8995366825576255 1.91374133452723e-06 0.8993953949813248 \
1.913742651124504e-06 0.8984641879157507 1.913742823168359e-06 0.8983566564859006 1.913744719544654e-06 0.8973720929359315 1.913744893250842e-06 0.897304621671452 \
1.913757467177875e-06 0.8982933655523699 1.913757552368112e-06 0.8983081509245614 1.913765819241151e-06 0.8993078551592517 1.913766293960572e-06 0.8993433667976791 \
1.914259794870011e-06 0.9002974142054325 1.914259914349735e-06 0.9003767372269074 1.914260807172787e-06 0.9012336455299185 1.914260953429423e-06 0.901423267690772 \
1.914261548322101e-06 0.9023325668564308 1.914261683292918e-06 0.9025673929107925 1.914262187968707e-06 0.9035294259428087 1.914262320579608e-06 0.9038000271808221 \
1.914262721206973e-06 0.9046475051114249 1.914262865572371e-06 0.9049556543240072 1.91426328869358e-06 0.9058123566484279 1.914263384150638e-06 0.9059850892484415 \
1.914264808709455e-06 0.9052205906349737 1.914264933747309e-06 0.9046352442223391 1.914265060157898e-06 0.9039223775493039 1.914265162806642e-06 0.9032486771507763 \
1.914265290021932e-06 0.9022944222362175 1.914265408867758e-06 0.9012801950564071 1.914265506520237e-06 0.9003603330664713 1.914265588522258e-06 0.8995243596151602 \
1.914265668185821e-06 0.8986589236008835 1.914265778963989e-06 0.8973708307079206 1.914265880140003e-06 0.8961049472956977 1.914265963084475e-06 0.8950067229086057 \
1.914266071529892e-06 0.8934921260891034 1.91426617999385e-06 0.8918872687155874 1.914266275049989e-06 0.8904106867557802 1.914266395922641e-06 0.8884444419111864 \
1.914266516699262e-06 0.8863849482818795 1.914266629744433e-06 0.8843763393508186 1.914266732915181e-06 0.8824794505619851 1.914266818515338e-06 0.8808620855018965 \
1.914266892989399e-06 0.8794251273161163 1.914266987312942e-06 0.8775673968166831 1.914267075773857e-06 0.8757888800524039 1.91426715484687e-06 0.8741711975775893 \
1.914267248834225e-06 0.872216793437976 1.914267330179529e-06 0.8704993514258973 1.914267425093555e-06 0.8684673705816817 1.914267518136275e-06 0.8664480751909672 \
1.914267614922069e-06 0.8643215060814092 1.914267738217442e-06 0.8615778533848952 1.914267851664452e-06 0.859022019682563 1.914267977516491e-06 0.8561558571929792 \
1.914268100844635e-06 0.8533196845306243 1.914268230022926e-06 0.850323637950593 1.914268370619783e-06 0.8470370034914 1.914268479399505e-06 0.8444782910716596 \
1.914268614459257e-06 0.8412850455921466 1.914268724119566e-06 0.8386804253780991 1.914268853299345e-06 0.8356002443501571 1.914268979483175e-06 0.8325812421138936 \
1.91426910657353e-06 0.8295317031556502 1.914269235595804e-06 0.826427745883674 1.914269344676045e-06 0.8237985689995477 1.914269484526701e-06 0.8204223029647078 \
1.914269623954893e-06 0.8170507778356514 1.914269756708524e-06 0.8138366863616762 1.914269886777199e-06 0.8106848159989707 1.914270010472646e-06 0.8076853837479523 \
1.914270147427036e-06 0.8043627031572629 1.914270261138882e-06 0.8016030849198694 1.914270388615922e-06 0.7985086235398901 1.914270499416994e-06 0.7958187897651571 \
1.914270618603452e-06 0.7929254985494992 1.914270731982509e-06 0.7901733724735396 1.914270866292901e-06 0.7869138859547327 1.914270973387169e-06 0.7843152933129034 \
1.914271089404312e-06 0.7815009627552112 1.914271218595275e-06 0.778367508739124 1.91427131620771e-06 0.7760002683782802 1.914271421787151e-06 0.773440790716327 \
1.91427153046932e-06 0.7708069008430674 1.914271632885583e-06 0.7683258101021144 1.914271726279241e-06 0.7660641808432364 1.914271845835017e-06 0.7631702213567544 \
1.914271938307379e-06 0.7609327305817616 1.914272030945494e-06 0.7586922094322426 1.91427212937031e-06 0.7563124992069843 1.914272237347962e-06 0.7537030947613649 \
1.914272333616474e-06 0.7513778334636231 1.914272419872877e-06 0.7492952979736797 1.914272522736666e-06 0.7468128004450286 1.914272601580994e-06 0.744910856519283 \
1.914272702387036e-06 0.7424801602439853 1.914272836915276e-06 0.7392377693660663 1.914272974140136e-06 0.7359316755186537 1.914273117619987e-06 0.7324773442723981 \
1.914273266044177e-06 0.7289066083419234 1.914273409305472e-06 0.7254625447335662 1.914273549382451e-06 0.7220977259655398 1.914273705808317e-06 0.7183435968963056 \
1.914273830210067e-06 0.715360858370426 1.914273951271848e-06 0.7124600029613375 1.91427410478411e-06 0.7087850045121084 1.914274239566055e-06 0.7055614325718365 \
1.914274365665087e-06 0.7025479112911024 1.914274508839371e-06 0.6991289103945657 1.914274628921163e-06 0.6962626602560111 1.914274758155491e-06 0.6931807499479741 \
1.914274864640539e-06 0.6906432840523983 1.914274976916361e-06 0.6879696524977363 1.914275073251648e-06 0.6856773754336868 1.91427517606134e-06 0.683232326200841 \
1.914275270865193e-06 0.6809792012818872 1.914275376187123e-06 0.6784784437814733 1.914275484625777e-06 0.6759058899658261 1.914275583635058e-06 0.673558569590366 \
1.91427570039165e-06 0.6707929011939652 1.914275808476928e-06 0.6682347329991606 1.914275918483137e-06 0.6656332609774134 1.914276004570979e-06 0.6635992664604092 \
1.914276134166118e-06 0.6605400273835189 1.914276226767366e-06 0.6583552307294462 1.914276322555092e-06 0.6560965362104854 1.914276407507078e-06 0.6540950852804182 \
1.914276526801602e-06 0.6512869789851043 1.91427661407154e-06 0.6492343850333612 1.914276704778561e-06 0.6471030993779646 1.914276805943536e-06 0.6447280068361273 \
1.914276885774359e-06 0.6428551652550211 1.914276974560193e-06 0.6407732405330839 1.91427705225042e-06 0.6389536101386547 1.914277114019368e-06 0.6375081226244841 \
1.914277177784013e-06 0.6360167668935747 1.914277241018233e-06 0.634538653569437 1.914277280258806e-06 0.6336218002627473 1.914277320897828e-06 0.6326726453797233 \
1.914277400982362e-06 0.6308039353694699 1.914277470886543e-06 0.6291742390428672 1.914277521523256e-06 0.6279942052995945 1.914277560272899e-06 0.6270914175114127 \
1.914277599267879e-06 0.6261832343283663 1.914277643882626e-06 0.6251445623164014 1.914277686739083e-06 0.6241478292286105 1.914277737053687e-06 0.6229782634938205 \
1.914277788990864e-06 0.6217719122409077 1.914277874058449e-06 0.6197972300178722 1.914277934038866e-06 0.6184052992407258 1.914278023826075e-06 0.61632338076978 \
1.914278100290156e-06 0.6145529519516876 1.914278179854447e-06 0.6127119801362371 1.914278260891059e-06 0.6108383709630588 1.914278350105382e-06 0.6087775861620425 \
1.914278440965394e-06 0.6066826282541496 1.914278528184102e-06 0.6046739453334793 1.914278621957293e-06 0.6025158549334848 1.914278723642757e-06 0.6001788642681311 \
1.914278823240848e-06 0.5978941858483342 1.914278935095889e-06 0.5953317151711254 1.914279051129026e-06 0.5926772450523136 1.914279172750132e-06 0.5899020947998995 \
1.914279277133946e-06 0.5875236635596754 1.914279421924166e-06 0.5842296531729801 1.914279534584127e-06 0.5816734289694181 1.914279643596094e-06 0.5792035939892568 \
1.914279736075537e-06 0.5771100174076607 1.914279829526176e-06 0.5749994714793375 1.91427992185204e-06 0.5729181236728181 1.914279994438741e-06 0.571283073141143 \
1.914280050392967e-06 0.5700232888304386 1.914280111461248e-06 0.5686498830286455 1.914280209950765e-06 0.5664400707212188 1.914280273162208e-06 0.5650238531380825 \
1.914280333588177e-06 0.5636708824310654 1.91428041053656e-06 0.5619492451093103 1.914280473695101e-06 0.5605380106414651 1.91428056200871e-06 0.558569506627369 \
1.914280633210033e-06 0.5569845302974165 1.914280719745787e-06 0.555060151797141 1.91428084109856e-06 0.5523665438352664 1.914280969027808e-06 0.5495364947125975 \
1.914281067158439e-06 0.5473694328713704 1.914281180282435e-06 0.5448752016832871 1.914281282350254e-06 0.5426314425864434 1.914281401299124e-06 0.5400217272291628 \
1.914281504386832e-06 0.5377630705755105 1.914281618593987e-06 0.5352670017334624 1.914281732009658e-06 0.532794946211756 1.914281859080713e-06 0.5300302694710822 \
1.914281982900802e-06 0.5273426867079006 1.914282127689607e-06 0.5242103332418484 1.914282263513109e-06 0.5212782585303676 1.914282418567968e-06 0.5179428401013338 \
1.914282579419853e-06 0.5144913885072363 1.914282758149301e-06 0.5106699876709851 1.91428294832834e-06 0.5066200804011861 1.914283158230362e-06 0.5021665212646098 \
1.914283386936347e-06 0.4973332357952056 1.914283640864285e-06 0.4919960258408594 1.91428388179775e-06 0.4869529241725989 1.914284177960236e-06 0.4807889695952298 \
1.914284467957623e-06 0.4747910561470179 1.914284774200956e-06 0.4684976697011882 1.914285094876887e-06 0.4619520863481486 1.914285422744054e-06 0.4553041925245184 \
1.914285762989109e-06 0.4484521981997251 1.914286088414654e-06 0.4419418052309769 1.914286410321802e-06 0.4355465312739703 1.914286740535907e-06 0.4290298934287748 \
1.9142870965285e-06 0.4220583188787752 1.914287415406928e-06 0.4158579595363656 1.914287752858691e-06 0.4093433989943853 1.914288180725407e-06 0.4011531841887147 \
1.914288529437356e-06 0.3945419525178304 1.914288837073319e-06 0.388759214407489 1.914289216899811e-06 0.3816861832573664 1.914289548089372e-06 0.3755780492082042 \
1.914289831697453e-06 0.370391509977049 1.914290142516397e-06 0.3647512908748707 1.914290421833004e-06 0.3597258263082204 1.914290648329152e-06 0.3556836811642302 \
1.914290864011538e-06 0.3518598964090484 1.914291061295543e-06 0.3483842179544538 1.914291266280002e-06 0.3447988491770444 1.914291478501966e-06 0.3411119200457455 \
1.914291733807154e-06 0.33670771290924 1.914291975329402e-06 0.3325734463267218 1.914292206706731e-06 0.3286464933807047 1.914292421559231e-06 0.3250253651850565 \
1.914292642118388e-06 0.3213332986541765 1.914292843544355e-06 0.3179852906236645 1.914293046612606e-06 0.3146379646143546 1.914293244508216e-06 0.3114011111455273 \
1.914293431469302e-06 0.3083651674074345 1.914293625269522e-06 0.3052406640298299 1.914293829186134e-06 0.3019773030815858 1.914294008255468e-06 0.2991336297844484 \
1.914294243846324e-06 0.2954229173226265 1.914294444650423e-06 0.2922868215109002 1.914294645829315e-06 0.2891696385850206 1.914294869639058e-06 0.2857334090862961 \
1.914295034201803e-06 0.2832271910241367 1.914295211129189e-06 0.2805503385691353 1.914295396922194e-06 0.2777610713150803 1.91429557873767e-06 0.2750538970423583 \
1.914295757762463e-06 0.2724132377985424 1.914295925107616e-06 0.2699606650006489 1.914296085536534e-06 0.2676371805838822 1.914296208110285e-06 0.2658719571410424 \
1.914296357874814e-06 0.2637236906090554 1.91429648557194e-06 0.2619099339733745 1.914296592880312e-06 0.2603957336038235 1.914296708880974e-06 0.2587625259947361 \
1.91429681918957e-06 0.2572125806747212 1.914296945068767e-06 0.2554509781935611 1.914297060550618e-06 0.2538402638894013 1.914297195131521e-06 0.2519757335310172 \
1.914297307194775e-06 0.2504255755821768 1.914297457534134e-06 0.2483447107137444 1.914297597159989e-06 0.2464124269747185 1.91429774305181e-06 0.2444035064209518 \
1.914297876012448e-06 0.2425734862730615 1.914297999574161e-06 0.2408709992523319 1.914298146783853e-06 0.2388417729476062 1.914298263370682e-06 0.2372355665500016 \
1.914298402825832e-06 0.23532008003217 1.914298537000301e-06 0.2334768281602104 1.914298662976757e-06 0.2317465561243653 1.914298782376161e-06 0.2301094434087779 \
1.914298877230585e-06 0.2288105340759602 1.914298990368184e-06 0.2272617792622066 1.914299070684642e-06 0.2261626001158484 1.914299158249699e-06 0.2249657246820506 \
1.914299283786836e-06 0.2232507767215072 1.914299389480543e-06 0.2218101326756785 1.914299479135054e-06 0.2205921574607158 1.914299549986253e-06 0.2196300825522397 \
1.914299593014783e-06 0.2190460135436258 1.914299635305326e-06 0.2184724035808872 1.914299677647042e-06 0.2178984240735344 1.914299749842461e-06 0.2169203674089526 \
1.914299792235817e-06 0.2163464205126744 1.914299827490656e-06 0.2158693585303403 1.914299871682239e-06 0.2152716287340076 1.914299941290466e-06 0.2143309212991285 \
1.914299975633796e-06 0.2138672544767182 1.914300020093325e-06 0.2132698436071631 1.914300087771806e-06 0.2123628126304402 1.914300174199065e-06 0.2112058698236149 \
1.914300248835668e-06 0.2102078598594563 1.914300330137676e-06 0.2091219706754807 1.914300427015059e-06 0.2078300362310651 1.914300552998548e-06 0.2061528795789772 \
1.914300655533384e-06 0.2047906894256944 1.914300757016901e-06 0.2034500128132261 1.914300858082597e-06 0.202119416354989 1.914300954696817e-06 0.2008491615811921 \
1.91430105666124e-06 0.1995112314821507 1.914301163383484e-06 0.1981153840927639 1.914301271788624e-06 0.1967018790395962 1.91430138378278e-06 0.1952465002768531 \
1.914301496249907e-06 0.1937897263683151 1.914301608323246e-06 0.1923454332378671 1.914301716215721e-06 0.1909603537828802 1.914301817598649e-06 0.1896629368444172 \
1.914301909236098e-06 0.1884941330679491 1.914302003211707e-06 0.1872990757663449 1.914302074478072e-06 0.1863957871745983 1.91430215115336e-06 0.1854271890400033 \
1.914302254812475e-06 0.184122202819407 1.914302328479596e-06 0.1831974022686171 1.914302401825496e-06 0.1822796569444652 1.914302515215845e-06 0.1808667181969195 \
1.914302603074485e-06 0.1797760932362061 1.914302686923162e-06 0.1787387947787487 1.91430281588559e-06 0.1771515524267008 1.914302917772084e-06 0.1759040172436072 \
1.914303023472791e-06 0.1746156056808686 1.914303125120866e-06 0.1733818993219825 1.914303255982584e-06 0.1718019019596718 1.914303363179221e-06 0.1705140034701537 \
1.914303492508118e-06 0.168969083715685 1.91430360420461e-06 0.167642098072289 1.914303704535189e-06 0.1664555496840579 1.914303800335743e-06 0.1653276075899142 \
1.914303911148015e-06 0.1640289617085985 1.914303998548296e-06 0.1630090521997956 1.914304109869413e-06 0.1617156184952586 1.914304202821272e-06 0.1606409001560029 \
1.91430429039415e-06 0.1596330843918451 1.914304392025023e-06 0.1584700928658864 1.914304476479078e-06 0.1575086241734052 1.914304551583458e-06 0.1566573095634876 \
1.9143046294057e-06 0.1557789554714152 1.914304709763569e-06 0.1548759612316424 1.914304810818399e-06 0.1537464547857493 1.914304893251963e-06 0.1528311848879565 \
1.914304985556514e-06 0.1518114053368895 1.914305062490987e-06 0.150965812476358 1.914305145413557e-06 0.1500585909391909 1.914305216944298e-06 0.1492793026301012 \
1.914305313327797e-06 0.1482344968214558 1.914305383556283e-06 0.1474766665551334 1.914305466536561e-06 0.1465853655470201 1.914305527978824e-06 0.1459298106834085 \
1.914305599661209e-06 0.1451677491870439 1.914305668289752e-06 0.1444408762699853 1.914305718558261e-06 0.1439102090153988 1.914305766138067e-06 0.143409423336876 \
1.914305820187418e-06 0.1428423132663369 1.914305879529516e-06 0.1422216078256897 1.914305947564923e-06 0.1415124633834424 1.914306023828345e-06 0.1407207186008814 \
1.914306092108145e-06 0.1400161356079559 1.914306186894323e-06 0.1390460813732662 1.914306276448135e-06 0.1381341561933974 1.914306348133609e-06 0.1374075731330657 \
1.914306432085018e-06 0.1365606113096345 1.914306497397473e-06 0.1359045398875483 1.914306558840598e-06 0.1352895588344758 1.914306633117097e-06 0.1345490408254265 \
1.914306695327357e-06 0.1339328028964004 1.914306763298366e-06 0.133265236037424 1.914306822505406e-06 0.1326856657519672 1.914306895177878e-06 0.1319767402814105 \
1.914306970197988e-06 0.1312477270463112 1.914307055651411e-06 0.1304208267333309 1.91430714175175e-06 0.1295914604616623 1.914307241877205e-06 0.1286317929389105 \
1.914307323166875e-06 0.127857435971709 1.914307424934223e-06 0.1268981149578782 1.914307509182182e-06 0.1261072369695883 1.914307607998911e-06 0.1251836587365037 \
1.914307680839456e-06 0.1245055382686853 1.914307760865543e-06 0.1237631876254407 1.914307831351338e-06 0.1231117958237987 1.91430790388176e-06 0.1224439308288319 \
1.914307981350756e-06 0.1217331219782777 1.914308088702104e-06 0.1207554316575004 1.91430818934012e-06 0.1198442997624752 1.914308261927674e-06 0.1191899427853172 \
1.914308330759514e-06 0.1185715582611356 1.914308396546334e-06 0.1179824683205609 1.914308466175132e-06 0.1173610347366148 1.914308536558877e-06 0.1167350538439435 \
1.914308611737249e-06 0.1160688810594495 1.914308715991485e-06 0.1151493019715505 1.914308791126139e-06 0.114489769343061 1.914308860041223e-06 0.1138870655592168 \
1.914308923246094e-06 0.1133369146236164 1.91430899278746e-06 0.1127339156958381 1.914309050088964e-06 0.1122385190692166 1.914309121730019e-06 0.1116210355509516 \
1.914309179565093e-06 0.1111240709857579 1.914309251686527e-06 0.1105063809580559 1.91430931410261e-06 0.1099736279351742 1.914309398424131e-06 0.1092565349771765 \
1.9143094660201e-06 0.1086842173446869 1.914309574816032e-06 0.1077671916889585 1.914309679126564e-06 0.1068924975608609 1.914309758614772e-06 0.1062289053282379 \
1.914309846183182e-06 0.1055008617114655 1.914309909639535e-06 0.1049752776433979 1.914309971350652e-06 0.10446579874651 1.914310075190416e-06 0.103612238268202 \
1.914310157871117e-06 0.1029362225408096 1.914310256339144e-06 0.1021348761715451 1.914310340785582e-06 0.101450818648051 1.914310457263062e-06 0.1005121841703865 \
1.914310591996508e-06 0.09943411943161744 1.914310728066044e-06 0.0983541971400249 1.914310842385451e-06 0.09745369041838402 1.914310927852596e-06 0.09678457778867394 \
1.914311038134269e-06 0.09592640631053104 1.914311118922622e-06 0.09530159220710262 1.914311218473493e-06 0.09453592511176086 1.914311308421543e-06 0.09384821103094763 \
1.914311380924943e-06 0.09329669945188329 1.914311462667009e-06 0.09267796846073476 1.914311590787245e-06 0.09171467366828615 1.914311672199308e-06 0.09110674702409056 \
1.914311746631215e-06 0.09055373306570065 1.914311821605099e-06 0.08999936228352182 1.914311901024074e-06 0.08941505746347288 1.914312009684932e-06 0.08862052380504259 \
1.914312104044903e-06 0.08793517800096999 1.914312193440026e-06 0.08728987318634121 1.914312300205742e-06 0.086524181682867 1.914312418708183e-06 0.08568073755029131 \
1.914312560233253e-06 0.08468224831562859 1.914312693371676e-06 0.08375174214918565 1.914312834217007e-06 0.08277682112810406 1.914312983268988e-06 0.08175525972387458 \
1.914313119066718e-06 0.08083369778093191 1.914313260523232e-06 0.0798830809748103 1.914313395783147e-06 0.07898330517332906 1.914313537164988e-06 0.07805242629322809 \
1.914313684232761e-06 0.07709434677344783 1.914313835960902e-06 0.07611680364043326 1.914314001309203e-06 0.07506403321855706 1.914314165176721e-06 0.07403332863189842 \
1.914314341490649e-06 0.07293832728335037 1.914314530925751e-06 0.07177777688466977 1.914314741692455e-06 0.07050569389938771 1.914314961464952e-06 0.06920150027616521 \
1.914315196433104e-06 0.06783224552442871 1.914315455333654e-06 0.06635227408830123 1.914315750264117e-06 0.06470266364809808 1.914316054610178e-06 0.06304001691994518 \
1.914316416556457e-06 0.06111393619706453 1.914316732684213e-06 0.05947639552636011 1.914317174006677e-06 0.0572596911373907 1.91431748757272e-06 0.05573556853365672 \
1.914317911072189e-06 0.0537382660685313 1.914318255024042e-06 0.05216649213267931 1.91431859526531e-06 0.05065508790922631 1.9143189061029e-06 0.04931137323461653 \
1.914319200574801e-06 0.04807062469528345 1.914319494274299e-06 0.04686392507224969 1.914319769145536e-06 0.04576537019482012 1.914320044685701e-06 0.04468949010490332 \
1.91432030977623e-06 0.04367785045825667 1.914320586533311e-06 0.04264571401740119 1.914320869801436e-06 0.04161414314527601 1.914321167794734e-06 0.04055545327485047 \
1.914321427280131e-06 0.03965542606183669 1.914321657303569e-06 0.03887446236327848 1.914321876995156e-06 0.03814321686473518 1.914322101935296e-06 0.0374128399305801 \
1.91432242218897e-06 0.0363978329183388 1.91432270998682e-06 0.03550963653148703 1.914322986382154e-06 0.03467738358988744 1.914323270201283e-06 0.03384352473043348 \
1.914323508310586e-06 0.03315996078327022 1.914323792621371e-06 0.03236211345273886 1.914324034533221e-06 0.03169864947531036 1.914324269673394e-06 0.03106710921041438 \
1.914324511380923e-06 0.03043352335444016 1.914324748333856e-06 0.02982731501219571 1.914324978676274e-06 0.02925002048968134 1.914325192426852e-06 0.02872465224286764 \
1.914325398273815e-06 0.02822791768061097 1.914325790610838e-06 0.02730524204782691 1.914325979002849e-06 0.02687312495148303 1.914326354614307e-06 0.02603163971789 \
1.914326529081082e-06 0.02564950258131362 1.914326953015541e-06 0.02474274850847508 1.914327073769958e-06 0.02449086781212801 1.914327544020721e-06 0.02353384026002922 \
1.914327693235786e-06 0.02323677291035493 1.914328086867998e-06 0.02246740853134286 1.914328257894342e-06 0.02213909006726131 1.914328745173275e-06 0.02121869533024997 \
1.914328887220983e-06 0.02095326544309953 1.914329420237252e-06 0.01997576278857772 1.914329542401289e-06 0.01975737097014436 1.914330064559034e-06 0.01885981776906158 \
1.914330235137336e-06 0.01857989792133653 1.914330722450399e-06 0.01781360777737795 1.914330893973323e-06 0.01755501440977742 1.91433151376008e-06 0.01666567753024489 \
1.914331684684406e-06 0.0164316648397145 1.914332390235396e-06 0.01551160061118263 1.914332552852409e-06 0.01530799450170666 1.914333309745899e-06 0.01439879525764199 \
1.914333450662544e-06 0.01423641007536438 1.914334350661384e-06 0.01324361033368418 1.914334438010635e-06 0.01315122959105692 1.914335342363989e-06 0.01223321097894121 \
1.914335479555938e-06 0.01209984223734439 1.914336450212214e-06 0.01118944790767422 1.914336578130092e-06 0.01107451071402888 1.914337728540039e-06 0.01011008206277823 \
1.914337822342074e-06 0.01003687265682024 1.914339078387887e-06 0.009120584045805383 1.914339215929201e-06 0.009026502753623255 1.914340774683602e-06 0.008029670037698805 \
1.914340858486287e-06 0.007977066150721189 1.914342463865106e-06 0.00699828665725172 1.91434257476345e-06 0.006935886594503895 1.914344507009824e-06 0.005959177461785255 \
1.91434468671476e-06 0.005876661013304485 1.914346798505876e-06 0.004981749118765498 1.914347141291012e-06 0.004848482978762325 1.914349654457045e-06 0.003966891390423618 \
1.914350124178715e-06 0.003819799497680527 1.91435376449499e-06 0.002847564273158896 1.914354280232175e-06 0.002731633924241866 1.914359622062014e-06 0.001773027297371861 \
1.914359907382299e-06 0.001729522787584184 1.914365136030129e-06 0.0007540451492352357 1.914365310176696e-06 0.0007162692714263865 1.917013698769002e-06 -0.0001123232525192561 \
1.91701387179429e-06 -0.0002901710972538241 1.917014491546045e-06 -0.001202022686018724 1.917014580115221e-06 -0.001365806793032466 1.917014941086355e-06 -0.002110727959526865 \
1.91701506578065e-06 -0.002395793696299351 1.917015429622532e-06 -0.003299857180474864 1.9170156008982e-06 -0.003758114451912169 1.917015894896037e-06 -0.004576312838821549 \
1.917016005104443e-06 -0.004886880824040592 1.917016283358441e-06 -0.005643955697619643 1.91701640463225e-06 -0.00594200199557267 1.917017498254348e-06 -0.00517389603226481 \
1.917017621358228e-06 -0.004409713243767066 1.917017744826303e-06 -0.003462788751204457 1.9170178649921e-06 -0.002366010162083454 1.917017962853767e-06 -0.001346276287748183 \
1.917018069556104e-06 -0.0001076498664581183 1.917018181397488e-06 0.001328007358939307 1.917018317371855e-06 0.003256083960376262 1.917018439401011e-06 0.00514709866632534 \
1.917018627817289e-06 0.008343062029134115 1.917018768805819e-06 0.01093380316938193 1.917018921577523e-06 0.01391176330477175 1.91701906428015e-06 0.01683596409946878 \
1.917019218632388e-06 0.02013443377634912 1.917019374426043e-06 0.02358734537610087 1.91701953048334e-06 0.02715365164079262 1.91701967788774e-06 0.03060642997674319 \
1.917019826504485e-06 0.03415780069914553 1.917019981925702e-06 0.03793559522944389 1.917020140311532e-06 0.04184227512730877 1.917020305251154e-06 0.04596085539464361 \
1.917020479500423e-06 0.05035714787605008 1.917020658443539e-06 0.05491177248689325 1.917020847583032e-06 0.0597604232635115 1.91702105036361e-06 0.06498910043066243 \
1.917021269735637e-06 0.07067233091134768 1.917021500572133e-06 0.07667464705993039 1.917021747383969e-06 0.0831083675499642 1.91702201751608e-06 0.09016243555275107 \
1.917022310704188e-06 0.0978236474935409 1.917022634359626e-06 0.1062798466079799 1.917022997926912e-06 0.1157689210849182 1.91702339022043e-06 0.1259925151671456 \
1.917023838699915e-06 0.1376538644086695 1.9170243603994e-06 0.1511757390224034 1.917024972772044e-06 0.1669844191341421 1.917025649417359e-06 0.1843663871188266 \
1.917026436327649e-06 0.2044554566749352 1.917027317548744e-06 0.2267919980918504 1.917028137292384e-06 0.2474048556006221 1.917028865745328e-06 0.2655829647002126 \
1.917029507221317e-06 0.2814688958417333 1.917030083144485e-06 0.2956305456066151 1.917030620401302e-06 0.3087428400511723 1.917031124292597e-06 0.3209487846516751 \
1.917031601896145e-06 0.3324328152479784 1.917032080019379e-06 0.343838772307344 1.917032532118228e-06 0.3545331600964184 1.917033003884519e-06 0.365596737404158 \
1.91703344758136e-06 0.3759140547845509 1.917033969549898e-06 0.3879344734281669 1.91703449708783e-06 0.399956933836353 1.917034876602574e-06 0.4085271910771138 \
1.917035405564174e-06 0.4203606102508351 1.917035874883255e-06 0.4307444005277802 1.917036310038791e-06 0.4402814026247405 1.917036757516117e-06 0.4500002273945978 \
1.917037197539592e-06 0.4594737646471725 1.917037600841335e-06 0.4680814138276727 1.917037919241101e-06 0.4748254127722248 1.917038289219015e-06 0.4826007100982719 \
1.917038525472097e-06 0.4875314737878706 1.917038760543493e-06 0.4924129045770672 1.917039011882831e-06 0.4975994385012801 1.917039318269865e-06 0.5038799449729535 \
1.917039575228319e-06 0.5091120301871851 1.917039783702615e-06 0.5133309170973237 1.917039984084905e-06 0.5173683849445317 1.917040126478606e-06 0.5202244049244739 \
1.917040275403072e-06 0.5231993726577677 1.917040486949328e-06 0.5274019882470222 1.917040713006951e-06 0.5318780389403845 1.917040907549333e-06 0.5357103559602913 \
1.917041096681229e-06 0.539423417888626 1.917041326128277e-06 0.5439012399750046 1.917041508634083e-06 0.5474563135343053 1.917041745996952e-06 0.5520623276458133 \
1.91704201499126e-06 0.5572695987004129 1.91704226390171e-06 0.5620706638085723 1.917042507918531e-06 0.5667633705755619 1.917042780273744e-06 0.5719926523718327 \
1.917043041669874e-06 0.5769928369418796 1.917043299301279e-06 0.5819084237686675 1.917043546144628e-06 0.586601202059797 1.917043791890354e-06 0.5912552023551558 \
1.917044018467874e-06 0.5955288021520931 1.917044249620064e-06 0.5998646534936181 1.917044455900444e-06 0.6037202012184053 1.917044684021204e-06 0.6079592993751251 \
1.917044906401185e-06 0.6120725203834017 1.917045133377667e-06 0.6162454422471376 1.917045348430617e-06 0.6201823359462864 1.91704557780019e-06 0.6243500782103125 \
1.917045846823065e-06 0.6292041961704016 1.917046069836712e-06 0.6331993632081415 1.917046282091289e-06 0.6369772451758789 1.917046493488879e-06 0.6407176358819484 \
1.917046693558109e-06 0.644236566349866 1.917046923151959e-06 0.6482486956559365 1.917047163988886e-06 0.6524328529570182 1.917047345738273e-06 0.6555667906748446 \
1.9170475342865e-06 0.6588018260593631 1.917047687366139e-06 0.6614154033769962 1.917047859374421e-06 0.6643352515471471 1.91704800954724e-06 0.6668697017322168 \
1.917048146064529e-06 0.6691578850264722 1.917048295693716e-06 0.6716547631652277 1.917048423434085e-06 0.673777752640997 1.917048563020223e-06 0.6760856948620949 \
1.91704868725891e-06 0.6781310478824312 1.91704881840875e-06 0.6802827752320969 1.917048942850093e-06 0.6823179209931315 1.917049080080916e-06 0.6845542421253382 \
1.917049200329086e-06 0.6865048414796368 1.91704934166053e-06 0.6887891282595083 1.917049441991641e-06 0.6904033553735033 1.917049563109343e-06 0.6923460943304175 \
1.917049653886877e-06 0.6937948943079848 1.917049751145343e-06 0.6953408241330762 1.917049847353223e-06 0.6968660703265798 1.917049935967068e-06 0.6982647859968389 \
1.917050033255091e-06 0.6997938110311075 1.917050165723729e-06 0.7018622871835729 1.917050320913928e-06 0.7042674555997347 1.917050458791879e-06 0.7063866855441746 \
1.917050603646153e-06 0.7085960165693863 1.91705073070791e-06 0.7105202221428537 1.91705085539347e-06 0.7123960184768648 1.917050968098846e-06 0.7140814553427599 \
1.917051079889191e-06 0.7157437310299281 1.91705118066784e-06 0.7172341607972841 1.917051317946295e-06 0.7192525454101454 1.917051437630367e-06 0.7210013704967912 \
1.917051557059838e-06 0.7227365757678518 1.91705168394306e-06 0.7245692610776365 1.917051808360712e-06 0.7263556789600311 1.917051932093537e-06 0.728121726658988 \
1.917052058689063e-06 0.7299181396522603 1.917052189074464e-06 0.7317573312219798 1.917052311884284e-06 0.7334798522758219 1.91705244732006e-06 0.7353678990088863 \
1.917052548609838e-06 0.7367723836293941 1.917052656232334e-06 0.7382576460517265 1.917052745760416e-06 0.7394878879617913 1.917052860308785e-06 0.7410528648863303 \
1.917052948337041e-06 0.7422487366778059 1.917053055415107e-06 0.7436953530868765 1.9170531854801e-06 0.7454403311053276 1.917053296759795e-06 0.7469230742113165 \
1.917053401378355e-06 0.7483084058091373 1.91705352546134e-06 0.7499400420429273 1.917053673762169e-06 0.7518749696944975 1.917053795162033e-06 0.7534462209622173 \
1.91705390960278e-06 0.7549170836379747 1.917054049940098e-06 0.7567069362027918 1.917054191702981e-06 0.7584995177563068 1.917054309503919e-06 0.759977341175643 \
1.917054437480785e-06 0.761570846386187 1.917054579183209e-06 0.7633205808366864 1.917054696694523e-06 0.7647599110190483 1.917054842299792e-06 0.7665289162262866 \
1.9170549639941e-06 0.7679951561698679 1.917055082724709e-06 0.7694149786178283 1.917055205011304e-06 0.7708662727382939 1.917055332055819e-06 0.77236234268503 \
1.917055441699792e-06 0.7736439866494906 1.917055567386705e-06 0.7751025186690397 1.917055673401805e-06 0.776323977486031 1.917055808987772e-06 0.7778743028704433 \
1.917055933950769e-06 0.7792913979962601 1.917056059856921e-06 0.7807070123991936 1.917056175124167e-06 0.7819915514687489 1.91705628142864e-06 0.7831664991275713 \
1.917056419833432e-06 0.7846822315516878 1.917056569129882e-06 0.7862997378875561 1.917056714637328e-06 0.7878588534534761 1.917056834041839e-06 0.7891257303126159 \
1.917056969134663e-06 0.7905455128963393 1.917057090387826e-06 0.7918076974797237 1.917057233381105e-06 0.7932816011184505 1.91705737758541e-06 0.7947523458802197 \
1.917057503122239e-06 0.7960199014141693 1.917057622168612e-06 0.7972110037065316 1.917057734104496e-06 0.7983213107123885 1.917057838976047e-06 0.7993531099923881 \
1.917057934226459e-06 0.8002831901653534 1.917058070569705e-06 0.8016020813281191 1.917058187393835e-06 0.8027203407102198 1.917058306798445e-06 0.803852171037294 \
1.917058428905249e-06 0.8049980820693966 1.91705855186025e-06 0.8061401395390313 1.917058678828951e-06 0.8073073595000361 1.91705880406856e-06 0.8084467645495962 \
1.917058934640955e-06 0.8096220968518901 1.917059060631473e-06 0.8107441738369082 1.917059188817386e-06 0.8118738099374113 1.917059294347114e-06 0.8127947795787664 \
1.917059397218887e-06 0.8136847278655364 1.917059490214057e-06 0.8144826950388273 1.91705961401066e-06 0.8155354283166244 1.917059701978917e-06 0.8162769513478326 \
1.917059800709989e-06 0.8171027376706747 1.917059943975142e-06 0.8182889948057973 1.917060079253827e-06 0.8193962136425846 1.917060188368449e-06 0.8202800249700468 \
1.917060336451758e-06 0.8214657808291811 1.917060486222685e-06 0.8226492530953341 1.917060611457285e-06 0.8236267526687548 1.917060755448703e-06 0.8247372275730155 \
1.917060879504774e-06 0.8256825756473101 1.917061029968032e-06 0.8268152483647575 1.917061165678884e-06 0.8278240064655301 1.917061290697392e-06 0.828742521381556 \
1.917061408452322e-06 0.8295983347934622 1.917061554429135e-06 0.8306466023667578 1.917061720938452e-06 0.8318251482734692 1.917061851861028e-06 0.8327390940956469 \
1.917062025288466e-06 0.8339327615268647 1.917062193435348e-06 0.8350717495747054 1.917062363270277e-06 0.8362042975620877 1.917062544195048e-06 0.8373912937861997 \
1.917062687293307e-06 0.8383160748488641 1.917062801379198e-06 0.8390446117604563 1.917062931553184e-06 0.8398665237782376 1.917063033394266e-06 0.8405024977857931 \
1.917063150213615e-06 0.8412243379523001 1.917063287078045e-06 0.8420597162999857 1.917063484876668e-06 0.8432475311273343 1.91706367648074e-06 0.8443767279905872 \
1.917063885921222e-06 0.8455874169714939 1.917064067846852e-06 0.8466193100105236 1.917064264979958e-06 0.8477171434207121 1.917064438329848e-06 0.8486653666163242 \
1.917064621329232e-06 0.8496493024239481 1.917064792495495e-06 0.8505537352954988 1.917064967127282e-06 0.8514606693963016 1.917065142389669e-06 0.8523550102558151 \
1.917065318541784e-06 0.8532381479010797 1.917065508812824e-06 0.8541746551565574 1.917065699414774e-06 0.85509499218684 1.917065900062401e-06 0.8560449689899254 \
1.917066092672966e-06 0.8569390259424264 1.917066303330652e-06 0.8578972157030333 1.917066531456051e-06 0.8589122247267402 1.917066797213368e-06 0.8600655879592763 \
1.917067095837813e-06 0.8613244245924475 1.917067372169332e-06 0.862454900702886 1.91706765640239e-06 0.8635842083919951 1.917067930614306e-06 0.8646423892283146 \
1.917068202842372e-06 0.8656634505877856 1.917068473051191e-06 0.8666487272755322 1.917068730204067e-06 0.8675609437488442 1.917069002786335e-06 0.868501515423508 \
1.917069278771335e-06 0.8694269133137555 1.917069548872911e-06 0.8703069289141475 1.917069848734863e-06 0.8712546000783432 1.917070219768993e-06 0.8723856543073821 \
1.917070514706754e-06 0.8732530157608677 1.917070768997536e-06 0.8739790309043101 1.917071067254951e-06 0.8748056771600844 1.917071340863484e-06 0.8755409825400007 \
1.91707157699155e-06 0.8761583495732972 1.91707181733693e-06 0.876770807053994 1.917072039670212e-06 0.8773233906735478 1.91707223367596e-06 0.8777948466981503 \
1.917072563398506e-06 0.8785737911727464 1.917072718571944e-06 0.8789308835864816 1.917073036347473e-06 0.8796437246174529 1.91707321520917e-06 0.8800342982281311 \
1.917073557671047e-06 0.8807611334253193 1.917073741799519e-06 0.8811407335605206 1.917074216677856e-06 0.8820849466541889 1.917074384074053e-06 0.8824061830950772 \
1.917074849915456e-06 0.8832696475595492 1.917075030737665e-06 0.8835931319180218 1.917075524775914e-06 0.8844450822729043 1.917075666124327e-06 0.8846804878101884 \
1.917076272457385e-06 0.8856498028150036 1.917076424526725e-06 0.8858829444029697 1.9170770712152e-06 0.8868329272509302 1.917077199509723e-06 0.8870138524519416 \
1.917077847626928e-06 0.8878919388991984 1.917077977425791e-06 0.8880607713689423 1.917078755627481e-06 0.8890227771434612 1.917078870684414e-06 0.8891574578072456 \
1.917079726342848e-06 0.8901003239091128 1.917079871707616e-06 0.8902505899439886 1.91708085746403e-06 0.8911948786459364 1.91708107856904e-06 0.8913892999646706 \
1.917082223696019e-06 0.8923206810037944 1.917082354912619e-06 0.892422953350996 1.917083696124267e-06 0.8934189515818408 1.917083847523211e-06 0.8935240845833778 \
1.917085328961459e-06 0.8944568913393511 1.917085567840892e-06 0.8945912088657246 1.917087337161074e-06 0.8954685138428928 1.91708772631084e-06 0.895637400736999 \
1.917090119976627e-06 0.896526474291006 1.91709059568945e-06 0.8966764365754722 1.917094011699057e-06 0.8975478548673914 1.917094658849071e-06 0.8976786076740833 \
1.917102137013678e-06 0.8986646932675814 1.917102809590796e-06 0.8987192862546014 1.917195253995367e-06 0.8997188196574962 1.917195917228051e-06 0.8997241906476866 \
1.917385126389945e-06 0.900686595210158 1.917385288462789e-06 0.9007292695325627 1.917387933983676e-06 0.8998161167154269 1.917388102533154e-06 0.8996881690130656 \
1.917389379285545e-06 0.8987393243250013 1.917389581451881e-06 0.8986030018074492 1.917391189561268e-06 0.8976721249252815 1.917391381667193e-06 0.8975774045828077 \
1.917406495049839e-06 0.8985726115129884 1.917406683108756e-06 0.8986004060702872 1.917417988037768e-06 0.8995874924221801 1.917418361423516e-06 0.8996034751727418 \
1.917907373786698e-06 0.9005892719715856 1.917907484554898e-06 0.9006868984798269 1.917908237227259e-06 0.9015617873136611 1.917908339021946e-06 0.9017086238768567 \
1.91790887442049e-06 0.9025814930725723 1.917908976929663e-06 0.9027670217776843 1.917909369148482e-06 0.9035254014384071 1.917909509991429e-06 0.9038129158713877 \
1.917909951028881e-06 0.9047472953155866 1.917910136514484e-06 0.9051402477015744 1.917910652827601e-06 0.9061269394579334 1.917910737502694e-06 0.9062564181617988 \
1.917911972174744e-06 0.9053011091537977 1.917912129388156e-06 0.9045688862145235 1.917912321204818e-06 0.9034162411061901 1.917912488045348e-06 0.9021712267446264 \
1.917912635003746e-06 0.9008824031243315 1.917912749119942e-06 0.8997575350477262 1.917912878992032e-06 0.8983446880789033 1.91791299010955e-06 0.8970273815442567 \
1.917913082914029e-06 0.8958483937359277 1.917913171236719e-06 0.8946639786015808 1.917913274417478e-06 0.8932058048613533 1.917913366625413e-06 0.8918333298588224 \
1.91791345419561e-06 0.8904732289418564 1.917913568189076e-06 0.8886245408236838 1.9179137299935e-06 0.8858564722885236 1.917913914992118e-06 0.8825005184224666 \
1.917914107151785e-06 0.8788219124347386 1.917914308599139e-06 0.874780227084481 1.917914515009728e-06 0.8704697801294994 1.917914700181681e-06 0.8664790122147591 \
1.917914884689405e-06 0.862405115500708 1.917915057841296e-06 0.8585071391690239 1.917915242887321e-06 0.8542751393552932 1.917915420261524e-06 0.8501657390392787 \
1.917915597007955e-06 0.8460284987362284 1.917915763166606e-06 0.8421077870518131 1.917915925211045e-06 0.8382599993991456 1.917916091783925e-06 0.8342839555277276 \
1.917916250437662e-06 0.8304816347052207 1.917916441313687e-06 0.8258903812682129 1.917916616297259e-06 0.8216694867670907 1.917916786243392e-06 0.8175615830390965 \
1.917916951419568e-06 0.8135626411663678 1.917917124611674e-06 0.8093650119631921 1.917917295673877e-06 0.8052155696745213 1.917917463774914e-06 0.801136095357175 \
1.917917654109863e-06 0.7965156511928794 1.917917837691807e-06 0.7920591698039 1.917918045682731e-06 0.7870113041480956 1.917918268259242e-06 0.7816114142545842 \
1.917918457674258e-06 0.7770174196885687 1.917918650984654e-06 0.7723312127316435 1.91791879443024e-06 0.7688556734481145 1.917918943853591e-06 0.7652374066097742 \
1.917919063006063e-06 0.7623536300085233 1.917919175722545e-06 0.7596269484184472 1.917919284997451e-06 0.7569846861296079 1.917919421027209e-06 0.753697254849378 \
1.917919533823024e-06 0.750972995067179 1.91791965602098e-06 0.7480232093637929 1.917919767605752e-06 0.7453311011793381 1.917919892312216e-06 0.7423241425761796 \
1.917920046694167e-06 0.7386034578119585 1.917920213478233e-06 0.7345862494782525 1.917920430642921e-06 0.7293605768817599 1.91792062520351e-06 0.7246835946359503 \
1.917920785534395e-06 0.7208333202545074 1.917920960959998e-06 0.7166251500492028 1.917921150723573e-06 0.7120779400724765 1.917921339451897e-06 0.7075610435995559 \
1.917921521273264e-06 0.7032145396962334 1.917921705870676e-06 0.6988062725207448 1.917921842953811e-06 0.6955348514212173 1.917921996242049e-06 0.6918805091472418 \
1.917922191613795e-06 0.6872279990818534 1.917922347770546e-06 0.6835136309588888 1.917922505722766e-06 0.6797605476340507 1.91792270397403e-06 0.6750570282453686 \
1.917922897319928e-06 0.6704763548785364 1.917923133825274e-06 0.6648822204491218 1.917923320030378e-06 0.6604858901039825 1.917923557652698e-06 0.6548824851665868 \
1.917923744451452e-06 0.6504854738275335 1.917923925009212e-06 0.6462424706993735 1.917924088085156e-06 0.6424159959781919 1.917924232696721e-06 0.6390271817202816 \
1.91792437329907e-06 0.6357379642635244 1.917924500108657e-06 0.632774906490579 1.917924632245193e-06 0.6296924762754078 1.917924758489145e-06 0.6267508340255646 \
1.917924889752774e-06 0.6236963630311418 1.917925018850514e-06 0.6206978048938425 1.917925158276179e-06 0.6174624210713571 1.917925306646171e-06 0.6140261568477932 \
1.91792550120306e-06 0.6095278574984737 1.917925644648937e-06 0.6062198040692683 1.917925879109183e-06 0.6008245134060309 1.917926051007495e-06 0.5968818013610552 \
1.917926263928033e-06 0.5920102583789468 1.917926436394651e-06 0.5880775912131976 1.917926566719197e-06 0.5851108450968721 1.917926698275517e-06 0.5821241897920357 \
1.917926808505599e-06 0.5796262478458715 1.917926904159847e-06 0.5774603558442819 1.917927003393806e-06 0.5752182923213994 1.917927086311907e-06 0.5733484809858778 \
1.917927165227534e-06 0.5715706040143225 1.917927228156309e-06 0.5701535626562365 1.917927293664786e-06 0.5686800671140783 1.917927374150839e-06 0.5668736364148982 \
1.917927424016846e-06 0.5657560592102344 1.917927473205615e-06 0.5646541775062763 1.917927534675401e-06 0.5632780399140616 1.917927582596929e-06 0.5622058085646952 \
1.917927633441648e-06 0.5610687758404553 1.917927692541903e-06 0.5597501790023616 1.91792775115623e-06 0.5584442118409422 1.917927826782323e-06 0.5567607189607793 \
1.917927897341035e-06 0.5551915720267918 1.917927986471042e-06 0.5532116467156011 1.91792807569462e-06 0.5512351177508077 1.91792816099823e-06 0.5493490637975145 \
1.917928248625197e-06 0.5474138635528197 1.91792834562712e-06 0.545274424894262 1.917928449972891e-06 0.5429792414815097 1.917928566264315e-06 0.5404269323775457 \
1.917928672601932e-06 0.5380963700835184 1.917928784310815e-06 0.5356536306660374 1.917928896605295e-06 0.5332047801427824 1.917929023802854e-06 0.5304364255197962 \
1.917929146572528e-06 0.5277698476303582 1.917929288796924e-06 0.5246912237717902 1.917929425160056e-06 0.5217463069543907 1.917929577381123e-06 0.5184691491721333 \
1.91792973701733e-06 0.5150420887864461 1.917929912992521e-06 0.5112761258030903 1.917930101501109e-06 0.5072591542828934 1.91793030856769e-06 0.5028616940969075 \
1.917930533509662e-06 0.4981043078903621 1.917930784905619e-06 0.4928144328841237 1.917931021331185e-06 0.4878598554762091 1.917931318494919e-06 0.4816683149127979 \
1.917931609172211e-06 0.4756487143466775 1.917931917027196e-06 0.469313240945046 1.917932230852953e-06 0.4628991126846517 1.917932559994313e-06 0.4562163541974347 \
1.91793289337242e-06 0.4494927613461197 1.917933224999028e-06 0.4428490490857003 1.917933546548425e-06 0.4364504708187015 1.917933874224238e-06 0.4299742838549845 \
1.91793422184386e-06 0.4231546934710667 1.917934555065174e-06 0.4166645133789623 1.917934900974402e-06 0.4099771621835854 1.917935346388221e-06 0.4014400148089548 \
1.917935704178092e-06 0.3946500490499754 1.917936018334912e-06 0.3887397205534429 1.917936402745392e-06 0.3815756289527631 1.917936732720037e-06 0.3754830843203271 \
1.917937017930125e-06 0.3702633801070484 1.917937326220382e-06 0.3646649204592909 1.917937606017444e-06 0.3596257204303125 1.917937832011793e-06 0.3555880084110294 \
1.917938046849747e-06 0.3517755993421203 1.91793824528482e-06 0.3482769933469286 1.917938449224337e-06 0.3447071465415313 1.917938659760396e-06 0.3410461989361561 \
1.917938916734522e-06 0.3366091000429626 1.917939157995129e-06 0.3324763702393667 1.917939389568845e-06 0.3285420159269506 1.917939604222291e-06 0.3249208057821749 \
1.917939825046275e-06 0.3212218866489027 1.917940026292867e-06 0.3178749657716667 1.91794022938212e-06 0.3145250552959265 1.917940427226991e-06 0.3112865758726304 \
1.917940614079937e-06 0.3082497660855442 1.917940808016663e-06 0.3051208532403978 1.917941011761317e-06 0.30185834615803 1.917941190488583e-06 0.2990186060348319 \
1.917941428134378e-06 0.2952727068736475 1.917941627896611e-06 0.2921508861588616 1.917941829525428e-06 0.2890253490052915 1.917942054991886e-06 0.285561995332 \
1.917942221086285e-06 0.2830312764183137 1.917942399705387e-06 0.2803277612349699 1.917942581409588e-06 0.2775983111934518 1.917942770043305e-06 0.2747882307029562 \
1.917942947466508e-06 0.2721695222189568 1.917943124659646e-06 0.2695724116247911 1.917943284731561e-06 0.2672552081803913 1.917943405132238e-06 0.2655193337608355 \
1.917943552958303e-06 0.2633957862580221 1.917943681588075e-06 0.2615692882062232 1.917943783793658e-06 0.2601227034409412 1.917943902028939e-06 0.2584516051170885 \
1.917944022482299e-06 0.2567534139348401 1.917944146190618e-06 0.2550183706610066 1.917944264442643e-06 0.2533694204037282 1.917944392295773e-06 0.2515887492000971 \
1.917944512581604e-06 0.249915736161692 1.91794466526121e-06 0.2477917697339537 1.917944800173988e-06 0.2459264316518071 1.91794492881341e-06 0.2441493177932957 \
1.917945086528788e-06 0.2419705448111171 1.917945213210091e-06 0.2402201997919771 1.917945348536158e-06 0.2383592392624043 1.917945487448727e-06 0.2364550510890953 \
1.917945605221031e-06 0.2348405558720491 1.917945764491849e-06 0.2326580599570062 1.917945901013704e-06 0.2307878375452989 1.91794604224565e-06 0.2288626996658652 \
1.917946148058693e-06 0.2274220928889542 1.91794627840164e-06 0.2256484734765637 1.917946378112453e-06 0.2242944442559471 1.917946480933888e-06 0.2228991027388591 \
1.917946554349543e-06 0.2219046249368765 1.917946634181104e-06 0.2208265149641777 1.917946704228335e-06 0.2198809561195558 1.917946754631427e-06 0.2192009305305119 \
1.917946806883225e-06 0.2184966408607167 1.917946886120743e-06 0.2174292050927151 1.917946927964696e-06 0.2168658036437602 1.917946967304648e-06 0.216336351877609 \
1.917947010340057e-06 0.2157575332679269 1.917947054507484e-06 0.2151638767852215 1.917947128273223e-06 0.2141731338947761 1.917947163785221e-06 0.2136967174286463 \
1.917947211500021e-06 0.2130606706933813 1.917947272229561e-06 0.2122518321687151 1.917947340486787e-06 0.2113438957752176 1.917947413008566e-06 0.2103801801047663 \
1.917947485683193e-06 0.2094152724966429 1.917947593999181e-06 0.2079788886429202 1.917947691670323e-06 0.20668564243436 1.917947803221819e-06 0.2052110974836689 \
1.917947901757253e-06 0.2039136008387587 1.917948005250393e-06 0.2025572972554956 1.917948101152128e-06 0.2013021587886929 1.917948203780057e-06 0.1999606878451601 \
1.91794830660317e-06 0.1986207062101238 1.917948416722797e-06 0.1971897063011611 1.917948525418353e-06 0.1957815523781236 1.917948645095582e-06 0.1942360962608612 \
1.917948755373261e-06 0.192818053470401 1.917948863436481e-06 0.1914343471929882 1.917948988535148e-06 0.1898375077741012 1.917949078504982e-06 0.1886931806549971 \
1.917949157191934e-06 0.1876950225942949 1.917949234476806e-06 0.1867173468865102 1.917949320985382e-06 0.1856271834369256 1.917949419934593e-06 0.1843848109964498 \
1.917949490443458e-06 0.1835017733581451 1.917949561894511e-06 0.1826096997732476 1.917949667039846e-06 0.1813018727451555 1.917949746279475e-06 0.1803200401832796 \
1.917949827363369e-06 0.1793174195483187 1.91794992085531e-06 0.1781663090788374 1.917950021631285e-06 0.1769308188703378 1.917950171343388e-06 0.175105380089017 \
1.917950287132704e-06 0.1737009932372819 1.91795043813808e-06 0.1718807311127691 1.9179505492465e-06 0.1705485445502526 1.917950691372958e-06 0.168854666407182 \
1.917950809031379e-06 0.167460358327668 1.917950913935975e-06 0.1662230887079887 1.917951008998573e-06 0.1651069099307241 1.917951102429828e-06 0.1640147999883682 \
1.91795120347649e-06 0.1628388413495604 1.917951299823398e-06 0.1617223204899406 1.917951396975643e-06 0.1606011553546776 1.917951480024216e-06 0.1596469772300165 \
1.91795159006187e-06 0.1583897228513109 1.917951672364431e-06 0.1574542248873526 1.917951777364141e-06 0.156267858580057 1.91795185506021e-06 0.1553950893374849 \
1.917951937879689e-06 0.1544690878994293 1.917952019541594e-06 0.1535604570452941 1.917952108890884e-06 0.152571060794856 1.91795218460332e-06 0.1517364980793458 \
1.917952267165934e-06 0.1508307726525361 1.917952343747367e-06 0.1499942554682341 1.917952412035253e-06 0.1492531084507001 1.917952505402265e-06 0.1482449401818621 \
1.917952574555677e-06 0.1475015570698688 1.917952650180008e-06 0.1466917482325688 1.917952711729129e-06 0.1460354497178591 1.917952778977892e-06 0.1453208357145237 \
1.917952850039892e-06 0.1445684785944268 1.91795292553732e-06 0.143772322008306 1.91795298444886e-06 0.1431546944759192 1.91795306112247e-06 0.1423563022825049 \
1.917953141443212e-06 0.1415233898163201 1.917953214594519e-06 0.1407682091691316 1.917953308750941e-06 0.139800669784813 1.917953380355125e-06 0.1390684367429364 \
1.9179534538159e-06 0.1383201464810226 1.917953537327651e-06 0.1374732033664194 1.917953626806795e-06 0.1365744208092838 1.9179536918717e-06 0.1359252211013016 \
1.917953803997723e-06 0.1348115665849295 1.917953869183863e-06 0.1341670699454539 1.917953939222108e-06 0.1334770515823289 1.917953999527163e-06 0.1328849371768329 \
1.917954054537987e-06 0.1323464455745446 1.917954142654965e-06 0.1314871014507438 1.917954183441259e-06 0.131090685705856 1.91795428714401e-06 0.1300923774523848 \
1.91795433045658e-06 0.1296773144713907 1.917954391675178e-06 0.1290920262082728 1.917954436511897e-06 0.1286643765206081 1.917954524107923e-06 0.127831527987147 \
1.91795456566188e-06 0.1274377589706847 1.917954625523389e-06 0.1268718307679372 1.917954697367115e-06 0.1261946708524367 1.917954753579841e-06 0.1256664967939027 \
1.91795481606734e-06 0.125081039250218 1.917954890295323e-06 0.1243877959456236 1.917954964976329e-06 0.1236954937854857 1.917955052159541e-06 0.1228905551604285 \
1.917955120558092e-06 0.1222610287411191 1.917955201128775e-06 0.1215216597888775 1.917955282424256e-06 0.120778012781285 1.917955349340781e-06 0.1201677797529914 \
1.917955432157725e-06 0.1194156054679852 1.917955491346448e-06 0.1188799972037829 1.917955557267448e-06 0.1182853617472536 1.917955637141492e-06 0.1175675408705869 \
1.91795571363729e-06 0.1168828806096336 1.917955795099401e-06 0.1161574242846086 1.917955893570282e-06 0.1152852106851665 1.91795596868063e-06 0.114622623867465 \
1.91795607166842e-06 0.1137180076826871 1.917956145852372e-06 0.1130691786503039 1.917956243471825e-06 0.1122190343868764 1.91795633928278e-06 0.1113890351962442 \
1.917956435131205e-06 0.110562946039519 1.917956516069412e-06 0.1098685209805978 1.917956604452683e-06 0.1091134439098378 1.917956703052662e-06 0.108274944429282 \
1.917956775836866e-06 0.1076586405352824 1.917956865109775e-06 0.1069058608836731 1.917956927091788e-06 0.1063852406583179 1.917956989684956e-06 0.1058613310701875 \
1.917957074907104e-06 0.105150777260444 1.917957180369478e-06 0.1042758147594986 1.91795726019996e-06 0.1036167065755082 1.917957340914214e-06 0.1029530974056021 \
1.917957423527949e-06 0.1022768941101355 1.917957493972561e-06 0.1017026162492672 1.917957597231928e-06 0.1008648142128753 1.917957670072053e-06 0.1002767039768694 \
1.917957755712335e-06 0.09958839426015198 1.917957874514073e-06 0.09863954321822334 1.917957942151898e-06 0.09810250133474645 1.91795801190202e-06 0.09755100310752296 \
1.917958089237e-06 0.09694230106952094 1.917958181657254e-06 0.09621870517595056 1.917958253354782e-06 0.09566033062548993 1.917958339171942e-06 0.09499542738017568 \
1.917958441597192e-06 0.09420660575030523 1.917958534892083e-06 0.09349264652734962 1.917958631208557e-06 0.09276005482712441 1.917958708110818e-06 0.09217843893134048 \
1.917958801590805e-06 0.09147541043939374 1.917958880833231e-06 0.09088281005358793 1.917958995455426e-06 0.0900310686188453 1.917959125063686e-06 0.08907580221142102 \
1.917959258320876e-06 0.08810234090122065 1.917959402350766e-06 0.08705990691030199 1.917959559518909e-06 0.08593388720602639 1.917959709295387e-06 0.08487214151476249 \
1.917959871762978e-06 0.08373303262435308 1.917960014942984e-06 0.08273971668837025 1.917960167622107e-06 0.0816913199659166 1.917960301891878e-06 0.08077856892457436 \
1.917960443644155e-06 0.07982444400446118 1.917960578643816e-06 0.07892500874648442 1.917960720601214e-06 0.07798882638923543 1.917960867448644e-06 0.07703088995320664 \
1.917961019894053e-06 0.07604750978240994 1.917961185112776e-06 0.07499422991502351 1.917961349250621e-06 0.07396067809208305 1.917961526112024e-06 0.07286119333145537 \
1.91796171645358e-06 0.07169407515132428 1.917961927410093e-06 0.07042030845332216 1.917962147819231e-06 0.0691121699798517 1.917962383344393e-06 0.06773900533435212 \
1.917962643793768e-06 0.0662496528900723 1.917962939459177e-06 0.06459579389282195 1.917963244581463e-06 0.06292902455725519 1.917963609576024e-06 0.06098725515092194 \
1.917964004456839e-06 0.05894944116461652 1.917964410847493e-06 0.05692211719668253 1.917964826573035e-06 0.05491854459141238 1.917965189379358e-06 0.0532251207245777 \
1.917965533980648e-06 0.05166301626031383 1.91796584916051e-06 0.05027284652491828 1.917966144689875e-06 0.04900240867073854 1.917966442670382e-06 0.04775344010203557 \
1.917966718469172e-06 0.04662857640242725 1.917966997243768e-06 0.04551884372531381 1.917967261178638e-06 0.04449205559535935 1.917967537201377e-06 0.04344260531795661 \
1.91796781615763e-06 0.04240676967887352 1.917968129850963e-06 0.04127097799875453 1.91796836585125e-06 0.04043636567030678 1.917968621645987e-06 0.03955075129286261 \
1.917968881769487e-06 0.03867033103466553 1.917969151904759e-06 0.03778142289416799 1.917969431124747e-06 0.03688501536902895 1.917969712963396e-06 0.03600226561751176 \
1.917969989839066e-06 0.03515600409566183 1.917970268932665e-06 0.03432349610146775 1.917970501810272e-06 0.03364444121149882 1.917970785646989e-06 0.03283527291840588 \
1.917971025751923e-06 0.03216626441466421 1.917971265550746e-06 0.0315119836023277 1.91797150482792e-06 0.03087436846876356 1.917971740084942e-06 0.03026290129608995 \
1.917971971011964e-06 0.02967475842909434 1.917972186001007e-06 0.02913788335257221 1.91797258815546e-06 0.02816043724496065 1.917972786878278e-06 0.02768988489927659 \
1.917973160561295e-06 0.0268265706552881 1.917973347359617e-06 0.02640514011949098 1.917973694919304e-06 0.02563810810034544 1.917973816848767e-06 0.0253740445387235 \
1.917974199320207e-06 0.02456430406701914 1.917974370028237e-06 0.02421180751242828 1.917974827125621e-06 0.02328894863848502 1.917975012758007e-06 0.0229225623309489 \
1.91797537621526e-06 0.02221803970155307 1.917975596582612e-06 0.02179832126591805 1.91797605430897e-06 0.02093867417890744 1.917976189728599e-06 0.02068687731869814 \
1.917976719624047e-06 0.01972418011126781 1.917976838945017e-06 0.01951377505543128 1.917977404730696e-06 0.01856069823426573 1.917977569110437e-06 0.0182962226476828 \
1.917978187655734e-06 0.01735107502432094 1.917978357709933e-06 0.01710418363667701 1.917978889842166e-06 0.01636278834442301 1.917979086926142e-06 0.01610013864443424 \
1.917979810045215e-06 0.01517806887136661 1.917979974675381e-06 0.01497647803580381 1.917980723800768e-06 0.01409711804523418 1.91798085710012e-06 0.01394643716836554 \
1.917981717353759e-06 0.01301449210748497 1.917981852457379e-06 0.01287422877142914 1.917982795034819e-06 0.01193816285908547 1.917982958630574e-06 0.01178202925388569 \
1.917983959987201e-06 0.0108653384673985 1.917984097529988e-06 0.01074500730514941 1.917985319636371e-06 0.009765086624518643 1.917985426589084e-06 0.00968516078425012 \
1.917986830780577e-06 0.008707372520026449 1.917986935611284e-06 0.008639312158696611 1.917988470448246e-06 0.00767719340797631 1.917988565731548e-06 0.007617466071856052 \
1.917990174528869e-06 0.006680264535635283 1.917990308605607e-06 0.006609506832171614 1.917992405618559e-06 0.005610918814474722 1.917992636163191e-06 0.005510783990371394 \
1.917994959158435e-06 0.004586584533412417 1.917995440488638e-06 0.004413562233393853 1.917998278050269e-06 0.003511943147855551 1.917998822969955e-06 0.003360532104877318 \
1.918002947178352e-06 0.002408309874554541 1.918003490902011e-06 0.002305347543005144 1.918009362191237e-06 0.001333291345955189 1.918009605056421e-06 0.001286469439319215 \
1.918023932948772e-06 0.0002880570268237783 1.918024077507414e-06 0.0002853642807229123 1.920661356428513e-06 -0.0006859155495331031 1.92066149598365e-06 -0.000901903561740745 \
1.920662005077583e-06 -0.001859438188174024 1.920662094565085e-06 -0.002052812934985279 1.920662457959945e-06 -0.00291126965001638 1.920662548982015e-06 -0.003143482006111167 \
1.920662914420052e-06 -0.004127275145644371 1.92066302468062e-06 -0.004436819103926468 1.920663336727774e-06 -0.005309594399865315 1.920663439442621e-06 -0.005584800160857357 \
1.920663803290477e-06 -0.006384516484886619 1.920663968081209e-06 -0.006586298968823262 1.920664547677408e-06 -0.005791490933239759 1.920664722787551e-06 -0.004914057272375438 \
1.920664839479485e-06 -0.004132845175365214 1.920664966064091e-06 -0.003100877896798674 1.920665067873012e-06 -0.002132773363901063 1.920665188361723e-06 -0.0008283127610571584 \
1.920665278808799e-06 0.0002599396317828252 1.92066537669893e-06 0.001541559978017447 1.920665475763239e-06 0.002943971508909197 1.920665646570516e-06 0.005594911825788154 \
1.920665868338539e-06 0.00944046646559993 1.920666064242384e-06 0.01317281463966807 1.920666223123766e-06 0.01639870563256729 1.920666387552263e-06 0.01989779506365397 \
1.920666541918294e-06 0.02331070396473752 1.920666700690818e-06 0.02693200463312963 1.920666847428777e-06 0.03036422445567413 1.920666996052748e-06 0.0339113704936035 \
1.920667151667245e-06 0.03768995713197771 1.920667308909259e-06 0.04156499463828727 1.920667473802058e-06 0.04567927910670353 1.920667647221578e-06 0.05005184210758699 \
1.920667825915293e-06 0.05459761989277153 1.920668014531131e-06 0.05943075613080645 1.920668215431274e-06 0.06460909294799391 1.920668434888065e-06 0.0702927970720964 \
1.920668664434352e-06 0.07626037976612585 1.920668910133291e-06 0.08266408948881369 1.920669178698229e-06 0.08967663153997742 1.920669470040144e-06 0.09728936802005522 \
1.920669791708172e-06 0.1056939239977524 1.920670152022263e-06 0.1150987971742611 1.920670543001701e-06 0.1252892839303718 1.920670986416517e-06 0.1368209045172546 \
1.920671502729604e-06 0.1502062239570841 1.920672108934821e-06 0.16586000516691 1.920672780191848e-06 0.1831102247110778 1.920673559691505e-06 0.20301830483439 \
1.920674432001388e-06 0.2251413938832897 1.920675262336714e-06 0.2460320778586349 1.920675993667063e-06 0.264292249712138 1.920676641612843e-06 0.280346965484095 \
1.920677224923317e-06 0.29469740877147 1.920677760655584e-06 0.3077798509628869 1.920678263914169e-06 0.3199778888071559 1.92067874911767e-06 0.3316516836183861 \
1.920679228040376e-06 0.3430829066939081 1.920679674471008e-06 0.3536501814456421 1.920680148800718e-06 0.3647819492304352 1.920680597991712e-06 0.3752331958288908 \
1.92068108846397e-06 0.3865396207984229 1.920681617036722e-06 0.3985997842463301 1.920681988181063e-06 0.4069920784971888 1.920682515935418e-06 0.4188173133762567 \
1.920682978292178e-06 0.4290642331729484 1.920683450624318e-06 0.4394285229343968 1.920683932409041e-06 0.4498981261869666 1.920683965448159e-06 0.4506126593745911 \
1.920684003207152e-06 0.45142837879914 1.920684078725137e-06 0.4530572051633331 1.920684229761107e-06 0.4563088938659436 1.920684437280372e-06 0.460764549126051 \
1.920684625319184e-06 0.4647825567212808 1.920684844328398e-06 0.469441659996985 1.920685087159409e-06 0.4745824626509371 1.920685386935037e-06 0.4808894567257585 \
1.920685624728187e-06 0.4858624696070272 1.920685887949588e-06 0.4913374535260851 1.920686148847133e-06 0.4967277906005185 1.92068637840122e-06 0.5014431429135263 \
1.920686601461414e-06 0.506003872007333 1.920686803037404e-06 0.5100983586086808 1.920686951867463e-06 0.51310967141356 1.920687196178516e-06 0.5180317772556589 \
1.920687328783749e-06 0.5206893064287169 1.920687468140331e-06 0.5234717264876519 1.920687679105724e-06 0.5276623644271943 1.920687853979606e-06 0.5311266030493931 \
1.920688122027852e-06 0.5364094032095129 1.92068831705351e-06 0.5402319029111832 1.920688496615017e-06 0.5437361368949839 1.920688747571146e-06 0.5486228351952749 \
1.920689024979257e-06 0.5540035987981641 1.920689308928559e-06 0.5594901708581531 1.920689564565851e-06 0.5644152233389156 1.92068985554807e-06 0.570006772487656 \
1.920690115853754e-06 0.5749917787111524 1.920690384297873e-06 0.5801232573974072 1.920690627063004e-06 0.5847450403362237 1.920690883594205e-06 0.5896146675871002 \
1.920691109757648e-06 0.59388771440121 1.920691347099143e-06 0.5983512154742827 1.92069155648786e-06 0.6022720321566808 1.920691770260628e-06 0.6062574570422776 \
1.920692023713469e-06 0.6109557890491497 1.920692226567816e-06 0.6146943332140289 1.920692419372338e-06 0.6182333111593361 1.920692609677365e-06 0.6217090173923294 \
1.920692800335854e-06 0.6251694921350958 1.920693002913779e-06 0.6288260100903066 1.920693265662542e-06 0.6335359534764116 1.920693494630232e-06 0.6376100987349322 \
1.920693714577867e-06 0.6414991146358265 1.92069394026254e-06 0.6454625140719233 1.920694149149966e-06 0.6491091855837361 1.920694370803585e-06 0.652957810138281 \
1.920694555693011e-06 0.6561429680377227 1.920694745707564e-06 0.6594017273991298 1.920694895862686e-06 0.6619630641908443 1.920695070740593e-06 0.6649292185271485 \
1.920695216461309e-06 0.6673855496832628 1.920695352493842e-06 0.6696641287411549 1.920695500856121e-06 0.672138295335571 1.920695630303833e-06 0.6742883907026684 \
1.920695764169531e-06 0.6764996355878535 1.92069589251393e-06 0.6786115243545502 1.920696017902058e-06 0.6806677490053815 1.920696147367755e-06 0.6827843190971332 \
1.92069627834897e-06 0.6849171426143115 1.920696426722072e-06 0.6873221141612875 1.920696534784826e-06 0.6890667486235877 1.920696663316499e-06 0.6911333958680312 \
1.920696798756284e-06 0.6933004139195943 1.920696923690607e-06 0.6952876996714908 1.920697049447875e-06 0.6972799977491608 1.920697155963766e-06 0.6989584331773744 \
1.920697273081655e-06 0.7007929859467624 1.920697391621401e-06 0.7026383448210159 1.920697514924798e-06 0.704545102273978 1.920697618097696e-06 0.7061304255463237 \
1.920697769068859e-06 0.7084341141567283 1.920697885323065e-06 0.7101955266062138 1.920698015883454e-06 0.7121605601685687 1.920698134445982e-06 0.7139335830373704 \
1.920698240519852e-06 0.7155108922888329 1.920698340544792e-06 0.716990346352101 1.920698477870007e-06 0.719009255813789 1.920698596531362e-06 0.7207429633399333 \
1.920698718230586e-06 0.7225107522614664 1.920698843413152e-06 0.7243181860083944 1.920698965432965e-06 0.7260693242762759 1.920699093464719e-06 0.7278954552757622 \
1.920699217946458e-06 0.7296603419865877 1.920699346245781e-06 0.7314685590147565 1.920699473339584e-06 0.7332489547570846 1.920699599364423e-06 0.7350034830462163 \
1.92069970210311e-06 0.7364262918236342 1.920699816775856e-06 0.7380063527755659 1.920699898181918e-06 0.7391232259175492 1.920700017381438e-06 0.7407496908814458 \
1.920700110023778e-06 0.7420059782745783 1.920700248182835e-06 0.7438668850244906 1.920700379238334e-06 0.7456179978167152 1.920700509370502e-06 0.7473439783685625 \
1.920700614344577e-06 0.7487266533969134 1.920700753484419e-06 0.7505456565005918 1.920700907428719e-06 0.7525407731682957 1.920701029372998e-06 0.7541080835708853 \
1.92070117691936e-06 0.7559892974429111 1.920701298924537e-06 0.7575320275232224 1.920701447624467e-06 0.7593968175435225 1.920701581671092e-06 0.7610632318338031 \
1.920701703924347e-06 0.7625711443351471 1.920701816790257e-06 0.763953046884334 1.920701959641225e-06 0.7656882893306027 1.920702086364119e-06 0.7672149413549471 \
1.920702202168994e-06 0.7685995877768005 1.920702331910823e-06 0.7701390587657672 1.920702447649211e-06 0.7715019052061673 1.920702570601637e-06 0.7729391548276606 \
1.920702688317297e-06 0.7743051053122872 1.920702794287273e-06 0.7755262985206828 1.920702910698467e-06 0.7768586864857919 1.9207030173164e-06 0.7780703956921795 \
1.92070312951512e-06 0.7793369495935717 1.92070321618369e-06 0.7803089322889447 1.920703319569181e-06 0.7814603789665585 1.920703432733433e-06 0.7827108149434853 \
1.920703538380715e-06 0.783868819044773 1.920703647720273e-06 0.7850578567336689 1.920703754897288e-06 0.786214126597127 1.920703884303365e-06 0.7875981444497275 \
1.920703996720751e-06 0.7887899291890393 1.92070412010849e-06 0.7900869036018625 1.920704237558825e-06 0.7913106402786101 1.920704381085744e-06 0.7927918312347375 \
1.920704496005322e-06 0.7939667362870242 1.920704634727735e-06 0.7953719780830618 1.920704772759875e-06 0.7967562205547866 1.920704882253029e-06 0.7978444364842524 \
1.920704983271459e-06 0.7988406866985471 1.92070508435942e-06 0.7998302780396641 1.920705216746616e-06 0.8011146558616069 1.920705335472037e-06 0.8022550163876687 \
1.920705457256542e-06 0.8034134048507504 1.920705576346336e-06 0.8045351524060473 1.920705697550853e-06 0.8056657048884367 1.920705829194664e-06 0.8068811249615274 \
1.920705952212703e-06 0.8080052413861453 1.920706079823023e-06 0.8091594649786741 1.920706210891683e-06 0.8103325925767672 1.920706334212046e-06 0.8114249716726942 \
1.92070644213631e-06 0.8123719892944993 1.920706549931703e-06 0.8133095350680949 1.920706631652631e-06 0.8140147772069938 1.920706748520247e-06 0.815015186305849 \
1.920706839581256e-06 0.8157880755829442 1.920706973749887e-06 0.8169164295805346 1.92070711832076e-06 0.8181184617099191 1.920707251823127e-06 0.8192158725965917 \
1.920707361789037e-06 0.8201107352847025 1.920707505654697e-06 0.8212684563313245 1.920707658960262e-06 0.8224861772268215 1.920707786698555e-06 0.8234883060891934 \
1.920707927340891e-06 0.8245786478120171 1.920708053124455e-06 0.8255423809867173 1.920708207742427e-06 0.8267124309768116 1.920708340154194e-06 0.8277017767197102 \
1.920708466433798e-06 0.8286345641820314 1.920708584064113e-06 0.8294941055817234 1.920708732230976e-06 0.8305638349826423 1.920708899375221e-06 0.8317531470681401 \
1.920709031993881e-06 0.832683775428688 1.920709204938569e-06 0.8338803479528284 1.920709373325224e-06 0.8350269493631071 1.920709542859754e-06 0.8361634673386688 \
1.920709724228909e-06 0.8373596561587384 1.920709866861491e-06 0.8382862741713709 1.92070998079734e-06 0.8390176620397163 1.920710111571134e-06 0.8398476357987267 \
1.920710213225074e-06 0.8404856735008092 1.920710329718803e-06 0.8412091703399448 1.920710465236349e-06 0.8420405885319162 1.920710662580143e-06 0.8432318270427018 \
1.920710853245141e-06 0.8443612543037786 1.92071106310198e-06 0.8455804035625291 1.920711244039104e-06 0.8466117334714958 1.920711441374591e-06 0.8477160230260256 \
1.920711615161427e-06 0.8486711109012058 1.920711797742881e-06 0.8496572451898022 1.920711969062461e-06 0.850566499179887 1.920712143447508e-06 0.8514760798656241 \
1.920712318831052e-06 0.8523748177975867 1.920712495063209e-06 0.8532619682996843 1.920712684901452e-06 0.8542000584728613 1.920712875637665e-06 0.8551245802328369 \
1.920713077434399e-06 0.856083442102113 1.920713270127775e-06 0.8569809170305027 1.920713479756076e-06 0.857937542729613 1.92071370919384e-06 0.8589615588718806 \
1.92071397499048e-06 0.8601183337444025 1.920714273565708e-06 0.8613802063570262 1.920714551467221e-06 0.8625196921548358 1.920714835677695e-06 0.8636511027355716 \
1.920715110089482e-06 0.8647118800460076 1.920715382252364e-06 0.8657341977214618 1.920715652421455e-06 0.8667205537246333 1.920715909616139e-06 0.8676338760342862 \
1.920716182155811e-06 0.868575115807136 1.920716458190291e-06 0.8695013130444248 1.920716728342986e-06 0.8703818891200001 1.920717028049788e-06 0.8713292845176382 \
1.920717398867258e-06 0.8724597217497643 1.920717693785921e-06 0.8733269024855727 1.920717948030199e-06 0.8740525764960509 1.920718246254198e-06 0.8748787854419284 \
1.920718519878969e-06 0.8756137195941651 1.920718756017959e-06 0.8762307200963571 1.920718996373686e-06 0.8768427579093606 1.920719218719338e-06 0.8773949085683344 \
1.920719412723072e-06 0.877865919014753 1.920719742447196e-06 0.878644045115768 1.920719897619855e-06 0.8790007149587372 1.920720215373248e-06 0.879712598742095 \
1.920720394238605e-06 0.8801026384247937 1.920720736700093e-06 0.8808283583858193 1.920720920841293e-06 0.8812073588304842 1.920721395746114e-06 0.8821499412898334 \
1.920721563140601e-06 0.8824705695712217 1.920722028971889e-06 0.8833323038036038 1.920722209796771e-06 0.8836551183393088 1.920722703830028e-06 0.8845051821644966 \
1.920722845172603e-06 0.8847400410050358 1.920723451563118e-06 0.8857071861637142 1.920723603635685e-06 0.8859397703602404 1.920724250313758e-06 0.8868873789663725 \
1.920724378610247e-06 0.8870678433440622 1.920725026723245e-06 0.8879435266410994 1.920725156528523e-06 0.8881118897635528 1.920725934785608e-06 0.8890711781604964 \
1.920726049780423e-06 0.8892053868933587 1.920726905511062e-06 0.8901454611437621 1.920727050777629e-06 0.8902951528450479 1.920728036533732e-06 0.8912364417375994 \
1.920728257640946e-06 0.8914302300078862 1.920729402752027e-06 0.892358484239638 1.920729533960174e-06 0.8924604119362172 1.92073087526337e-06 0.8934531785430913 \
1.920731026651031e-06 0.8935579568409697 1.920732508109867e-06 0.8944876667405802 1.920732746990229e-06 0.894621531696939 1.920734516461986e-06 0.8954958910368339 \
1.920734905568823e-06 0.8956641700186337 1.920737299334232e-06 0.8965498195158238 1.920737774894223e-06 0.8966991754584082 1.920741837950387e-06 0.8976977719002629 \
1.920742329424408e-06 0.8977905759376156 1.920750645951487e-06 0.8987839664765119 1.920751565805377e-06 0.8988472044554419 1.920877770945903e-06 0.8998441026240215 \
1.920878784754255e-06 0.8998514601858095 1.921070497347411e-06 0.8990059056521554 1.921070727348974e-06 0.8988405173838494 1.921072342221535e-06 0.8978439928078279 \
1.921072519935389e-06 0.8977495532019018 1.921089285710429e-06 0.8987316330193963 1.921089421698825e-06 0.8987497732072308 1.921104884427938e-06 0.8997471920221268 \
1.921105152292531e-06 0.8997526389354535 1.921588977619798e-06 0.9006560548284696 1.921589098408998e-06 0.9007687033315858 1.921589886180037e-06 0.9017381658104292 \
1.921590020318756e-06 0.901943163319478 1.92159051393353e-06 0.9027850367016239 1.921590658833145e-06 0.9030569221572713 1.92159105464053e-06 0.9038490360455199 \
1.921591174436184e-06 0.9041001886668685 1.921591558609718e-06 0.9049189780371781 1.921591670731365e-06 0.9051556495331843 1.921592178052335e-06 0.9061253139956988 \
1.921592272051192e-06 0.90626859229291 1.921593430700898e-06 0.9055667778886739 1.921593533663832e-06 0.9051589876696525 1.921593617506701e-06 0.9047707260375384 \
1.921593751246752e-06 0.9040404158978201 1.921593851964133e-06 0.9033957423200318 1.921593959579919e-06 0.9026166239542108 1.921594077153173e-06 0.9016533104038295 \
1.921594165418223e-06 0.90085556431878 1.921594285051691e-06 0.8996698288011099 1.921594382373389e-06 0.8986166602050341 1.921594493390828e-06 0.8973222354192386 \
1.921594595500416e-06 0.8960407982554908 1.921594678931815e-06 0.8949326975987755 1.921594783112883e-06 0.8934749428758865 1.921594874199646e-06 0.8921321265381427 \
1.921594966740432e-06 0.8907058396397178 1.92159506189443e-06 0.8891776325191247 1.921595176449407e-06 0.88725933118288 1.921595265292509e-06 0.8857137884271823 \
1.921595363531691e-06 0.8839502506198179 1.921595448901865e-06 0.8823735982707064 1.921595529802106e-06 0.8808434949738935 1.9215956027634e-06 0.8794355441897157 \
1.921595669782045e-06 0.8781198554636557 1.921595738393124e-06 0.8767515715160701 1.921595821888036e-06 0.8750591081124355 1.921595884015366e-06 0.8737811510706814 \
1.921595946997964e-06 0.8724704924326797 1.921596042153715e-06 0.8704632161180945 1.921596142764353e-06 0.8683077530860182 1.921596222643545e-06 0.8665738309361769 \
1.921596306905814e-06 0.8647250601592834 1.921596386016073e-06 0.8629723295901451 1.921596448831519e-06 0.8615696597604833 1.921596536288554e-06 0.8596016864744445 \
1.921596602182084e-06 0.8581079708060287 1.921596670243627e-06 0.856556281928966 1.921596719556134e-06 0.8554267461646872 1.921596774792924e-06 0.85415654045335 \
1.92159681553253e-06 0.8532164928603474 1.921596861834283e-06 0.8521450198670055 1.921596892048343e-06 0.8514441160591502 1.921596921089625e-06 0.8507691938976955 \
1.92159695172822e-06 0.8500558939662993 1.92159701300541e-06 0.8486254874746039 1.921597066077972e-06 0.8473828229799116 1.921597119733165e-06 0.8461232012188223 \
1.921597182390447e-06 0.8446482873934593 1.921597245673395e-06 0.8431545995644786 1.921597336171269e-06 0.8410121009440262 1.921597433169049e-06 0.8387078554355326 \
1.92159751614655e-06 0.8367307351423475 1.921597598150905e-06 0.8347721678896715 1.921597687219307e-06 0.8326403548070889 1.921597771732643e-06 0.8306135893189693 \
1.921597862591523e-06 0.8284303722590877 1.921597954526378e-06 0.8262176456275642 1.921598056957308e-06 0.8237486178045141 1.92159815707534e-06 0.8213320995840899 \
1.921598271896223e-06 0.8185572053828121 1.92159838410276e-06 0.8158423448209959 1.921598509096305e-06 0.8128151787794674 1.921598640356713e-06 0.8096337870015397 \
1.921598785627754e-06 0.8061104108175116 1.921598940135368e-06 0.8023613213197434 1.921599111575989e-06 0.7981999722344618 1.921599275625781e-06 0.794217661721315 \
1.921599460041203e-06 0.7897413884478564 1.921599666533577e-06 0.7847307375046715 1.92159985602742e-06 0.7801344622909899 1.921600049421182e-06 0.775444374634302 \
1.921600249988038e-06 0.7705834242206392 1.921600397552439e-06 0.7670092004965298 1.92160052756389e-06 0.7638619034739171 1.921600662428303e-06 0.7605987503374771 \
1.921600768918754e-06 0.7580234999254772 1.921600900608546e-06 0.7548403390839162 1.921601007032976e-06 0.7522693550468039 1.921601150211605e-06 0.7488125398635642 \
1.921601311338716e-06 0.7449250928176189 1.921601429565533e-06 0.7420746008290786 1.921601599798354e-06 0.7379721584775248 1.921601765724623e-06 0.7339761998059781 \
1.921601985266954e-06 0.7286940862104242 1.921602178454078e-06 0.724050920820232 1.921602353368041e-06 0.719851304223293 1.921602520315139e-06 0.7158476177432674 \
1.9216027078061e-06 0.711355754450834 1.921602895234537e-06 0.7068709122373377 1.921603063571096e-06 0.7028473835914892 1.92160325640163e-06 0.6982428782038785 \
1.921603396451377e-06 0.694901318858167 1.921603552708666e-06 0.6911769338170629 1.921603746878113e-06 0.6865540563080536 1.921603905984602e-06 0.6827702245679255 \
1.921604064344632e-06 0.679008548037742 1.92160425966174e-06 0.6743756772263459 1.921604470090519e-06 0.6693917663527935 1.921604722792664e-06 0.6634173774538097 \
1.921604902460615e-06 0.6591769455535931 1.921605154037489e-06 0.6532475027332399 1.921605354410306e-06 0.6485340174553987 1.921605526064158e-06 0.6445032789616798 \
1.921605684756274e-06 0.6407814961122935 1.921605823964202e-06 0.637522316374186 1.921605960288252e-06 0.6343349641335875 1.921606087501276e-06 0.6313646237382058 \
1.921606216993834e-06 0.6283457899522861 1.921606344985121e-06 0.6253646753452949 1.92160647605963e-06 0.6223174651643489 1.921606606771705e-06 0.6192830747181834 \
1.921606749379758e-06 0.6159760732208495 1.921606892103235e-06 0.612672916206165 1.921607044651037e-06 0.6091471600588 1.921607189155024e-06 0.6058158037532523 \
1.921607353173272e-06 0.6020406322262999 1.921607490637933e-06 0.5988837056407329 1.921607625454949e-06 0.5957940466067043 1.921607746953592e-06 0.5930134750293682 \
1.921607885803897e-06 0.5898448108574432 1.921607999450713e-06 0.5872554148224447 1.921608150860885e-06 0.5838116422847746 1.92160826457956e-06 0.5812320812748947 \
1.921608383992651e-06 0.5785269636915771 1.921608472673178e-06 0.5765205397309219 1.921608563818269e-06 0.5744630259469776 1.921608629157145e-06 0.5729901393713442 \
1.921608693626847e-06 0.5715377831648228 1.921608744447459e-06 0.5703933076453638 1.921608803422398e-06 0.569066051987989 1.921608870867107e-06 0.5675516747474645 \
1.921608937959298e-06 0.5660472084764079 1.921608990879742e-06 0.5648615894615425 1.921609086527225e-06 0.5627204246953637 1.921609143708362e-06 0.5614413394337 \
1.921609197510977e-06 0.5602399192081799 1.921609259253083e-06 0.5588634520375642 1.921609345086214e-06 0.5569525037715509 1.921609427781862e-06 0.5551133137453282 \
1.921609553910589e-06 0.552313430559463 1.921609689009664e-06 0.5493247407981657 1.921609787329828e-06 0.5471534914294828 1.92160989990789e-06 0.5446716589975775 \
1.921610002452305e-06 0.5424173856211837 1.921610122561131e-06 0.5397821662853191 1.921610224248782e-06 0.5375541863492928 1.921610339752745e-06 0.5350300289250629 \
1.921610454643861e-06 0.5325260225312031 1.921610581121134e-06 0.5297740207092871 1.92161070633833e-06 0.5270565158317848 1.921610853184312e-06 0.5238798967507053 \
1.921610988642446e-06 0.5209557060405445 1.921611146203054e-06 0.5175672114705414 1.921611308357229e-06 0.5140875588169389 1.921611489068307e-06 0.5102248342695275 \
1.92161168131606e-06 0.5061308236654174 1.921611894038323e-06 0.5016182665703952 1.921612125943484e-06 0.4967183500883584 1.921612383137188e-06 0.4913135654247419 \
1.921612622690499e-06 0.4863004534671564 1.921612924620373e-06 0.4800178499336004 1.921613212386815e-06 0.4740665530855001 1.921613525189057e-06 0.4676409412178996 \
1.921613845020806e-06 0.4611139840073785 1.921614184657409e-06 0.4542292677834274 1.921614511873228e-06 0.4476411633207955 1.921614847034797e-06 0.4409363684817221 \
1.921615164291458e-06 0.4346351592989786 1.921615498111436e-06 0.4280489847791872 1.92161584979678e-06 0.4211625252737479 1.921616163864498e-06 0.4150547397555842 \
1.921616486893702e-06 0.4088175946446666 1.921616927873099e-06 0.4003732788922496 1.921617270275942e-06 0.3938810608698495 1.92161757072383e-06 0.3882325136127223 \
1.921617946053402e-06 0.3812375944419973 1.92161827612863e-06 0.3751439175705365 1.921618559406411e-06 0.3699597784791666 1.921618859913773e-06 0.3645020109013299 \
1.921619139561233e-06 0.3594637112692664 1.921619363423524e-06 0.3554634414471464 1.921619575274513e-06 0.35170280677964 1.921619777623113e-06 0.3481338771034005 \
1.921619978758139e-06 0.3446120049995081 1.921620184535656e-06 0.3410324794262659 1.921620445514371e-06 0.3365252478245505 1.921620685004553e-06 0.3324209773202946 \
1.921620917679624e-06 0.3284665339262754 1.921621131761216e-06 0.3248537323113044 1.921621352906983e-06 0.3211475567840967 1.921621553789873e-06 0.3178053707831449 \
1.921621757181075e-06 0.3144500223650613 1.921621954849487e-06 0.3112139453100684 1.921622141093175e-06 0.3081862077816076 1.921622336074257e-06 0.3050391973134606 \
1.921622539536502e-06 0.3017803754370622 1.921622717477408e-06 0.2989521325826759 1.921622953201112e-06 0.2952356640875101 1.921623151333965e-06 0.2921385263640672 \
1.921623352678032e-06 0.2890160050544278 1.92162357696723e-06 0.2855690750291008 1.921623741897129e-06 0.2830551950838826 1.921623919525814e-06 0.2803657404651576 \
1.921624103924961e-06 0.2775946687427531 1.921624287746306e-06 0.2748547260732712 1.921624466202979e-06 0.2722194282383935 1.921624638103246e-06 0.2696976713509589 \
1.921624798643653e-06 0.2673699088296289 1.921624920125712e-06 0.265617282026588 1.921625073047239e-06 0.2634201198254058 1.921625200480934e-06 0.2616085083773952 \
1.921625304654605e-06 0.2601317890528609 1.921625421559082e-06 0.2584775571399547 1.921625536570573e-06 0.2568557450124987 1.921625660932803e-06 0.2551103168403305 \
1.921625776507087e-06 0.2534925198640895 1.921625910614607e-06 0.2516172680784447 1.921626025601848e-06 0.2500177396912131 1.921626179351445e-06 0.2478798443778067 \
1.921626316154646e-06 0.2459790966208961 1.921626450740453e-06 0.2441094379339017 1.921626606604589e-06 0.2419575875351012 1.921626731253412e-06 0.2402378086535915 \
1.921626870468935e-06 0.2383186229544463 1.92162700069296e-06 0.236525770455347 1.921627121045801e-06 0.2348769158236033 1.921627256439084e-06 0.233027137746051 \
1.921627407644063e-06 0.2309620730808924 1.921627542400533e-06 0.2291249940296414 1.92162764708672e-06 0.2277003186426776 1.921627769622861e-06 0.2260366668203369 \
1.92162790456742e-06 0.2242086518061946 1.921627999683168e-06 0.2229209267876512 1.921628114943223e-06 0.2213657311907907 1.921628197476202e-06 0.2202562617028589 \
1.921628268681533e-06 0.2192992955643472 1.921628317389017e-06 0.2186449771734718 1.921628364583973e-06 0.2180112263680214 1.921628411132791e-06 0.2173864029843717 \
1.921628464521355e-06 0.2166701476649976 1.921628501898025e-06 0.2161690444847812 1.921628539283138e-06 0.2156680710113931 1.921628579604508e-06 0.2151283464800275 \
1.921628650854647e-06 0.2141753141901174 1.921628685068904e-06 0.2137180869447317 1.921628731463535e-06 0.2131018213873352 1.921628791907201e-06 0.2122998083652294 \
1.92162886091012e-06 0.2113853596849882 1.921628926205071e-06 0.210520730631805 1.921628994183195e-06 0.2096212333552783 1.921629110629525e-06 0.2080823984153433 \
1.921629200551714e-06 0.2068957989735914 1.92162930821762e-06 0.2054771097790837 1.921629404278935e-06 0.2042146625011118 1.921629507657509e-06 0.2028641889872041 \
1.921629604342544e-06 0.2016026287683381 1.921629707152397e-06 0.2002625524503448 1.921629807912368e-06 0.1989526210414513 1.921629919058035e-06 0.1975116692735505 \
1.921630026097528e-06 0.1961279675313261 1.921630144004064e-06 0.1946083430154048 1.921630252114388e-06 0.1932197128021231 1.921630361412988e-06 0.1918224631760269 \
1.921630482044739e-06 0.1902849927564414 1.921630576945331e-06 0.1890796997295432 1.92163070550625e-06 0.18745262875399 1.921630798541039e-06 0.1862801166370808 \
1.921630900937595e-06 0.1849947785893032 1.921630988904885e-06 0.1838942174288659 1.921631087175557e-06 0.182668828510528 1.921631183776179e-06 0.1814691026470878 \
1.921631270414692e-06 0.1803971466393716 1.921631356823705e-06 0.1793305247657973 1.921631452660814e-06 0.1781527189679156 1.921631557387688e-06 0.1768710765218302 \
1.921631703199975e-06 0.1750963017969037 1.921631819167907e-06 0.1736923427161618 1.921631975631711e-06 0.1718092975148396 1.92163208681163e-06 0.1704786474822015 \
1.921632227061631e-06 0.1688098560703619 1.921632350073035e-06 0.1673544160765056 1.921632456564033e-06 0.1661007559767333 1.921632552889492e-06 0.1649724583647661 \
1.921632650322958e-06 0.1638357962207703 1.921632754176237e-06 0.1626293386330815 1.92163284597681e-06 0.1615673458739011 1.921632944364525e-06 0.1604337426303964 \
1.92163302728317e-06 0.1594828374885931 1.921633122651503e-06 0.1583950132920943 1.921633205213852e-06 0.1574587876231885 1.921633307798537e-06 0.1563016192679324 \
1.921633384076854e-06 0.1554454316211293 1.921633472662479e-06 0.1544557264474612 1.921633544831984e-06 0.1536532700165102 1.921633626541473e-06 0.1527486200895024 \
1.921633700220281e-06 0.1519363404455653 1.921633780440409e-06 0.1510573496788611 1.921633852168484e-06 0.1502755532525617 1.921633920425463e-06 0.149534520573691 \
1.921634018141422e-06 0.1484788062294206 1.921634087591606e-06 0.147731872792437 1.921634170343085e-06 0.1468455801890639 1.921634230379995e-06 0.1462052652532956 \
1.921634300618658e-06 0.1454587420502366 1.921634372046193e-06 0.1447037411390827 1.921634452559695e-06 0.1438588888651768 1.921634515822599e-06 0.1431977449412327 \
1.921634593496578e-06 0.1423892845091393 1.921634682806343e-06 0.141463758692191 1.921634752169929e-06 0.1407479403162204 1.921634850118149e-06 0.1397418416088305 \
1.921634940462669e-06 0.1388188591118084 1.921635026242994e-06 0.1379520826379384 1.921635093896779e-06 0.1372719511642241 1.921635160204629e-06 0.1366075914250998 \
1.921635238824321e-06 0.1358227655030745 1.92163531951923e-06 0.135020537018139 1.921635377921894e-06 0.1344419857224206 1.921635438674417e-06 0.1338420332148588 \
1.921635532580729e-06 0.1329184183639811 1.921635574978232e-06 0.1325029080242558 1.921635654222426e-06 0.1317336600863391 1.921635694592585e-06 0.1313430593815061 \
1.921635784293463e-06 0.130477658168832 1.92163582324155e-06 0.1301029732927899 1.921635918857236e-06 0.1291862249441596 1.921635957741065e-06 0.1288146335111444 \
1.921636050975841e-06 0.1279263274670414 1.92163611931843e-06 0.1272775968534341 1.921636171639285e-06 0.1267823325594629 1.921636253739999e-06 0.1260075984242486 \
1.921636324903378e-06 0.1253406747583812 1.921636402856366e-06 0.1246136378429537 1.921636481976102e-06 0.1238779526756392 1.921636560619333e-06 0.1231489004754178 \
1.921636640654241e-06 0.122409328367501 1.921636702388658e-06 0.1218405706457005 1.92163677598364e-06 0.1211645344030958 1.921636859363458e-06 0.120401093559758 \
1.921636923460189e-06 0.1198161795466899 1.921636992898777e-06 0.119184869057559 1.921637065921715e-06 0.1185234239195788 1.921637150796627e-06 0.1177582144838446 \
1.921637230159479e-06 0.117046673033812 1.921637314893136e-06 0.1162898833629492 1.921637405604425e-06 0.1154830714735263 1.921637481187504e-06 0.1148135241260771 \
1.921637546915428e-06 0.1142333070693714 1.921637606975201e-06 0.1137047561823949 1.921637676580917e-06 0.1130943456353956 1.921637742999968e-06 0.1125141752866663 \
1.921637822411232e-06 0.1118230150855203 1.921637912674161e-06 0.1110406875128299 1.921637981718461e-06 0.1104447270551955 1.921638056273581e-06 0.1098035355921305 \
1.921638144757501e-06 0.1090456469739195 1.921638223865648e-06 0.1083709350695736 1.921638293734029e-06 0.1077773127978274 1.921638374743399e-06 0.1070920034756896 \
1.921638430948213e-06 0.106618206733547 1.921638493607492e-06 0.1060916009495399 1.921638558754098e-06 0.105545887371837 1.921638630089726e-06 0.1049504956797945 \
1.921638750386101e-06 0.1039516085561449 1.921638801939674e-06 0.103525508500865 1.921638857088742e-06 0.1030709598036589 1.921638947785926e-06 0.1023262935955709 \
1.921639030175778e-06 0.1016530765296615 1.921639125755585e-06 0.1008759670630478 1.921639232965152e-06 0.1000092507657299 1.921639336624558e-06 0.09917656019160864 \
1.921639422832161e-06 0.09848810438956324 1.921639509074386e-06 0.09780303991321163 1.92163958861546e-06 0.09717448010577609 1.921639668628334e-06 0.09654538840876434 \
1.921639759916661e-06 0.09583163072761708 1.921639841662079e-06 0.09519620281310773 1.921639930588917e-06 0.09450872319168514 1.921640020366224e-06 0.09381864801001834 \
1.921640097328872e-06 0.09323024625953365 1.921640187653689e-06 0.0925435244861572 1.921640251462415e-06 0.09206084550525626 1.921640323925983e-06 0.09151514907748673 \
1.921640388054635e-06 0.09103438864950099 1.92164046630201e-06 0.09045054736970405 1.921640566003292e-06 0.08971110930136832 1.921640640056444e-06 0.08916512281998501 \
1.921640726664979e-06 0.08852997392441805 1.921640872964685e-06 0.08746544055362569 1.921640983676948e-06 0.08666684197409438 1.921641093986626e-06 0.08587717033461532 \
1.921641236182269e-06 0.08486839672072237 1.92164137623472e-06 0.08388450488753585 1.921641518880534e-06 0.08289222299161547 1.921641667651249e-06 0.08186778387581196 \
1.921641804363935e-06 0.08093569403044946 1.921641946484565e-06 0.07997640434545976 1.921642081061545e-06 0.07907728405019222 1.921642221281423e-06 0.07814997945867638 \
1.921642369028229e-06 0.07718353387841098 1.921642518982415e-06 0.07621348085094087 1.921642683698247e-06 0.07516037195605636 1.921642847284363e-06 0.07412732798506308 \
1.921643021932715e-06 0.07303837372665309 1.921643208986408e-06 0.07188781219077654 1.921643418972925e-06 0.0706159374129187 1.921643637046174e-06 0.06931715807027321 \
1.921643870366327e-06 0.06795188046253516 1.921644124845882e-06 0.0664909822812602 1.92164441780254e-06 0.06484528303377844 1.921644719953089e-06 0.06318745987130532 \
1.921645057674792e-06 0.06138078634948794 1.921645452783393e-06 0.05932807220464856 1.921645820234636e-06 0.05747953410674719 1.921646237842402e-06 0.05544691527644593 \
1.921646582838376e-06 0.0538196438399016 1.921646933380665e-06 0.05221302159193914 1.921647248341029e-06 0.0508087490907442 1.921647547582395e-06 0.049508488261462 \
1.921647846948248e-06 0.04824029756235761 1.921648122190958e-06 0.04710512226277328 1.921648405654524e-06 0.04596497870754415 1.921648667254946e-06 0.04493681260994405 \
1.921648944707071e-06 0.04387103439794762 1.921649220766506e-06 0.04283531238677037 1.921649529036243e-06 0.04170718945545093 1.921649751468863e-06 0.0409114719535993 \
1.921650039009947e-06 0.03990505631995635 1.921650275242879e-06 0.0390969788355163 1.921650593704555e-06 0.03803800466874574 1.921650844115589e-06 0.03722710566490722 \
1.921651167100391e-06 0.03620720400565681 1.921651425436406e-06 0.03541203096995557 1.921651715410285e-06 0.03454066075983582 1.921651945205102e-06 0.0338658635512188 \
1.921652230100444e-06 0.03304787219836024 1.921652469846563e-06 0.03237513696606491 1.921652710481132e-06 0.03171392889024889 1.921652949599619e-06 0.03107212555077287 \
1.92165318553853e-06 0.03045460689686571 1.921653416367391e-06 0.02986254663395104 1.921653631393918e-06 0.02932175456294728 1.92165403355976e-06 0.0283374222946415 \
1.92165423211788e-06 0.02786401170979088 1.921654605819066e-06 0.02699470773596776 1.921654792632261e-06 0.02657042318767052 1.921655138633508e-06 0.02580176906824739 \
1.921655260576946e-06 0.02553595448027303 1.921655643429964e-06 0.02472011952872977 1.921655803864149e-06 0.02438657631284594 1.921656246865303e-06 0.02348572425118655 \
1.921656417479344e-06 0.02314627247835563 1.92165673805594e-06 0.02251902970747987 1.921656938340868e-06 0.0221336684630111 1.921657385278801e-06 0.02128811173678137 \
1.921657513222916e-06 0.02104854104185888 1.921658001100276e-06 0.02014826272243131 1.921658136077553e-06 0.01990454278080647 1.921658618329071e-06 0.0190640092473091 \
1.921658780655186e-06 0.01879235028057063 1.921659267049527e-06 0.01801148170254873 1.921659430077186e-06 0.01776103207540622 1.921660110298877e-06 0.01676849304257711 \
1.921660249382614e-06 0.01657541006259178 1.921660981877147e-06 0.01560782569993242 1.92166114077078e-06 0.01540693214221847 1.921661923851867e-06 0.01445869962397344 \
1.921662069644422e-06 0.01428952172302696 1.921662920425781e-06 0.01334248985256295 1.921663031529053e-06 0.01322388191882306 1.921663964823417e-06 0.0122699293983148 \
1.921664098661466e-06 0.01213902814618388 1.921665057199482e-06 0.01123495036716388 1.921665178316551e-06 0.01112486091825863 1.921666300400348e-06 0.01017270671243764 \
1.921666405901602e-06 0.01008921053061839 1.921667734976014e-06 0.009112307258623473 1.921667855180288e-06 0.009029744095492466 1.921669403542048e-06 0.008036808760534916 \
1.921669484329819e-06 0.007986285493236449 1.921671055209352e-06 0.007024564730313319 1.921671122625551e-06 0.006986095570813155 1.92167304339223e-06 0.006001386377072119 \
1.921673230194113e-06 0.005914747648762168 1.921675545608061e-06 0.0049318160947762 1.921675945134907e-06 0.004777795182599986 1.921678508944408e-06 0.003889929704329555 \
1.921679007815328e-06 0.003736330440833864 1.921682637539317e-06 0.002784984367379526 1.921683188233292e-06 0.002663729254427667 1.921688586673671e-06 0.001711392372544448 \
1.921688899941243e-06 0.001662511220227468 1.921693892233791e-06 0.0006970413096974805 1.921694076252826e-06 0.0006571176749162138 1.92434255539561e-06 -0.0002691198397987355 \
1.924342711454572e-06 -0.0004551674219448388 1.924343259438427e-06 -0.001322174727784445 1.92434337237642e-06 -0.001539785040943742 1.92434380163135e-06 -0.002474302920374066 \
1.924343907888515e-06 -0.002730173903076456 1.924344190690666e-06 -0.003454402452283872 1.92434430428521e-06 -0.003760966378165151 1.924344642839789e-06 -0.004705104513819927 \
1.92434475526375e-06 -0.005021586953003071 1.924345083541651e-06 -0.005887841248467669 1.924345191080172e-06 -0.006130875888161453 1.924346071006203e-06 -0.005789627805322099 \
1.92434624621225e-06 -0.004910736584223327 1.924346363043013e-06 -0.004127745010746014 1.924346489910138e-06 -0.00309221842859156 1.924346591442863e-06 -0.002125750314016509 \
1.924346712864133e-06 -0.0008095618968406578 1.924346803029046e-06 0.0002767910803854594 1.924346900212696e-06 0.001550247908954045 1.92434699828696e-06 0.002938803805678211 \
1.924347165508046e-06 0.005530627736217106 1.924347387813323e-06 0.009378371294171852 1.924347573551714e-06 0.01290572951649239 1.92434779763305e-06 0.01747895571448658 \
1.924347957277782e-06 0.02091945933227325 1.924348121767111e-06 0.02459614091902196 1.924348271591569e-06 0.0280452875125503 1.924348420991461e-06 0.03156498790849799 \
1.924348570522766e-06 0.03515592969144176 1.924348724602661e-06 0.03891669635189081 1.924348886786809e-06 0.0429309674228065 1.924349053210035e-06 0.0470989728378523 \
1.924349229143508e-06 0.05154884981278444 1.924349410271779e-06 0.05616867911875007 1.924349602402705e-06 0.06110225049351239 1.924349810098117e-06 0.0664648391313285 \
1.924350032018198e-06 0.07222051812179281 1.92435026721968e-06 0.07834079218654426 1.924350519405989e-06 0.08491829088081257 1.924350795545224e-06 0.09213111703448683 \
1.924351096666701e-06 0.1000001933597138 1.924351428586562e-06 0.1086702418150647 1.92435180590533e-06 0.1185147411083515 1.924352204195386e-06 0.1288888856248832 \
1.924352673503706e-06 0.1410822143415975 1.924353219529231e-06 0.1552200475789812 1.924353854489538e-06 0.1715918832733369 1.924354553890129e-06 0.1895291194622146 \
1.924355372129055e-06 0.2103807608661494 1.924356277823022e-06 0.2332840710921665 1.924357067334088e-06 0.253091928008631 1.924357771092906e-06 0.2706124241987875 \
1.924358388943719e-06 0.2858796548825839 1.924358954567131e-06 0.2997575097153312 1.924359476302404e-06 0.3124620269501652 1.924359974086121e-06 0.3244932238414255 \
1.924360457724081e-06 0.3360954048923613 1.924360914598215e-06 0.3469667650518959 1.924361387439109e-06 0.3581213589834248 1.924361827052466e-06 0.3684065070151987 \
1.924362314929562e-06 0.379719432411247 1.924362845729984e-06 0.3919028193132517 1.92436334362536e-06 0.4032143644097119 1.924363775002613e-06 0.41292177789323 \
1.924364261889801e-06 0.4237731225600331 1.924364761989243e-06 0.4348012155672935 1.924365106609934e-06 0.4423321287141763 1.924365460003778e-06 0.4500000647748709 \
1.924365887773617e-06 0.4592134948422093 1.924366279634688e-06 0.4675816212925634 1.924366579929045e-06 0.4739471552041949 1.924366921860125e-06 0.4811428413521782 \
1.92436726519457e-06 0.4883132334011818 1.924367525955058e-06 0.4937215836208605 1.924367768011588e-06 0.4987106167174703 1.924368034010056e-06 0.5041617362307154 \
1.924368293498239e-06 0.5094435946950286 1.924368483414539e-06 0.5132872703533161 1.924368698649141e-06 0.5176241792560061 1.9243688371999e-06 0.5204025546691405 \
1.924368982080679e-06 0.5232962183003332 1.924369195494746e-06 0.5275364624051522 1.92436939751936e-06 0.5315382148201082 1.924369590248024e-06 0.5353370730264509 \
1.924369775503404e-06 0.5389735557287745 1.924369952500928e-06 0.5424323215059959 1.924370261764263e-06 0.5484573594957171 1.924370522912311e-06 0.5535233414883098 \
1.92437082473148e-06 0.5593562770234363 1.924371080160122e-06 0.5642781701956761 1.924371372515619e-06 0.5698968483756405 1.924371631969813e-06 0.5748654731717864 \
1.92437190208979e-06 0.5800301911327002 1.924372144100348e-06 0.5846380733684551 1.924372401610146e-06 0.5895273573494454 1.924372628054483e-06 0.5938057549890672 \
1.924372864942966e-06 0.5982619499065401 1.924373074987873e-06 0.6021962733001386 1.924373287918585e-06 0.6061670177072124 1.924373541397282e-06 0.6108668889270118 \
1.924373744692931e-06 0.6146150465592417 1.924373936381114e-06 0.6181346807088086 1.924374125007479e-06 0.6215812235468744 1.924374312325417e-06 0.6249823889551316 \
1.924374517937406e-06 0.6286953279350977 1.924374767760625e-06 0.6331759959753138 1.924374971572403e-06 0.6368063379741715 1.924375179211121e-06 0.6404826298163093 \
1.924375371862737e-06 0.6438748386876914 1.92437561647481e-06 0.6481531432733096 1.924375864373314e-06 0.6524620620600715 1.924376044208219e-06 0.6555644139995785 \
1.924376234982255e-06 0.6588391718544121 1.924376388158437e-06 0.6614554104590837 1.924376559827147e-06 0.6643705886591137 1.924376710293968e-06 0.6669108747194671 \
1.924376846897971e-06 0.6692010654183506 1.924376996338372e-06 0.6716954191563786 1.924377124072524e-06 0.6738189269502312 1.92437726394477e-06 0.6761323074508511 \
1.924377388021905e-06 0.6781756764962316 1.92437751938327e-06 0.6803315871556701 1.924377643554731e-06 0.6823627547057004 1.924377781331592e-06 0.6846081866267727 \
1.924377901575812e-06 0.6865586181592046 1.924378043628417e-06 0.6888545186016138 1.924378143856122e-06 0.6904668682779994 1.924378265160113e-06 0.6924123325129877 \
1.924378356135388e-06 0.6938641504265992 1.924378453518671e-06 0.695411869780077 1.924378550601538e-06 0.6969507228893711 1.924378639884158e-06 0.6983595753378042 \
1.924378737855943e-06 0.699898781449533 1.92437886813103e-06 0.7019319515314388 1.924379021543255e-06 0.7043083163565919 1.924379157109067e-06 0.7063909659299702 \
1.924379301449562e-06 0.708591461371511 1.924379427320445e-06 0.710496752775434 1.924379552347831e-06 0.712376488910674 1.924379666630191e-06 0.7140841686551523 \
1.924379777613336e-06 0.7157331888171029 1.924379877308405e-06 0.7172065512867005 1.924380014352623e-06 0.7192196995505324 1.924380133379835e-06 0.7209572005600779 \
1.924380253677943e-06 0.7227029412191364 1.924380380176863e-06 0.7245276185835638 1.924380504108467e-06 0.7263044524160376 1.9243806283948e-06 0.7280754330070212 \
1.924380754759953e-06 0.7298652243312684 1.924380884571695e-06 0.7316925631262517 1.924381008410214e-06 0.7334254795816325 1.924381141191101e-06 0.735272086289578 \
1.924381242042306e-06 0.7366670415914529 1.924381355233975e-06 0.738224777043618 1.924381442019956e-06 0.7394137384482823 1.924381558645253e-06 0.7410021813026957 \
1.92438164793451e-06 0.7422110784210975 1.924381759111394e-06 0.7437075443329063 1.924381888370158e-06 0.7454347509364776 1.924382002229193e-06 0.7469455276109591 \
1.924382106633406e-06 0.74832188588007 1.924382231000437e-06 0.7499498655229884 1.924382378240616e-06 0.7518616907275563 1.924382498520907e-06 0.753411006437983 \
1.924382614425446e-06 0.7548933175676444 1.92438275450129e-06 0.7566706674475765 1.92438289711296e-06 0.7584645678799224 1.924383015067203e-06 0.7599365027959469 \
1.924383141883712e-06 0.7615071445339606 1.924383282766856e-06 0.7632375905494565 1.924383402560354e-06 0.7646969139886852 1.924383547519211e-06 0.7664484133613445 \
1.924383669077996e-06 0.7679052725436226 1.92438378811749e-06 0.7693214142140735 1.924383909748853e-06 0.7707575700077021 1.924384037717832e-06 0.772256936813787 \
1.924384146933014e-06 0.7735272422640712 1.924384271823892e-06 0.774969549136603 1.924384378939953e-06 0.7761978171588899 1.924384512193147e-06 0.7777146071439789 \
1.924384639296593e-06 0.7791497354387434 1.924384761047568e-06 0.7805132846941326 1.924384877632151e-06 0.7818078758210534 1.924384983459753e-06 0.7829735233300771 \
1.924385122825895e-06 0.7844949153190801 1.924385271897694e-06 0.786105286864636 1.924385419626362e-06 0.7876841235632186 1.92438553893224e-06 0.7889471147195867 \
1.924385672939052e-06 0.7903527806482344 1.924385793365227e-06 0.791604423795974 1.924385934910404e-06 0.7930616786923709 1.924386082336417e-06 0.7945638089648995 \
1.924386206810925e-06 0.7958198087139573 1.924386325854918e-06 0.7970105506108808 1.924386437445202e-06 0.7981174590942314 1.92438654267449e-06 0.7991530841216606 \
1.924386638185594e-06 0.8000862307887144 1.924386774247547e-06 0.8014036057482816 1.924386891123681e-06 0.8025237700417888 1.924387010277354e-06 0.8036549841722296 \
1.924387132589548e-06 0.8048050501807249 1.924387255861622e-06 0.8059526272620129 1.924387382358398e-06 0.8071184350969989 1.924387507861062e-06 0.8082633544790385 \
1.924387638586967e-06 0.8094437311890262 1.924387764154939e-06 0.8105658358439867 1.924387893209803e-06 0.8117072367686948 1.924387999065961e-06 0.8126345588578442 \
1.924388100234837e-06 0.8135133322873783 1.924388194854657e-06 0.8143286754242188 1.92438831913574e-06 0.8153900871385379 1.924388408847426e-06 0.816149614585347 \
1.92438850788495e-06 0.8169816577628611 1.924388645662827e-06 0.8181280288377792 1.924388780198677e-06 0.81923501721715 1.924388888604943e-06 0.8201180631035904 \
1.924389038518447e-06 0.8213254631869725 1.924389189097025e-06 0.8225223201378843 1.92438931459218e-06 0.8235077122548546 1.924389458438707e-06 0.8246238332260477 \
1.924389583021971e-06 0.8255790649890803 1.924389731875191e-06 0.8267066458678887 1.924389868023775e-06 0.827725029289517 1.924389993047602e-06 0.8286494160599757 \
1.924390110754582e-06 0.8295103773055483 1.924390256393581e-06 0.8305630309532103 1.924390422774875e-06 0.8317484146982921 1.924390553358564e-06 0.8326660250626342 \
1.924390726880675e-06 0.8338683097812621 1.924390895002577e-06 0.8350147136930499 1.92439106486518e-06 0.8361549927788252 1.924391245766883e-06 0.8373497079260466 \
1.924391388876165e-06 0.8382806519784776 1.924391502965127e-06 0.839013953006387 1.924391633127604e-06 0.8398410866028793 1.924391734972734e-06 0.8404811280669765 \
1.92439185179894e-06 0.8412075886390841 1.92439198869038e-06 0.8420483852080155 1.924392186497604e-06 0.843243620449199 1.924392378122751e-06 0.8443797466267589 \
1.924392587554618e-06 0.8455974227529048 1.9243927695013e-06 0.8466352798309468 1.924392966630154e-06 0.8477391449715804 1.924393139971014e-06 0.8486924050423899 \
1.924393322979321e-06 0.8496814535024207 1.924393494142356e-06 0.8505903669473519 1.92439366877945e-06 0.851501688465695 1.924393844039281e-06 0.8524001683007644 \
1.92439402018973e-06 0.8532872510191711 1.924394210470029e-06 0.8542278331088334 1.92439440106916e-06 0.8551519386507073 1.924394601692395e-06 0.8561055033533737 \
1.92439479430095e-06 0.8570028516027762 1.924395004981641e-06 0.8579644845832216 1.924395233083109e-06 0.8589827023971403 1.924395498871091e-06 0.860139640227508 \
1.924395797483852e-06 0.8614018215255795 1.92439607377249e-06 0.8625348754565382 1.92439635800901e-06 0.8636666213345715 1.92439663221378e-06 0.8647267940813509 \
1.924396904448639e-06 0.8657495569722869 1.92439717465278e-06 0.8667361702337206 1.92439743180839e-06 0.867649441901348 1.924397704388604e-06 0.8685908808535525 \
1.92439798037489e-06 0.8695169452638583 1.924398250477721e-06 0.870397355937691 1.924398550334798e-06 0.8713451925332844 1.924398921362456e-06 0.8724761722512941 \
1.924399216299767e-06 0.8733433185969293 1.924399470589206e-06 0.8740690226522811 1.92439976884599e-06 0.874895168896023 1.924400042455427e-06 0.8756299040683481 \
1.924400278583914e-06 0.8762466977562872 1.924400518929827e-06 0.8768585021646264 1.924400741263492e-06 0.8774104263690854 1.92440093526917e-06 0.8778812671168952 \
1.924401264991885e-06 0.8786590883967833 1.924401420165319e-06 0.8790156160651978 1.924401737941389e-06 0.8797272612331356 1.924401916803032e-06 0.8801171459162566 \
1.924402259264861e-06 0.8808425821290963 1.924402443393021e-06 0.881221400612852 1.924402918270754e-06 0.8821634994206867 1.924403085666965e-06 0.8824839765989225 \
1.924403551508905e-06 0.8833452998114757 1.924403732330958e-06 0.8836679564577563 1.924404226369383e-06 0.8845176198113115 1.924404367718007e-06 0.8847523712107549 \
1.924404974052072e-06 0.8857188576377059 1.924405126121396e-06 0.8859512996759633 1.924405772809558e-06 0.8868983431897121 1.92440590110417e-06 0.8870786909355212 \
1.924406549221232e-06 0.8879538337624689 1.924406679020295e-06 0.8881220828502663 1.924407457223772e-06 0.8890807033877333 1.924407572278734e-06 0.8892148977954012 \
1.924408427940206e-06 0.8901543051721961 1.924408573301076e-06 0.8903040038307473 1.924409559057127e-06 0.8912446482480114 1.924409780162496e-06 0.8914382978987679 \
1.924410925289423e-06 0.8923659558950503 1.924411056506439e-06 0.8924678262926897 1.924412397715013e-06 0.8934599079028542 1.924412549114272e-06 0.8935646301988298 \
1.924414030551995e-06 0.8944937559627255 1.924414269431373e-06 0.8946275407274444 1.924416038746979e-06 0.8955013787854181 1.924416427898191e-06 0.8956696032899972 \
1.924418821561142e-06 0.8965547188539188 1.92441929727014e-06 0.8967039926079825 1.92442336043021e-06 0.8977020505850396 1.924423851854269e-06 0.8977948037134476 \
1.924432168453822e-06 0.898787348739254 1.92443308835295e-06 0.8988506593152591 1.92457657358348e-06 0.8998476076348748 1.924577692016455e-06 0.8998537475785264 \
1.924782783635956e-06 0.898985773748599 1.924783010725457e-06 0.8988224379910277 1.924784620332255e-06 0.8978282360369357 1.924784797740799e-06 0.8977338482811539 \
1.9248017048891e-06 0.8987315468430059 1.924801814328198e-06 0.8987460089186867 1.924817595049444e-06 0.8997418097871094 1.924817891375339e-06 0.8997476966799167 \
1.925301325027745e-06 0.9007060148833608 1.925301454078085e-06 0.9008313386292994 1.925302104227931e-06 0.9016292186224167 1.925302293723662e-06 0.9019133038041363 \
1.92530279694564e-06 0.9027675859898705 1.9253029324183e-06 0.9030208676018907 1.925303332877016e-06 0.9038195223753869 1.925303464814953e-06 0.9040958310886574 \
1.925303866030017e-06 0.9049509627747726 1.925303964290193e-06 0.9051582028152527 1.925304430164004e-06 0.9060587574877488 1.925304591662727e-06 0.9063060456044927 \
1.925305735675251e-06 0.9055153668657776 1.925305880654596e-06 0.9049059606760256 1.925306059207353e-06 0.9039396653125833 1.925306239402631e-06 0.9027054491383806 \
1.92530638209356e-06 0.9015369228101149 1.925306499253165e-06 0.9004524619440171 1.925306588234525e-06 0.8995505656965809 1.925306679878178e-06 0.8985529714258781 \
1.92530681299011e-06 0.8969831049011855 1.925306906711193e-06 0.8957895978311226 1.925306997850002e-06 0.8945634483845346 1.925307111142313e-06 0.8929516940777753 \
1.925307214251226e-06 0.8913998138690341 1.925307310518406e-06 0.8898830246517148 1.925307429655523e-06 0.8879200664089764 1.925307598240771e-06 0.8849885378698126 \
1.925307760012273e-06 0.8820195265790133 1.925307953231331e-06 0.8782956415026882 1.925308138794443e-06 0.8745571577041361 1.925308349060748e-06 0.8701566079887386 \
1.925308531309788e-06 0.8662213066841463 1.925308716173183e-06 0.8621339172744639 1.92530888885833e-06 0.8582419637438897 1.925309074966403e-06 0.8539816046497358 \
1.925309252782491e-06 0.849858603441091 1.925309433499072e-06 0.8456251963850057 1.925309598637331e-06 0.8417258760277182 1.925309763911433e-06 0.837798995916667 \
1.925309927159096e-06 0.8339004324287677 1.92531008574937e-06 0.8300982805770993 1.925310262673771e-06 0.8258418712800655 1.925310459187584e-06 0.8211009660847696 \
1.925310626744125e-06 0.8170498602679914 1.925310793484544e-06 0.8130123908857781 1.925310967908061e-06 0.8087844286215062 1.925311137277684e-06 0.8046757316210446 \
1.925311305476779e-06 0.8005936994537799 1.925311494325046e-06 0.7960093488074458 1.925311685140882e-06 0.7913773844868103 1.925311893523092e-06 0.7863203192056716 \
1.925312119942597e-06 0.7808277108969495 1.925312309142794e-06 0.7762391340290878 1.925312519289483e-06 0.7711455503222944 1.925312668057987e-06 0.7675418410361046 \
1.925312799050976e-06 0.7643705172588006 1.925312936616212e-06 0.7610417440783073 1.925313042367441e-06 0.7584842184275663 1.925313177141075e-06 0.7552262509102785 \
1.9253132889738e-06 0.7525244432456109 1.925313418408964e-06 0.7493992292091655 1.925313573597688e-06 0.7456545577979357 1.925313685233441e-06 0.7429626190147979 \
1.925313844808055e-06 0.7391166470929011 1.925314020129688e-06 0.7348935218456193 1.925314232505151e-06 0.7297828120356423 1.925314425387679e-06 0.7251458607116523 \
1.925314582088971e-06 0.7213823872711312 1.925314768763662e-06 0.716903961299824 1.925314957650011e-06 0.7123775767926828 1.925315148534203e-06 0.70780884692282 \
1.925315335282138e-06 0.7033444557767304 1.925315518366954e-06 0.698972331957095 1.925315655685935e-06 0.6956951921588121 1.925315808928893e-06 0.6920418367118417 \
1.925316004057543e-06 0.6873949992893974 1.925316161351872e-06 0.6836535194673684 1.925316320746467e-06 0.6798660670227984 1.92531651649026e-06 0.6752219404489795 \
1.925316708689394e-06 0.6706682621108646 1.925316943641022e-06 0.6651105611269369 1.92531713111727e-06 0.6606839627962382 1.925317368354404e-06 0.6550894036851447 \
1.925317557534366e-06 0.6506361170423679 1.925317738150178e-06 0.6463915264929231 1.925317901844741e-06 0.6425504277539856 1.92531804639615e-06 0.6391628119244788 \
1.92531818686792e-06 0.6358764726647652 1.925318313968707e-06 0.6329064225879303 1.925318446276183e-06 0.6298198307262635 1.92531857286323e-06 0.626870110582017 \
1.925318703443497e-06 0.62383130535404 1.925318832712897e-06 0.6208285625908692 1.925318971819793e-06 0.6176004736356133 1.925319120330103e-06 0.6141606483517721 \
1.925319309878658e-06 0.6097777958748198 1.925319455581915e-06 0.6064170107178907 1.925319690632478e-06 0.601007464699683 1.925319873631749e-06 0.5968099615921 \
1.925320097973423e-06 0.5916778694808832 1.925320269146672e-06 0.5877753019413697 1.925320401480491e-06 0.5847634284691802 1.92532053327703e-06 0.5817721407249107 \
1.925320639820933e-06 0.5793579518205488 1.925320735711292e-06 0.5771868999037388 1.925320828211542e-06 0.5750974572268882 1.925320920638905e-06 0.5730134868920421 \
1.925320993067211e-06 0.5713818265150021 1.925321048796317e-06 0.5701269325864891 1.925321109905404e-06 0.5687522410723198 1.92532120667008e-06 0.5665806864277688 \
1.925321268161594e-06 0.5652027770813386 1.925321327214216e-06 0.5638802801505602 1.925321402840882e-06 0.5621878686488651 1.92532146986366e-06 0.5606896577364279 \
1.92532154346077e-06 0.5590483558003441 1.925321611066772e-06 0.5575429304381756 1.925321727135829e-06 0.5549610936632026 1.925321827342234e-06 0.5527359403974305 \
1.925321939349424e-06 0.5502565947066531 1.925322033841475e-06 0.5481686943853854 1.925322154996173e-06 0.5454955387196141 1.925322255183939e-06 0.5432910220514219 \
1.925322371174451e-06 0.5407443765731218 1.925322478878288e-06 0.5383833065966291 1.925322588456977e-06 0.5359861028148916 1.925322700578421e-06 0.5335400310751951 \
1.925322827515605e-06 0.5307765704644959 1.925322949665123e-06 0.5281221248815906 1.925323089426037e-06 0.525095489155881 1.925323226564154e-06 0.522132778766487 \
1.925323376529244e-06 0.5189020692106626 1.925323535302247e-06 0.5154923220538846 1.925323709327904e-06 0.511765695450105 1.925323896158028e-06 0.5077823379664483 \
1.925324101125994e-06 0.5034264211640872 1.925324323834942e-06 0.4987133299464507 1.925324576739139e-06 0.4933874474923696 1.925324811693046e-06 0.4884604410272814 \
1.925325107961308e-06 0.4822828691822955 1.925325397751266e-06 0.4762763831984252 1.925325704087085e-06 0.4699660956099861 1.925326016405612e-06 0.4635767846525711 \
1.925326354971068e-06 0.4566963260653934 1.925326678082485e-06 0.4501741115777416 1.925327016477788e-06 0.4433881855507311 1.925327340309053e-06 0.4369378830387565 \
1.925327664703474e-06 0.4305204627449936 1.92532800763776e-06 0.4237851826852676 1.925328346918578e-06 0.4171698123421442 1.925328686393212e-06 0.4105997181257849 \
1.925329129505058e-06 0.4020958655332711 1.925329491573227e-06 0.3952155038183801 1.925329812124964e-06 0.3891775711374149 1.925330199059535e-06 0.3819561902961204 \
1.925330526929795e-06 0.3758957719299574 1.925330812088852e-06 0.3706704968427373 1.925331130457646e-06 0.3648820026298218 1.925331413288573e-06 0.3597820188690578 \
1.925331641977337e-06 0.3556924369094372 1.925331859870141e-06 0.3518226517641353 1.925332055119486e-06 0.3483769517668343 1.925332262027586e-06 0.344751588202948 \
1.925332476824341e-06 0.3410137651016431 1.925332729050892e-06 0.3366564674340092 1.925332971046205e-06 0.3325077909124976 1.925333201898484e-06 0.3285822460490526 \
1.925333416746675e-06 0.3249550452085373 1.925333637103364e-06 0.3212604562488142 1.925333838674264e-06 0.3179050685021769 1.925334041758211e-06 0.3145531374773136 \
1.925334239655597e-06 0.3113121771742085 1.925334426754836e-06 0.3082694484595072 1.925334620655179e-06 0.3051385396431291 1.925334825703514e-06 0.3018527636900292 \
1.925335005938266e-06 0.2989872106339772 1.925335241836278e-06 0.2952669081535775 1.925335443123827e-06 0.2921198200609627 1.925335644514631e-06 0.2889965001417216 \
1.925335869163794e-06 0.2855437159941698 1.925336034543768e-06 0.2830223598911593 1.925336212348106e-06 0.280330186126118 1.925336396004319e-06 0.277570343839212 \
1.925336581246076e-06 0.2748090658167894 1.925336759391454e-06 0.2721781298892599 1.925336932983517e-06 0.2696316866093095 1.92533709334837e-06 0.267306655456324 \
1.925337214459552e-06 0.2655585721882695 1.92533736765434e-06 0.2633570345323199 1.925337494985789e-06 0.2615475749425888 1.925337598313628e-06 0.2600830587034867 \
1.925337715638424e-06 0.2584225376281647 1.925337833445381e-06 0.2567591557214636 1.925337957409147e-06 0.2550199666844239 1.925338074393314e-06 0.2533821414201824 \
1.925338205189441e-06 0.2515535495016885 1.925338322399552e-06 0.2499173892700276 1.925338475652677e-06 0.2477853623028658 1.925338611183197e-06 0.2459029165157107 \
1.925338742864406e-06 0.244074199323236 1.925338899457317e-06 0.2419017673596028 1.925339024653874e-06 0.2401755227310949 1.925339160371501e-06 0.2383060149301216 \
1.925339292798663e-06 0.2364844144139329 1.925339412772324e-06 0.2348355337769661 1.925339575820161e-06 0.232606585912384 1.925339714627252e-06 0.230713852557009 \
1.925339853100972e-06 0.2288300961780371 1.925339958645721e-06 0.2273962817971701 1.925340087007401e-06 0.2256537837490921 1.925340191135024e-06 0.2242444877898851 \
1.925340291651026e-06 0.222886569499566 1.925340366695402e-06 0.2218745444235658 1.925340444028458e-06 0.2208349692306942 1.925340518791637e-06 0.2198305887827458 \
1.925340596755314e-06 0.218785487158918 1.925340651621824e-06 0.2180503923904892 1.9253407081186e-06 0.2172938400168352 1.925340751572119e-06 0.2167123195211523 \
1.925340791613165e-06 0.2161767335077376 1.925340830852113e-06 0.2156521099473339 1.92534087172635e-06 0.2151058606261434 1.92534092587884e-06 0.2143825797409383 \
1.925340964295971e-06 0.2138698309421548 1.925341003584678e-06 0.2133480458229882 1.925341065121386e-06 0.2125332203444249 1.925341127098915e-06 0.2117131287842428 \
1.925341183575664e-06 0.2109664019951111 1.925341248207254e-06 0.2101124842966758 1.925341343715876e-06 0.2088522205996687 1.925341431031608e-06 0.207701294711168 \
1.925341527641208e-06 0.2064291756790013 1.925341624870762e-06 0.2051510266126755 1.925341725717823e-06 0.2038307158897115 1.925341826317594e-06 0.2025192706911573 \
1.925341922808891e-06 0.2012627769767186 1.925342024991065e-06 0.1999338657614989 1.925342128630721e-06 0.1985898465970496 1.925342238404734e-06 0.1971698847140261 \
1.925342347579759e-06 0.1957617939809042 1.925342467677852e-06 0.1942174441246506 1.925342577697376e-06 0.1928086337505992 1.925342685809285e-06 0.1914295694688549 \
1.925342808837984e-06 0.1898652723262108 1.925342898948554e-06 0.1887234630454603 1.925343006314045e-06 0.1873671680421656 1.925343083125353e-06 0.1864004060894758 \
1.925343166570621e-06 0.1853535952511875 1.925343256102432e-06 0.1842338297700716 1.925343340667898e-06 0.1831790839553313 1.925343420384039e-06 0.1821880912968773 \
1.925343521709242e-06 0.1809331989518758 1.925343630056471e-06 0.1795959386230563 1.925343726532169e-06 0.1784102562612937 1.925343851909986e-06 0.1768766438339704 \
1.925343984693456e-06 0.1752616821119887 1.925344102464279e-06 0.1738362801839788 1.925344248115856e-06 0.1720835746408261 1.925344358713008e-06 0.1707596463148658 \
1.925344500843447e-06 0.1690680578777541 1.92534461655307e-06 0.1676985735146403 1.925344722027083e-06 0.166456424915798 1.925344816543743e-06 0.1653485352650968 \
1.925344912181115e-06 0.1642320043563913 1.925345009252958e-06 0.1631032360400927 1.925345108304212e-06 0.161956192050434 1.925345202227769e-06 0.1608730077890209 \
1.925345287503444e-06 0.1598934595213354 1.925345387883236e-06 0.1587475631033795 1.925345472186073e-06 0.1577906478848196 1.925345574585582e-06 0.1566342854655733 \
1.925345651979844e-06 0.1557646215197878 1.925345744324758e-06 0.154731814591042 1.92534581457623e-06 0.1539498814072817 1.925345910750659e-06 0.1528844393027091 \
1.925345987575322e-06 0.152038051282755 1.925346066345474e-06 0.1511758489440315 1.925346140238395e-06 0.150370438825067 1.925346207936138e-06 0.1496353997608715 \
1.925346304000026e-06 0.1485973848112393 1.925346373572453e-06 0.1478489919002561 1.925346457461625e-06 0.1469503328160803 1.925346518593461e-06 0.146298213254472 \
1.925346590861543e-06 0.1455309799806117 1.925346663300106e-06 0.1447677488542132 1.925346744281147e-06 0.1439178685120187 1.925346810355616e-06 0.1432275520600639 \
1.925346887756114e-06 0.1424219220725307 1.925346977131571e-06 0.1414956876531561 1.925347047992216e-06 0.1407644282175171 1.925347146879283e-06 0.1397487730030469 \
1.925347224198192e-06 0.1389620820751095 1.925347306243419e-06 0.1381330876879582 1.92534739435453e-06 0.1372467208126059 1.925347461981677e-06 0.1365690714953818 \
1.925347542278859e-06 0.1357674830239305 1.925347617062888e-06 0.1350239185327315 1.925347685064065e-06 0.1343502586094245 1.925347731746974e-06 0.1338891847862563 \
1.925347820998567e-06 0.1330118383700247 1.925347859221617e-06 0.1326395291833771 1.925347928213527e-06 0.1319690872918072 1.925347980961596e-06 0.1314578750898332 \
1.925348063954378e-06 0.1306559489775353 1.925348104132829e-06 0.1302688434457458 1.925348196650203e-06 0.1293805059784019 1.92534823536857e-06 0.1290098403727171 \
1.925348309129285e-06 0.1283055160094505 1.925348370757287e-06 0.1277188748199021 1.925348442784976e-06 0.1270353589407805 1.925348510952008e-06 0.1263909833196726 \
1.925348585574169e-06 0.1256908956540175 1.925348667426635e-06 0.1249253613889138 1.925348750880797e-06 0.124147338931438 1.925348823832511e-06 0.1234692772477456 \
1.925348896559441e-06 0.122795332839617 1.925348956549436e-06 0.1222410931008323 1.925349042917447e-06 0.121445549533078 1.925349103886165e-06 0.1208856452315438 \
1.925349162271955e-06 0.1203507897957366 1.92534922790662e-06 0.119751336354628 1.925349287260861e-06 0.1192111367930785 1.925349355292642e-06 0.1185941868697126 \
1.925349452587012e-06 0.11771710490035 1.925349531078992e-06 0.1170124163111649 1.925349621315123e-06 0.1162055395685231 1.925349717161809e-06 0.1153523005684616 \
1.925349792119505e-06 0.1146878351828532 1.925349896478921e-06 0.1137670532163148 1.925349983267518e-06 0.1130053589403202 1.925350092924934e-06 0.1120476726212376 \
1.925350174478997e-06 0.1113387926087848 1.925350270092629e-06 0.1105114393564785 1.925350346804822e-06 0.10985058581598 1.925350441723287e-06 0.1090364400125625 \
1.925350517546392e-06 0.1083889268999046 1.925350595246049e-06 0.1077282965354292 1.9253506775775e-06 0.1070311517075373 1.925350737142764e-06 0.1065286079538068 \
1.925350800900501e-06 0.1059924133642201 1.925350861995109e-06 0.1054803128126646 1.925350957858847e-06 0.1046801683739134 1.925351002721942e-06 0.1043071445723913 \
1.925351085962687e-06 0.1036173314376927 1.925351135082509e-06 0.1032117000904133 1.925351244131271e-06 0.1023149933518279 1.925351288967353e-06 0.1019479364619093 \
1.925351379228585e-06 0.1012117400678687 1.925351420105203e-06 0.1008795969612472 1.925351490563617e-06 0.1003088525914566 1.925351576851038e-06 0.09961307626065434 \
1.925351668628597e-06 0.09887705578174606 1.92535173815669e-06 0.09832225024344161 1.925351816683849e-06 0.09769854072774181 1.925351907412525e-06 0.09698178745350861 \
1.925351983228664e-06 0.09638605854785212 1.925352065241407e-06 0.09574500473888557 1.925352146994443e-06 0.09510943278387665 1.925352237502267e-06 0.09440967388330095 \
1.925352327061565e-06 0.09372126988887708 1.925352412671398e-06 0.09306698857649189 1.925352505450897e-06 0.09236212353634379 1.925352586338857e-06 0.0917510971760913 \
1.925352687467827e-06 0.09099177263830999 1.925352767961352e-06 0.09039108594384238 1.925352852204218e-06 0.08976589684797046 1.925352926049265e-06 0.08922077348043934 \
1.925353002898743e-06 0.08865632925481931 1.925353091039113e-06 0.08801255002475737 1.925353171103481e-06 0.08743108261130086 1.925353264139672e-06 0.08675939571108145 \
1.925353382140385e-06 0.08591369538214398 1.925353524513612e-06 0.08490278100234279 1.925353668761962e-06 0.08388867104764453 1.925353811089671e-06 0.08289807427203813 \
1.925353960667415e-06 0.08186746790234835 1.92535409698116e-06 0.08093761126893445 1.925354239101592e-06 0.0799778356000513 1.92535437365502e-06 0.07907840240745091 \
1.925354514007729e-06 0.07814980287393705 1.925354661689802e-06 0.0771833418413561 1.925354811805299e-06 0.07621180464723754 1.925354976525777e-06 0.07515824360926991 \
1.925355140155128e-06 0.07412455432658185 1.925355314933688e-06 0.07303438636984133 1.925355502186304e-06 0.07188220095900363 1.925355712231308e-06 0.07060976590783831 \
1.925355930441531e-06 0.06930979572898451 1.92535616389862e-06 0.06794333957253913 1.925356418744638e-06 0.06648001693367038 1.925356711839195e-06 0.06483321328442151 \
1.925357014178957e-06 0.06317411115207273 1.925357328765833e-06 0.06148945259513613 1.925357725026527e-06 0.05942677493938087 1.925358058743672e-06 0.05774249301432461 \
1.925358466054501e-06 0.05574994498853819 1.92535879393926e-06 0.05419380357502902 1.925359150629899e-06 0.05254809000207299 1.92535946386806e-06 0.05114243792209583 \
1.925359766835193e-06 0.04981740498512215 1.925360064375719e-06 0.04854875663330436 1.925360343155274e-06 0.04739109061078805 1.925360626155169e-06 0.04624570307560639 \
1.925360887895477e-06 0.04521055793698023 1.92536116713437e-06 0.04413130357485813 1.92536143924029e-06 0.0431040186124033 1.925361746607047e-06 0.04197194005652995 \
1.925361968409948e-06 0.04117329707315532 1.925362274870428e-06 0.04009446155587663 1.925362501059881e-06 0.03931650950691581 1.925362739977207e-06 0.03851359500741255 \
1.925362964401039e-06 0.03777663690506906 1.92536316666332e-06 0.03712468825868943 1.925363367705949e-06 0.03648814235703791 1.925363719479983e-06 0.03540095449820539 \
1.925363969725821e-06 0.03464776841732944 1.925364216044101e-06 0.03392252499723709 1.925364497376964e-06 0.03311308780599518 1.92536474046795e-06 0.03242954897046491 \
1.925364975941701e-06 0.03178112583711486 1.925365217601206e-06 0.03113119522156456 1.925365454483484e-06 0.03050988948014832 1.925365685016041e-06 0.02991733361391674 \
1.925365898984569e-06 0.02937801894285819 1.925366104927116e-06 0.02886851641492237 1.925366497651603e-06 0.02792196059063811 1.925366685729283e-06 0.02747992420741849 \
1.925367061168249e-06 0.02661861215736662 1.925367236042477e-06 0.02622659266649364 1.925367659365492e-06 0.02530049759795254 1.925367780614875e-06 0.02504150687334681 \
1.925368221176528e-06 0.02412433837770948 1.925368363674648e-06 0.02383402682615681 1.925368695728157e-06 0.02316883068419595 1.925368878693682e-06 0.02280879143785283 \
1.925369267997886e-06 0.02205689891561978 1.925369436343594e-06 0.02173705378531499 1.925369908457993e-06 0.02085107653961301 1.925370048202727e-06 0.0205916297664938 \
1.925370543782805e-06 0.01969297428531048 1.925370671008237e-06 0.01946923320191776 1.925371238917342e-06 0.01851512288677271 1.92537140317129e-06 0.0182513999453204 \
1.925372013043029e-06 0.0173209960017622 1.925372172728257e-06 0.01708922829277545 1.925372699639798e-06 0.01635462467776483 1.925372904157091e-06 0.01608193551804103 \
1.925373627634478e-06 0.01515939662837778 1.92537379307661e-06 0.01495683325581705 1.925374539636356e-06 0.01408081084911163 1.925374672939569e-06 0.01393008075245666 \
1.925375533124155e-06 0.01299799962960837 1.92537566920557e-06 0.01285670227674402 1.925376609799459e-06 0.01192267652923807 1.925376773572533e-06 0.01176632439256516 \
1.925377774751465e-06 0.01084959205883911 1.925377912229187e-06 0.01072929995296418 1.925379082926798e-06 0.009787962024485789 1.925379175323166e-06 0.009718668544398181 \
1.925380593399014e-06 0.008725931027897449 1.925380680375162e-06 0.00866912727384293 1.925382221370792e-06 0.00770199130002063 1.925382330686807e-06 0.007633428668288294 \
1.925383973934629e-06 0.006673746291950173 1.925384106791908e-06 0.006603544020797993 1.925386201172206e-06 0.005605323336654431 1.925386409576941e-06 0.00551468736035817 \
1.925388763913366e-06 0.004577307911602986 1.925389237472123e-06 0.004407121484391641 1.92539212290898e-06 0.003492041675788492 1.925392652573326e-06 0.00334538389506189 \
1.925396860800552e-06 0.00237996320858989 1.925397374234803e-06 0.002283557532494709 1.925403133485495e-06 0.001325291758975802 1.925403368066713e-06 0.001279502680325907 \
1.925418035894088e-06 0.0002809017338477542 1.92541814896418e-06 0.0002788534805396912 1.92805516904393e-06 -0.0006849217749926401 1.928055335205606e-06 -0.0009443270389602415 \
1.928055814074993e-06 -0.001850320037528519 1.92805590679462e-06 -0.002050462221988249 1.928056272019697e-06 -0.002913187630468476 1.928056363676814e-06 -0.00314709230904735 \
1.928056729783165e-06 -0.004133001189868674 1.92805683993029e-06 -0.004442309109773816 1.928057150668543e-06 -0.005311341427314526 1.928057252407188e-06 -0.005583925258601597 \
1.928057616111313e-06 -0.00638370916272213 1.928057780957636e-06 -0.006585924750287024 1.928058360754957e-06 -0.005792290386912202 1.928058535589415e-06 -0.004916934050781314 \
1.928058652279015e-06 -0.00413641027497409 1.928058778708708e-06 -0.00310656561120747 1.92805888073091e-06 -0.002137079422087956 1.928059000577393e-06 -0.0008406209844352954 \
1.928059091214629e-06 0.0002489246187367611 1.92805918963468e-06 0.001536790859923857 1.928059289358324e-06 0.002948496343048522 1.928059456842332e-06 0.005545701385567424 \
1.928059675420934e-06 0.009327395936412004 1.928059861491256e-06 0.0128572688386996 1.928060082873864e-06 0.01737012273305725 1.928060243533997e-06 0.02082840415615294 \
1.928060406999647e-06 0.02447866954313523 1.928060557635164e-06 0.02794359528291388 1.928060706690917e-06 0.03145289236167962 1.928060856153671e-06 0.03504014479003619 \
1.928061010184684e-06 0.03879791952579481 1.928061172300943e-06 0.04280891157365373 1.928061338330408e-06 0.04696567134311741 1.928061514283228e-06 0.05141478668696391 \
1.928061694953865e-06 0.05602187592747932 1.928061886774812e-06 0.06094655248807559 1.928062093880317e-06 0.06629309753158302 1.928062315452046e-06 0.07203901748582854 \
1.928062550186215e-06 0.07814662931008168 1.928062801725783e-06 0.08470684589377442 1.928063077167849e-06 0.09190125212984442 1.928063377363667e-06 0.09974607960254324 \
1.928063708295878e-06 0.108390578238945 1.928064083962612e-06 0.1181923833971668 1.92806448154548e-06 0.1285487285136021 1.928064948370082e-06 0.1406786766767902 \
1.928065491362617e-06 0.1547396794802719 1.92806612478764e-06 0.1710742296429572 1.928066820727691e-06 0.1889259607126788 1.928067636284801e-06 0.2097135943149445 \
1.928068546312904e-06 0.2327316641523666 1.928069339569124e-06 0.2526372689279454 1.9280700450442e-06 0.2702038474981599 1.928070663988468e-06 0.2855008995781749 \
1.928071231094408e-06 0.2994177966724069 1.928071754174414e-06 0.3121574438576628 1.928072253153207e-06 0.3242197130846058 1.928072737193214e-06 0.3358335658028451 \
1.928073192420047e-06 0.3466679577370423 1.928073666932009e-06 0.3578644504627745 1.928074106840717e-06 0.368158604789619 1.928074592685345e-06 0.3794271463718566 \
1.928075124288118e-06 0.3916316501999784 1.928075626951417e-06 0.4030538969706937 1.92807605602367e-06 0.4127111343288326 1.928076547040338e-06 0.4236561147984291 \
1.928077048470418e-06 0.434714731975362 1.928077395015009e-06 0.442288187401736 1.928077750424386e-06 0.4500000616404133 1.928078177652114e-06 0.4592019891792938 \
1.928078569851637e-06 0.4675774400278049 1.928078870233395e-06 0.4739448723400065 1.928079212045155e-06 0.4811381049525967 1.928079555484969e-06 0.4883107756756314 \
1.928079816220095e-06 0.4937186470393492 1.928080058250048e-06 0.4987071765458648 1.928080324195291e-06 0.5041573145298286 1.928080581464587e-06 0.509394255416739 \
1.92808077158369e-06 0.5132422368582924 1.928080985109851e-06 0.5175451019736222 1.928081124800157e-06 0.5203466115392713 1.928081271000449e-06 0.5232668091041763 \
1.92808148498835e-06 0.5275186200231483 1.92808169300461e-06 0.5316389396023125 1.928081885465879e-06 0.5354321131715788 1.92808207058211e-06 0.5390651926504321 \
1.928082244955557e-06 0.5424725330931349 1.928082549497633e-06 0.5484058192982523 1.928082810056515e-06 0.5534602958276967 1.928083111487545e-06 0.5592859190791987 \
1.928083365805138e-06 0.5641865993769294 1.928083658661328e-06 0.5698153316805189 1.92808391787448e-06 0.5747800306938655 1.928084188950812e-06 0.579963273174682 \
1.928084430794571e-06 0.5845680738798381 1.928084688299729e-06 0.5894577538325241 1.928084915043605e-06 0.5937419314630586 1.928085152044424e-06 0.5982006324572362 \
1.928085362230986e-06 0.6021379329905048 1.92808557499152e-06 0.6061060319396779 1.928085827870286e-06 0.6107954169450593 1.928086031533555e-06 0.6145509252949414 \
1.928086222250936e-06 0.6180531102377972 1.928086409587375e-06 0.6214768531423983 1.928086598465652e-06 0.6249070011644339 1.928086806665447e-06 0.6286671070650327 \
1.928087050997562e-06 0.6330499453121026 1.928087250564095e-06 0.6366057789565548 1.928087454709835e-06 0.6402215701419991 1.92808763934909e-06 0.643474671963314 \
1.928087908884781e-06 0.6481901084955864 1.928088136591637e-06 0.652149230294136 1.928088324263375e-06 0.6553888277830079 1.92808850516352e-06 0.6584949378977958 \
1.928088664704602e-06 0.661221510907812 1.928088835167002e-06 0.6641177016088209 1.928088986918443e-06 0.6666817235716488 1.928089124561455e-06 0.6689905419339194 \
1.928089273556319e-06 0.6714784915997724 1.928089401298182e-06 0.6736028790357499 1.928089544284695e-06 0.675968899142866 1.928089666067751e-06 0.6779749688503388 \
1.928089802351161e-06 0.6802121872853304 1.928089922180063e-06 0.682172759947357 1.928090068775623e-06 0.6845626218370968 1.928090187248565e-06 0.6864845934661837 \
1.928090283181927e-06 0.6880368302455475 1.928090375701512e-06 0.6895284278106264 1.928090480762023e-06 0.6912169000724893 1.928090578843908e-06 0.6927871490736753 \
1.928090715959225e-06 0.6949707622226827 1.928090835157868e-06 0.6968607547931925 1.928090945097838e-06 0.6985951241089645 1.928091082597081e-06 0.7007503743809057 \
1.928091214026983e-06 0.7027960765825516 1.928091346256498e-06 0.7048392108129343 1.928091459433897e-06 0.7065756917706891 1.928091613866752e-06 0.708927873976708 \
1.928091744646745e-06 0.7109048231498766 1.928091867315455e-06 0.7127465601965561 1.928091973583711e-06 0.7143329262278221 1.928092095963735e-06 0.7161490373358268 \
1.928092197817232e-06 0.7176517022913665 1.928092331955131e-06 0.7196190116794019 1.928092452648172e-06 0.7213783352064487 1.928092571789971e-06 0.7231049829175343 \
1.928092696807985e-06 0.7249059312823601 1.928092826647791e-06 0.7267645120560844 1.928092946459962e-06 0.7284691779696002 1.928093075453213e-06 0.730293808329565 \
1.928093207560277e-06 0.7321507998840678 1.928093325866095e-06 0.7338038328985433 1.928093469126786e-06 0.7357927618453034 1.928093571581473e-06 0.7372070005703254 \
1.928093667788358e-06 0.7385290937783453 1.92809377280598e-06 0.7399656334130889 1.928093883577511e-06 0.7414708009413548 1.928093985256052e-06 0.7428439364018735 \
1.928094088217507e-06 0.7442258341871242 1.92809420514366e-06 0.7457850038572696 1.928094333903937e-06 0.747489965072781 1.928094435062908e-06 0.7488201182152049 \
1.928094583931952e-06 0.7507626302114226 1.928094731611489e-06 0.75267249971878 1.928094850976855e-06 0.7542038164026367 1.9280949974607e-06 0.7560679527984652 \
1.92809512063619e-06 0.7576223900169708 1.928095261439865e-06 0.7593848990234215 1.928095398032531e-06 0.7610800595258669 1.928095520190381e-06 0.7625841275516777 \
1.928095632846778e-06 0.7639610711610054 1.928095774572919e-06 0.7656796138775311 1.92809590073942e-06 0.767196844592689 1.928096016156724e-06 0.768574452686535 \
1.928096146464904e-06 0.7701179991486644 1.928096262177572e-06 0.7714782821591826 1.92809638500186e-06 0.7729116492687436 1.928096502846128e-06 0.7742769236963016 \
1.928096608476119e-06 0.7754922619072108 1.928096723849553e-06 0.7768108638983861 1.928096829112716e-06 0.7780056027231214 1.928096940062529e-06 0.7792565499870431 \
1.92809702646703e-06 0.7802246528436213 1.92809713050085e-06 0.7813823422463088 1.928097244396594e-06 0.7826398494046257 1.928097347430014e-06 0.7837684443710583 \
1.928097455512714e-06 0.7849432998269023 1.92809756376437e-06 0.7861107422109641 1.928097699181616e-06 0.7875582910536544 1.928097811855724e-06 0.7887521292973186 \
1.928097936279784e-06 0.7900592323105087 1.928098054252648e-06 0.7912877959129118 1.928098198720603e-06 0.7927781272271259 1.928098316389742e-06 0.7939806363584788 \
1.928098452269581e-06 0.7953567374150946 1.928098587013954e-06 0.7967081403609936 1.928098698084933e-06 0.7978123285366109 1.928098797974273e-06 0.7987978371087655 \
1.928098899654231e-06 0.7997937268659365 1.928099032867897e-06 0.8010867894381996 1.928099151240716e-06 0.8022243628210853 1.92809927278179e-06 0.8033812848148773 \
1.928099392145442e-06 0.8045065422543012 1.928099513276819e-06 0.80563739819571 1.928099644976236e-06 0.8068544426691319 1.928099767984513e-06 0.8079795872959963 \
1.92809989582812e-06 0.8091371804586788 1.92810002673464e-06 0.8103101881504271 1.928100150327798e-06 0.8114062915203997 1.928100257500303e-06 0.8123479140825919 \
1.928100364929502e-06 0.8132835730547656 1.92810044759862e-06 0.8139979974227743 1.92810056531038e-06 0.8150069815425507 1.928100655915986e-06 0.8157770472204025 \
1.928100786569431e-06 0.8168774959419571 1.928100930959301e-06 0.8180800468042847 1.928101064133715e-06 0.8191766687328477 1.928101174025107e-06 0.8200725423139092 \
1.928101317623992e-06 0.8212302325252553 1.928101471014683e-06 0.8224508494407716 1.928101599092908e-06 0.8234574467428303 1.928101738880276e-06 0.8245431382086058 \
1.928101865129839e-06 0.8255122018650548 1.928102019728392e-06 0.8266841987320058 1.928102151939368e-06 0.8276738265999063 1.928102278166151e-06 0.8286078934539939 \
1.928102395913874e-06 0.8294698388787296 1.928102544986667e-06 0.8305480062617677 1.92810271231822e-06 0.8317406852496945 1.928102845539497e-06 0.8326770812274722 \
1.92810301832082e-06 0.8338744310092966 1.928103186826194e-06 0.8350236380668206 1.928103356205492e-06 0.8361608866600232 1.928103537840761e-06 0.8373606451951652 \
1.928103680174083e-06 0.8382866867625347 1.928103794011069e-06 0.8390185116470331 1.928103925192579e-06 0.8398522525089582 1.928104026724794e-06 0.8404903982372576 \
1.928104143009054e-06 0.8412135669902132 1.928104277643808e-06 0.8420406924792603 1.928104474666644e-06 0.8432316292878405 1.928104664772186e-06 0.8443592803112207 \
1.928104874895498e-06 0.8455816023960827 1.928105055213604e-06 0.8466107566581813 1.928105252676705e-06 0.8477171937062282 1.92810542674582e-06 0.8486750118570332 \
1.92810560906524e-06 0.8496608982186138 1.928105780480376e-06 0.8505716849290491 1.928105954593653e-06 0.8514808063694008 1.928106130324621e-06 0.8523822271368225 \
1.928106306436322e-06 0.8532696099472232 1.928106496054173e-06 0.8542074684498208 1.928106686835671e-06 0.8551330189126392 1.928106888431747e-06 0.8560917259710515 \
1.928107081166005e-06 0.856990088884472 1.928107290037826e-06 0.8579439907476532 1.928107520740263e-06 0.8589743400177088 1.928107785183227e-06 0.8601259267840322 \
1.928108084005915e-06 0.8613896125360476 1.928108363960216e-06 0.8625380186322354 1.928108648086082e-06 0.8636694076724545 1.928108922855057e-06 0.8647317823994775 \
1.928109194712217e-06 0.8657531067718063 1.928109465089334e-06 0.8667403371654003 1.928109722167855e-06 0.8676533221001362 1.928109994792686e-06 0.868594905839151 \
1.928110270759836e-06 0.8695208838709013 1.928110540864093e-06 0.8704012674911344 1.928110840740104e-06 0.8713491368600049 1.928111211801162e-06 0.8724801680184872 \
1.92811150674079e-06 0.8733472453740196 1.928111761036548e-06 0.8740729094291386 1.928112059297474e-06 0.8748989982677786 1.928112332904015e-06 0.8756336613858092 \
1.928112569029957e-06 0.876250392688866 1.928112809374056e-06 0.8768621356511911 1.928113031706182e-06 0.8774140071409635 1.928113225712247e-06 0.8778848105679672 \
1.928113555434997e-06 0.8786625669521169 1.928113710608526e-06 0.8790190643519731 1.928114028387606e-06 0.879730644938159 1.928114207248864e-06 0.8801204696806418 \
1.928114549710761e-06 0.8808457867651537 1.928114733837363e-06 0.8812245477320809 1.928115208711942e-06 0.8821665346129511 1.928115376108352e-06 0.8824869809105039 \
1.928115841951854e-06 0.883348261932613 1.928116022773548e-06 0.8836708855253055 1.928116516812651e-06 0.8845204537290557 1.928116658162059e-06 0.8847551796839913 \
1.928117264500122e-06 0.8857215808967022 1.928117416569336e-06 0.8859539944113424 1.928118063256356e-06 0.8869009218298172 1.928118191551239e-06 0.8870812460539503 \
1.928118839667745e-06 0.8879562712787433 1.92811896946764e-06 0.8881245027440973 1.92811974767834e-06 0.8890830197250962 1.928119862725472e-06 0.8892171882189283 \
1.928120718396314e-06 0.8901564861234483 1.928120863744077e-06 0.8903061494816453 1.928121849499649e-06 0.8912466483555094 1.928122070607711e-06 0.8914402669210102 \
1.928123215727714e-06 0.892367747196105 1.928123346939158e-06 0.8924695935232408 1.928124688211624e-06 0.8934615053489913 1.9281248396029e-06 0.8935661991834861 \
1.92812632105512e-06 0.8944951400107031 1.928126559934816e-06 0.8946288932334222 1.928128329356654e-06 0.895502508848118 1.928128718477945e-06 0.895670668133377 \
1.928131112210654e-06 0.8965556062201232 1.928131587750592e-06 0.8967047758494365 1.928135650819818e-06 0.8977025964496719 1.928136142295653e-06 0.8977953148389237 \
1.928144458892796e-06 0.8987880790885289 1.928145378794248e-06 0.8988514070442593 1.928299242370168e-06 0.8998485708192639 1.928302885496457e-06 0.8998628537402877 \
1.928529614276672e-06 0.8989664306490068 1.928529844616583e-06 0.8988008565867064 1.928531459536881e-06 0.897804750401333 1.928531637269166e-06 0.8977103535805105 \
1.928548403669271e-06 0.8986978311584225 1.928548539768402e-06 0.8987160394686986 1.928563710608672e-06 0.8997133888183054 1.928563987713508e-06 0.899719468756186 \
1.929048028906422e-06 0.9005852143835333 1.929048202241039e-06 0.9007408621809421 1.929048862730638e-06 0.9015135064485434 1.929049028795821e-06 0.9017527716291757 \
1.929049555130528e-06 0.9026184054967997 1.929049746244448e-06 0.9029704910143604 1.9290501104655e-06 0.9036902342402512 1.929050289664922e-06 0.9040628043424317 \
1.929050651551594e-06 0.9048333795345931 1.929050846661164e-06 0.9052442844328937 1.929051379059525e-06 0.9062266394381637 1.929051561413164e-06 0.9064623886473868 \
1.929052553393556e-06 0.905594670761786 1.929052714934123e-06 0.9049318860608667 1.929052882926576e-06 0.9040378649110347 1.929053042758061e-06 0.9029782421366458 \
1.929053180254799e-06 0.9018984154159868 1.929053313162111e-06 0.9007052793196499 1.929053439587579e-06 0.8994328447569792 1.929053546986819e-06 0.8982475863895881 \
1.929053651483477e-06 0.8970047013543965 1.929053765533146e-06 0.8955451342423859 1.929053855502734e-06 0.8943225684615312 1.929053960321373e-06 0.8928208677113324 \
1.929054049769612e-06 0.891473284704788 1.929054132145393e-06 0.8901820884368528 1.929054223238393e-06 0.8887006634027688 1.92905436057447e-06 0.8863657732814155 \
1.929054459067403e-06 0.8846195012157601 1.929054571141153e-06 0.8825649218508906 1.929054702024186e-06 0.880080778639088 1.929054838495216e-06 0.8774018563482072 \
1.929054991949379e-06 0.8742910281085086 1.929055151043747e-06 0.8709679977889497 1.929055315327649e-06 0.867445283300377 1.929055471995751e-06 0.8640104344288071 \
1.929055624086531e-06 0.860615744772629 1.929055777800206e-06 0.857132398554192 1.929055937362381e-06 0.853469801378647 1.929056092451083e-06 0.8498714074018293 \
1.929056266130401e-06 0.8458039138600054 1.929056429161269e-06 0.8419559450883216 1.929056590803684e-06 0.8381170660338335 1.92905675345042e-06 0.8342344554797501 \
1.929056914868927e-06 0.8303657475978833 1.929057083463406e-06 0.8263109424305363 1.929057266356504e-06 0.8219002364007665 1.929057434185218e-06 0.8178440888239877 \
1.929057602471033e-06 0.8137703061148112 1.929057773299085e-06 0.8096302849976138 1.929057945473642e-06 0.8054541271740473 1.929058113235561e-06 0.8013830614994394 \
1.929058296865018e-06 0.7969255463994016 1.929058468271496e-06 0.7927646873948894 1.929058653714802e-06 0.7882638003278283 1.929058820385453e-06 0.7842196820467244 \
1.929058989271585e-06 0.7801233737411432 1.929059173427882e-06 0.7756572567105651 1.929059368037911e-06 0.7709405333854473 1.929059515293241e-06 0.7673736106648734 \
1.929059641923832e-06 0.7643079795643375 1.929059783780644e-06 0.7608754495129878 1.929059888184422e-06 0.7583505812556488 1.929060020577074e-06 0.7551502542766809 \
1.92906013016127e-06 0.7525028097975122 1.929060263325923e-06 0.7492875979647342 1.929060419507685e-06 0.7455190770546114 1.929060532737112e-06 0.7427887939149777 \
1.929060695258476e-06 0.7388718945951063 1.929060867439292e-06 0.7347246296492568 1.929061063444044e-06 0.7300078517193382 1.929061227834023e-06 0.7260553905833119 \
1.929061380230703e-06 0.7223944885043934 1.929061543905858e-06 0.718466402706526 1.929061711831558e-06 0.7144406657912139 1.929061891671936e-06 0.7101336212543717 \
1.929062067965886e-06 0.7059164985576465 1.929062239040521e-06 0.7018286413152719 1.929062407358697e-06 0.6978099102718778 1.929062560624829e-06 0.6941537154717222 \
1.929062722508398e-06 0.6902960245155986 1.929062901459938e-06 0.6860364417190952 1.92906303567149e-06 0.6828448068431195 1.929063139177788e-06 0.6803854168085423 \
1.929063238462201e-06 0.6780286039046017 1.929063339916676e-06 0.6756220912380299 1.929063432373276e-06 0.6734303711245889 1.929063516962075e-06 0.6714267031582685 \
1.929063610539412e-06 0.6692114082407524 1.929063727081631e-06 0.6664546942583044 1.929063836559192e-06 0.6638675763958631 1.929063949672203e-06 0.6611971533414394 \
1.92906407279097e-06 0.6582923426231613 1.929064197017283e-06 0.6553636581362478 1.929064367777427e-06 0.6513432847262797 1.929064526226014e-06 0.6476181700514572 \
1.929064698513837e-06 0.6435738126612673 1.929064844491904e-06 0.6401512360303271 1.929064986285119e-06 0.6368325564797357 1.929065117883574e-06 0.6337564355289309 \
1.929065248046859e-06 0.630718219665797 1.9290653735718e-06 0.6277924818644975 1.929065505354707e-06 0.6247239543970449 1.929065635278203e-06 0.6217046839485236 \
1.929065771586778e-06 0.6185408917806742 1.929065916200345e-06 0.615188962872713 1.929066075692536e-06 0.611499189008522 1.929066249152652e-06 0.6074939486938447 \
1.929066420159954e-06 0.6035554342946753 1.929066651528522e-06 0.5982402936372396 1.929066894990528e-06 0.5926661367297537 1.929067069111016e-06 0.5886942528256315 \
1.929067215383094e-06 0.5853638081576373 1.929067349755311e-06 0.58231230528805 1.929067466850207e-06 0.5796585826255305 1.929067562614553e-06 0.5774900935424465 \
1.929067661461095e-06 0.5752566196463251 1.929067745438414e-06 0.5733628024369305 1.929067823052463e-06 0.571614165956722 1.929067884377937e-06 0.5702331258704825 \
1.929067949058576e-06 0.5687779664863769 1.929068030366711e-06 0.5669528575016536 1.929068080436707e-06 0.5658306078972934 1.929068129757269e-06 0.5647256890740617 \
1.929068191677069e-06 0.5633393552914843 1.929068239508894e-06 0.5622690492396486 1.929068290013679e-06 0.5611395143522533 1.929068350075717e-06 0.559799205480933 \
1.929068409358512e-06 0.5584782058326896 1.929068484415226e-06 0.5568072508052372 1.929068554097883e-06 0.5552574373576753 1.929068639686449e-06 0.5533559356568912 \
1.929068726753821e-06 0.5514265885063823 1.929068810416341e-06 0.5495763264044081 1.929068896561366e-06 0.5476734676082877 1.929068992265987e-06 0.5455621222678217 \
1.929069096550939e-06 0.5432673229847179 1.929069211218113e-06 0.5407497407899529 1.929069319936575e-06 0.5383664115638558 1.929069429508814e-06 0.5359693749054023 \
1.929069541813575e-06 0.5335193270114367 1.929069668589196e-06 0.530759392645703 1.929069790866427e-06 0.5281021910076299 1.929069930952405e-06 0.5250685463469849 \
1.929070067969762e-06 0.5221084647952599 1.929070218271135e-06 0.5188705764247719 1.929070377166376e-06 0.5154582091324615 1.929070551500259e-06 0.5117250894133971 \
1.929070738517481e-06 0.5077378180012799 1.929070943835486e-06 0.5033745272871338 1.929071155677679e-06 0.498891131759938 1.929071408479721e-06 0.4935662239713107 \
1.92907161056737e-06 0.4893264048484654 1.929071845160675e-06 0.4844277613141263 1.929072081275272e-06 0.4795194943790256 1.929072334451769e-06 0.474283574581623 \
1.929072644981732e-06 0.4679020429045382 1.92907286303971e-06 0.4634451779596257 1.929073036485344e-06 0.4599153839204358 1.929073212977781e-06 0.4563351808422506 \
1.929073492459577e-06 0.4506930409909046 1.929073724703484e-06 0.4460279192631412 1.929074011797073e-06 0.44029020239849 1.929074229643181e-06 0.435960758243863 \
1.929074439695769e-06 0.4318042429497612 1.929074640893604e-06 0.4278406951573778 1.929074823313766e-06 0.4242617300271556 1.929074997208751e-06 0.4208637793449936 \
1.929075162072867e-06 0.4176529694331993 1.92907532082684e-06 0.4145718140694327 1.929075487073786e-06 0.4113577680628809 1.929075635718993e-06 0.4084923702366076 \
1.929075788087249e-06 0.4055658186126443 1.929075930150432e-06 0.4028468403491589 1.92907609952631e-06 0.3996150665462138 1.92907621990823e-06 0.3973276483660343 \
1.929076329881494e-06 0.3952449223617059 1.929076444806895e-06 0.3930732253581283 1.929076597048475e-06 0.3902080468194818 1.92907670926954e-06 0.3881039677199808 \
1.929076816462041e-06 0.386098874836553 1.92907696899029e-06 0.383254723448244 1.929077097137419e-06 0.380874963946598 1.929077219985412e-06 0.3786015923730871 \
1.929077399083788e-06 0.375299968600122 1.92907754816842e-06 0.3725653942578417 1.929077715875808e-06 0.3695018296724824 1.929077871273442e-06 0.3666748141177644 \
1.929077995440288e-06 0.3644243980538668 1.929078109332155e-06 0.3623666676050148 1.929078230775526e-06 0.3601804966264144 1.929078410927293e-06 0.3569532670533712 \
1.929078577415113e-06 0.3539878629329621 1.929078767834223e-06 0.3506138544217919 1.929078959590818e-06 0.3472380408565978 1.929079142640212e-06 0.344035729794033 \
1.929079291612277e-06 0.3414435189591631 1.929079411552182e-06 0.3393660536257183 1.929079534213665e-06 0.3372483242714233 1.929079657244151e-06 0.3351324902755385 \
1.929079802148562e-06 0.3326515017845288 1.929079905461337e-06 0.3308907757076019 1.929079999190847e-06 0.3292979229163631 1.929080089851148e-06 0.3277620998585528 \
1.929080200972602e-06 0.3258853746017661 1.929080308145579e-06 0.3240820510456246 1.92908040642023e-06 0.3224338250618513 1.929080518824776e-06 0.3205545940512134 \
1.929080682764676e-06 0.3178277446588927 1.929080844402555e-06 0.3151576097143818 1.929080992189301e-06 0.3127316247504084 1.929081154434516e-06 0.3100832165115083 \
1.929081314465073e-06 0.3074868334344322 1.929081466728372e-06 0.3050304870660137 1.929081620100242e-06 0.3025703731928215 1.929081778808771e-06 0.3000411640344692 \
1.9290819432579e-06 0.297437246442505 1.929082110484976e-06 0.2948063590562646 1.929082263596514e-06 0.292412731930112 1.92908244669444e-06 0.2895700146919417 \
1.929082637002178e-06 0.2866380344427262 1.929082785905236e-06 0.2843603072871506 1.929082959842542e-06 0.2817165165722222 1.92908313671993e-06 0.2790484233348025 \
1.929083284317148e-06 0.2768363681311815 1.929083473948849e-06 0.2740172295061162 1.929083623950767e-06 0.2718052906662373 1.929083761060958e-06 0.2697943906627059 \
1.929083902591401e-06 0.2677397479842996 1.92908401605027e-06 0.2661005451260196 1.929084152340597e-06 0.2641384584581135 1.929084282417217e-06 0.2622807416655737 \
1.92908440067147e-06 0.2606037730704709 1.929084518527066e-06 0.2589348966568543 1.929084649420877e-06 0.2570853888657079 1.929084789659635e-06 0.2551145527343576 \
1.929084905154221e-06 0.2534976852533538 1.929085034005598e-06 0.2516957519945816 1.92908514915158e-06 0.2500885525459272 1.929085302462547e-06 0.2479513765689386 \
1.929085440316308e-06 0.2460367343642474 1.92908557977796e-06 0.2441002375748529 1.929085735245815e-06 0.2419427021952501 1.92908586002843e-06 0.2402176526454788 \
1.929085999893338e-06 0.2382916534360561 1.929086128595515e-06 0.2365220787132559 1.929086249554366e-06 0.234860341242685 1.929086366599666e-06 0.2332541163798121 \
1.92908649260073e-06 0.2315368940272461 1.929086589320323e-06 0.2302195772445239 1.929086681409196e-06 0.2289683907689286 1.929086795826667e-06 0.2274152998827935 \
1.929086894197314e-06 0.2260807986508055 1.929087011344107e-06 0.2244933520241092 1.929087114435226e-06 0.2231010305483718 1.929087219949952e-06 0.2216798666278746 \
1.929087300868012e-06 0.2205933880575098 1.929087374539197e-06 0.2196046443759679 1.929087417268434e-06 0.2190314036349237 1.929087460398579e-06 0.2184540235451489 \
1.929087511196061e-06 0.217774515685755 1.929087548370939e-06 0.217277430841393 1.929087589041954e-06 0.2167338127731004 1.929087631833755e-06 0.2161620985357572 \
1.929087668244897e-06 0.2156758299561118 1.929087710169888e-06 0.2151161507306283 1.929087764712098e-06 0.2143884526296278 1.929087803170856e-06 0.2138756926875936 \
1.929087842797626e-06 0.2133496230586122 1.929087904630127e-06 0.212531488259555 1.929087966356578e-06 0.2117156525305126 1.929088022493854e-06 0.210974237875411 \
1.929088086149084e-06 0.210134110843225 1.929088180240117e-06 0.2088936328424611 1.929088267048376e-06 0.2077505933124353 1.92908836100502e-06 0.2065146061917991 \
1.929088459047253e-06 0.2052266823513323 1.929088560634619e-06 0.2038976009052371 1.929088661543568e-06 0.2025832113009377 1.929088758279377e-06 0.2013244528083448 \
1.929088860404348e-06 0.1999972806373927 1.929088963735905e-06 0.1986583046056677 1.929089073618507e-06 0.1972379690671278 1.929089182560764e-06 0.1958337611883887 \
1.929089302395885e-06 0.1942937175364915 1.929089412679751e-06 0.1928822800638286 1.929089520558496e-06 0.191507108810815 1.929089646621254e-06 0.1899051957406391 \
1.929089736488961e-06 0.1887671190866151 1.9290898469673e-06 0.1873723090993208 1.929089924500249e-06 0.1863971337376019 1.929090008823992e-06 0.1853400660204312 \
1.92909009641205e-06 0.1842452710069853 1.929090184204644e-06 0.18315095174413 1.929090265924515e-06 0.1821357652581398 1.929090363486193e-06 0.1809282658474054 \
1.929090470197344e-06 0.1796118512064394 1.929090570679026e-06 0.178377576484793 1.929090694850237e-06 0.1768595317522179 1.929090828741761e-06 0.1752320886156309 \
1.929090947653953e-06 0.1737937102924047 1.929091098054147e-06 0.1719851742607024 1.92909120888924e-06 0.1706594030660365 1.929091348655982e-06 0.168997130456427 \
1.92909146718129e-06 0.1675953052211382 1.929091572608521e-06 0.1663548750207849 1.92909166731838e-06 0.1652455210322802 1.929091760628154e-06 0.1641568522804657 \
1.929091861534271e-06 0.1629842804551663 1.929091956952102e-06 0.1618800504313296 1.929092054143025e-06 0.1607598891027116 1.929092135704507e-06 0.1598237474547246 \
1.929092241020952e-06 0.1586229753023833 1.929092324500659e-06 0.1576763029943549 1.92909242602995e-06 0.1565306813704828 1.929092503260486e-06 0.1556635090415242 \
1.929092594132523e-06 0.154647919213242 1.929092663483833e-06 0.1538765336840219 1.929092748067884e-06 0.1529397840535594 1.929092822461091e-06 0.1521208717489242 \
1.929092901831293e-06 0.151251902275755 1.929092976418964e-06 0.1504388356812226 1.929093045640521e-06 0.1496871728711989 1.929093140321328e-06 0.1486640077242138 \
1.929093210087093e-06 0.1479134441579097 1.929093294531656e-06 0.147008717574758 1.929093356097002e-06 0.1463518850554192 1.929093430139493e-06 0.1455673550676988 \
1.929093503525017e-06 0.1447940960774066 1.929093584960259e-06 0.1439395015691976 1.929093654409405e-06 0.1432139999234875 1.929093729511103e-06 0.1424323701137583 \
1.929093819423173e-06 0.1415006120834361 1.929093896506793e-06 0.1407052977810757 1.929093995617377e-06 0.1396885207473417 1.92909406515744e-06 0.138983077430453 \
1.929094146475916e-06 0.1381612812129989 1.929094216644324e-06 0.1374549162714094 1.929094295612438e-06 0.1366629455350578 1.92909437459072e-06 0.1358740351737466 \
1.929094446912511e-06 0.1351544405911459 1.929094516277969e-06 0.1344667589602006 1.929094564981976e-06 0.1339854049281765 1.929094655744348e-06 0.1330945614011112 \
1.929094687765876e-06 0.1327823711724506 1.929094775869844e-06 0.131925672678654 1.929094808363886e-06 0.1316105445757083 1.929094907031544e-06 0.1306564447580443 \
1.929094950687519e-06 0.130235859061297 1.929095028669336e-06 0.1294866595045693 1.929095066000293e-06 0.1291289430202982 1.929095168151694e-06 0.128153223240932 \
1.929095235595654e-06 0.1275115375392494 1.929095300748611e-06 0.1268935577290946 1.929095366654626e-06 0.1262729746041904 1.929095437806609e-06 0.1256052797936485 \
1.92909552074397e-06 0.1248293808775363 1.929095606139451e-06 0.1240331657139879 1.929095682226844e-06 0.1233259817834828 1.929095762687521e-06 0.1225806238777534 \
1.929095820771462e-06 0.1220441728027253 1.929095892104936e-06 0.1213870835332726 1.929095976893369e-06 0.1206085709991845 1.929096038048402e-06 0.1200487744399507 \
1.929096108134853e-06 0.1194096117168642 1.929096170640142e-06 0.1188419501154776 1.92909623664509e-06 0.1182453094891599 1.929096305417857e-06 0.1176255789053269 \
1.929096374874482e-06 0.1170017375875525 1.929096458038731e-06 0.1162574953874909 1.929096531156255e-06 0.1156056107435251 1.929096601870241e-06 0.1149774116339468 \
1.929096661221924e-06 0.1144518657417393 1.929096766519136e-06 0.1135239342411639 1.92909681238663e-06 0.1131212254602471 1.929096899340683e-06 0.1123603821649216 \
1.929096942354464e-06 0.1119852310621949 1.929096987221211e-06 0.1115947726395539 1.929097076954706e-06 0.1108164664143028 1.929097147839058e-06 0.110204256460374 \
1.929097226692571e-06 0.109525796983828 1.929097289470346e-06 0.1089876103666232 1.929097349464702e-06 0.1084750215669379 1.929097460462474e-06 0.1075310013968523 \
1.92909754121676e-06 0.1068475792877216 1.929097653680086e-06 0.1059005796323111 1.929097704824629e-06 0.1054717782906781 1.929097787809798e-06 0.1047785948356612 \
1.929097845974503e-06 0.1042945647727652 1.929097960212503e-06 0.1033482075721767 1.92909801011597e-06 0.1029366076865433 1.929098095857569e-06 0.1022320954501846 \
1.929098144889019e-06 0.1018307629303728 1.929098227455441e-06 0.101157455862875 1.929098298387777e-06 0.1005815064560546 1.929098366538127e-06 0.1000302812267231 \
1.929098444148443e-06 0.0994053199805509 1.929098516491814e-06 0.09882546240595018 1.929098594067778e-06 0.09820656846618626 1.929098682738439e-06 0.09750287271560702 \
1.929098756553227e-06 0.09692010793638871 1.929098838144235e-06 0.09627924899616347 1.929098916282703e-06 0.09566870926115327 1.929099002032493e-06 0.09500229249765579 \
1.929099089729402e-06 0.09432453920671229 1.929099183638967e-06 0.09360304191323381 1.929099280098285e-06 0.09286661217778783 1.929099358728946e-06 0.09226977907248698 \
1.929099461452545e-06 0.09149473120661993 1.929099545280196e-06 0.09086620530027881 1.929099666032378e-06 0.08996702094116031 1.929099795302029e-06 0.08901247130467421 \
1.929099951190493e-06 0.08787237469953549 1.929100106290076e-06 0.08675000010972149 1.929100263305882e-06 0.08562614142917294 1.929100443326735e-06 0.08435280068725284 \
1.929100593847602e-06 0.08330035525696428 1.929100742221624e-06 0.08227363395463329 1.929100879838855e-06 0.08133079092382095 1.929101019758505e-06 0.08038162993974078 \
1.929101156365493e-06 0.07946425488810546 1.929101295092791e-06 0.07854214404995859 1.929101440403653e-06 0.07758663187171365 1.929101588151466e-06 0.07662571164688473 \
1.929101746748333e-06 0.07560598447141591 1.929101911000851e-06 0.07456266320243836 1.929102080017927e-06 0.07350246718885647 1.929102261906921e-06 0.07237646636762114 \
1.929102462529019e-06 0.07115268999588262 1.929102676406562e-06 0.0698691158856425 1.929102904040694e-06 0.0685263410462881 1.929103145626235e-06 0.06712722147996912 \
1.929103427215414e-06 0.06552977831071743 1.929103724369534e-06 0.06388229915275011 1.929104047802611e-06 0.06213267023812474 1.929104438962031e-06 0.0600758559534558 \
1.929104840456333e-06 0.05803293250078725 1.929105217397059e-06 0.05617754872181892 1.929105584510791e-06 0.05442503025024555 1.929105934627471e-06 0.05280240270907886 \
1.929106253933125e-06 0.05136309724710254 1.929106558257407e-06 0.05002640192327024 1.929106855163312e-06 0.04875503464657577 1.929107137163639e-06 0.04757867888787161 \
1.929107417596943e-06 0.04643900623749339 1.929107682320567e-06 0.04538777697325767 1.929107958218279e-06 0.04431704973151576 1.929108232683143e-06 0.04327654260273706 \
1.929108531102423e-06 0.04217254828989973 1.92910875761848e-06 0.04135316230013186 1.929109069531318e-06 0.04025053053625379 1.929109289786109e-06 0.03948972371590862 \
1.929109507050863e-06 0.03875470657060948 1.929109716773513e-06 0.03806113111453101 1.9291100269559e-06 0.03705828856757609 1.929110249553778e-06 0.03635538859683734 \
1.929110496919279e-06 0.03559019656168042 1.929110769325656e-06 0.03476651972027592 1.929110989958209e-06 0.03411384091885184 1.92911127423846e-06 0.03329124852897781 \
1.929111512151752e-06 0.0326183788879464 1.929111750241164e-06 0.03195887699386461 1.929111985496492e-06 0.03132132139405813 1.929112214275199e-06 0.03071728735992773 \
1.929112447005948e-06 0.03011490821398154 1.929112666308989e-06 0.02955843195412813 1.929112870252059e-06 0.02905055018162466 1.929113269161796e-06 0.02808303002558106 \
1.929113456316051e-06 0.02764052191221165 1.929113828521772e-06 0.0267814187683372 1.929114015473295e-06 0.02635997027055515 1.929114384827242e-06 0.02554620807076183 \
1.92911453848041e-06 0.02521471147941385 1.929114954694564e-06 0.02434161493068329 1.92911516018238e-06 0.02392065165079968 1.929115499190341e-06 0.02323955384462723 \
1.929115681885069e-06 0.02287916718068597 1.929116138978978e-06 0.02199597290476789 1.929116268719714e-06 0.02174967209293581 1.929116722140138e-06 0.02089828923199067 \
1.92911686451243e-06 0.0206336680476187 1.92911739407919e-06 0.01967289368906444 1.929117520286198e-06 0.01945139161001456 1.929118082520635e-06 0.01850749734048266 \
1.929118245259022e-06 0.01824627541187189 1.929118809439087e-06 0.01738327200207762 1.929118961183154e-06 0.01716165742474803 1.929119662862638e-06 0.01618760396393164 \
1.929119832951728e-06 0.01596324388168 1.929120488009604e-06 0.01513221026437959 1.929120654523916e-06 0.01492874613340729 1.929121387637676e-06 0.01406966818047924 \
1.929121520900854e-06 0.01391906482409888 1.929122372558029e-06 0.01299647369571925 1.929122510500477e-06 0.01285324185793544 1.929123450559967e-06 0.0119198170026788 \
1.929123614321604e-06 0.01176347583728811 1.929124601555038e-06 0.01085909507266535 1.929124736144114e-06 0.0107410715025141 1.929125877583545e-06 0.009819907073012045 \
1.929125985822443e-06 0.009738548299709823 1.929127309069827e-06 0.00880579379490502 1.929127441815525e-06 0.008718202093769473 1.92912896431665e-06 0.007760835273143199 \
1.929129076858719e-06 0.007690148685505111 1.929130769150306e-06 0.00669558715138598 1.929130909416891e-06 0.00662113250846694 1.929132982426193e-06 0.005629132576249021 \
1.92913317498771e-06 0.005545002188831318 1.929135385197559e-06 0.004656096148610405 1.929135791984232e-06 0.004507219767123045 1.929138613724209e-06 0.003590578528330178 \
1.929139135019959e-06 0.00344214578404881 1.929143347121009e-06 0.002447529662748036 1.929143899683877e-06 0.002340875287107731 1.929149782973417e-06 0.001359168649576994 \
1.929150032246415e-06 0.001311490127959886 1.929163182367465e-06 0.0003136950974005476 1.929163299150435e-06 0.0003112730584132499 1.958990000000011e-06 3.042397160644726e-06 \
2.002746667027013e-06 -0.0009024818035526668 2.002746739442629e-06 -0.001022682652537627 2.002747175467347e-06 -0.001858525046639076 2.00274726236173e-06 -0.002046124893065343 \
2.002747617065043e-06 -0.00288168582347465 2.002747716611644e-06 -0.003135075204051477 2.002747976881349e-06 -0.003828199033013717 2.00274811720375e-06 -0.004216406518003108 \
2.002748344689832e-06 -0.004856871791621592 2.002748481897271e-06 -0.005239031028659006 2.00274886679612e-06 -0.006187559915121 2.002748998893307e-06 -0.006423332025500122 \
2.002749687336335e-06 -0.005917035979538006 2.002749844265069e-06 -0.005202654566481615 2.002749971914231e-06 -0.004414133290428114 2.002750099456021e-06 -0.003433350487145549 \
2.002750217130234e-06 -0.002355902309038119 2.00275031626992e-06 -0.001320627313728655 2.00275042165263e-06 -9.507383675133965e-05 2.002750535559933e-06 0.001369964538583592 \
2.002750666615328e-06 0.003229572948258866 2.002750791978548e-06 0.005172303930030842 2.002750983820411e-06 0.008432154569684791 2.002751127490205e-06 0.01107975669588844 \
2.002751285472017e-06 0.01417105828876112 2.002751434071664e-06 0.01723098336859398 2.002751587122593e-06 0.02051714008521248 2.002751746187569e-06 0.02405720796424875 \
2.002751899257778e-06 0.02756764950178633 2.002752047604842e-06 0.03105219347129199 2.002752196711284e-06 0.03462388853332505 2.002752351275713e-06 0.03838854885099419 \
2.002752511961677e-06 0.04235886888523473 2.002752676640863e-06 0.04647718198980624 2.002752853163807e-06 0.05093664320808645 2.002753032175606e-06 0.05549818742091989 \
2.002753222948448e-06 0.0603932190016783 2.0027534277958e-06 0.06567927942044927 2.002753648293053e-06 0.07139554989571946 2.002753881211021e-06 0.07745499876455469 \
2.002754130458799e-06 0.08395499695136356 2.002754403380327e-06 0.09108394918256098 2.002754700173384e-06 0.09884095133633181 2.002755027609896e-06 0.1073964775374675 \
2.002755397423695e-06 0.1170487607486894 2.002755792369975e-06 0.1273407304921971 2.002756250458529e-06 0.1392499850125259 2.002756782558388e-06 0.1530377249371455 \
2.002757408110397e-06 0.169180864038255 2.002758094102463e-06 0.1867931863309214 2.002758896945878e-06 0.2072766958045763 2.002759796258209e-06 0.2300508264895909 \
2.002760696698323e-06 0.2526618731709107 2.002761498589855e-06 0.2726215666318766 2.002762194096996e-06 0.2897857674353052 2.002762826931282e-06 0.3052728323588638 \
2.002763422339773e-06 0.3197161646377594 2.002763969382815e-06 0.3328722959176427 2.002764503143162e-06 0.3455929446372428 2.002765022382586e-06 0.3578476146335662 \
2.002765529774049e-06 0.3697097539883151 2.002766033395218e-06 0.3813674725871593 2.002766545138114e-06 0.3930934709428262 2.002767052299123e-06 0.404595334768291 \
2.002767582595137e-06 0.4164962117964878 2.002768068708626e-06 0.4272847049163567 2.002768546816947e-06 0.437781779057129 2.002768986249071e-06 0.4473362978389137 \
2.002769109408535e-06 0.4500002106608159 2.002769355727463e-06 0.4553046876287923 2.002769698999458e-06 0.4626558934952216 2.002770010436459e-06 0.4692815017887791 \
2.002770261147724e-06 0.4745855323881177 2.002770531976868e-06 0.480281321066213 2.002770868458777e-06 0.4873122872019196 2.002771224467388e-06 0.4946959640027882 \
2.002771541737556e-06 0.5012322602315481 2.002771780618105e-06 0.506122906570856 2.002772021646287e-06 0.5110269393752048 2.002772273577991e-06 0.5161276795544476 \
2.002772513731835e-06 0.5209621749612534 2.002772736483297e-06 0.5254248476203834 2.002772925040944e-06 0.5291850880529715 2.002773139790987e-06 0.5334523706207774 \
2.002773354339378e-06 0.5376948565446859 2.00277361310367e-06 0.5427871977552768 2.002773863931242e-06 0.5477009885064807 2.002774119350104e-06 0.5526782776843104 \
2.002774470392629e-06 0.5594898819265107 2.002774735000954e-06 0.5645984056527484 2.00277500141751e-06 0.569709962982798 2.00277526193182e-06 0.5746801970751495 \
2.002775529021882e-06 0.5797469183389945 2.002775772159962e-06 0.5843213438768613 2.002776027852189e-06 0.5890994944692448 2.002776255671159e-06 0.5933243819692556 \
2.002776493215979e-06 0.5976999800355528 2.002776704606465e-06 0.6015679915939678 2.002776916747225e-06 0.6054277082074113 2.002777105936602e-06 0.6088479815213901 \
2.00277723709492e-06 0.6112112531841202 2.002777369391478e-06 0.6135871094428261 2.002777554614204e-06 0.6169015645304802 2.002777716636591e-06 0.6197943209800671 \
2.002777875055755e-06 0.6226100751126036 2.002778009167621e-06 0.6249846001944386 2.002778181488729e-06 0.6280247049765127 2.002778310427531e-06 0.6302937061188456 \
2.002778430805044e-06 0.6324061607157294 2.002778571333915e-06 0.634864734791624 2.002778764419407e-06 0.6382321981637986 2.002778914230186e-06 0.6408363654380513 \
2.002779081537779e-06 0.6437327988167145 2.002779262592003e-06 0.6468572757970242 2.002779465918433e-06 0.6503523798695617 2.002779648771588e-06 0.6534819287355287 \
2.002779819395834e-06 0.6563879501053153 2.002779996860074e-06 0.6594029650344411 2.002780162839025e-06 0.6622113135173925 2.002780320075814e-06 0.6648594636266301 \
2.002780460561866e-06 0.6672075432495704 2.002780604291994e-06 0.6695987751186935 2.002780737338986e-06 0.6718055529208897 2.002780879311128e-06 0.6741523780906628 \
2.002780999371661e-06 0.6761293215200647 2.002781144309748e-06 0.6785098354674278 2.002781260306798e-06 0.6804095298668216 2.002781379886686e-06 0.6823647593763783 \
2.00278147884666e-06 0.68397755359623 2.002781597355079e-06 0.6859039329668146 2.00278168439936e-06 0.6873150904607619 2.002781806410179e-06 0.6892866586554622 \
2.002781905332791e-06 0.6908817703737582 2.002781997228166e-06 0.6923536807698466 2.002782097196705e-06 0.6939486118486815 2.002782195442366e-06 0.6955126686751646 \
2.002782287156128e-06 0.6969676095571918 2.00278239128907e-06 0.698613189139943 2.002782527015812e-06 0.7007470979739818 2.002782681624274e-06 0.7031613517373301 \
2.002782816731986e-06 0.7052558942641604 2.002782963068532e-06 0.7075085519458914 2.002783091536073e-06 0.7094732734147607 2.002783215720207e-06 0.7113609898537658 \
2.002783325624507e-06 0.7130225953369277 2.002783442207576e-06 0.7147759898693785 2.002783542385407e-06 0.7162749667021007 2.002783679474216e-06 0.7183149847558421 \
2.002783799463242e-06 0.7200901405411056 2.00278391857669e-06 0.7218426783097279 2.002784045072077e-06 0.723693513465353 2.002784170939449e-06 0.7255245570057045 \
2.002784293560468e-06 0.7272980597885179 2.002784421177992e-06 0.7291334326655684 2.002784551426783e-06 0.7309957624152177 2.002784673019733e-06 0.73272442801297 \
2.002784811788425e-06 0.7346853525547948 2.002784912196869e-06 0.7360963845229137 2.002785015584257e-06 0.7375412410987998 2.0027851092447e-06 0.7388443755773992 \
2.002785220866297e-06 0.7403895158541485 2.0027853073349e-06 0.7415798421827293 2.002785408198011e-06 0.7429609798983192 2.002785540294732e-06 0.7447573558536402 \
2.002785649496034e-06 0.7462323422761349 2.002785754027664e-06 0.747635567415085 2.002785877674145e-06 0.7492836897664436 2.00278602637058e-06 0.7512497161812216 \
2.002786148251239e-06 0.7528480713857697 2.002786261855803e-06 0.7543274008692354 2.002786402375488e-06 0.7561429069656862 2.00278654356493e-06 0.7579511824827749 \
2.002786661311106e-06 0.7594470562859095 2.002786790000766e-06 0.7610693809796742 2.002786932555413e-06 0.7628512182523866 2.002787048411964e-06 0.7642872416835913 \
2.00278719417523e-06 0.7660789429779771 2.002787316007677e-06 0.7675637574673733 2.002787434476374e-06 0.7689965471136999 2.002787557264006e-06 0.7704700089613156 \
2.002787683416888e-06 0.7719718272910862 2.002787793785939e-06 0.7732757954107932 2.002787919217035e-06 0.7747465774777432 2.002788024698747e-06 0.775974259539018 \
2.002788157865176e-06 0.7775122819577122 2.002788280546631e-06 0.7789173428708996 2.002788415309674e-06 0.7804473432620218 2.002788525980963e-06 0.7816923373676121 \
2.002788635302591e-06 0.7829118427552927 2.002788770435026e-06 0.7844048889494442 2.00278892121405e-06 0.7860523747618094 2.002789061582958e-06 0.7875692293014268 \
2.002789181294483e-06 0.7888502570533434 2.002789319548824e-06 0.7903153082715967 2.002789442919159e-06 0.7916096503654788 2.002789588017784e-06 0.7931164937536124 \
2.002789727758043e-06 0.7945521172774316 2.002789854939467e-06 0.7958455533278409 2.00278997397922e-06 0.7970449251022731 2.002790086337411e-06 0.7981670522831598 \
2.002790190566191e-06 0.79919939674296 2.002790285905002e-06 0.8001364844871954 2.002790422193112e-06 0.8014634245741865 2.002790539085656e-06 0.8025894467082511 \
2.002790658725145e-06 0.8037305025474466 2.002790780606717e-06 0.8048811831579785 2.002790902985054e-06 0.8060245537852575 2.002791031013733e-06 0.8072081965553952 \
2.002791155658532e-06 0.8083483262222385 2.00279128615728e-06 0.8095291977395493 2.002791412617707e-06 0.8106611567088965 2.002791539743675e-06 0.8117869190804841 \
2.002791644861151e-06 0.8127087429624065 2.00279175011134e-06 0.8136235164943317 2.00279184125159e-06 0.8144090748259969 2.002791964669625e-06 0.8154632009865571 \
2.002792051748274e-06 0.8162003374872545 2.002792151070959e-06 0.8170344894488412 2.002792295992703e-06 0.8182390501293432 2.002792432261207e-06 0.8193582434421302 \
2.002792541723485e-06 0.8202477434185359 2.002792687843586e-06 0.8214214001843773 2.002792839202198e-06 0.8226208465286928 2.00279296500612e-06 0.8236052915965452 \
2.00279310941678e-06 0.824721541823094 2.00279323401773e-06 0.8256729463037898 2.002793384729791e-06 0.8268094083523665 2.00279352010105e-06 0.8278169867326588 \
2.002793645303979e-06 0.8287379047458127 2.002793762973362e-06 0.829593908450195 2.002793908801339e-06 0.8306418458276996 2.00279407529732e-06 0.8318207857986918 \
2.002794206154408e-06 0.8327345044534114 2.002794379603849e-06 0.833928356718921 2.002794547722323e-06 0.8350667646575466 2.002794717596125e-06 0.8361988603660855 \
2.002794898450754e-06 0.8373843006762304 2.002795041633135e-06 0.8383085120571983 2.002795155746479e-06 0.8390361588138326 2.00279528581247e-06 0.8398559950134801 \
2.002795387687706e-06 0.8404909448220066 2.002795504566998e-06 0.8412116130393378 2.002795641678929e-06 0.8420465258793415 2.002795839559572e-06 0.843231707656198 \
2.002796031345765e-06 0.8443585547012582 2.002796240708829e-06 0.8455646258450146 2.002796422822406e-06 0.846593677725298 2.002796619917178e-06 0.8476867969181797 \
2.002796793185875e-06 0.8486305714188691 2.002796976264561e-06 0.8496104335327738 2.002797147401587e-06 0.8505103231661706 2.002797322080438e-06 0.8514128411730317 \
2.002797497318728e-06 0.8523022053693007 2.002797673458368e-06 0.8531802340241421 2.002797863809624e-06 0.8541115036082744 2.002798054386771e-06 0.855025905954957 \
2.002798254818193e-06 0.8559685891497206 2.002798447410669e-06 0.8568563992305701 2.002798658273806e-06 0.8578086227668252 2.002798886187182e-06 0.8588150784816577 \
2.002799152217719e-06 0.8599606428795262 2.002799450738801e-06 0.8612090806949765 2.002799726692482e-06 0.8623286542354505 2.002800010954596e-06 0.8634483918036945 \
2.002800285103046e-06 0.8644969441068078 2.002800557392313e-06 0.8655088801415273 2.002800827558089e-06 0.8664846790737442 2.002801084736186e-06 0.8673881555543895 \
2.002801357299353e-06 0.868319368003445 2.002801633304697e-06 0.8692355072818493 2.002801903418629e-06 0.870106770567397 2.002802203245002e-06 0.8710447971670072 \
2.002802574222291e-06 0.8721640818024149 2.002802869154012e-06 0.8730224021943973 2.002803123432376e-06 0.873740732376842 2.002803421677207e-06 0.8745584461000401 \
2.002803695285219e-06 0.8752856917963749 2.002803931415444e-06 0.8758961959341748 2.002804171760979e-06 0.8765017794770257 2.002804394097168e-06 0.8770481951318053 \
2.002804588102451e-06 0.8775144010549708 2.002804917823794e-06 0.8782846129827527 2.00280507299682e-06 0.8786376896881318 2.002805390752407e-06 0.8793424631377607 \
2.002805569616983e-06 0.8797286397841958 2.002805912078462e-06 0.8804474051285093 2.002806096217817e-06 0.880822800830328 2.002806571118475e-06 0.881756283451624 \
2.002806738513154e-06 0.8820737784441692 2.0028072043462e-06 0.8829272622221894 2.002807385170493e-06 0.8832470363605239 2.002807879204793e-06 0.8840891816604841 \
2.002808020548669e-06 0.8843218944112644 2.002808626940586e-06 0.8852805359894154 2.002808779011766e-06 0.8855111592597558 2.002809425691436e-06 0.8864506941541785 \
2.002809553987642e-06 0.8866295550025313 2.002810202164815e-06 0.8874976172723908 2.002810331923675e-06 0.8876644392549727 2.002811100144498e-06 0.8886037370453904 \
2.002811229881009e-06 0.8887539063021698 2.002812083306654e-06 0.8896836309705964 2.002812226565088e-06 0.8898301468060963 2.002813212785821e-06 0.890764641901611 \
2.002813434267227e-06 0.8909571971396437 2.002814577308628e-06 0.8918770673440963 2.002814707298117e-06 0.8919774876506176 2.002816058923388e-06 0.8929731820841386 \
2.00281620928357e-06 0.89307657739048 2.002817689916169e-06 0.8939986636922405 2.002817928817934e-06 0.8941315911431026 2.002819693311633e-06 0.894999985510941 \
2.002820000994978e-06 0.8951330875684044 2.002822522266181e-06 0.8960612226716312 2.002822959317422e-06 0.8961978289811912 2.002826862729643e-06 0.8971619289239613 \
2.00282710951145e-06 0.8972094058147089 2.002834686001284e-06 0.8981998139535015 2.002834801913031e-06 0.8982099955090975 2.002853900445735e-06 0.8992062631372056 \
2.002854297888509e-06 0.8992194728667773 2.00300471332359e-06 0.9002121614362558 2.003004979381947e-06 0.9002436812458944 2.003010247532015e-06 0.8993470931706574 \
2.003010453902932e-06 0.899191170936528 2.003011932015742e-06 0.8982046351054961 2.003012112466398e-06 0.8981003355419954 2.003014334948061e-06 0.8971299612768925 \
2.003014541040576e-06 0.897079983173831 2.003024949306681e-06 0.8980580240048047 2.003025087164257e-06 0.8980839755683444 2.003031884513298e-06 0.8990685088718567 \
2.003032070084766e-06 0.8990874390200084 2.003528299258968e-06 0.9000706848616691 2.003528359054814e-06 0.9000975977971888 2.003529612605432e-06 0.9010828413531861 \
2.003529718298035e-06 0.9012097231395001 2.003530376428752e-06 0.9021613947651476 2.003530513611021e-06 0.9023918767045529 2.003531036637641e-06 0.9033649777562528 \
2.003531099501233e-06 0.9034908765919824 2.003531572096783e-06 0.904476514442582 2.003531623410595e-06 0.9045863669199017 2.003532089373931e-06 0.9055619780118375 \
2.003532121578392e-06 0.9056252631670594 2.003532838677129e-06 0.9066212416280413 2.003532923113402e-06 0.9066528951765993 2.003533523179782e-06 0.9059679814895146 \
2.003533643037393e-06 0.9055903401525059 2.003533774200172e-06 0.9050640446667092 2.003533909019925e-06 0.9043926011431642 2.003534057154984e-06 0.9034897747335404 \
2.003534194714336e-06 0.902493211317788 2.003534334926096e-06 0.9013135799985507 2.003534433588205e-06 0.9003872218501816 2.003534519272014e-06 0.8995148096066522 \
2.003534601836213e-06 0.8986166894493001 2.003534716618842e-06 0.8972773101170661 2.003534797717086e-06 0.8962642459447687 2.003534877134364e-06 0.8952218112132616 \
2.003534982588892e-06 0.8937633947192651 2.003535105230195e-06 0.8919606744930825 2.003535204954274e-06 0.890414036797163 2.003535375148685e-06 0.8876203405523397 \
2.003535521333777e-06 0.8850727273800474 2.003535689551925e-06 0.8819879035815887 2.003535861713021e-06 0.8786780617039783 2.003536046099114e-06 0.8749807502679057 \
2.003536230665458e-06 0.8711418063496947 2.003536414912944e-06 0.8671917613865908 2.003536600248607e-06 0.8631174608718694 2.003536774636335e-06 0.8592060069639053 \
2.003536957340272e-06 0.8550405244181323 2.003537132687366e-06 0.8509893565349284 2.003537315016877e-06 0.8467313026054767 2.003537505330306e-06 0.8422468264612591 \
2.003537675660435e-06 0.838204894125699 2.003537842184074e-06 0.8342320488410089 2.003538004754937e-06 0.830337741667393 2.00353815461616e-06 0.8267359097041467 \
2.003538305792179e-06 0.8230937075736249 2.003538494937653e-06 0.8185270080344306 2.003538640655708e-06 0.8150026134285653 2.003538815646674e-06 0.8107652770601156 \
2.003538964118218e-06 0.807166938184282 2.003539136005683e-06 0.8029987283123258 2.003539305073922e-06 0.7988973224349885 2.003539469252632e-06 0.7949140139776875 \
2.003539628580169e-06 0.7910485911592836 2.003539789029776e-06 0.7871568543472617 2.003539990849157e-06 0.7822630953020117 2.003540139296892e-06 0.7786646206504594 \
2.003540293464276e-06 0.77492821376164 2.003540430547636e-06 0.7716074476660475 2.003540539933082e-06 0.7689587163513494 2.003540645866538e-06 0.7663946531324515 \
2.003540772880886e-06 0.7633217481666642 2.003540887243854e-06 0.7605561828888391 2.003540990091676e-06 0.7580702160470256 2.003541111681993e-06 0.7551325442760125 \
2.003541222459267e-06 0.7524575925939972 2.003541339308092e-06 0.7496376180588871 2.003541450092818e-06 0.7469652567786068 2.003541568458919e-06 0.7441116745915923 \
2.003541693286015e-06 0.7411038668912771 2.00354184584781e-06 0.7374292753756717 2.003541979744798e-06 0.7342062928952946 2.003542100776237e-06 0.7312947572377408 \
2.003542264973752e-06 0.7273475399259534 2.003542442334699e-06 0.7230877912371642 2.003542624545108e-06 0.7187161681757385 2.003542805542373e-06 0.7143786395952922 \
2.003542986206316e-06 0.7100537072471783 2.003543176357883e-06 0.7055071781827296 2.003543364117777e-06 0.7010230964996226 2.003543564650882e-06 0.696237807975249 \
2.003543773336343e-06 0.6912646166759551 2.003543980979908e-06 0.6863227581165517 2.003544208547776e-06 0.6809140411171237 2.00354440082261e-06 0.6763521085712711 \
2.003544638087858e-06 0.6707310800019505 2.003544831366122e-06 0.6661595641347996 2.003545064098869e-06 0.6606646229758047 2.003545269656336e-06 0.6558174602470968 \
2.003545502009757e-06 0.6503484594495911 2.003545697011728e-06 0.6457674053103037 2.003545900240336e-06 0.6410004262200759 2.003546080092881e-06 0.6367906205544323 \
2.003546259199312e-06 0.6326052789263827 2.003546422576526e-06 0.628795088826817 2.00354659462593e-06 0.6247880828503264 2.003546758118769e-06 0.6209892715878097 \
2.003546933908588e-06 0.6169100951581823 2.003547115847573e-06 0.6126978430086294 2.003547304331306e-06 0.6083422542008314 2.003547510763727e-06 0.6035858951323969 \
2.00354769007839e-06 0.5994633272559844 2.003547887257257e-06 0.5949432360761027 2.003548096345398e-06 0.5901646611556908 2.00354830209466e-06 0.5854760387944159 \
2.003548542605348e-06 0.5800160304866983 2.00354871573345e-06 0.5760958285528379 2.003548880627452e-06 0.5723746772837877 2.003549061488027e-06 0.5683014035092815 \
2.003549218774123e-06 0.5647722902613652 2.003549387756918e-06 0.5609879409349005 2.003549567863379e-06 0.5569709657351898 2.003549720846506e-06 0.5535669615732179 \
2.003549852560951e-06 0.5506462283231492 2.003549999948651e-06 0.5473865746199473 2.003550087374242e-06 0.5454560063082221 2.003550172245481e-06 0.5435860258811447 \
2.003550270874694e-06 0.5414171943998213 2.003550342966855e-06 0.5398340751058975 2.003550440057874e-06 0.5377039800781129 2.003550525648258e-06 0.5358302678688993 \
2.003550590729134e-06 0.5344081412607664 2.003550714329502e-06 0.5317121235594142 2.003550808753773e-06 0.52965475734789 2.003550906276994e-06 0.5275349985745696 \
2.003551079137645e-06 0.5237893654184622 2.003551214133166e-06 0.5208709659121862 2.003551368316628e-06 0.5175498113398643 2.003551542781984e-06 0.5138002600288881 \
2.003551694587971e-06 0.510550000123414 2.003551840818953e-06 0.5074290310664136 2.003551984717826e-06 0.5043644611166801 2.00355212773967e-06 0.5013276181140283 \
2.003552223349517e-06 0.499301733014788 2.003552317793473e-06 0.4973032961550828 2.003552438849414e-06 0.4947494705229025 2.00355253372771e-06 0.4927525559781179 \
2.003552649558553e-06 0.4903172469328811 2.003552736822402e-06 0.4884854516151125 2.003552819252848e-06 0.4867593351188191 2.003552914660802e-06 0.484765406725184 \
2.003553015371081e-06 0.4826639978995959 2.003553112231473e-06 0.4806459052877932 2.003553250961225e-06 0.4777646955734051 2.003553386666086e-06 0.4749532752442271 \
2.00355358715081e-06 0.4708139964547478 2.003553802464962e-06 0.4663911383470885 2.003553984040267e-06 0.462674698484628 2.003554183012236e-06 0.4586189944293299 \
2.003554353577757e-06 0.455154096457448 2.003554527931445e-06 0.4516251957269069 2.003554696864699e-06 0.4482170126441485 2.00355486946186e-06 0.4447467276163349 \
2.00355505206819e-06 0.4410867902598327 2.003555240617055e-06 0.4373240875354826 2.003555434084593e-06 0.4334777823509549 2.003555642405232e-06 0.4293535036700135 \
2.003555856750462e-06 0.4251286740881063 2.003556082455792e-06 0.4207018662297695 2.003556308999161e-06 0.4162771402745992 2.003556571175911e-06 0.4111844468197049 \
2.003556820209735e-06 0.4063709766754009 2.003557121308433e-06 0.4005865607947761 2.00355741072925e-06 0.3950673729298416 2.003557718243529e-06 0.3892455819062323 \
2.003558040439924e-06 0.3831936848847286 2.003558368170407e-06 0.3770882112794804 2.003558700600163e-06 0.3709500980558715 2.003559030329171e-06 0.3649083177186754 \
2.003559351558758e-06 0.3590729273462687 2.003559682375082e-06 0.3531219177045733 2.003560024730645e-06 0.3470224718704957 2.003560324371677e-06 0.3417374346434491 \
2.003560654159242e-06 0.3359723367088904 2.003560981053185e-06 0.3303128110141857 2.003561319032532e-06 0.3245206193888226 2.003561628003696e-06 0.3192755432624759 \
2.003561952801669e-06 0.31382336954194 2.003562268431866e-06 0.3085864885517507 2.003562573419032e-06 0.3035810258414895 2.003562828757678e-06 0.2994330834535801 \
2.003563093620834e-06 0.295170851203172 2.003563380703519e-06 0.2905978071194348 2.003563603673298e-06 0.2870801635277143 2.003563803212567e-06 0.2839591363066187 \
2.00356401286858e-06 0.2807045410859125 2.003564193125121e-06 0.2779290029372279 2.003564355469842e-06 0.2754463208250681 2.003564505904815e-06 0.2731629026725527 \
2.003564656910124e-06 0.2708866524077067 2.003564853800715e-06 0.2679392949564011 2.003564984945479e-06 0.2659970646012914 2.003565109682018e-06 0.2641561221543183 \
2.00356526127406e-06 0.2619266655689588 2.003565357242231e-06 0.2605306204207966 2.0035654537936e-06 0.2591282589302421 2.003565578413389e-06 0.2573209601776467 \
2.003565720989924e-06 0.255257422470362 2.003565879923458e-06 0.25296979123958 2.003566012589525e-06 0.251062957019046 2.003566196158294e-06 0.2484301322588876 \
2.00356637739346e-06 0.2458327969660818 2.003566588907565e-06 0.2428051031600066 2.003566791497399e-06 0.2399069804317323 2.003566958053847e-06 0.2375282895552967 \
2.003567168273059e-06 0.2345337828133105 2.003567341690945e-06 0.2320692345528927 2.003567570533673e-06 0.2288260787734411 2.003567791168424e-06 0.2257162440502939 \
2.003567966830138e-06 0.2232503232699662 2.003568147290643e-06 0.2207258962977968 2.003568318047021e-06 0.2183528725291195 2.003568498243287e-06 0.2158619697278009 \
2.003568664973905e-06 0.2135675266585953 2.003568814095326e-06 0.2115251542210239 2.003568969905344e-06 0.2094125291275523 2.00356910508577e-06 0.2075875692769576 \
2.003569255167197e-06 0.2055694209972212 2.003569387612823e-06 0.2037957203154137 2.003569528157359e-06 0.2019220745191926 2.003569645226124e-06 0.2003748851744883 \
2.00356977493373e-06 0.1986681706274326 2.003569896991199e-06 0.1970700654731777 2.003570019534635e-06 0.1954731161836187 2.003570137553958e-06 0.1939418157697267 \
2.003570272576732e-06 0.1921981789937757 2.003570417201182e-06 0.1903420634523806 2.003570545551681e-06 0.1887049708672087 2.003570669186156e-06 0.1871351133418249 \
2.003570766736279e-06 0.1859021016257166 2.003570881809208e-06 0.1844539912642748 2.003570975507888e-06 0.1832809848801438 2.003571074292012e-06 0.1820493959460708 \
2.003571197226553e-06 0.1805230483556907 2.003571292980556e-06 0.1793400249325384 2.003571422068107e-06 0.177753298391591 2.003571524533477e-06 0.1764993061988986 \
2.003571622786974e-06 0.1753029542432101 2.003571742874187e-06 0.1738483570896001 2.003571845423405e-06 0.1726127298531683 2.003571955881064e-06 0.1712877101305652 \
2.003572084370928e-06 0.1697552709290656 2.003572175855769e-06 0.1686698090598139 2.003572280340358e-06 0.1674358120019214 2.003572355277094e-06 0.1665544493622226 \
2.003572444845591e-06 0.1655049734124585 2.0035724954106e-06 0.164914347906921 2.003572545388977e-06 0.1643318187475747 2.003572610358061e-06 0.163576534137217 \
2.003572645872029e-06 0.1631646263336159 2.003572718071202e-06 0.162329174921529 2.003572785200297e-06 0.1615546732967998 2.003572844430032e-06 0.160873195114598 \
2.003572888175631e-06 0.1603710314414745 2.003572935822459e-06 0.1598254649913795 2.003573006202993e-06 0.1590230739426561 2.003573088541159e-06 0.1580883269013631 \
2.00357316671276e-06 0.1572048664554128 2.003573248765709e-06 0.1562816770844126 2.003573341469331e-06 0.1552436243401225 2.003573464249494e-06 0.153877370231325 \
2.003573563395588e-06 0.1527810927807017 2.003573664895935e-06 0.1516651170047695 2.003573766171127e-06 0.1505582666538253 2.003573862662911e-06 0.1495093242781697 \
2.003573962080945e-06 0.1484346886615803 2.003574046381569e-06 0.1475281828465028 2.003574139320259e-06 0.1465342051547719 2.0035742219212e-06 0.1456551508734999 \
2.003574330687285e-06 0.1445034822456445 2.003574436330265e-06 0.1433917535370727 2.003574517989855e-06 0.1425365900703354 2.003574611735024e-06 0.1415598856352903 \
2.003574705302971e-06 0.1405903867550886 2.003574788187462e-06 0.139735765814107 2.003574876346636e-06 0.1388313836440244 2.003574956132722e-06 0.1380170907865772 \
2.003575049728122e-06 0.1370669869522621 2.003575139660646e-06 0.1361590166429519 2.003575210211042e-06 0.1354501541392388 2.003575279971219e-06 0.1347521119166949 \
2.003575394120126e-06 0.1336164586193709 2.00357547609874e-06 0.1328058651355588 2.003575563704043e-06 0.1319440719770354 2.003575663205239e-06 0.1309710196939938 \
2.003575772385241e-06 0.1299110174488692 2.003575874550573e-06 0.1289256009328031 2.003575982010779e-06 0.1278959836800649 2.003576102045057e-06 0.1267549558890445 \
2.003576196253092e-06 0.1258657925752028 2.003576327232195e-06 0.1246390638240933 2.003576426659897e-06 0.1237164070883829 2.003576535781582e-06 0.1227104370444639 \
2.00357664463475e-06 0.1217138859540913 2.003576736944154e-06 0.120874257454373 2.003576849784485e-06 0.1198547128626846 2.003576946796524e-06 0.118986084968971 \
2.003577051062872e-06 0.1180628196869088 2.003577160029803e-06 0.1171053395831002 2.003577259569368e-06 0.1162371554254778 2.003577376562078e-06 0.1152245300989246 \
2.003577463662869e-06 0.1144761644999183 2.00357757295452e-06 0.1135478691973115 2.003577654479583e-06 0.1128618460838699 2.003577754254576e-06 0.1120273350449922 \
2.003577871679726e-06 0.1110526766231405 2.003577973464844e-06 0.1102143708571793 2.003578061203792e-06 0.1094962336869811 2.0035781420033e-06 0.1088432886892514 \
2.003578228954319e-06 0.1081456845520918 2.003578309740945e-06 0.1075007757815706 2.003578399947511e-06 0.1067842832273628 2.003578490898266e-06 0.1060655611559195 \
2.00357857956879e-06 0.1053685613006139 2.003578678583611e-06 0.1045946508745568 2.003578772289787e-06 0.1038723470842792 2.003578866149063e-06 0.1031520741219857 \
2.003578966976511e-06 0.1023817709659086 2.003579071607409e-06 0.1015861061604995 2.003579195570165e-06 0.1006484085638475 2.003579292969478e-06 0.09991551135558702 \
2.003579413227425e-06 0.09901872452754552 2.003579524095301e-06 0.09819831936474602 2.003579628568336e-06 0.09742874659471555 2.003579745805045e-06 0.09656937225591002 \
2.003579847599366e-06 0.09582695326576983 2.003579945574917e-06 0.09511577589263259 2.003580086079407e-06 0.09410164141823299 2.003580191157203e-06 0.09334832721827611 \
2.003580289770019e-06 0.09264549593674179 2.003580382484827e-06 0.09198739948435641 2.003580468683213e-06 0.09137785861853052 2.003580562596188e-06 0.09071637432184691 \
2.003580659696934e-06 0.09003559055802626 2.003580769117988e-06 0.08927317549644689 2.003580870101537e-06 0.08857281843916648 2.003580963759483e-06 0.08792605868920525 \
2.003581037934155e-06 0.08741581771673042 2.003581175834007e-06 0.08647193599618339 2.003581248191011e-06 0.08597917321277694 2.003581383512214e-06 0.08506274029062395 \
2.003581469423819e-06 0.08448410751389913 2.003581614152054e-06 0.08351486081643937 2.003581710382619e-06 0.0828744112740944 2.003581798218398e-06 0.08229260392026354 \
2.003581914017306e-06 0.08152964121883956 2.003582029145758e-06 0.08077575264951149 2.00358214291219e-06 0.08003553900012179 2.003582283169683e-06 0.0791300282244784 \
2.003582424545716e-06 0.07822490276368012 2.003582574181758e-06 0.07727536491519127 2.003582718670613e-06 0.07636690312463701 2.003582869844724e-06 0.07542565384097814 \
2.003583019215544e-06 0.07450459906593411 2.003583168562251e-06 0.0735926433331697 2.003583328517767e-06 0.07262574717347114 2.003583484664678e-06 0.07169171823582712 \
2.003583659153113e-06 0.07065947636250877 2.003583828862219e-06 0.0696671357044583 2.003584014041303e-06 0.0685979885997255 2.00358421076238e-06 0.06747763456279594 \
2.0035844212802e-06 0.06629631776014881 2.003584643312255e-06 0.06507007089066431 2.003584873524276e-06 0.0638195278444372 2.003585116035382e-06 0.06252626147401 \
2.003585376689467e-06 0.06116236403900636 2.003585656588531e-06 0.05972739422233359 2.003585950172255e-06 0.05825544847408989 2.003586265108239e-06 0.05671370145268265 \
2.003586607914165e-06 0.05507846134953124 2.003586957380758e-06 0.0534565727116736 2.003587366284915e-06 0.05161746230842366 2.003587712949942e-06 0.05010669351290297 \
2.003588100364996e-06 0.04846839895323611 2.003588444582788e-06 0.04705645202362623 2.003588768009047e-06 0.04576625679949029 2.003589073054809e-06 0.04458093278443617 \
2.003589365916806e-06 0.04347099288378908 2.003589650057723e-06 0.04242242262004604 2.003589926078015e-06 0.04142902112907627 2.003590192930566e-06 0.04049015932812138 \
2.003590461822789e-06 0.03956531631184226 2.003590737883211e-06 0.03863769040165695 2.003591025478782e-06 0.03769451689421055 2.003591265044408e-06 0.03692662498323904 \
2.003591554211835e-06 0.03602084344675294 2.003591770003438e-06 0.03535960341037672 2.003591957720477e-06 0.03479599077274986 2.003592155849583e-06 0.03421285035004928 \
2.003592518724446e-06 0.03317032497347058 2.003592776866276e-06 0.03244834222605905 2.00359308657919e-06 0.0316030971185694 2.003593352049328e-06 0.03089664771451467 \
2.003593620168408e-06 0.03019941363307669 2.003593899042439e-06 0.02949128999862272 2.003594145228876e-06 0.02888043298519722 2.003594375860285e-06 0.02832033800396738 \
2.003594614150204e-06 0.02775711540944564 2.003594849157568e-06 0.02721270742060762 2.003595076940031e-06 0.02669509678424227 2.003595485552303e-06 0.02579039168486155 \
2.003595661854632e-06 0.02540904040268441 2.003596016332316e-06 0.02465798827491217 2.003596200203288e-06 0.02427641469830137 2.00359653515201e-06 0.02359448510613503 \
2.003596699060727e-06 0.02326678168937357 2.003597091331304e-06 0.02249905491676728 2.003597247322069e-06 0.02220010404946675 2.003597678925426e-06 0.02138321689778962 \
2.003597816314806e-06 0.0211255367654138 2.003598333123589e-06 0.02017559010600388 2.003598458659483e-06 0.01995091418019728 2.003598915901008e-06 0.01915998482559782 \
2.003599075046989e-06 0.01889493739859509 2.003599682285467e-06 0.01793263500095189 2.003599816822955e-06 0.01772934138481063 2.003600480086948e-06 0.01678091027541291 \
2.003600673410379e-06 0.01651856846389665 2.00360134106704e-06 0.01565087920017967 2.003601502655887e-06 0.01544858341705342 2.00360225789114e-06 0.01454101846553843 \
2.003602407452107e-06 0.01436800730673201 2.003603297789931e-06 0.01338293844200974 2.003603396447817e-06 0.01327873262558703 2.003604353121314e-06 0.01230993787860994 \
2.003604474231022e-06 0.01219243157195396 2.00360546572373e-06 0.01126376273051215 2.00360562925246e-06 0.01111855113153209 2.003606759174536e-06 0.01018247077230436 \
2.003606871621774e-06 0.01009565848301377 2.003608249445262e-06 0.009103273453806031 2.003608388390534e-06 0.009009747578659758 2.003609942788868e-06 0.008018073335410726 \
2.00361005485534e-06 0.00794673960805117 2.00361169983817e-06 0.006958154532207958 2.003611807090665e-06 0.006899512253112593 2.003613751584153e-06 0.005937533026687714 \
2.00361395848211e-06 0.005843834961138424 2.003616297369853e-06 0.00487227039639981 2.003616721356264e-06 0.004712306502041247 2.00361949358946e-06 0.003780857497341114 \
2.003619941898552e-06 0.003647790772321777 2.003623582397237e-06 0.00272553831825111 2.003624079053072e-06 0.002619503085887757 2.003629830173496e-06 0.001650572925599863 \
2.003630116955383e-06 0.001609446887446839 2.003635471944067e-06 0.0006353228983793809 2.003635677300692e-06 0.0005920420449145349 2.006282712074507e-06 -0.0002718533828215428 \
2.006282867950111e-06 -0.0004579010352009555 2.006283416265203e-06 -0.001326296959495401 2.006283529048879e-06 -0.001543805653187533 2.006283963541019e-06 -0.002491429791030493 \
2.006284039366175e-06 -0.002673591589873599 2.006284396016773e-06 -0.003590195133438418 2.006284523065853e-06 -0.003936807634339821 2.006284801566247e-06 -0.004716444651655622 \
2.00628490965073e-06 -0.005020876868076652 2.006285253249855e-06 -0.00592430224391268 2.00628536024372e-06 -0.006162325733041658 2.006286259614116e-06 -0.005653094509861465 \
2.006286438047546e-06 -0.004687598829536962 2.006286543770961e-06 -0.003940993102967527 2.006286668833738e-06 -0.002883597584075996 2.006286762417834e-06 -0.001971418478057775 \
2.006286840257396e-06 -0.001132968824455395 2.006286920329394e-06 -0.0001977429743171 2.006287042702205e-06 0.001370578777960296 2.006287160958077e-06 0.003041212838230153 \
2.006287279607187e-06 0.004860750887681821 2.006287393089626e-06 0.006730904986417607 2.006287496532764e-06 0.008536402178002854 2.006287611192018e-06 0.01064190690353853 \
2.006287801775811e-06 0.0143607330143792 2.006287935565949e-06 0.01711819191720031 2.006288085819515e-06 0.02033933849841947 2.006288240988763e-06 0.02378599874269359 \
2.006288396380812e-06 0.0273434151175349 2.006288544088042e-06 0.03080849965087477 2.006288693077668e-06 0.03437359286003162 2.006288848068751e-06 0.03814545786868043 \
2.006289007439365e-06 0.04208062121327779 2.006289172372776e-06 0.04620305710844342 2.006289347319105e-06 0.0506208066052034 2.006289526449176e-06 0.05518387280380205 \
2.006289716238431e-06 0.06005265756871143 2.0062899199354e-06 0.06530840376289772 2.006290139745932e-06 0.07100650943730057 2.006290371497377e-06 0.07703584544314998 \
2.006290619322674e-06 0.08349927754587044 2.006290890643604e-06 0.09058756662233436 2.006291185356381e-06 0.09829181712822582 2.00629151061403e-06 0.106792896697727 \
2.006291876859735e-06 0.1163551101154179 2.006292270156448e-06 0.1266079356677421 2.006292722809344e-06 0.1383809089651769 2.006293248524511e-06 0.1520098384503803 \
2.006293867738049e-06 0.1679979965193872 2.006294548482366e-06 0.1854865650013753 2.00629534215732e-06 0.2057488551561759 2.006296230922954e-06 0.2282732214494322 \
2.006297044312215e-06 0.2487218262351868 2.006297766061792e-06 0.2667261628598245 2.006298401725801e-06 0.282460740414376 2.006298973442562e-06 0.2965101025186013 \
2.006299508996846e-06 0.3095696210007924 2.006300012355259e-06 0.3217495654069301 2.006300488682702e-06 0.3331878525640654 2.006300962606306e-06 0.3444754071334732 \
2.006301420078025e-06 0.3552759747331513 2.006301886058294e-06 0.3661792384270033 2.006302335046104e-06 0.376592601923634 2.006302831152646e-06 0.3879857357798637 \
2.006303350914508e-06 0.3998002499051578 2.006303730319153e-06 0.4083447473225827 2.006304170327876e-06 0.4181679450526055 2.006304640096814e-06 0.4285466970600206 \
2.006305125617752e-06 0.4391589006481625 2.006305565065858e-06 0.4486701556983262 2.006305626818807e-06 0.4500002248264944 2.006305750324704e-06 0.4526540461147197 \
2.006305997336498e-06 0.4579447795386873 2.006306249931409e-06 0.463325462421476 2.006306447502524e-06 0.467511453725808 2.006306673074271e-06 0.4722681264242033 \
2.006306994642268e-06 0.4790073975813253 2.006307263421497e-06 0.4846013351959894 2.00630748207297e-06 0.4891262574467725 2.006307692176936e-06 0.4934547887280634 \
2.006307918582462e-06 0.4980921872304203 2.006308127687652e-06 0.5023516957637455 2.006308317089911e-06 0.5061927337048852 2.006308441251129e-06 0.5086969563931187 \
2.006308568006226e-06 0.5112441466129884 2.006308728004704e-06 0.5144514110933732 2.006308975647656e-06 0.5193914248715521 2.006309154234115e-06 0.5229351592435862 \
2.006309325187692e-06 0.5263079149198099 2.006309586537288e-06 0.5314455197962068 2.00630981260887e-06 0.5358634945234868 2.006310015740537e-06 0.5398188128751134 \
2.006310180971268e-06 0.5430252218652345 2.006310337758288e-06 0.5460612552756139 2.006310526914905e-06 0.5497137532216215 2.006310728782659e-06 0.5535976061995346 \
2.006310952933981e-06 0.5578986282275192 2.006311191316346e-06 0.5624617013850463 2.006311426077985e-06 0.566941985223824 2.006311656348691e-06 0.5713275351537204 \
2.006311862141324e-06 0.5752375533958141 2.006312067125538e-06 0.5791255875933676 2.00631230994078e-06 0.5837094709690289 2.006312564698362e-06 0.588493349632063 \
2.006312792926793e-06 0.5927514274590796 2.006313030765665e-06 0.5971656109489694 2.006313243043101e-06 0.6010807441713891 2.006313454836506e-06 0.6049674646600495 \
2.006313708720774e-06 0.6095919957414236 2.006313913314301e-06 0.6132953190650409 2.006314165037654e-06 0.6178178328453598 2.006314352827174e-06 0.6211736970442716 \
2.006314605700251e-06 0.6256587164710262 2.006314804109613e-06 0.6291560967673944 2.006314983842284e-06 0.6323071487074056 2.006315254113091e-06 0.6370161336915187 \
2.006315471396857e-06 0.6407803561788556 2.006315651923236e-06 0.6438916924996977 2.006315853084131e-06 0.6473460740030906 2.006316021667513e-06 0.650231451944099 \
2.00631622602572e-06 0.6537144072723954 2.006316371688778e-06 0.6561873372238678 2.006316536247377e-06 0.6589728476742622 2.006316705716593e-06 0.6618316558839334 \
2.006316859256675e-06 0.664412775690417 2.006317000490202e-06 0.6667750288922751 2.006317144066014e-06 0.6691685747430841 2.006317277296139e-06 0.6713840140331436 \
2.006317419196459e-06 0.6737368819239464 2.006317539430086e-06 0.6757233098298149 2.006317684081139e-06 0.6781085120392751 2.006317800299844e-06 0.6800197521569988 \
2.006317919382163e-06 0.6819757159594566 2.006318017960477e-06 0.6835903813535821 2.006318135558183e-06 0.6855122399681081 2.006318222994146e-06 0.6869376986921233 \
2.006318347740232e-06 0.6889650632873403 2.006318447547296e-06 0.6905825000046129 2.006318540037093e-06 0.6920753042469043 2.006318641321177e-06 0.6937043390836264 \
2.006318739114283e-06 0.695273833970533 2.006318830385075e-06 0.6967333967490603 2.006318932842905e-06 0.6983656370917724 2.006319065752136e-06 0.7004728611232253 \
2.006319220767541e-06 0.7029137789397926 2.006319355649227e-06 0.7050222373350452 2.006319501145018e-06 0.7072806469370021 2.006319628999685e-06 0.709252249158637 \
2.006319753457981e-06 0.7111597484283609 2.006319864783685e-06 0.7128563623504806 2.006319978813713e-06 0.7145852226468989 2.00632007932493e-06 0.7161013069709498 \
2.006320216526077e-06 0.7181590832501857 2.006320336471979e-06 0.7199473375636642 2.006320455641778e-06 0.7217141075019444 2.006320582586792e-06 0.7235855504531626 \
2.006320707354209e-06 0.7254141264975077 2.006320830849597e-06 0.7272133847865295 2.00632095763087e-06 0.7290498056238117 2.006321088220356e-06 0.730930225429108 \
2.006321210432259e-06 0.7326797786847141 2.006321347490272e-06 0.7346298644824388 2.006321448705626e-06 0.7360619656663578 2.006321553674562e-06 0.7375401619041119 \
2.006321645165995e-06 0.7388229997694907 2.006321758241356e-06 0.7404001534680551 2.00632184554224e-06 0.7416107338190071 2.00632195000557e-06 0.7430512000342341 \
2.006322080768703e-06 0.7448411286358657 2.0063221906822e-06 0.7463352048609909 2.006322295341958e-06 0.7477488743938407 2.00632241917362e-06 0.7494094725133206 \
2.006322567926971e-06 0.751387874302702 2.006322689842132e-06 0.7529958494242643 2.006322803696392e-06 0.7544867042370438 2.00632294419585e-06 0.7563117925204224 \
2.006323085519365e-06 0.7581313010100689 2.006323203298971e-06 0.7596352654099263 2.006323331697459e-06 0.7612620174900669 2.006323474021161e-06 0.7630496612437514 \
2.006323590410316e-06 0.7644991888858087 2.006323736133978e-06 0.7662987831554334 2.006323857913867e-06 0.7677897310961733 2.006323976478797e-06 0.7692300520321635 \
2.006324099092246e-06 0.7707078417740018 2.006324225543629e-06 0.77221964326554 2.006324335666584e-06 0.7735261258099556 2.006324461188726e-06 0.7750039859681491 \
2.006324566849672e-06 0.7762386743660952 2.006324702026829e-06 0.7778058706872942 2.006324825637346e-06 0.7792267957652825 2.006324955634725e-06 0.7807078764205345 \
2.006325068606223e-06 0.7819831642610904 2.006325176500111e-06 0.7831908181350914 2.006325313030793e-06 0.7847046126527283 2.006325463151702e-06 0.7863508260127218 \
2.006325605416006e-06 0.7878933964149381 2.006325724997519e-06 0.7891771019825847 2.006325861808649e-06 0.7906313890246753 2.006325984312413e-06 0.7919206245676671 \
2.006326128984341e-06 0.7934276941869095 2.006326269769414e-06 0.794878360380241 2.006326396585209e-06 0.796171745508174 2.006326515632602e-06 0.7973744708066829 \
2.006326627895563e-06 0.7984986270115709 2.006326732283334e-06 0.7995352562746869 2.006326827560395e-06 0.8004739840425704 2.006326963902891e-06 0.8018044219089175 \
2.00632708076796e-06 0.8029326473252685 2.006327200364489e-06 0.8040757482679398 2.006327322250299e-06 0.8052288531124292 2.006327444838559e-06 0.8063765489401953 \
2.006327572579618e-06 0.8075599074701925 2.006327697362526e-06 0.8087035441861687 2.0063278278629e-06 0.8098867241643505 2.006327954229597e-06 0.8110199871086299 \
2.006328081578389e-06 0.8121498004723215 2.006328186791179e-06 0.8130740322933268 2.006328291495184e-06 0.8139855427426806 2.00632838302539e-06 0.8147757515715357 \
2.00632850639836e-06 0.8158311616195392 2.006328593352409e-06 0.8165684017534872 2.006328692208245e-06 0.8173999442793862 2.006328836710884e-06 0.8186029267949408 \
2.006328973036572e-06 0.8197243345631372 2.006329082445009e-06 0.8206145128367788 2.006329228461948e-06 0.821788834531623 2.006329380203008e-06 0.8229927727264784 \
2.006329506119585e-06 0.8239792970156907 2.006329650568649e-06 0.8250971468990039 2.006329775264817e-06 0.8260503472050121 2.006329925878834e-06 0.8271873005969326 \
2.006330061249302e-06 0.8281959289694237 2.006330186472937e-06 0.8291179217777711 2.006330304128897e-06 0.8299746468143927 2.00633044991051e-06 0.8310230722388168 \
2.00633061639426e-06 0.8322027532553667 2.006330747215024e-06 0.8331167337813133 2.006330920675046e-06 0.834311196379941 2.006331088787841e-06 0.8354501125721271 \
2.006331258668969e-06 0.8365827385393307 2.006331439512628e-06 0.8377685497174457 2.006331582704692e-06 0.8386931238161603 2.006331696822189e-06 0.8394210074154138 \
2.006331826873799e-06 0.8402408682651782 2.006331928753516e-06 0.8408758513273116 2.006332045641139e-06 0.841596551294542 2.006332182786859e-06 0.8424315815669623 \
2.006332380696072e-06 0.8436167827761205 2.006332572515411e-06 0.8447436440637145 2.006332781866158e-06 0.8459494874145237 2.006332964017768e-06 0.8469786287449077 \
2.006333161103991e-06 0.8480715276019779 2.006333334356719e-06 0.8490148531186206 2.006333517450963e-06 0.8499943787178993 2.00633368858243e-06 0.8508936588199895 \
2.006333863270272e-06 0.8517955326875627 2.006334038504287e-06 0.8526841769874772 2.006334214641154e-06 0.8535614892404448 2.006334405008494e-06 0.8544920815553035 \
2.006334595580845e-06 0.8554057038167108 2.006334795976838e-06 0.8563474066245403 2.006334988566463e-06 0.8572344253714166 2.006335199466375e-06 0.858185963363946 \
2.006335427341862e-06 0.8591913103610016 2.006335693424718e-06 0.8603357477151101 2.006335991926854e-06 0.8615822374427254 2.006336267816323e-06 0.8627000332972231 \
2.006336552083493e-06 0.8638181192989086 2.006336826221443e-06 0.8648650323418529 2.006337098522366e-06 0.8658754039994767 2.006337368678563e-06 0.8668495780678541 \
2.006337625862699e-06 0.8677515347235455 2.006337898421613e-06 0.8686810999091764 2.006338174469332e-06 0.8695957110915412 2.006338444589598e-06 0.8704649939918846 \
2.006338744449489e-06 0.8714007440816277 2.006339115430114e-06 0.8725171209518352 2.006339410352536e-06 0.8733732402027278 2.006339664628271e-06 0.8740897163373675 \
2.006339962841735e-06 0.8749052413925265 2.006340236411347e-06 0.8756305047096297 2.006340472534748e-06 0.8762394088953867 2.006340712859886e-06 0.8768433401198644 \
2.006340935193821e-06 0.8773882060838187 2.006341129200254e-06 0.8778530214284207 2.006341458909681e-06 0.8786208714695904 2.00634161408109e-06 0.87897283049042 \
2.006341931723491e-06 0.8796750328643211 2.006342110604035e-06 0.8800599154915705 2.006342453064798e-06 0.8807759898408113 2.00634263726721e-06 0.8811501695110489 \
2.006343112296513e-06 0.8820806183873429 2.006343279683462e-06 0.8823969901232691 2.006343745459844e-06 0.8832471741583867 2.006343926299187e-06 0.8835657112976044 \
2.006344420308805e-06 0.8844044135654346 2.006344561623711e-06 0.8846360992458032 2.006345167867327e-06 0.8855901496945974 2.006345319942526e-06 0.8858196526512701 \
2.006345966662599e-06 0.8867549368993356 2.006346094949267e-06 0.8869330782847171 2.006346743158687e-06 0.8877977435561634 2.006346872882985e-06 0.8879638504720397 \
2.006347641302053e-06 0.8888993076310558 2.006347771073903e-06 0.8890488273083775 2.006348624736509e-06 0.8899738047157748 2.006348767761561e-06 0.8901192131187072 \
2.006349754067048e-06 0.8910487927319016 2.0063499755536e-06 0.8912403904783051 2.006351118378139e-06 0.8921548233216382 2.006351248258076e-06 0.8922544308366913 \
2.006352600758498e-06 0.8932425879319322 2.006352751041431e-06 0.8933452769452155 2.006354231575698e-06 0.8942627870546499 2.006354470485492e-06 0.8943950258099049 \
2.006356252518433e-06 0.8952625983306248 2.00635663826586e-06 0.895426813549116 2.006359040424079e-06 0.8963023915260389 2.006359515360049e-06 0.8964490046842035 \
2.006363433287165e-06 0.8974035634625627 2.006363903247409e-06 0.8974927205890085 2.006372272035387e-06 0.8984807567386782 2.006372492545714e-06 0.8984960697096243 \
2.006417072074293e-06 0.8994905034760702 2.006418273460192e-06 0.8995076493514624 2.006554083268694e-06 0.9004821828323031 2.006554262245419e-06 0.9005421539807538 \
2.006557707120338e-06 0.8996085030263692 2.006557879904192e-06 0.8994755022453073 2.0065592062239e-06 0.8985168769831137 2.006559392989208e-06 0.8983970610744239 \
2.006561177194233e-06 0.8974304740967198 2.006561389324515e-06 0.8973403978332656 2.006574730020299e-06 0.8983331062395279 2.006574843308145e-06 0.8983517458922662 \
2.006583546661242e-06 0.8993273409280406 2.00658409447182e-06 0.8993637478389299 2.007076621843715e-06 0.9003542216796759 2.007076717582567e-06 0.9004233209197793 \
2.007077660131942e-06 0.9014023545001312 2.007077822585254e-06 0.9016297223302431 2.007078389291501e-06 0.9025464066367429 2.007078496462212e-06 0.9027401250447874 \
2.007078889770564e-06 0.9035002370985188 2.007079022567928e-06 0.9037710185404622 2.007079402169035e-06 0.9045728679206633 2.007079532383781e-06 0.9048512534150681 \
2.007079993790073e-06 0.9057878278182891 2.007080113037131e-06 0.9060008176934132 2.007081542646165e-06 0.9050557440230738 2.007081626316293e-06 0.9046580283931719 \
2.007081751622122e-06 0.9039622140338933 2.007081859436291e-06 0.9032622438705011 2.007081978430637e-06 0.9023800387125585 2.007082093802854e-06 0.9014106868475621 \
2.007082183899751e-06 0.900578017289966 2.007082295347455e-06 0.8994526603282017 2.007082381426603e-06 0.8985125975436928 2.007082487392252e-06 0.8972736935213672 \
2.007082587160618e-06 0.8960214106762436 2.007082668156228e-06 0.8949470092681954 2.007082777804195e-06 0.8934133399212493 2.007082863391606e-06 0.8921520042367302 \
2.007082955514215e-06 0.8907345325087322 2.007083043733598e-06 0.8893220116766375 2.007083152508351e-06 0.8875100775672261 2.007083235401386e-06 0.8860780350921965 \
2.007083343975057e-06 0.8841400608632336 2.007083436201252e-06 0.8824412727986957 2.00708352082175e-06 0.8808423775446282 2.00708360666218e-06 0.8791839877465467 \
2.00708368587706e-06 0.8776224824828824 2.00708376196503e-06 0.8760960492665846 2.007083854301399e-06 0.874210837196514 2.007083914177735e-06 0.8729702140710593 \
2.007083971566019e-06 0.8717685933706794 2.007084033561192e-06 0.8704574090763495 2.007084096840043e-06 0.8691057216070059 2.007084146911381e-06 0.8680269866686803 \
2.007084196353533e-06 0.8669542389500936 2.00708426002324e-06 0.8655623656543436 2.007084335970659e-06 0.8638877358586781 2.007084384801671e-06 0.8628032002737418 \
2.007084433325624e-06 0.8617197496806845 2.007084509037347e-06 0.8600184098866027 2.007084576246125e-06 0.8584975010852487 2.007084618952631e-06 0.8575263577286506 \
2.007084662855205e-06 0.8565244243916033 2.007084750660351e-06 0.8545103166059256 2.00708481351352e-06 0.8530605771626394 2.007084872183177e-06 0.8517018597088126 \
2.007084908361778e-06 0.8508614974547222 2.007084943180258e-06 0.8500510151036469 2.007084978206243e-06 0.8492340038666518 2.007085048258214e-06 0.8475953578585981 \
2.007085096728698e-06 0.8464581214772323 2.007085140673499e-06 0.8454248116355969 2.007085186191255e-06 0.8443523575543517 2.007085250092166e-06 0.8428433081697474 \
2.007085316218539e-06 0.8412777165526386 2.007085421348608e-06 0.8387809254526315 2.007085509283283e-06 0.8366857089760468 2.007085588228565e-06 0.834800137446173 \
2.007085676393602e-06 0.8326899670047023 2.007085763209599e-06 0.8306078985741704 2.007085851101283e-06 0.8284959280419055 2.007085942350373e-06 0.8262996967350639 \
2.007086045112241e-06 0.8238226494465998 2.007086143615716e-06 0.8214450402687625 2.007086255948632e-06 0.8187302447322098 2.007086368922768e-06 0.8159967029774419 \
2.007086490210663e-06 0.8130591602364435 2.007086620717817e-06 0.8098958628758253 2.00708674976372e-06 0.8067658935936169 2.00708690323932e-06 0.8030416153605923 \
2.00708706852354e-06 0.799029304640783 2.007087236264745e-06 0.7949567682299736 2.007087432788334e-06 0.7901857478752816 2.007087637550659e-06 0.7852160332972318 \
2.007087850227715e-06 0.7800563994093253 2.007088050847662e-06 0.7751902022758907 2.00708825170639e-06 0.7703212856706637 2.007088401728407e-06 0.766686939713112 \
2.007088532263574e-06 0.7635264252913375 2.007088666681014e-06 0.7602735436595947 2.007088772876545e-06 0.7577048602246427 2.007088906182877e-06 0.754482067181252 \
2.007089013215803e-06 0.7518959494812111 2.007089156291704e-06 0.7484409822837247 2.007089320797846e-06 0.7444713482725677 2.007089441615092e-06 0.74155777711076 \
2.007089612721757e-06 0.7374334100931738 2.007089773612309e-06 0.733558046396253 2.00708999020493e-06 0.7283457217000903 2.007090183460631e-06 0.7236999380850822 \
2.007090362395765e-06 0.7194029726762079 2.007090529212387e-06 0.7154015770462002 2.007090715418352e-06 0.7109395231330657 2.007090903351594e-06 0.7064416825495208 \
2.007091069273699e-06 0.7024749886985119 2.007091261631787e-06 0.6978803202016938 2.007091402988682e-06 0.6945068232011449 2.007091559996444e-06 0.6907636199298515 \
2.007091755976089e-06 0.6860965106368763 2.007091918410194e-06 0.6822325558671515 2.007092079586376e-06 0.6784034260021697 2.007092271894574e-06 0.6738409413562468 \
2.007092489556454e-06 0.6686845685784016 2.007092737577756e-06 0.6628199086538362 2.007092915635219e-06 0.6586162961343578 2.007093164179028e-06 0.6527567611811057 \
2.007093366786271e-06 0.6479896840619462 2.007093536596938e-06 0.6440011601507294 2.007093695213124e-06 0.6402799599229552 2.007093833743559e-06 0.637035894415233 \
2.007093969951322e-06 0.6338503464729111 2.007094096262698e-06 0.6309003762865483 2.007094225721933e-06 0.6278810604265532 2.007094354053673e-06 0.6248911458464299 \
2.007094485383603e-06 0.6218374290191309 2.007094617410215e-06 0.6187713222160208 2.007094761570095e-06 0.6154276788919771 2.007094905778687e-06 0.6120888358645944 \
2.007095053433791e-06 0.6086753592300279 2.007095200490149e-06 0.6052842859263143 2.007095358304176e-06 0.6016504852589418 2.007095490909828e-06 0.5986039825107707 \
2.007095622374795e-06 0.5955897059985247 2.007095741804594e-06 0.5928552647156846 2.007095877873286e-06 0.5897484304797134 2.007095992801548e-06 0.5871283594046445 \
2.007096143912269e-06 0.5836892419704927 2.007096258561337e-06 0.5810871834776226 2.007096376499006e-06 0.5784138884735546 2.007096466280295e-06 0.576381560286313 \
2.007096556599689e-06 0.5743415774978985 2.007096623290559e-06 0.5728373329037385 2.007096688852372e-06 0.5713590910263378 2.007096739894496e-06 0.5702089751121119 \
2.007096801596215e-06 0.5688198806440578 2.007096864686071e-06 0.5674025889664359 2.007096929044425e-06 0.5659586381304559 2.007096982438224e-06 0.5647616504486359 \
2.007097075080806e-06 0.5626864159088959 2.007097151688078e-06 0.5609719030357503 2.007097207513141e-06 0.5597256439368602 2.007097276567267e-06 0.5581857825097393 \
2.007097383455393e-06 0.5558054549196561 2.007097461199018e-06 0.5540764009223496 2.007097562049117e-06 0.5518382286767042 2.007097687729972e-06 0.5490568313009737 \
2.007097787971657e-06 0.5468419758621708 2.00709789988934e-06 0.5443739014182352 2.007098003155247e-06 0.5421024366463116 2.007098122904589e-06 0.5394737463112931 \
2.007098224637469e-06 0.5372436950013484 2.007098340157213e-06 0.5347185748314579 2.007098455192299e-06 0.5322102907975605 2.007098581673211e-06 0.529456475824718 \
2.007098707047009e-06 0.5267350629320526 2.007098853862932e-06 0.5235577714138258 2.007098989426381e-06 0.5206304261698983 2.007099147124634e-06 0.5172373565578411 \
2.007099309443689e-06 0.5137528589513558 2.007099490267585e-06 0.5098871206809381 2.007099682715906e-06 0.5057874350093188 2.007099895621209e-06 0.5012700264709963 \
2.007100127802608e-06 0.4963634062180514 2.007100385093187e-06 0.4909555076455908 2.00710062471901e-06 0.4859407514401474 2.007100926434446e-06 0.479662588092526 \
2.0071012143538e-06 0.4737079198104491 2.007101527242619e-06 0.4672821326282255 2.007101846980824e-06 0.4607585360408045 2.007102186575985e-06 0.4538766993710576 \
2.007102513478483e-06 0.4472977926730654 2.007102849036864e-06 0.4405887635920606 2.007103166132787e-06 0.4342949501181722 2.007103500370542e-06 0.4277061431972559 \
2.007103851801664e-06 0.4208322784122511 2.007104166327818e-06 0.4147233751108969 2.007104489505308e-06 0.4084912998479469 2.007104930620066e-06 0.400057814108821 \
2.007105272736104e-06 0.3935812134363078 2.007105572680633e-06 0.3879522399691127 2.007105947811639e-06 0.3809760137481454 2.007106277555878e-06 0.3749002425561211 \
2.007106560798804e-06 0.3697269896098562 2.007106860945059e-06 0.3642865787664632 2.007107140547253e-06 0.3592589179584539 2.007107364323365e-06 0.3552676761685443 \
2.007107576103695e-06 0.3515151294490645 2.007107778537159e-06 0.3479514629380864 2.007107979628427e-06 0.3444362246481504 2.007108185342845e-06 0.3408632458568372 \
2.007108452965717e-06 0.3362478643926977 2.007108691897011e-06 0.3321601360780691 2.007108925403074e-06 0.3281974319442653 2.007109138868474e-06 0.3246000376975314 \
2.007109360246046e-06 0.3208952602338652 2.007109560209693e-06 0.3175728982722026 2.007109764482006e-06 0.3142073831356898 2.007109961828878e-06 0.3109812293225088 \
2.007110147201405e-06 0.3079732989686547 2.007110343307796e-06 0.3048147723336881 2.007110545584936e-06 0.3015820927993307 2.007110721243233e-06 0.2988007390096292 \
2.00711090711339e-06 0.295878328903569 2.007111114092782e-06 0.2926488196724605 2.007111299414374e-06 0.2897857719971084 2.007111494641182e-06 0.2867989994419413 \
2.007111650415531e-06 0.28443329608414 2.007111829172313e-06 0.2817356906084737 2.007112010203233e-06 0.2790344478478936 2.007112160100347e-06 0.2768142575519123 \
2.007112361143775e-06 0.273859574769726 2.007112510258904e-06 0.2716833853889438 2.007112648798334e-06 0.2696726034832688 2.007112800673409e-06 0.2674956304896134 \
2.007112915147538e-06 0.2658586287383957 2.007113046677468e-06 0.2639823142040156 2.007113172435956e-06 0.2622048582339201 2.007113276776362e-06 0.2607341604582348 \
2.007113389755722e-06 0.2591418073851619 2.007113506084246e-06 0.2575033437579446 2.007113649011668e-06 0.2554974228347739 2.007113762273172e-06 0.2539102348881249 \
2.007113896429905e-06 0.2520298733123076 2.00711400690271e-06 0.2504818583075984 2.007114162335285e-06 0.2483006006477398 2.007114303220384e-06 0.2463217957442577 \
2.007114454612954e-06 0.2441928603691365 2.007114609775034e-06 0.2420086586735095 2.007114739184283e-06 0.2401849910837116 2.007114873896377e-06 0.2382868210192302 \
2.007115011594201e-06 0.2363478190565156 2.007115129346217e-06 0.2346905900295477 2.00711528867041e-06 0.2324499447852502 2.007115425932636e-06 0.2305210708572645 \
2.007115566678993e-06 0.2285488733964877 2.007115672470167e-06 0.2270688194984586 2.007115802411565e-06 0.2252532503786337 2.007115902948028e-06 0.2238506847401111 \
2.007116005281736e-06 0.2224250970611539 2.007116079010317e-06 0.2214012665004395 2.00711615824426e-06 0.2203047212273054 2.007116229215507e-06 0.2193236206014474 \
2.007116280678535e-06 0.218612902325451 2.007116333626988e-06 0.2178825126218075 2.007116412781991e-06 0.2167921001391954 2.007116455054626e-06 0.2162104926182252 \
2.007116494899171e-06 0.2156628374086678 2.00711653812282e-06 0.2150692779925967 2.007116579029823e-06 0.2145080585354088 2.007116649152284e-06 0.2135474129702876 \
2.007116682837256e-06 0.2130867492099046 2.007116727666638e-06 0.212477723463 2.0071167865238e-06 0.2116792343136102 2.007116851309261e-06 0.2108017053965978 \
2.007116908790024e-06 0.2100241135398916 2.007116969219033e-06 0.209207737948094 2.007117066255463e-06 0.2078991976528634 2.007117150945123e-06 0.2067595417901527 \
2.007117259855885e-06 0.2052972881712416 2.007117356256692e-06 0.2040065614180294 2.00711745127333e-06 0.2027428333585779 2.007117554705128e-06 0.2013717100485363 \
2.007117649634473e-06 0.2001158751783069 2.007117752654899e-06 0.198757993281026 2.007117857737332e-06 0.1973779917312911 2.007117967046146e-06 0.1959482000350934 \
2.007118077489628e-06 0.1945091075764383 2.007118193779904e-06 0.1929996650696684 2.007118303709896e-06 0.1915811184357085 2.007118413372321e-06 0.1901717999899754 \
2.007118515088965e-06 0.1888694322720079 2.007118608043679e-06 0.1876837490531375 2.007118700772569e-06 0.1865049219968967 2.007118774458125e-06 0.1855719169757668 \
2.00711885729934e-06 0.1845269810791141 2.007118931885337e-06 0.1835895008849975 2.007119001608678e-06 0.1827150226754214 2.007119068327086e-06 0.1818808699270075 \
2.007119164170411e-06 0.1806871657728035 2.007119246877184e-06 0.1796611249561687 2.007119340441008e-06 0.1785035608809835 2.007119435337095e-06 0.1773351434884491 \
2.007119546707405e-06 0.1759704596301353 2.007119688349759e-06 0.1742450478777388 2.007119803596612e-06 0.1728486436789435 2.007119948144251e-06 0.1711076225712051 \
2.007120059739928e-06 0.1697708811114609 2.007120200958902e-06 0.1680898955975501 2.007120316696175e-06 0.1667201145354908 2.007120422656861e-06 0.1654722325850081 \
2.007120521416478e-06 0.164314417410061 2.00712061775965e-06 0.1631901152369615 2.007120706417402e-06 0.1621596955203892 2.007120831751673e-06 0.1607099933926625 \
2.007120926277088e-06 0.1596224416957933 2.00712102401604e-06 0.1585042187118262 2.007121132110917e-06 0.1572745454417887 2.007121226778605e-06 0.1562036643369483 \
2.007121334226452e-06 0.1549951394274829 2.007121425315495e-06 0.1539767092330788 2.007121532087207e-06 0.1527896463435911 2.007121635480473e-06 0.1516469620792683 \
2.007121746560958e-06 0.1504267727114754 2.00712183578694e-06 0.1494522115900035 2.007121921266868e-06 0.1485231035185812 2.007122005192055e-06 0.1476157397758405 \
2.007122074898619e-06 0.1468658175993407 2.007122153536697e-06 0.1460232248551682 2.007122231847954e-06 0.1451880611912267 2.007122302483827e-06 0.1444378248611795 \
2.007122387974695e-06 0.1435337156153706 2.007122475363672e-06 0.1426139614481139 2.007122556951186e-06 0.1417594571206545 2.007122654270137e-06 0.1407454482154784 \
2.007122734959659e-06 0.139910090776864 2.007122825744691e-06 0.1389752404035735 2.007122947088963e-06 0.1377336220260025 2.007123036138604e-06 0.13682812281983 \
2.007123134655454e-06 0.1358318692385875 2.007123221741723e-06 0.1349560640726983 2.007123332152611e-06 0.1338550874529322 2.007123420611433e-06 0.1329791517134813 \
2.007123521340026e-06 0.1319874611681985 2.00712362612958e-06 0.1309622419763913 2.007123720519813e-06 0.1300442429014473 2.007123817024605e-06 0.1291112112475518 \
2.007123916511258e-06 0.1281591654439075 2.007124002912429e-06 0.1273384721630967 2.00712409789256e-06 0.1264411177628728 2.007124202081388e-06 0.1254629331099751 \
2.007124311200139e-06 0.124445178694 2.007124405550594e-06 0.1235704029653004 2.007124517846343e-06 0.1225411084520107 2.007124613309697e-06 0.1216733466577494 \
2.007124717520587e-06 0.1207311846737792 2.007124806865944e-06 0.1199276649878674 2.007124877253218e-06 0.1192980345746366 2.007124952639251e-06 0.1186268760051257 \
2.007125028771421e-06 0.1179522201461119 2.007125097748918e-06 0.1173458504859956 2.007125180268091e-06 0.1166263596898966 2.007125252211578e-06 0.1160015972854393 \
2.007125334290304e-06 0.1152916772467617 2.00712541862478e-06 0.1145654108773922 2.007125496418619e-06 0.113898375935255 2.007125589183521e-06 0.1131065723182637 \
2.007125704787342e-06 0.1121254933399327 2.007125810692912e-06 0.1112341778178403 2.007125888349831e-06 0.1105854195321705 2.007125976646302e-06 0.1098504899494786 \
2.007126056703354e-06 0.1091866403929743 2.007126153629479e-06 0.1083861389179563 2.007126248864964e-06 0.1076031391441806 2.007126337436159e-06 0.1068780200140514 \
2.00712643874426e-06 0.1060523297458165 2.007126544289947e-06 0.1051963702337609 2.007126653484312e-06 0.1043160928234657 2.007126761601933e-06 0.1034503663302994 \
2.007126881519694e-06 0.1024949450012773 2.007126982881521e-06 0.1016914181115986 2.007127088891151e-06 0.100855068690839 2.00712721468278e-06 0.09986840123414902 \
2.007127344240086e-06 0.09885896724496235 2.007127479915441e-06 0.09780904711780367 2.007127655987304e-06 0.09645781830037269 2.007127819787824e-06 0.09521257997344186 \
2.007127982612565e-06 0.09398642071914091 2.0071280677512e-06 0.09334985726464029 2.007128137589223e-06 0.09282999162688726 2.007128207084828e-06 0.09231474740697931 \
2.007128281043488e-06 0.09176875214326782 2.007128377198376e-06 0.09106241641841166 2.007128451613741e-06 0.09051841344162129 2.00712852960331e-06 0.08995079828656057 \
2.00712860605214e-06 0.08939693755534793 2.007128693546224e-06 0.08876614459792892 2.007128795722934e-06 0.08803382885421264 2.007128884287322e-06 0.08740269463919083 \
2.00712899395281e-06 0.08662585268124241 2.007129110009218e-06 0.08580942306245626 2.007129251558034e-06 0.0848216759818637 2.007129384427018e-06 0.08390253510334872 \
2.007129525187328e-06 0.08293727564630923 2.007129674896948e-06 0.08192024575105315 2.007129810608835e-06 0.08100683753927941 2.007129952125717e-06 0.08006309454860433 \
2.007130087247591e-06 0.07917070961097784 2.007130228520028e-06 0.07824718349428782 2.00713037561292e-06 0.07729532867436953 2.007130527122786e-06 0.07632524417621221 \
2.0071306924985e-06 0.07527819040792309 2.00713085625969e-06 0.07425356708383206 2.007131032389632e-06 0.07316505371836476 2.00713122152861e-06 0.07201151367936541 \
2.007131432202234e-06 0.07074528708793332 2.007131651768856e-06 0.06944624562626683 2.007131886535262e-06 0.06808094281860989 2.0071321449277e-06 0.06660616301228137 \
2.00713243959236e-06 0.06496103773121734 2.007132743671683e-06 0.06330286177969326 2.007133104582163e-06 0.06138472526627536 2.007133440499035e-06 0.05964719353945821 \
2.007133880676406e-06 0.05743991201668189 2.007134259043809e-06 0.05560437501227136 2.007134701502771e-06 0.05352996728430704 2.007135055522917e-06 0.05192508193542229 \
2.007135442039672e-06 0.05022502935509546 2.007135786643729e-06 0.04875485597254389 2.007136108618665e-06 0.04741934964807833 2.007136412152492e-06 0.04619304551845941 \
2.007136707073488e-06 0.04503122626702559 2.007136989555767e-06 0.04394770877170886 2.007137266636177e-06 0.04291147062934708 2.007137532363669e-06 0.04194013461971725 \
2.007137803594355e-06 0.0409708748276704 2.007138079853372e-06 0.04000619535229137 2.007138369752594e-06 0.03901828782233653 2.007138598128988e-06 0.03825741181922668 \
2.007138903013054e-06 0.03726495139513845 2.00713911968491e-06 0.03657573971894532 2.007139311041637e-06 0.03597943984071691 2.007139509636156e-06 0.03537298232318693 \
2.007139839551497e-06 0.03438820140908775 2.00714008149717e-06 0.03368375433354889 2.007140396809222e-06 0.03278771666975258 2.007140666929207e-06 0.03203957074185158 \
2.007140923300881e-06 0.03134567005659093 2.007141203312881e-06 0.03060515313352298 2.007141448968657e-06 0.02997014710356035 2.007141681704302e-06 0.02938120249260199 \
2.007141924434299e-06 0.02878348292867495 2.007142161161564e-06 0.02821317433052753 2.007142389807974e-06 0.0276732289298247 2.007142807093635e-06 0.02671456010533928 \
2.007143002274328e-06 0.02627749693639509 2.007143383441411e-06 0.02544369227895442 2.007143560694233e-06 0.02506446942885681 2.007143903145688e-06 0.02434654114125227 \
2.00714405641412e-06 0.02403127656358269 2.007144431432584e-06 0.02327616399748992 2.007144569066725e-06 0.02300530455388665 2.007145053333359e-06 0.02207084195640928 \
2.00714517295276e-06 0.02184403312078184 2.007145589991564e-06 0.02106026682208277 2.007145733393791e-06 0.02079332360769017 2.007146254605173e-06 0.01984598817089831 \
2.007146382379043e-06 0.0196205814374062 2.007146966791417e-06 0.01863359713481367 2.007147139226823e-06 0.01835589372257288 2.007147743323573e-06 0.01743644241612937 \
2.007147904755214e-06 0.01720262545858322 2.007148544701434e-06 0.01631831686205014 2.007148723017601e-06 0.016083210242981 2.007149371001649e-06 0.01526127675881721 \
2.00714953625524e-06 0.01505930898173208 2.007150272557175e-06 0.01419381259610907 2.007150406833225e-06 0.01404154276213586 2.007151203932744e-06 0.01317592498067951 \
2.007151344530355e-06 0.01302934089458718 2.007152309873577e-06 0.0120661300044765 2.007152474212383e-06 0.01190857475316222 2.007153474943512e-06 0.01099048917119646 \
2.007153612213369e-06 0.01087009009405628 2.007154750907886e-06 0.009949273443646761 2.007154865085787e-06 0.009863136028526375 2.007156245730622e-06 0.008889755784408603 \
2.007156400087833e-06 0.00878832203975914 2.007157946582061e-06 0.00781340401000951 2.007158030943765e-06 0.007760176032106158 2.007159716371082e-06 0.006770348169342283 \
2.007159839899572e-06 0.00670487246831437 2.007161889714139e-06 0.005720970231232756 2.007162086114296e-06 0.005634691917282852 2.007164404793654e-06 0.004698942116576918 \
2.007164865407989e-06 0.004530544077955615 2.00716760550353e-06 0.003639937533647344 2.007168123648567e-06 0.00349159181499799 2.007172274289875e-06 0.002502201117031859 \
2.007172812139882e-06 0.002396807933581942 2.00717889437533e-06 0.001421603691354927 2.00717915335574e-06 0.001378272220758726 2.00718447611909e-06 0.0003814093765652445 \
2.007184589276134e-06 0.0003711807182531981 2.00983070639237e-06 -0.0004615907568095335 2.009830868831339e-06 -0.0006852153244161934 2.009831369832807e-06 -0.001554404032531494 \
2.00983145401537e-06 -0.001725199767551738 2.009831855538194e-06 -0.002626792336557519 2.009831944873161e-06 -0.002845673237760077 2.00983223146497e-06 -0.0035898660494722 \
2.009832359033499e-06 -0.003937855927128601 2.009832677745161e-06 -0.004830400105952924 2.009832791946314e-06 -0.00515011308870196 2.009833074346638e-06 -0.005887653497963378 \
2.009833204572857e-06 -0.006177415671381139 2.009834182925754e-06 -0.005220113099403402 2.009834370233287e-06 -0.004004368716724641 2.009834501677689e-06 -0.002901539130564616 \
2.009834607105243e-06 -0.001869327786897239 2.009834692822726e-06 -0.0009323217369615201 2.009834774749213e-06 4.151965372454519e-05 2.009834895786036e-06 0.001618129410352471 \
2.009834994714683e-06 0.003024565667809575 2.009835153111357e-06 0.005482561958548801 2.009835370558587e-06 0.00923691162542661 2.009835551780809e-06 0.0126653356758144 \
2.009835763874906e-06 0.01697021734206094 2.009835926898563e-06 0.02046388365739064 2.009836087520979e-06 0.02403759527126768 2.009836241061221e-06 0.02755862871109176 \
2.009836389117902e-06 0.031036270750196 2.009836538198811e-06 0.03460722192241437 2.009836692728723e-06 0.03837091703902212 2.009836853379538e-06 0.04234026030123839 \
2.009837018034218e-06 0.04645786783841532 2.009837194575117e-06 0.05091770581196236 2.009837373537969e-06 0.05547793877747508 2.009837564281134e-06 0.0603721650098247 \
2.009837769062163e-06 0.06565647483694508 2.009837989534449e-06 0.07137203566208646 2.009838222394174e-06 0.0774299331224613 2.00983847158165e-06 0.08392829098722057 \
2.009838744423778e-06 0.09105513637423955 2.009839041127578e-06 0.09880974921055499 2.009839368453968e-06 0.1073623706929605 2.009839738105355e-06 0.11701033799881 \
2.009840132977169e-06 0.1273002725707723 2.00984059081541e-06 0.1392030195235975 2.00984112262225e-06 0.1529832553757746 2.009841747860046e-06 0.1691182447448397 \
2.009842433607517e-06 0.1867241161332086 2.009843236003391e-06 0.2071957342970069 2.009844134802183e-06 0.2299563735557614 2.009844940415632e-06 0.2501946571168963 \
2.009845654166966e-06 0.2679877251922811 2.009846283728848e-06 0.2835633151515627 2.009846854092298e-06 0.2975737963344939 2.00984738504768e-06 0.3105173405876944 \
2.009847886835131e-06 0.3226580892822354 2.009848366129684e-06 0.3341673054699896 2.009848831685103e-06 0.3452566901045974 2.009849295481511e-06 0.3562094254686541 \
2.009849751229541e-06 0.3668794056881832 2.009850211449675e-06 0.3775613305945491 2.009850749733646e-06 0.3899285626759094 2.00985125058418e-06 0.4013172511919189 \
2.009851650806863e-06 0.4103337945930838 2.009852157667644e-06 0.421642452039157 2.009852643633856e-06 0.4323669409017459 2.009853043148568e-06 0.4410997362599856 \
2.009853453760627e-06 0.4500002277813482 2.00985388268706e-06 0.4592207708982954 2.009854284201442e-06 0.4677760623951868 2.009854591591889e-06 0.4742753916877908 \
2.009854941833647e-06 0.4816249679276425 2.00985529507385e-06 0.4889795533930016 2.00985554824443e-06 0.4942125642332652 2.00985578118832e-06 0.4989990073547648 \
2.009856022831611e-06 0.5039392821429431 2.00985624782223e-06 0.5085102868389438 2.009856439858338e-06 0.5123881070394828 2.009856624670034e-06 0.5161059569497825 \
2.00985684696035e-06 0.5205538992744256 2.009857013671758e-06 0.5238726938135662 2.009857230888353e-06 0.5281726418673847 2.009857433967244e-06 0.5321820613122353 \
2.0098576113787e-06 0.5356681922482178 2.009857799451086e-06 0.5393528234657015 2.009858035483266e-06 0.5439555888699217 2.00985830136529e-06 0.5491186112539347 \
2.009858523127178e-06 0.5534070305875756 2.009858803185033e-06 0.5588091140818973 2.009859046184818e-06 0.5634839438879177 2.009859321538161e-06 0.5687575845994758 \
2.009859566533502e-06 0.5734440561015828 2.009859806827721e-06 0.5780305526007354 2.009860047867023e-06 0.5826153106864888 2.009860305457841e-06 0.5874946531182738 \
2.009860540824618e-06 0.5919209497705462 2.009860772126727e-06 0.5962518282209535 2.009860994653448e-06 0.6003950532231523 2.009861203013056e-06 0.6042587207462122 \
2.00986144085487e-06 0.6086392006348278 2.009861651715085e-06 0.612499186772883 2.009861907322267e-06 0.617151767543529 2.009862106050033e-06 0.620751700070918 \
2.009862381682677e-06 0.6257066023742009 2.009862604438798e-06 0.6296824120643636 2.009862897809921e-06 0.6348814180513288 2.009863130579923e-06 0.6389753720667986 \
2.009863350781309e-06 0.6428252659334456 2.009863552051921e-06 0.6463216644290061 2.009863769340794e-06 0.6500784077528632 2.009863944056703e-06 0.6530842133917786 \
2.009864130321334e-06 0.6562672470877895 2.009864309060386e-06 0.6593113758161715 2.009864471764399e-06 0.6620700940033843 2.00986463703341e-06 0.6648583661366954 \
2.009864780301224e-06 0.6672607123132118 2.009864919531648e-06 0.669583864918244 2.009865059332215e-06 0.6719085596965743 2.009865194107422e-06 0.6741424479378803 \
2.009865321601663e-06 0.6762463034350935 2.009865454555775e-06 0.6784344250006583 2.009865576160125e-06 0.680430207161383 2.009865704573366e-06 0.6825336955632141 \
2.009865820340421e-06 0.6844241240890321 2.009865918381594e-06 0.686020684362688 2.0098660190777e-06 0.687656981754083 2.009866128831463e-06 0.689434454762776 \
2.009866245599418e-06 0.6913211166705923 2.009866336826192e-06 0.6927889453402305 2.009866446031605e-06 0.6945396927028351 2.009866547140326e-06 0.6961566646470493 \
2.009866642540618e-06 0.6976767415743361 2.009866752022643e-06 0.6994136821864276 2.009866886474277e-06 0.7015344809028976 2.009867035493214e-06 0.7038694457768003 \
2.009867164423233e-06 0.7058755144243859 2.009867311083691e-06 0.7081418729260142 2.009867437868072e-06 0.7100885084081828 2.009867562465961e-06 0.7119899232102255 \
2.009867674319728e-06 0.7136874821928206 2.009867787275692e-06 0.7153928249203609 2.00986788782909e-06 0.716903336497302 2.009868025110592e-06 0.7189542886859326 \
2.009868144979452e-06 0.7207346491296758 2.009868264162204e-06 0.7224952472954583 2.009868391164314e-06 0.7243608783177121 2.009868515712665e-06 0.726179956024653 \
2.009868639383676e-06 0.7279757435764195 2.009868765971953e-06 0.7298035010246171 2.009868896541188e-06 0.7316777339938921 2.009869019056222e-06 0.7334262671520465 \
2.009869155299713e-06 0.7353588786631546 2.009869256742486e-06 0.7367901064855561 2.009869362765969e-06 0.7382789144707947 2.009869453297152e-06 0.7395446819117977 \
2.009869567123378e-06 0.7411267287627761 2.009869654784961e-06 0.742338113895605 2.009869760680238e-06 0.7437932991468792 2.009869891033533e-06 0.7455718205320391 \
2.00987000160114e-06 0.7470699275523445 2.009870106271611e-06 0.7484790865773925 2.009870230233143e-06 0.7501360792234356 2.009870378790597e-06 0.752105598322839 \
2.009870500473193e-06 0.7537054667443914 2.009870614584883e-06 0.7551949470168074 2.009870755005484e-06 0.7570132059451244 2.009870896533544e-06 0.7588296197226846 \
2.009871014322813e-06 0.7603289862386273 2.009871142522635e-06 0.7619481626911874 2.009871284590468e-06 0.7637269294216019 2.009871401465576e-06 0.7651780119234867 \
2.009871547139362e-06 0.7669714049983392 2.00987166887781e-06 0.7684572223066155 2.009871787518301e-06 0.7698939375992205 2.009871909984595e-06 0.7713653733660819 \
2.009872036701684e-06 0.7728756341192486 2.009872146603679e-06 0.7741754302862822 2.009872272219022e-06 0.7756497674172792 2.009872378029431e-06 0.7768823528242577 \
2.009872514199553e-06 0.7784559787239111 2.009872638546601e-06 0.7798807766277074 2.009872765971877e-06 0.7813271999647126 2.009872880527956e-06 0.7826155184370988 \
2.009872987208226e-06 0.7838050786084815 2.009873125150823e-06 0.785328674235108 2.009873274600319e-06 0.7869612315653352 2.009873419452537e-06 0.7885256944569791 \
2.009873538888287e-06 0.7898026796320731 2.00987367431316e-06 0.7912364721526877 2.009873795807481e-06 0.7925100718437531 2.009873939166556e-06 0.7939977458315933 \
2.009874082600237e-06 0.7954699260458764 2.009874208411247e-06 0.7967479640295563 2.009874327457929e-06 0.7979459892863545 2.009874439471573e-06 0.7990632136113104 \
2.009874544263454e-06 0.8000996927221937 2.009874639456303e-06 0.8010335634530776 2.009874775866829e-06 0.8023587211299719 2.009874892679005e-06 0.8034813603122919 \
2.009875012140248e-06 0.8046180202255495 2.0098751341806e-06 0.8057672874017472 2.009875257080697e-06 0.8069126780167393 2.009875384200053e-06 0.8080849010520604 \
2.009875509341915e-06 0.8092265787736463 2.009875639893142e-06 0.8104047139317369 2.009875765969389e-06 0.811530109085512 2.009875893966049e-06 0.8126603425876329 \
2.009875999427297e-06 0.8135823118114501 2.009876102696598e-06 0.814477091043954 2.009876195349946e-06 0.8152732203909091 2.009876319044181e-06 0.8163262937528154 \
2.009876406664096e-06 0.8170655553659417 2.009876505330151e-06 0.8178914289762149 2.009876648877154e-06 0.819080619224994 2.009876784463307e-06 0.8201904093102529 \
2.009876893653288e-06 0.8210742465492874 2.009877041102747e-06 0.8222539401850584 2.009877191506449e-06 0.8234410273756358 2.009877316975412e-06 0.8244188977545531 \
2.009877461141395e-06 0.8255287290252299 2.00987758542996e-06 0.8264738611628292 2.009877735900257e-06 0.8276038147969816 2.009877871506615e-06 0.8286089145501508 \
2.009877996601616e-06 0.8295251220930787 2.009878114317453e-06 0.8303776282987162 2.009878260203052e-06 0.8314210189912619 2.009878426696148e-06 0.8325942517713072 \
2.009878557562851e-06 0.833503494447128 2.009878731007462e-06 0.8346911703335461 2.009878899140202e-06 0.8358239212093587 2.009879068993949e-06 0.8369500705213252 \
2.009879249886955e-06 0.838129582835239 2.009879393021216e-06 0.8390486258646698 2.009879507119162e-06 0.8397723391454259 2.009879637246322e-06 0.8405879656882547 \
2.009879739102179e-06 0.8412191375388212 2.009879855947599e-06 0.8419354178465567 2.009879992919396e-06 0.84276453896487 2.009880190759142e-06 0.843942473808897 \
2.00988038244463e-06 0.8450620046306492 2.009880591850993e-06 0.8462610422160779 2.009880773861877e-06 0.8472832413425977 2.009880970977334e-06 0.8483697584184032 \
2.009881144290447e-06 0.8493077402131245 2.009881327325656e-06 0.8502809338042043 2.009881498478783e-06 0.8511747489972419 2.009881673131736e-06 0.8520708361396651 \
2.009881848382891e-06 0.8529540285731302 2.009882024530391e-06 0.8538259128238825 2.009882214836779e-06 0.8547503816925358 2.009882405427748e-06 0.8556583881771193 \
2.009882605979791e-06 0.8565949481971697 2.009882798582589e-06 0.8574764650234362 2.009883009331288e-06 0.8584213553684483 2.009883237362186e-06 0.8594210644592908 \
2.009883503241952e-06 0.8605573106989262 2.009883801820094e-06 0.8617960322792503 2.009884077983729e-06 0.8629075153790151 2.009884362230229e-06 0.8640180616030438 \
2.009884636414231e-06 0.8650581816846495 2.00988490866944e-06 0.8660616517296992 2.009885178858915e-06 0.8670295451208139 2.009885436023238e-06 0.8679256252637404 \
2.009885708596972e-06 0.8688492356117473 2.009885984602435e-06 0.8697577927663542 2.009886254710518e-06 0.8706213441784563 2.009886554568938e-06 0.8715508809746347 \
2.009886925582817e-06 0.8726599440782473 2.009887220515529e-06 0.873510245983525 2.009887474800896e-06 0.8742218447789023 2.009887773044171e-06 0.8750318897722944 \
2.009888046640929e-06 0.8757523113099853 2.009888282767907e-06 0.8763571312809064 2.009888523107206e-06 0.876957042728428 2.009888745440861e-06 0.8774982514557473 \
2.009888939446794e-06 0.8779599514934209 2.009889269165229e-06 0.8787226653583874 2.009889424338019e-06 0.8790722725343518 2.009889742071409e-06 0.8797700114458387 \
2.00988992093906e-06 0.880152324917399 2.009890263400534e-06 0.8808637455080008 2.009890447552368e-06 0.8812353200296749 2.009890922478419e-06 0.8821594045029107 \
2.009891089871654e-06 0.8824737723885729 2.009891555692961e-06 0.8833186808430151 2.009891736520447e-06 0.883635209600208 2.009892230549786e-06 0.8844687288968743 \
2.009892371887773e-06 0.8846990198924604 2.009892978249103e-06 0.8856473543416146 2.009893130320955e-06 0.8858754372639542 2.009893777008948e-06 0.8868048391838264 \
2.009893905303109e-06 0.8869818633102416 2.009894553496582e-06 0.8878410756373726 2.009894683245133e-06 0.8880061989117775 2.009895451498601e-06 0.8889361126992519 \
2.009895581240626e-06 0.8890847997417872 2.009896434697557e-06 0.8900046759307325 2.009896577924673e-06 0.8901495209380393 2.009897564158077e-06 0.8910738355210844 \
2.009897785636141e-06 0.8912643084423501 2.009898928653689e-06 0.8921737958641509 2.009899058631989e-06 0.8922730011388891 2.009900410338988e-06 0.8932565980587214 \
2.009900560692342e-06 0.8933589605607284 2.009902041315768e-06 0.8942730372387374 2.00990228021907e-06 0.8944047337041336 2.009904061344228e-06 0.8952702388217941 \
2.009904447325595e-06 0.8954343910560414 2.009906848871634e-06 0.896309305076933 2.00990732380842e-06 0.8964562995603377 2.00991114197014e-06 0.8973944547681553 \
2.009911624459336e-06 0.897487269196476 2.009919510474849e-06 0.898471373493449 2.00992012663754e-06 0.8985180228791175 2.010015282612379e-06 0.899508178894561 \
2.010016773214557e-06 0.8995204306067698 2.010128061288741e-06 0.9005118233983579 2.010128237625743e-06 0.9005706457326812 2.010131860757067e-06 0.8996048713171836 \
2.010132041955094e-06 0.8994654179496379 2.01013335307657e-06 0.8985275682722235 2.010133534953976e-06 0.8984123497545736 2.01013535794417e-06 0.8974436520388238 \
2.010135517857424e-06 0.8973766233009967 2.010148668688723e-06 0.8983720910457982 2.010148779670277e-06 0.8983905835035384 2.010157601254383e-06 0.8993863063850064 \
2.010158148023847e-06 0.8994226481040219 2.01065071997668e-06 0.9003987622903815 2.010650789769166e-06 0.9004496773542636 2.010651622421929e-06 0.9012853800543292 \
2.010651748468094e-06 0.9014513953152168 2.010652328988957e-06 0.9023435091985418 2.010652469953212e-06 0.9025895326188698 2.010652869091291e-06 0.9033428289365844 \
2.010653019240832e-06 0.9036449200440446 2.010653462322153e-06 0.9045762589490434 2.010653619494256e-06 0.9049121924877023 2.010654065120987e-06 0.9058152254958243 \
2.010654163577326e-06 0.9059929146639856 2.010655580258721e-06 0.9052304871087643 2.010655711415865e-06 0.904616184869324 2.010655880423041e-06 0.9036290332250884 \
2.010656045714917e-06 0.9024406226812831 2.010656151980698e-06 0.9015554774641358 2.010656255417528e-06 0.9006052096506509 2.010656341184247e-06 0.8997486040545581 \
2.010656430678233e-06 0.8987887485205278 2.010656554922633e-06 0.8973492764100613 2.01065667300358e-06 0.8958624931586439 2.010656760219672e-06 0.8946938835082598 \
2.010656884526716e-06 0.8929289312882503 2.010656991510644e-06 0.8913158670103165 2.010657091342348e-06 0.8897378501708729 2.010657217633174e-06 0.8876466417139378 \
2.010657385821785e-06 0.884705368138502 2.010657541521538e-06 0.8818365157686672 2.010657738126367e-06 0.8780362649814708 2.010657921747617e-06 0.8743271923380105 \
2.01065813325501e-06 0.8698916163736473 2.010658314064811e-06 0.8659808238081558 2.010658498645858e-06 0.8618945354625286 2.010658671649854e-06 0.8579913311618118 \
2.010658857050504e-06 0.8537436868396935 2.010659036133651e-06 0.8495884889292737 2.010659219722713e-06 0.8452850234109005 2.010659386484418e-06 0.8413449312544377 \
2.010659554574996e-06 0.8373487193315756 2.010659717684167e-06 0.8334514816705533 2.010659872870403e-06 0.829729402178684 2.010660045969282e-06 0.8255639501984255 \
2.010660231959738e-06 0.8210763864673301 2.010660396580222e-06 0.8170961425007568 2.010660561450132e-06 0.8131038678717658 2.010660736782165e-06 0.8088537582860886 \
2.010660901208668e-06 0.8048648186953292 2.010661069844279e-06 0.8007719922541914 2.010661260647645e-06 0.7961398815555145 2.010661446171818e-06 0.7916360074082958 \
